
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000621374528301084*x_10 + 0.00235714779147471*x_100 + 0.00201968248391174*x_101 + 0.00330468012441902*x_102 + 0.00536203563364123*x_103 - 0.000347087882604569*x_104 - 0.00239709299563619*x_105 - 0.000325089452235976*x_106 + 0.00298649771761541*x_107 + 0.00108621048768665*x_108 + 0.00198362733424485*x_109 + 0.00175644822310361*x_11 - 0.00241203203227019*x_110 - 0.00215735887794471*x_111 - 0.000252922997075098*x_112 + 0.00107349481395801*x_113 - 0.00113686324620588*x_114 - 0.00144848213221108*x_115 - 0.00204526686939749*x_116 - 0.000714123076923665*x_117 - 0.00405840817175351*x_118 + 0.0020407265765687*x_119 + 0.0032165934815853*x_12 - 0.000471297578822508*x_120 - 0.00112255546670694*x_13 + 0.000503259704645599*x_14 + 0.00133565450941983*x_15 - 0.000117367814895529*x_17 + 0.000133175215206601*x_18 + 0.00123633673967488*x_19 + 8.33340915522727e-5*x_2 - 9.72190551295719e-5*x_20 - 0.00181118335114527*x_21 - 0.000403122517903731*x_22 + 0.00015185420115355*x_23 + 0.00120497665874733*x_24 - 0.00113355733143783*x_25 - 6.78497030323262e-5*x_26 + 0.00229113946420396*x_27 - 0.00151888252682926*x_28 - 0.000718465346819427*x_3 - 5.13072643341229e-5*x_30 - 1.85935660294006e-5*x_32 + 0.00287798679985594*x_33 + 0.00352585023606617*x_34 + 0.00020969817835265*x_35 - 0.00465229689008096*x_36 - 0.00010239928901739*x_37 + 0.00133378674878191*x_38 + 0.00228055571574046*x_39 - 0.000101287584021492*x_4 + 0.000721522178068508*x_40 - 0.00108169330295247*x_41 - 0.0042239107622709*x_42 - 0.00673466740344437*x_43 + 0.00250490652800291*x_44 + 0.00715385908299052*x_45 + 0.0027673559148783*x_46 - 0.000912973827434983*x_47 + 0.000237859183526656*x_48 + 0.00217605492570418*x_49 - 0.00737372193600739*x_50 - 0.00467996174467389*x_51 - 1.85033081716382e-5*x_52 - 0.000298043840190021*x_53 + 0.00542095520965769*x_54 + 0.0068093975551723*x_55 + 0.000461427705477216*x_56 + 0.000645840820900838*x_57 - 0.00332226815775085*x_58 + 0.00724691108448578*x_59 + 0.000383874625802537*x_6 + 0.00101286526455587*x_60 + 0.000244197253994338*x_61 - 0.00212857265960239*x_62 - 0.000905129752119439*x_63 + 0.000992404336490381*x_64 + 0.00159687820398948*x_65 - 0.000769376941673953*x_66 - 6.2644958356833e-5*x_67 - 9.19235986803114e-5*x_68 - 0.00158224384220026*x_69 + 0.000381767570786651*x_7 - 0.00300991661870866*x_70 - 0.00120662736589635*x_71 + 0.000389233590638559*x_72 + 0.000880154808115983*x_73 - 0.00323358356664859*x_74 - 0.00117377523357065*x_75 - 0.00136459749660689*x_76 + 0.000464149458499946*x_77 + 0.000713929506457016*x_78 - 0.00301965067268726*x_79 + 5.96782548168045e-5*x_8 - 0.00125054515721688*x_80 - 0.00130795527107607*x_81 + 0.00084293960180081*x_82 - 0.000704906424630753*x_83 - 0.000379006071218294*x_84 - 0.000629945571587295*x_85 - 0.000862215649807337*x_86 + 0.00397474194208168*x_87 + 0.00277654631127861*x_88 + 0.000889321785627562*x_89 + 0.00123673935628637*x_9 + 0.000824663353451139*x_90 + 0.000203026191828402*x_92 - 0.00639868644724168*x_93 + 0.000365833620933319*x_94 - 0.00153320201636361*x_95 + 9.71362066800408e-5*x_96 - 0.00105116685195406*x_97 + 0.00141044748788205*x_98 - 0.00106314293954459*x_99 - 0.0380741557289343*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.0256598824438142*std::sin(0.289279937744141*x_1 - 4.30231952667236) - 0.0132160452778165*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.0120925879536677*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.00733957693517219*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.00341507746044758*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.00240526864123499*std::sin(0.308879911899567*x_10 - 7.43832015991211) - 0.00611842144368642*std::sin(0.235679984092712*x_101 + 1.99255979061127) - 0.0125145255866705*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.00365945488374757*std::sin(0.247759968042374*x_107 - 7.41655969619751) - 0.00892076041942253*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.00105571011376125*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.0244777051829021*std::sin(0.240399971604347*x_109 - 7.43703985214233) - 0.00859715512960246*std::sin(0.240639984607697*x_109 + 1.97959983348846) + 0.00348482625375915*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.0155645966556898*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.00449718133130708*std::sin(0.284479945898056*x_11 + 5.16048002243042) - 0.0116480048181322*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.0338993687062749*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.00603095997881602*std::sin(0.280559957027435*x_112 - 7.44392013549805) + 0.00895395606722406*std::sin(0.280879944562912*x_112 - 7.43415975570679) - 0.0194151916500049*std::sin(0.278159946203232*x_113 - 7.40975999832153) + 0.00435914226632573*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.00676709823485274*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.0270993505253024*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.00713094450099442*std::sin(0.277199953794479*x_12 + 5.15424013137817) - 0.00377379469779264*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.00633227550067044*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.0059402701287763*std::sin(0.269039958715439*x_120 + 5.15144014358521) - 0.0444984864779311*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.00670370726317637*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.012580876105363*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.00540114035339504*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.00389846511959259*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.0135029938673805*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.00283389741251019*std::sin(0.310479938983917*x_15 - 7.44432020187378) - 0.0022277756393614*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.000838462519327914*std::sin(0.332719832658768*x_15 + 5.06071949005127) + 0.0064185698836293*std::sin(0.385759830474854*x_15 + 5.02367973327637) - 0.00265322922676767*std::sin(0.292719930410385*x_16 - 7.40079975128174) - 0.0414519120712713*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.0115848575448095*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.00417779369747032*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.00213511818858524*std::sin(0.331919848918915*x_16 - 1.13143992424011) + 0.01880646511237*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.0295794619083938*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.00152639236642995*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.00402079107228662*std::sin(0.331439822912216*x_18 + 2.01263976097107) + 0.0145889641768653*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.00461338852535408*std::sin(0.371599853038788*x_18 - 1.17215991020203) + 0.00243745170758609*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.00839243496693955*std::sin(0.317199915647507*x_19 + 1.98535978794098) - 0.00697429138531447*std::sin(0.36695984005928*x_2 - 7.40399980545044) + 0.0106882953108365*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.0115987672712884*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.0274537212673506*std::sin(0.381119847297668*x_2 - 7.39511966705322) + 0.00629587909001979*std::sin(0.257119953632355*x_20 + 1.97903978824615) + 0.0134395081072446*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.0291728669373294*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.00359852449207296*std::sin(0.301119923591614*x_20 - 7.42543983459473) - 0.0191498944026753*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.00254860641274066*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.00120560805590973*std::sin(0.294639945030212*x_22 - 1.14359986782074) + 0.0170533103922927*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.00165197395533935*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.0123328233410297*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.00767247966545272*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.00154279831862187*std::sin(0.279199957847595*x_24 - 1.16119992733002) - 0.00893771000436623*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.0084604319042518*std::sin(0.347999840974808*x_24 + 2.00127983093262) - 0.0156666529383113*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.0013173910352621*std::sin(0.37527984380722*x_25 - 4.39687967300415) - 0.0136232331352584*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.00385864919123015*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.0027557295381902*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.0263376216684131*std::sin(0.23879998922348*x_28 + 8.20119953155518) - 0.00464949382362781*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.00382240465004518*std::sin(0.361279845237732*x_28 - 1.1632798910141) - 0.0247045387671858*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.003671062455761*std::sin(0.26063996553421*x_29 + 2.00991988182068) + 0.00582043059311451*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.00235577482212998*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.0319066031297448*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.0245444455749985*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.00592554674887733*std::sin(0.350639849901199*x_3 - 7.40711975097656) - 0.00931442145343832*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.0055800343971575*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.0557094883868488*std::sin(0.299279928207397*x_30 + 1.98919987678528) + 0.0698383841407741*std::sin(0.317359924316406*x_30 + 1.98943984508514) + 0.0101635651762588*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.00583543255482364*std::sin(0.377519845962524*x_30 - 1.15831983089447) + 0.00269281047595905*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.0345247741596886*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.00929655969970698*std::sin(0.378239840269089*x_31 + 5.16991996765137) - 0.0280243694039666*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.00340787729622321*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.00633376176447156*std::sin(0.305999934673309*x_32 - 1.13367986679077) + 0.0289466864007351*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.00912596712213855*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.0428346503941724*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.0330198874949419*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.00999881249707097*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.00201173938548157*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.0197299358018674*std::sin(0.236879989504814*x_35 + 1.97175979614258) - 0.0141937214183015*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.00264173478158954*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.00523405590865416*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.00378686376124563*std::sin(0.228959992527962*x_37 + 1.97391974925995) - 0.0141367011083236*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.0250246364522289*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.00127661341770183*std::sin(0.30583992600441*x_4 + 2.03351974487305) + 0.0148149143051628*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.0175278150578657*std::sin(0.343119859695435*x_4 + 1.99575984477997) - 0.00154556541679561*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.00243868918021845*std::sin(0.244799971580505*x_41 + 1.98759984970093) + 0.0211718274036234*std::sin(0.232479989528656*x_42 + 1.96527981758118) - 0.00499269875549582*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.00134195651989847*std::sin(0.260159969329834*x_44 + 1.9625598192215) - 0.0057488460591813*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.0294013171305406*std::sin(0.188880011439323*x_47 - 1.1975998878479) - 0.00800722165653461*std::sin(0.202639997005463*x_47 + 1.9793598651886) + 0.024074832873885*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.00250315985463045*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.0030249759677966*std::sin(0.264479964971542*x_49 - 7.47544002532959) + 0.00330650222443523*std::sin(0.285279929637909*x_5 - 1.16967988014221) + 0.0140291894691177*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.00468229189695423*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.00964056620371422*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.00210118464973615*std::sin(0.410559862852097*x_5 + 1.96807980537415) - 0.00745705995052818*std::sin(0.18384000658989*x_51 + 1.98735988140106) - 0.00654804157261483*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.00346944211085857*std::sin(0.227119997143745*x_52 - 7.40711975097656) + 0.0107765991626199*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.0602808072422423*std::sin(0.243119969964027*x_53 - 7.4256796836853) + 0.0155682114285484*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.0186961005460603*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.00235486502901228*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.00483420359944206*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.00324272689656454*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.0203940388521429*std::sin(0.407519847154617*x_6 - 7.41775989532471) - 0.0017397470383936*std::sin(0.433199852705002*x_6 - 7.42935991287231) + 0.016205691799312*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.00462263950798785*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.00550924407645679*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.0640481376976932*std::sin(0.361599832773209*x_7 + 1.99375987052917) - 0.0134607162632372*std::sin(0.398479849100113*x_7 - 1.17207992076874) + 0.00386676207456942*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0395921510754756*std::sin(0.327199846506119*x_8 - 1.14231991767883) + 0.0147398269408196*std::sin(0.332799851894379*x_8 - 1.1379998922348) + 0.0181752883598264*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.0062091819543119*std::sin(0.312959939241409*x_9 - 7.42560005187988) - 0.00307426651701128*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.000649791890352946*std::sin(0.342559844255447*x_9 - 1.12967991828918) + 0.00839789944661073*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.00165358802765745*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.00347520413393733*std::sin(0.360959857702255*x_91 - 7.41048002243042) - 0.0111312602700725*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.00889348313480499*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.0209992100412606*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.00192117604294955*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.00233199343746624*std::sin(0.309759914875031*x_92 + 1.98343980312347) + 0.00469623018053284*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.00348723454107302*std::sin(0.29479992389679*x_94 + 1.96527981758118) - 0.0132603427428833*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.00228652936760216*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.00195435151367827*std::sin(0.265119940042496*x_95 - 7.42375993728638) - 0.0114289799854361*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.0286854207171131*std::sin(0.281999945640564*x_96 - 7.44087982177734) + 0.0170145336397892*std::sin(0.265919953584671*x_97 + 1.98175978660583) + 0.00236255239505336*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.00464018349991019*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.00244465302171152*std::sin(0.276719957590103*x_97 - 1.20031988620758) - 0.0235339587074069*std::sin(0.246239975094795*x_98 - 7.40775966644287) + 0.0125663756236199*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.042470375648814);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00235242615245338*x_10 + 0.00471903445550152*x_100 + 0.00107102193226646*x_101 - 0.000869346962634833*x_102 - 0.00301318523094588*x_103 - 0.00045463353106761*x_104 + 0.00133082361842541*x_105 + 0.00316604034381567*x_106 - 0.000252078685888416*x_107 + 0.00414134295100682*x_108 - 0.00171404689222183*x_109 - 0.000682254861367408*x_11 - 0.00517072452134189*x_110 - 0.00692721184443863*x_111 + 0.000470176516465399*x_112 + 0.000478482481561211*x_113 - 0.00165716255572791*x_114 - 0.00416247619619823*x_115 + 0.00140479435510313*x_116 + 0.00619544037895832*x_117 + 0.00387252020546188*x_118 + 0.00787784122104162*x_119 - 0.00178239453621858*x_12 - 0.00604360305078314*x_120 - 0.000544930033032896*x_13 - 0.00155483420096396*x_14 - 1.42731036436304e-5*x_15 - 0.000684671279383419*x_17 + 0.00068427047438127*x_18 - 0.000130944785223673*x_19 + 0.000397223069326594*x_2 - 0.00046340760133416*x_20 - 0.00285822783497707*x_21 - 0.000603571705898909*x_22 - 0.000855436241655358*x_23 - 0.000110766737891839*x_24 - 0.00179801411828036*x_25 + 2.69905023815108e-5*x_26 - 0.0134010534927727*x_27 + 0.000969384250072974*x_28 + 0.000458540393432455*x_3 - 0.000244562923023733*x_30 - 0.00010131964919273*x_32 + 0.00024586693933979*x_33 - 0.000590036917233191*x_34 + 0.00114268268031262*x_35 + 0.00503611890472643*x_36 + 0.00584019142759133*x_37 + 0.0067319524323607*x_38 + 0.010251941534065*x_39 - 0.000482800787291898*x_4 + 0.000708162625457756*x_40 - 0.00500545355926766*x_41 + 0.000977224106991921*x_42 - 0.00268347565407458*x_43 + 1.34152712486691e-5*x_44 + 0.00190793408892223*x_45 - 0.000871173139874271*x_46 - 0.00422628931972839*x_47 - 0.0028062902728229*x_48 + 0.00665217806650582*x_49 - 0.00571553919124587*x_50 + 0.00215434417039633*x_51 + 0.000928956453439656*x_52 - 0.00254448421407303*x_53 - 0.00481978879997*x_54 - 0.0012633710861838*x_55 + 0.000545940658609117*x_56 - 0.00097624297125342*x_57 + 0.00489869856468793*x_58 - 0.00118279019903495*x_59 - 0.000223628279070454*x_6 + 0.00375495268822124*x_60 - 0.00286171867854445*x_61 - 0.00273501925779436*x_62 - 0.00270766851559515*x_63 - 0.00506586153868575*x_64 - 7.15916619797262e-5*x_65 + 0.00250721564336264*x_66 - 0.00156994987908889*x_67 + 0.00423327582274071*x_68 - 0.00370503412600001*x_69 + 0.00208031941178479*x_7 - 0.00199028754398751*x_70 - 0.00439409848637158*x_71 + 0.000786669812284535*x_72 - 0.00118164482295335*x_73 + 0.000361004396952892*x_74 - 0.00490497107281638*x_75 - 0.00729443934139386*x_76 - 1.62036014211835e-5*x_77 - 0.00395726742724518*x_78 - 0.000228731731155181*x_79 + 0.0005843817703711*x_8 + 0.00689446639962355*x_80 + 0.00799800367004785*x_81 - 0.00267238369602213*x_82 + 0.00337322347059337*x_83 + 0.00731981376382315*x_84 - 0.00168647752399734*x_85 - 0.000212861564843654*x_86 + 0.00784006929698989*x_87 + 0.00202098909356412*x_88 + 0.00197742273473127*x_89 - 1.32160741328981e-5*x_9 + 0.0058992685686849*x_90 - 0.000640733502871923*x_92 + 0.00246626010100083*x_93 - 3.90938012119164e-6*x_94 + 0.000216701350899515*x_95 - 0.000542115332018889*x_96 + 1.12330047320441e-5*x_97 + 4.5168807725271e-5*x_98 - 0.00451975631148145*x_99 + 0.0242997639689113*std::sin(0.248799979686737*x_1 + 5.06423997879028) + 0.000274207258704213*std::sin(0.289279937744141*x_1 - 4.30231952667236) - 0.0720165819265802*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.0576409343833146*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.0126460098110253*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.00588414065983466*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.0114650339906455*std::sin(0.308879911899567*x_10 - 7.43832015991211) + 0.00390491119494266*std::sin(0.235679984092712*x_101 + 1.99255979061127) + 0.0079870455986998*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.00630520025495045*std::sin(0.247759968042374*x_107 - 7.41655969619751) - 0.0486108105781912*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.00181897683942053*std::sin(0.262639969587326*x_108 - 7.44599962234497) - 0.000261574247359482*std::sin(0.240399971604347*x_109 - 7.43703985214233) - 0.0468474277827857*std::sin(0.240639984607697*x_109 + 1.97959983348846) + 0.0189894382266529*std::sin(0.261039972305298*x_11 + 1.96351981163025) - 0.000166326770636563*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.00774859365055962*std::sin(0.284479945898056*x_11 + 5.16048002243042) + 0.00743401297731883*std::sin(0.209519997239113*x_111 + 1.9819997549057) + 0.000362256256828326*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.0103912772814635*std::sin(0.280559957027435*x_112 - 7.44392013549805) + 0.0487916995687516*std::sin(0.280879944562912*x_112 - 7.43415975570679) + 0.0123912025223915*std::sin(0.278159946203232*x_113 - 7.40975999832153) + 0.0237537417247962*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.0116596353476485*std::sin(0.256719976663589*x_116 + 5.1450400352478) - 0.000289589737461914*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.0339905986748031*std::sin(0.277199953794479*x_12 + 5.15424013137817) - 0.0205640786872803*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.0301836362927186*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.0102350196737713*std::sin(0.269039958715439*x_120 + 5.15144014358521) + 0.0283999132137233*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.0319541153607653*std::sin(0.291599929332733*x_13 + 5.1430401802063) - 0.000134442063657254*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.00930610503889428*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.0185825542898716*std::sin(0.291999936103821*x_14 - 7.42631959915161) + 0.000144296020871553*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.00488277387083514*std::sin(0.310479938983917*x_15 - 7.44432020187378) - 0.012139545792523*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.00399664350134336*std::sin(0.332719832658768*x_15 + 5.06071949005127) - 0.00409647253377246*std::sin(0.385759830474854*x_15 + 5.02367973327637) - 0.0144579180808527*std::sin(0.292719930410385*x_16 - 7.40079975128174) + 0.0264555223906511*std::sin(0.321839928627014*x_16 - 7.42136001586914) - 0.000123798385935584*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.00719829229304342*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.0101773258032443*std::sin(0.331919848918915*x_16 - 1.13143992424011) - 0.0120026998516704*std::sin(0.337999850511551*x_17 + 2.00311970710754) + 0.000316092763932426*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.00262995715037005*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.00692777850785299*std::sin(0.331439822912216*x_18 + 2.01263976097107) - 0.00931099795285341*std::sin(0.334559857845306*x_18 + 2.01887989044189) + 4.92997044567432e-5*std::sin(0.371599853038788*x_18 - 1.17215991020203) + 0.0132821079908148*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.0144600725447425*std::sin(0.317199915647507*x_19 + 1.98535978794098) - 0.0380041545236991*std::sin(0.36695984005928*x_2 - 7.40399980545044) - 0.00682150525234032*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.019984547611404*std::sin(0.377119839191437*x_2 + 5.18016004562378) - 0.000293376622688485*std::sin(0.381119847297668*x_2 - 7.39511966705322) + 0.0343073652333282*std::sin(0.257119953632355*x_20 + 1.97903978824615) - 0.00857738979662084*std::sin(0.273119956254959*x_20 - 1.17575979232788) - 0.000311747798881918*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.00620021786458756*std::sin(0.301119923591614*x_20 - 7.42543983459473) + 0.0122218839815522*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.012148272608687*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.00574669170147413*std::sin(0.294639945030212*x_22 - 1.14359986782074) - 0.0108837979329475*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.00284633283788713*std::sin(0.3018399477005*x_23 + 2.02303981781006) + 0.000131791316185173*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.0365718983106128*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.00735395409081141*std::sin(0.279199957847595*x_24 - 1.16119992733002) - 0.0487031718819747*std::sin(0.314239919185638*x_24 - 1.16023993492126) + 9.04100728052169e-5*std::sin(0.347999840974808*x_24 + 2.00127983093262) + 0.00999880263384298*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.00627952019134815*std::sin(0.37527984380722*x_25 - 4.39687967300415) + 0.00869464715217989*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.0183927663534147*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.013135552629229*std::sin(0.203599989414215*x_28 - 4.38679981231689) - 0.000281449732059284*std::sin(0.23879998922348*x_28 + 8.20119953155518) - 0.0253359190156877*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.00658596089844597*std::sin(0.361279845237732*x_28 - 1.1632798910141) + 0.015766980239229*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.00632519997303509*std::sin(0.26063996553421*x_29 + 2.00991988182068) + 0.0317165617887667*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.0112291150963325*std::sin(0.301919937133789*x_29 + 2.01615977287292) + 0.00034096111694696*std::sin(0.3504798412323*x_29 - 1.14943993091583) - 0.000262287450157729*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.0102096514531915*std::sin(0.350639849901199*x_3 - 7.40711975097656) - 0.0507559395870247*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.0265979786771483*std::sin(0.363599836826324*x_3 - 7.40783977508545) - 0.000595324087233086*std::sin(0.299279928207397*x_30 + 1.98919987678528) - 0.0445723934805808*std::sin(0.317359924316406*x_30 + 1.98943984508514) + 0.0553830748000517*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.0100543856943908*std::sin(0.377519845962524*x_30 - 1.15831983089447) + 0.0146736033494203*std::sin(0.372399836778641*x_31 + 5.19208002090454) + 0.000368939479767276*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.0160178694507435*std::sin(0.378239840269089*x_31 + 5.16991996765137) + 0.0178857692010871*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.0162441019549013*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.0301907207674865*std::sin(0.305999934673309*x_32 - 1.13367986679077) - 0.0184744122030634*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.0157239403280334*std::sin(0.311199933290482*x_32 - 1.14927983283997) - 0.000457740680919248*std::sin(0.311919927597046*x_32 - 1.14735984802246) + 0.00035285792335702*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.0172278432467436*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.00346620469146006*std::sin(0.213759988546371*x_34 - 1.18095993995667) - 0.000210838518940463*std::sin(0.236879989504814*x_35 + 1.97175979614258) + 0.00905874532742691*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.00455167978497718*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.0249488260366822*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.00652472434047791*std::sin(0.228959992527962*x_37 + 1.97391974925995) + 0.00902235371092565*std::sin(0.234239995479584*x_38 + 1.95567977428436) + 0.00026741887756736*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.00219959078673587*std::sin(0.30583992600441*x_4 + 2.03351974487305) - 0.00945520429653349*std::sin(0.333039849996567*x_4 + 2.02287983894348) + 0.000187306162786043*std::sin(0.343119859695435*x_4 + 1.99575984477997) - 0.00842206092077943*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.0116243374500854*std::sin(0.244799971580505*x_41 + 1.98759984970093) - 0.013512326113317*std::sin(0.232479989528656*x_42 + 1.96527981758118) - 0.0272061037474975*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.00231217622848002*std::sin(0.260159969329834*x_44 + 1.9625598192215) - 0.031326484928079*std::sin(0.231039986014366*x_46 + 1.98183989524841) - 0.000314189068882592*std::sin(0.188880011439323*x_47 - 1.1975998878479) - 0.0436327753356021*std::sin(0.202639997005463*x_47 + 1.9793598651886) - 0.0153650880820928*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.00431291671983524*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.0144189516701413*std::sin(0.264479964971542*x_49 - 7.47544002532959) + 0.0180177188660329*std::sin(0.285279929637909*x_5 - 1.16967988014221) - 0.0089537374171012*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.00806753710601687*std::sin(0.34911984205246*x_5 + 1.99775981903076) + 0.000103021252605708*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.0100155770614788*std::sin(0.410559862852097*x_5 + 1.96807980537415) - 0.0406348463227541*std::sin(0.18384000658989*x_51 + 1.98735988140106) - 0.0356814434620929*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.0165375588604301*std::sin(0.227119997143745*x_52 - 7.40711975097656) - 0.00687786271358411*std::sin(0.203919991850853*x_53 + 2.00807976722717) - 0.000644174225761391*std::sin(0.243119969964027*x_53 - 7.4256796836853) + 0.084833953745323*std::sin(0.245759963989258*x_56 + 5.15263986587524) - 0.000199790723531916*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.0112247784460141*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.00832927928775826*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.00558718254616519*std::sin(0.180560007691383*x_6 + 8.18007946014404) - 0.00021793527307844*std::sin(0.407519847154617*x_6 - 7.41775989532471) - 0.00948019112285441*std::sin(0.433199852705002*x_6 - 7.42935991287231) - 0.0103428290959303*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.0220344281619907*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.00949236655703383*std::sin(0.327359855175018*x_7 + 2.03519988059998) + 0.000684432763932174*std::sin(0.361599832773209*x_7 + 1.99375987052917) + 0.00859092530843904*std::sin(0.398479849100113*x_7 - 1.17207992076874) + 0.021070674462749*std::sin(0.316959917545319*x_8 - 7.4203200340271) - 0.00042309060598313*std::sin(0.327199846506119*x_8 - 1.14231991767883) - 0.00940728188838931*std::sin(0.332799851894379*x_8 - 1.1379998922348) - 0.0115998689598007*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.010698351772346*std::sin(0.312959939241409*x_9 - 7.42560005187988) - 0.0167522251802594*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.00309731976795621*std::sin(0.342559844255447*x_9 - 1.12967991828918) - 0.00535972421398204*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.00284911386662363*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.0165650243124467*std::sin(0.360959857702255*x_91 - 7.41048002243042) - 0.0606562175245671*std::sin(0.365199834108353*x_91 + 2.00367975234985) + 9.50377553781394e-5*std::sin(0.374399840831757*x_91 + 1.98335981369019) + 0.000224402268131051*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.0091575420129042*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.00401799887785394*std::sin(0.309759914875031*x_92 + 1.98343980312347) + 0.0255905937391204*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.00600846651098167*std::sin(0.29479992389679*x_94 + 1.96527981758118) + 0.00846304251873559*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.0108990473956821*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.00336732602362014*std::sin(0.265119940042496*x_95 - 7.42375993728638) + 0.00729422650967555*std::sin(0.281519949436188*x_96 + 1.96807980537415) + 0.000306538839249937*std::sin(0.281999945640564*x_96 - 7.44087982177734) - 0.0108590497562571*std::sin(0.265919953584671*x_97 + 1.98175978660583) + 0.0128739683118208*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.00799498480404512*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.0116527648965089*std::sin(0.276719957590103*x_97 - 1.20031988620758) + 0.0150198902876658*std::sin(0.246239975094795*x_98 - 7.40775966644287) + 0.068476416401028*std::sin(0.253519982099533*x_98 - 7.43039989471436) + 0.588010536281445);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000861902795337582*x_10 - 0.0010644220013722*x_100 - 0.00205991107957005*x_101 + 0.00230832487590904*x_102 + 0.00270933803558652*x_103 - 0.00273223355356129*x_104 - 0.0014983228863026*x_105 - 0.00263916417979857*x_106 + 0.00142749103277915*x_107 - 0.00169946745661123*x_108 + 0.000955939164609558*x_109 + 0.00103422033501476*x_11 + 0.00395513844195147*x_110 + 0.00476498049105048*x_111 - 0.000475394171240649*x_112 + 0.000120660335695139*x_113 + 0.00279650901636174*x_114 + 0.00224356705849763*x_115 - 0.00245323190311054*x_116 - 0.00151210585084644*x_117 - 0.00223075263117944*x_118 + 0.00050873574587923*x_119 + 0.00312992786613093*x_12 + 0.0025614864003732*x_120 - 0.000455288881079674*x_13 + 0.000991153775138506*x_14 + 0.000548823043406673*x_15 + 0.000120720907186203*x_17 - 0.000389369328734873*x_18 + 0.000530874623586333*x_19 - 0.000328011902577531*x_2 + 0.000382664605155476*x_20 + 0.000456389275943746*x_21 + 0.000579816633132955*x_22 + 0.000482085591556605*x_23 + 0.00226513259388446*x_24 - 2.62486010307931e-5*x_25 + 0.000746968816169626*x_26 + 0.00731209924009354*x_27 - 0.0012273674647957*x_28 - 0.000580572213909241*x_3 + 0.000201950883207594*x_30 + 3.86012756722457e-5*x_32 + 0.00167022547574957*x_33 + 0.00244253222886008*x_34 - 0.000435345063865586*x_35 - 0.0034455742870791*x_36 - 0.00272435203401971*x_37 - 0.00018370066177074*x_38 - 0.00129680450516515*x_39 + 0.000398678770278921*x_4 + 0.000689721734339496*x_40 - 0.000559945572885967*x_41 - 0.00426718006877926*x_42 - 0.00125437468370945*x_43 + 0.000839373960893715*x_44 + 0.00436593321654747*x_45 + 0.00450840910290365*x_46 + 0.00320686979702462*x_47 + 0.00230457027568988*x_48 - 0.000170235456066025*x_49 - 0.00401943831127688*x_50 - 0.0142493048084776*x_51 - 0.00174619238949325*x_52 + 0.00515594116053017*x_53 + 0.00666222215857414*x_54 + 0.00307773599258447*x_55 + 0.00320668160077548*x_56 + 0.000789127114888446*x_57 - 0.0067760406127756*x_58 + 0.00705189521663401*x_59 + 0.000291441727960337*x_6 + 0.000775071341652732*x_60 + 0.0021602606445896*x_61 - 0.00015530696505493*x_62 + 0.00210059479381813*x_63 + 0.00154476536288273*x_64 + 0.00167325825452422*x_65 - 0.000798903215489365*x_66 + 0.000672307628286313*x_67 - 0.00240780672316642*x_68 - 0.000471416163588446*x_69 - 0.000792570678446353*x_7 - 0.0014592865517162*x_70 + 0.00092950871663479*x_71 + 0.000197534309435094*x_72 + 0.000637055554814606*x_73 - 0.00145587990023487*x_74 + 0.000862557479387887*x_75 + 0.0033481544975236*x_76 + 0.00156587432723092*x_77 + 0.00306788981240005*x_78 + 2.006944301615e-5*x_79 - 0.00115884698079164*x_8 - 0.00518073969960748*x_80 - 0.00400262953233708*x_81 + 0.00117616071006838*x_82 - 0.000451050164617566*x_83 - 0.00367234292744164*x_84 - 0.000197391307144007*x_85 - 0.000796784401241633*x_86 - 0.0015301606529076*x_87 + 0.00245252038433433*x_88 - 0.000599881055848154*x_89 + 0.000508178614028506*x_9 - 0.00218749652112847*x_90 + 0.00040623957092266*x_92 - 0.00347727546499006*x_93 + 0.000150321748479941*x_94 - 0.000595885247291511*x_95 + 0.00107562630278821*x_96 - 0.000431926509998628*x_97 + 0.00234925113078364*x_98 + 0.00131589149093424*x_99 - 0.0307666848263848*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.0105436957513726*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.0274372439509024*std::sin(0.290159940719604*x_1 - 4.30847978591919) - 0.0475977203073079*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.0399299539063079*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.0185792569226531*std::sin(0.25519996881485*x_10 + 1.97087979316711) + 0.00946739477836243*std::sin(0.308879911899567*x_10 - 7.43832015991211) - 0.00494412917604998*std::sin(0.235679984092712*x_101 + 1.99255979061127) - 0.0101126461534174*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.0199087585184944*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.0185199940458806*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.0057434449632785*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.0100579368087687*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.0178481714927679*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.00723469283291499*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.00639552312797076*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.0244662934735199*std::sin(0.284479945898056*x_11 + 5.16048002243042) - 0.0094124343989943*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.0139293167295366*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.0328106042203728*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.0185889100542396*std::sin(0.280879944562912*x_112 - 7.43415975570679) - 0.0156888858309105*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.00904982143021448*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.0368154626600135*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.0111351759940532*std::sin(0.26463994383812*x_12 - 4.23848009109497) - 0.0280681606936191*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.00783460737061469*std::sin(0.292879939079285*x_12 - 7.44807958602905) - 0.0249245140365768*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.0323172186255571*std::sin(0.269039958715439*x_120 + 5.15144014358521) - 0.035958010952748*std::sin(0.270159959793091*x_120 + 5.14448022842407) - 0.0263865092035953*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.00516950653344238*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.029384157596204*std::sin(0.286319941282272*x_14 + 5.15823984146118) - 0.0153447759157199*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.00554840652064763*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.0154174271972643*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.00462498594701659*std::sin(0.328799843788147*x_15 - 4.33783960342407) - 0.00330027820645509*std::sin(0.332719832658768*x_15 + 5.06071949005127) + 0.0051866709284817*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.00550825122207177*std::sin(0.292719930410385*x_16 - 7.40079975128174) - 0.0334961574257215*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.00476024056395904*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.0227287091944817*std::sin(0.32535982131958*x_16 - 1.15327990055084) + 0.00840405368583675*std::sin(0.331919848918915*x_16 - 1.13143992424011) + 0.0151969905499697*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.0121542585993648*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.00830412670550722*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.0218745581116431*std::sin(0.331439822912216*x_18 + 2.01263976097107) + 0.0117889432918385*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.00189565034449069*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.00506028510902865*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.0456578825116875*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.0144790162337553*std::sin(0.36695984005928*x_2 - 7.40399980545044) + 0.00863691937126606*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.0631014902634401*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.0112807876232384*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.0130705946330412*std::sin(0.257119953632355*x_20 + 1.97903978824615) + 0.0108600992521289*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.0119871879326021*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.0195772751438326*std::sin(0.301119923591614*x_20 - 7.42543983459473) - 0.0154745063748825*std::sin(0.268319964408875*x_21 - 1.17343986034393) + 0.0100315875866959*std::sin(0.341759830713272*x_21 + 8.24199962615967) + 0.00474540232953392*std::sin(0.294639945030212*x_22 - 1.14359986782074) + 0.0137803141275555*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.00898733598322501*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.00506758116869668*std::sin(0.311359941959381*x_23 + 5.05335998535156) + 0.0301997010548072*std::sin(0.322639942169189*x_23 - 1.15719985961914) + 0.00607261928891543*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.0185551823255203*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.00347640797337874*std::sin(0.347999840974808*x_24 + 2.00127983093262) - 0.0126597941309327*std::sin(0.263039946556091*x_25 - 7.39647960662842) + 0.00518539209902889*std::sin(0.37527984380722*x_25 - 4.39687967300415) - 0.0110085624267785*std::sin(0.284639924764633*x_26 - 1.17999982833862) - 0.0151880561606738*std::sin(0.308879911899567*x_26 - 1.17639982700348) + 0.0108468463743182*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.0108221801208388*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.00965260738787106*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.0207952642006035*std::sin(0.361279845237732*x_28 - 1.1632798910141) - 0.0199630626990789*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.0199719079097405*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.0120835371493947*std::sin(0.282079964876175*x_29 + 1.99119985103607) - 0.00927258180964744*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.0131104854668156*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.0100853605660728*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.0322371181121482*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.0193372562144951*std::sin(0.35455983877182*x_3 - 7.410719871521) + 0.0219636125499922*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.02289113745169*std::sin(0.299279928207397*x_30 + 1.98919987678528) + 0.0564344898135272*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.0211001257403366*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.0317468642941625*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.005590424093541*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.0141862970503343*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.0505766481604203*std::sin(0.378239840269089*x_31 + 5.16991996765137) - 0.0226457271186393*std::sin(0.381119847297668*x_31 - 7.3982400894165) - 0.0134137697413282*std::sin(0.385039836168289*x_31 - 7.40535974502563) + 0.0249303641299547*std::sin(0.305999934673309*x_32 - 1.13367986679077) + 0.023391026280402*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.0496485628199121*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.0176008414053137*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.0135679361841795*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.0543971574454915*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.0109445900824117*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.00810706910853959*std::sin(0.236879989504814*x_35 + 1.97175979614258) - 0.011469558419086*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.0143719929627097*std::sin(0.244559973478317*x_35 - 7.43903970718384) + 0.0206018041934003*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.0206019089072276*std::sin(0.228959992527962*x_37 + 1.97391974925995) - 0.0114234818647356*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.010282671934244*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.00694523885712393*std::sin(0.30583992600441*x_4 + 2.03351974487305) + 0.01197152741618*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.00720221339911146*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.0032086796383695*std::sin(0.388719856739044*x_4 - 1.17711985111237) + 0.00959894159639252*std::sin(0.244799971580505*x_41 + 1.98759984970093) + 0.0171083751814064*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.010365119886343*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.0073007289734961*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.0119349236814964*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.0120810585626346*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.0166234368406754*std::sin(0.202639997005463*x_47 + 1.9793598651886) + 0.0194542145741084*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.0136180952251534*std::sin(0.208159998059273*x_48 + 8.21032047271729) - 0.0119066291353987*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00686448224479898*std::sin(0.285279929637909*x_5 - 1.16967988014221) + 0.011336604646967*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.0254733619216262*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.00396132745913775*std::sin(0.369679838418961*x_5 + 1.99015974998474) + 0.00827048764543545*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.0154812705857307*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.0135940979507726*std::sin(0.216719999909401*x_52 + 1.99559986591339) + 0.0136560954402615*std::sin(0.227119997143745*x_52 - 7.40711975097656) + 0.00870827530089243*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.0247695012867278*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.0323204715075614*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.00768226418520683*std::sin(0.201920002698898*x_57 - 7.38839960098267) + 0.00926900076657216*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.026299816543159*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.0176416075005731*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.00837995034737593*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.00361181146869917*std::sin(0.433199852705002*x_6 - 7.42935991287231) + 0.0130953767046778*std::sin(0.305199921131134*x_60 + 8.297119140625) - 0.0181952038079643*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.0299722809604092*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.0263175047198741*std::sin(0.361599832773209*x_7 + 1.99375987052917) - 0.0108772369834504*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.00802761280775416*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0162684921100575*std::sin(0.327199846506119*x_8 - 1.14231991767883) + 0.0119108513688991*std::sin(0.332799851894379*x_8 - 1.1379998922348) + 0.014686953863838*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.0337801962458395*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00638234801895786*std::sin(0.321279913187027*x_9 + 5.14111995697021) + 0.00255765041970158*std::sin(0.342559844255447*x_9 - 1.12967991828918) + 0.00678611306097046*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.00899611712058929*std::sin(0.359999865293503*x_91 - 7.40871953964233) - 0.0136787753797383*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.02310911449612*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.00365434956877413*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.00862861636950309*std::sin(0.269919961690903*x_92 + 2.01959991455078) + 0.00756195450500556*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.0126868879896352*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.00974963466031332*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.0189718175469011*std::sin(0.29479992389679*x_94 + 1.96527981758118) - 0.0107153206170791*std::sin(0.300399929285049*x_94 + 1.94839978218079) - 0.00900002429013255*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.010632379297495*std::sin(0.265119940042496*x_95 - 7.42375993728638) - 0.00923544641678687*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.0117868953298448*std::sin(0.281999945640564*x_96 - 7.44087982177734) + 0.0137489796934749*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00490478997667125*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.0252442770073474*std::sin(0.27167996764183*x_97 - 7.43623971939087) - 0.00962241591474619*std::sin(0.276719957590103*x_97 - 1.20031988620758) - 0.0190171489401588*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.0260884936693328*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.237795202316682);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0006459448271597*x_10 - 0.000915757171393374*x_100 + 0.00335842692427862*x_101 + 0.00177292473941493*x_102 + 0.00326377189452054*x_103 + 0.00285098768160978*x_104 - 0.00243470109207025*x_105 - 0.00030513323225263*x_106 + 0.000123305290152965*x_107 - 0.000253015405931726*x_108 + 0.00298316681560269*x_109 + 0.00176463386414268*x_11 - 0.000853406549212364*x_110 - 0.00198499481137864*x_111 - 3.96166717575853e-5*x_112 + 0.000331963569371762*x_113 - 0.00528642419572856*x_114 - 0.00169962476353484*x_115 - 0.00169685412656504*x_116 - 0.00308606439823089*x_117 - 0.00471235903586527*x_118 - 0.00725793129548368*x_119 + 0.00179121723005527*x_12 + 0.0011447179709153*x_120 - 0.000387525667738642*x_13 + 0.000805146880709588*x_14 + 0.000135040603524002*x_15 + 0.000441805524534508*x_17 + 0.000170714073739457*x_18 + 0.000644451969479978*x_19 + 0.00033145767593456*x_2 - 0.000386684506539424*x_20 + 0.000524692141767482*x_21 - 0.000518966127895894*x_22 + 0.00035943810155704*x_23 - 0.00134055332963823*x_24 + 0.000733569942396463*x_25 - 0.00101624752965157*x_26 + 0.00213508277579743*x_27 - 0.00130716665327856*x_28 - 0.000618319011713894*x_3 - 0.000204072382358439*x_30 + 1.81324183461413e-5*x_32 + 0.00112840881142593*x_33 - 0.000544721116811266*x_34 - 0.000204497356252246*x_35 - 0.00287865189888606*x_36 - 0.00420879218845916*x_37 - 0.00513424316924336*x_38 - 0.00443108737025308*x_39 - 0.000402866900873711*x_4 - 0.00138651127236611*x_40 + 0.00438222970547265*x_41 + 0.002233604340527*x_42 - 0.00230741952810643*x_43 + 0.00140489198876361*x_44 - 0.00390028353039427*x_45 - 0.00511778073651539*x_46 - 0.00315106027076817*x_47 + 0.000236216048431704*x_48 - 0.00377044447894269*x_49 + 0.00567892734763688*x_50 + 0.0153914685753345*x_51 - 6.0867788378988e-5*x_52 - 0.00647912716914531*x_53 + 0.0017599366234194*x_54 + 0.00402531988473*x_55 - 0.00501573880649373*x_56 + 0.000725922046021855*x_57 + 0.0024760175037764*x_58 - 0.00303100009921947*x_59 + 0.000342689577354277*x_6 - 0.00403502059056914*x_60 - 6.21942534081263e-5*x_61 + 0.000647969016755754*x_62 - 0.000689221120283795*x_63 + 0.00320287476236247*x_64 - 0.00160663107969763*x_65 - 0.00225562814877065*x_66 + 0.00182859691807497*x_67 - 0.000306919774704041*x_68 + 0.00226983456230901*x_69 - 0.000372299175615256*x_7 + 0.00111679070549346*x_70 + 0.000973196301327855*x_71 - 0.00117553025703459*x_72 + 0.00184179582033295*x_73 - 0.00158485033902611*x_74 + 0.00360405171770585*x_75 + 0.000815090385332059*x_76 - 0.00149830384420715*x_77 - 6.95133451849928e-5*x_78 - 0.00327609272487718*x_79 + 0.00138486274323604*x_8 - 0.00062300959726957*x_80 - 0.00251071921820191*x_81 + 0.000128639484781372*x_82 - 0.00231393400008173*x_83 - 0.00208378065710384*x_84 + 0.00132499410923849*x_85 + 0.000221949183287906*x_86 - 0.00126816548913147*x_87 - 0.00192218184745672*x_88 + 0.000501336085038524*x_89 + 0.000125039842187439*x_9 - 0.00180089876045191*x_90 + 0.000328879056010939*x_92 - 0.00283419693299645*x_93 + 3.69874040118843e-5*x_94 - 0.00144444579089736*x_95 - 0.000331723284302159*x_96 - 0.000106277637735795*x_97 - 0.00234231280117606*x_98 + 0.00380116714862165*x_99 - 0.0327670282865743*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.00259432808943442*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.0128882679890448*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.0480977355665148*std::sin(0.332159847021103*x_1 - 4.25568008422852) + 0.0562772409022154*std::sin(0.362959831953049*x_1 - 4.21336030960083) - 0.0261855878940828*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.00956685000066202*std::sin(0.308879911899567*x_10 - 7.43832015991211) - 0.00526557935891668*std::sin(0.235679984092712*x_101 + 1.99255979061127) - 0.0107701354380884*std::sin(0.231359988451004*x_107 + 5.18703985214233) + 0.0280593862401715*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.00869951248915335*std::sin(0.257119953632355*x_107 - 7.43703985214233) - 0.00809480613389784*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.00247480471743961*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.00838393308470971*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.00339839745624171*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.00157364985568386*std::sin(0.272159963846207*x_11 - 4.23663997650146) + 0.034482771881589*std::sin(0.284479945898056*x_11 + 5.16048002243042) - 0.0100243983366345*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.00342737674817306*std::sin(0.2743199467659*x_112 + 1.97775983810425) - 0.0462432358972863*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.00873188483624679*std::sin(0.280879944562912*x_112 - 7.43415975570679) - 0.0167089229374956*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.00425102915053421*std::sin(0.291439920663834*x_113 - 7.43760013580322) - 0.0518876797580472*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.00273986470620677*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.0283630174336913*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.00368019905942872*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.025186346688774*std::sin(0.263919949531555*x_120 + 5.15687990188599) - 0.0455478586864264*std::sin(0.269039958715439*x_120 + 5.15144014358521) - 0.0382958764867384*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.0266637001521075*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.00127198245515368*std::sin(0.301519930362701*x_13 + 8.32544040679932) + 0.0414140051258361*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.0155059731759549*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.00136521265669519*std::sin(0.32367992401123*x_14 + 5.12024021148682) + 0.0217293079403165*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.00217252353907636*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.00333494771272979*std::sin(0.332719832658768*x_15 + 5.06071949005127) + 0.00552389033741345*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.00258742525408458*std::sin(0.292719930410385*x_16 - 7.40079975128174) - 0.0356739617561561*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.0011712805546325*std::sin(0.322159916162491*x_16 + 5.16720008850098) + 0.0320338221710838*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.00849233848298631*std::sin(0.331919848918915*x_16 - 1.13143992424011) + 0.0161850463262984*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.00299061498303165*std::sin(0.352239847183228*x_17 + 1.99975979328156) + 0.0117038286641879*std::sin(0.373839855194092*x_17 - 1.17871987819672) + 0.0308299824078679*std::sin(0.331439822912216*x_18 + 2.01263976097107) + 0.0125554196200306*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.00046643407135662*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.00237699933356422*std::sin(0.275839954614639*x_19 + 2.01927995681763) + 0.0643501782953315*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.00680131873931275*std::sin(0.36695984005928*x_2 - 7.40399980545044) + 0.00919846200343419*std::sin(0.369359821081161*x_2 - 4.22071981430054) + 0.0889351832756165*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.00277569316224831*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.00613973206303999*std::sin(0.257119953632355*x_20 + 1.97903978824615) + 0.0115661853526819*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.00294950642547044*std::sin(0.295519918203354*x_20 + 1.97047984600067) - 0.0275921938718885*std::sin(0.301119923591614*x_20 - 7.42543983459473) - 0.0164806052705331*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.0101369696687585*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.00479525290137903*std::sin(0.294639945030212*x_22 - 1.14359986782074) + 0.0146762625015829*std::sin(0.363759845495224*x_22 + 2.0052797794342) + 0.012666743201955*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.00124690321889525*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.0305169496804429*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.00613641230858544*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.0087160416995537*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.000855387244505433*std::sin(0.347999840974808*x_24 + 2.00127983093262) - 0.0134828901693931*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.00523986477456346*std::sin(0.37527984380722*x_25 - 4.39687967300415) - 0.0117243010895807*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.0153476070759067*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.0109607927706249*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.00266285053537853*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.00453417956375403*std::sin(0.316079914569855*x_28 - 1.18503987789154) + 0.0293088265463211*std::sin(0.361279845237732*x_28 - 1.1632798910141) - 0.0212609920060808*std::sin(0.220639988780022*x_29 - 1.18039989471436) - 0.0281483889350488*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.00567607538554743*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.00936999051676899*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.00322589929705184*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.00248155246752361*std::sin(0.346159845590591*x_3 - 7.39567947387695) - 0.0454349650953124*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.0090834101526818*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.0221943408569657*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.00563247672262285*std::sin(0.299279928207397*x_30 + 1.98919987678528) + 0.0601036651980263*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.00991149386689967*std::sin(0.345839858055115*x_30 - 1.15679979324341) + 0.0447440018078829*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.00262602483029639*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.00349060801739768*std::sin(0.375599831342697*x_31 + 5.19080018997192) + 0.0712826821495758*std::sin(0.378239840269089*x_31 + 5.16991996765137) - 0.0241180739898939*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.0135546817327187*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.0251922582375312*std::sin(0.305999934673309*x_32 - 1.13367986679077) + 0.0249118299260061*std::sin(0.306239932775497*x_32 - 1.14095985889435) + 0.0699746395105047*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.00433077341496137*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.00333845729128596*std::sin(0.235679984092712*x_33 + 1.98999989032745) + 0.0766673044787074*std::sin(0.241439983248711*x_33 + 1.98831987380981) + 0.0154252953581942*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.00199478414468971*std::sin(0.236879989504814*x_35 + 1.97175979614258) - 0.0122152694472435*std::sin(0.242319971323013*x_35 + 1.98367977142334) + 0.0202558738761675*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.0208182266690438*std::sin(0.248479977250099*x_35 + 1.97895979881287) - 0.0290363117708078*std::sin(0.228959992527962*x_37 + 1.97391974925995) - 0.0121661971546559*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.00253010189809161*std::sin(0.237199977040291*x_38 + 1.97767984867096) + 0.00978861336035863*std::sin(0.30583992600441*x_4 + 2.03351974487305) + 0.0127498747327846*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.0017721399562372*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.00150723312969403*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.00969977872135237*std::sin(0.244799971580505*x_41 + 1.98759984970093) + 0.0182207025771498*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.00486887251040286*std::sin(0.203439995646477*x_44 + 1.98855984210968) - 0.0102896408086842*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.0056062662529508*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.00297260375471902*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.0078086308262218*std::sin(0.202639997005463*x_47 + 1.9793598651886) + 0.0207190603355558*std::sin(0.215279996395111*x_47 + 1.98183989524841) - 0.0191933310870713*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.0120317085764933*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00322449612414876*std::sin(0.285279929637909*x_5 - 1.16967988014221) + 0.0120736714805982*std::sin(0.347439825534821*x_5 + 2.02791976928711) + 0.0359021332410357*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.000974704064023381*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.00835736932794252*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.00727211393669337*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.00638564054656516*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.0137995530692662*std::sin(0.227119997143745*x_52 - 7.40711975097656) + 0.00927445724886528*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.00609465736348419*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.0151820969725363*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.00189025880830671*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.00936637185474536*std::sin(0.211840003728867*x_57 + 5.19672012329102) + 0.0370669376367502*std::sin(0.247519969940186*x_57 - 7.42671966552734) + 0.0248640656470991*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.00206192791284146*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.00169659876253603*std::sin(0.433199852705002*x_6 - 7.42935991287231) + 0.0139467928158948*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.0183863448855122*std::sin(0.29751992225647*x_7 - 4.18368005752563) - 0.0422429056631433*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.00647555120600895*std::sin(0.361599832773209*x_7 + 1.99375987052917) - 0.0115844373200338*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.00377086070903346*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0040029423315226*std::sin(0.327199846506119*x_8 - 1.14231991767883) + 0.0126852537387194*std::sin(0.332799851894379*x_8 - 1.1379998922348) + 0.0156418488184753*std::sin(0.30991992354393*x_9 - 7.43063974380493) - 0.0476097780205776*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00299802020257113*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.0025845186022387*std::sin(0.342559844255447*x_9 - 1.12967991828918) + 0.00722732266669233*std::sin(0.356239855289459*x_91 - 7.3982400894165) - 0.01267911932901*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.0138224712620825*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.0108551887043931*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.000899170647412609*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.00212311340807053*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.00764139302889954*std::sin(0.271199941635132*x_92 - 7.38695955276489) + 0.0178808884519982*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.00457975679052359*std::sin(0.291919946670532*x_94 - 7.43031978607178) + 0.0267388624826628*std::sin(0.29479992389679*x_94 + 1.96527981758118) - 0.011411993711407*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.00909456977359782*std::sin(0.30447992682457*x_94 + 1.94823980331421) - 0.0149852657604577*std::sin(0.265119940042496*x_95 - 7.42375993728638) - 0.00983590320782555*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.00290022344750027*std::sin(0.281999945640564*x_96 - 7.44087982177734) + 0.0146428908109487*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00230395763373459*std::sin(0.270639955997467*x_97 + 1.98279988765717) + 0.0355792611701541*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.00972349963801581*std::sin(0.276719957590103*x_97 - 1.20031988620758) - 0.0202535782054033*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.0122547110942533*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.1299997351643);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000122336282232055*x_10 + 0.00115909356829136*x_100 - 0.000498962411011562*x_101 + 0.00138373665262964*x_102 + 0.0030238225291012*x_103 - 0.00163623554612873*x_104 - 9.44633697971852e-5*x_105 - 0.000374423947592248*x_106 + 0.000768957279401724*x_107 + 0.000273619004611152*x_108 - 0.000129259837107869*x_109 + 0.00091496457683053*x_11 + 0.00154346936464089*x_110 + 0.002567371961791*x_111 + 0.000153107988343582*x_112 + 0.000830200359442909*x_113 + 0.00450091651775429*x_114 - 0.00121831618698314*x_115 + 0.000709431056306601*x_116 + 0.00569649837615628*x_117 + 0.00555986009858346*x_118 + 0.00619336041631051*x_119 + 0.00159220946172452*x_12 + 0.000759227417552915*x_120 - 0.00032386733527038*x_13 + 0.000334122845796512*x_14 + 0.000429387686465496*x_15 + 0.000387232412308254*x_17 + 0.000234954056239262*x_18 + 0.000563276674531412*x_19 + 0.000372430133034861*x_2 - 0.000434483714419786*x_20 - 0.00024196157400963*x_21 + 0.000357538429420672*x_22 + 0.000153500081601027*x_23 + 0.00169180578727544*x_24 - 0.000416895993374336*x_25 + 0.000638522975404514*x_26 + 0.00242551027749504*x_27 - 0.000500629163932474*x_28 - 0.00023680877193546*x_3 - 0.000229298369078952*x_30 + 9.30808731648406e-6*x_32 - 7.54824181474365e-5*x_33 - 0.000329376706025954*x_34 - 0.000104976579055774*x_35 - 0.00182571440658336*x_36 - 0.00143412916135592*x_37 - 0.00172331937448394*x_38 - 0.0011634852010703*x_39 - 0.00045266646205943*x_4 - 0.00107745461878155*x_40 - 0.0017208926576353*x_41 - 0.00276916120199569*x_42 - 0.00387051485611966*x_43 + 0.0013278831147698*x_44 - 0.000720210148993984*x_45 + 0.000721478682347952*x_46 - 0.00410098866190685*x_47 - 0.00126718984682949*x_48 + 0.00139825802014689*x_49 + 0.000171530577151499*x_50 - 0.00482317897141417*x_51 - 0.000895955248642098*x_52 - 0.0017839322375343*x_53 + 0.00450461172261715*x_54 + 0.00409286044999389*x_55 + 0.00191659954811234*x_56 + 0.000289798144326473*x_57 - 0.00303549410024128*x_58 + 0.00531748388393495*x_59 + 0.000142892701149687*x_6 - 0.000937340927493291*x_60 + 0.00233350062968316*x_61 - 0.000428969767020733*x_62 + 0.00134760056849784*x_63 + 0.0002325819265016*x_64 - 0.000554511772195295*x_65 + 0.000302315638440684*x_66 + 0.00100860375299185*x_67 - 0.000142518970210276*x_68 + 0.000931669635605387*x_69 - 0.000191115888037036*x_7 - 9.65724937321451e-7*x_70 - 0.000971116530831656*x_71 - 0.00117214168627624*x_72 + 0.00100874535292739*x_73 - 0.000350535159616377*x_74 - 0.000294222950639405*x_75 + 0.00163081945225926*x_76 + 0.000846119239869885*x_77 - 0.000300785579182985*x_78 - 0.000634822317922571*x_79 + 0.000217014991015248*x_8 - 0.00272055287246259*x_80 + 0.000453403982341492*x_81 - 0.00140609267843078*x_82 + 0.00182168692736897*x_83 - 0.000285430218110011*x_84 - 0.0013363295852669*x_85 - 0.000159511693730135*x_86 + 0.000222694202832898*x_87 + 0.000837623907113154*x_88 + 0.000233986411983376*x_89 + 0.000397588333817926*x_9 - 0.000549067094799308*x_90 + 0.00013663086142954*x_92 - 0.00203715932319892*x_93 + 0.000117608596396748*x_94 - 0.000983730903630081*x_95 + 0.00260876351660925*x_96 - 0.00033793028022331*x_97 + 0.00137471518937724*x_98 + 0.000202784186289007*x_99 - 0.0125493791740445*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.00824916734067095*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.00661605757765922*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.0540432379645637*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.0365028931890627*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.0169846584990078*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.0107494364353612*std::sin(0.308879911899567*x_10 - 7.43832015991211) - 0.00201665379503282*std::sin(0.235679984092712*x_101 + 1.99255979061127) - 0.00412483281017473*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.018200053208993*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.00446580375072338*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.00525050338209119*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.00786911968951925*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.00430380436400227*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.00174453179134524*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.00500372371868697*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.0223664294602422*std::sin(0.284479945898056*x_11 + 5.16048002243042) - 0.00383922443676811*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.0108980064820437*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.0299945746026938*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.00448242175653115*std::sin(0.280879944562912*x_112 - 7.43415975570679) - 0.00639931725570725*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.00218222135419196*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.033655708802912*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.00871192912891184*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.0318690533453968*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.00188919169706312*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.0282997049970693*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.0295435347214347*std::sin(0.269039958715439*x_120 + 5.15144014358521) - 0.0146668617804248*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.029959678462271*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.00404451394166096*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.0268622089747861*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.0174227120746964*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.00434095737796054*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.0140941985445914*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.00111524223701485*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.00374719039712773*std::sin(0.332719832658768*x_15 + 5.06071949005127) + 0.00211558380435877*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.00132822769308213*std::sin(0.292719930410385*x_16 - 7.40079975128174) - 0.0136626998580094*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.00372431279504969*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.0207779765035082*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.00954210139221544*std::sin(0.331919848918915*x_16 - 1.13143992424011) + 0.00619867879143061*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.00950923807478958*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.00759140996933851*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.0199971344865768*std::sin(0.331439822912216*x_18 + 2.01263976097107) + 0.00480857525812193*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.0014831172370531*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.00122020774756438*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.0417392119328145*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.00349138584187998*std::sin(0.36695984005928*x_2 - 7.40399980545044) + 0.00352290071866036*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.057685690410806*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.00882585262634773*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.00315176724095134*std::sin(0.257119953632355*x_20 + 1.97903978824615) + 0.00442971038809634*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.00937852547454559*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.0178970199961919*std::sin(0.301119923591614*x_20 - 7.42543983459473) - 0.0063118743252777*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.011390030270566*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.00538800820032597*std::sin(0.294639945030212*x_22 - 1.14359986782074) + 0.00562083266689273*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.00821598157162051*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.00396476966509297*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.0342892394851324*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.00689495226200295*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.00447428884800836*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.00271986899025521*std::sin(0.347999840974808*x_24 + 2.00127983093262) - 0.00516378536429678*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.00588757985336455*std::sin(0.37527984380722*x_25 - 4.39687967300415) - 0.00449026682056781*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.017244769875763*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.0123156885663354*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.00846704769492802*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.00232757365743338*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.0190104729330292*std::sin(0.361279845237732*x_28 - 1.1632798910141) - 0.00814270515980722*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.0182577826891978*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.00291375393480621*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.0105282425723175*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.0102573700041674*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.00789057546446254*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.0294703089798721*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.00466287360122556*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.0249378485342808*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.0179095478388314*std::sin(0.299279928207397*x_30 + 1.98919987678528) + 0.0230189835258543*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.0050879617152409*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.0290221320850163*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.0013480423818291*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.0110990625177552*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.0462358155982989*std::sin(0.378239840269089*x_31 + 5.16991996765137) - 0.00923693332211185*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.0152302157635302*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.0283063472897357*std::sin(0.305999934673309*x_32 - 1.13367986679077) + 0.00954093233376475*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.0453873848654611*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.0137705307050558*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.0106152698911357*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.0497284227445031*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.0100052507877611*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.0063428015466039*std::sin(0.236879989504814*x_35 + 1.97175979614258) - 0.00467830181809283*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.0131384905993812*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.0233916288287516*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.0188337127084067*std::sin(0.228959992527962*x_37 + 1.97391974925995) - 0.00465950771808366*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.00804494775788245*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.00634915113523516*std::sin(0.30583992600441*x_4 + 2.03351974487305) + 0.0048830492360774*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.00563486133832708*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.000773722363430646*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.0108987968657428*std::sin(0.244799971580505*x_41 + 1.98759984970093) + 0.00697831074146668*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.00249938478114274*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.00667413066759698*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.00287791814670044*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.00945196789490486*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.00400847896652072*std::sin(0.202639997005463*x_47 + 1.9793598651886) + 0.00793515182416865*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.012449297502538*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.0135189834211737*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00165526136129703*std::sin(0.285279929637909*x_5 - 1.16967988014221) + 0.00462407149368978*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.0232870644322123*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.0030992598679043*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.00939044830339548*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.00373306363255001*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.00327800178908615*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.0155053563653874*std::sin(0.227119997143745*x_52 - 7.40711975097656) + 0.00355200598698065*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.0193791404719339*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.0077935706958675*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.0060104430470468*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.01052417659685*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.0240425870868641*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.016127484539246*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.00655629812848294*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.00087093123053191*std::sin(0.433199852705002*x_6 - 7.42935991287231) + 0.00534145451878579*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.0206591349934164*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.0273998555845454*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.0205902660264905*std::sin(0.361599832773209*x_7 + 1.99375987052917) - 0.00443670067287188*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.0019357319066848*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0127281284438408*std::sin(0.327199846506119*x_8 - 1.14231991767883) + 0.00485830016972828*std::sin(0.332799851894379*x_8 - 1.1379998922348) + 0.0059906406552759*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.0308809496339704*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00153900231559868*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.00290399853962915*std::sin(0.342559844255447*x_9 - 1.12967991828918) + 0.00276797797359765*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.00822400905194365*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.0155311075433483*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.00557239759024779*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.0028590867780116*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.00675084923056675*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.00858596807058582*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.0115980128169919*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.00235097025011703*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.0173435268956701*std::sin(0.29479992389679*x_94 + 1.96527981758118) - 0.0043706568372249*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.0102187762619339*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.0097198360597343*std::sin(0.265119940042496*x_95 - 7.42375993728638) - 0.00376703306124281*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.00922182072545152*std::sin(0.281999945640564*x_96 - 7.44087982177734) + 0.00560805170928547*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00118271255487801*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.0230776411462058*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.0109254499946039*std::sin(0.276719957590103*x_97 - 1.20031988620758) - 0.00775687774636895*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.00629082777189898*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.066813268199936);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00079309067400157*x_10 - 0.00092568929799278*x_100 - 0.00504817229675601*x_101 - 0.000509191834410416*x_102 - 0.00499156645733897*x_103 - 0.00495957113453058*x_104 + 0.00144596545507917*x_105 - 0.00138838422491922*x_106 - 0.00357500157418623*x_107 - 0.000275197488691733*x_108 - 0.00195756551868384*x_109 + 5.70070164354194e-5*x_11 + 0.0081797118656157*x_110 + 0.00621792259293852*x_111 + 0.000315047195500349*x_112 - 0.000450391638868272*x_113 + 0.0051062489823531*x_114 - 0.000755737333659753*x_115 - 0.00012446410513175*x_116 + 0.0100080970540072*x_117 + 0.0107240301024003*x_118 + 0.00621520397637954*x_119 + 0.000528646930964319*x_12 - 0.000195201059542757*x_120 + 1.35426518468833e-5*x_13 - 3.67687227016491e-5*x_14 - 0.0014829548394881*x_15 + 0.000382991698708157*x_17 + 0.000240424025668247*x_18 - 0.000704525443182357*x_19 + 0.00037607293569438*x_2 - 0.000438733473743794*x_20 + 0.00147006006414246*x_21 + 0.00122235169181714*x_22 + 6.48884946480177e-6*x_23 + 0.00250928926254071*x_24 + 0.000347684515908165*x_25 + 0.00150066982249321*x_26 - 0.00464081579462753*x_27 + 0.000280454134909609*x_28 + 0.000132661067426596*x_3 - 0.00023154117554012*x_30 + 8.58548279459529e-6*x_32 - 0.00137639623737546*x_33 - 0.00479990088931289*x_34 - 9.68270475635432e-5*x_35 + 0.00629209834531466*x_36 - 0.003558751932784*x_37 - 0.000620014093797543*x_38 + 0.00140511204423402*x_39 - 0.000457094069939674*x_4 - 0.00164981589706701*x_40 - 0.00328398624342649*x_41 + 0.00167275941017019*x_42 + 0.00307550847469716*x_43 - 0.00126591166820506*x_44 - 0.00956116030526257*x_45 - 0.00265855965310061*x_46 - 0.00433048195786766*x_47 - 0.000304569732424086*x_48 + 0.00179279271301934*x_49 + 0.00628923194790382*x_50 - 0.00656749112475287*x_51 - 0.00384408996641322*x_52 + 3.52322832187319e-5*x_53 + 0.00159146403013351*x_54 - 0.00285404391139611*x_55 + 0.00361198332748309*x_56 - 9.35754859753218e-5*x_57 - 0.000492897071866373*x_58 - 0.00118940834471568*x_59 - 5.23083185550842e-5*x_6 - 0.000207921463745604*x_60 + 0.00228973720465464*x_61 + 0.000889782505175974*x_62 + 0.00364619735045019*x_63 - 0.00290612031938307*x_64 - 0.00246052237101918*x_65 + 0.0016328810323542*x_66 + 0.00250296004621555*x_67 + 0.000631203056006404*x_68 + 0.00034478600269521*x_69 - 0.000176279198155992*x_7 + 0.0020481921879603*x_70 - 0.00160512108471542*x_71 - 0.00175911291118911*x_72 + 0.000640776552745789*x_73 + 0.0029011399141438*x_74 + 0.00120813297249044*x_75 + 0.00246919275079939*x_76 + 0.00176867931464045*x_77 - 0.000960669036023955*x_78 + 0.00279116563942748*x_79 - 0.00023336056254767*x_8 - 0.00192277669791683*x_80 + 0.00383006772458032*x_81 - 0.00483988661924587*x_82 + 0.00521510782052578*x_83 + 0.00095730294321672*x_84 - 0.001355346916563*x_85 - 6.64101803687227e-5*x_86 - 0.00238821659628067*x_87 + 0.00097964798481626*x_88 + 0.000332691272293312*x_89 - 0.00137313100106024*x_9 - 0.000613376169005084*x_90 - 1.42197696183314e-5*x_92 + 0.0062454395130655*x_93 - 0.000406178944318597*x_94 + 4.79629503141926e-5*x_95 + 0.00370687435304718*x_96 + 0.00116709295646511*x_97 + 0.000902940958407378*x_98 + 0.00347058892294239*x_99 + 0.00703020425790464*std::sin(0.248799979686737*x_1 + 5.06423997879028) + 0.0284897378643814*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.00610244044449949*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.0545718440936707*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.0705638342638547*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.032833085891155*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.0108545785067505*std::sin(0.308879911899567*x_10 - 7.43832015991211) + 0.00112973621244006*std::sin(0.235679984092712*x_101 + 1.99255979061127) + 0.00231074515982525*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.0351825684496022*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.00411911491182242*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.0101497612404789*std::sin(0.262639969587326*x_108 - 7.44599962234497) - 0.0271771862443042*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.00396969184560709*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.0016091004703721*std::sin(0.261039972305298*x_11 + 1.96351981163025) - 0.0172811110750949*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.0432366008177023*std::sin(0.284479945898056*x_11 + 5.16048002243042) + 0.00215074639215957*std::sin(0.209519997239113*x_111 + 1.9819997549057) + 0.0376379015112209*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.0579825873011481*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.00413444283023274*std::sin(0.280879944562912*x_112 - 7.43415975570679) + 0.0035849189664939*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.00201281135999167*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.0650599349947641*std::sin(0.256719976663589*x_116 + 5.1450400352478) - 0.0300879551748285*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.0321807699923205*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.00174253015247329*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.0285765092389465*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.0571106809768272*std::sin(0.269039958715439*x_120 + 5.15144014358521) + 0.00821642510827172*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.0302527191877659*std::sin(0.291599929332733*x_13 + 5.1430401802063) - 0.0139683361032878*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.0519274034592355*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.0175931265934265*std::sin(0.291999936103821*x_14 - 7.42631959915161) + 0.0149921480158129*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.0272455305126445*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.0010286638610212*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.00378384230558946*std::sin(0.332719832658768*x_15 + 5.06071949005127) - 0.00118515713511298*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.00122511485104644*std::sin(0.292719930410385*x_16 - 7.40079975128174) + 0.00765389023505727*std::sin(0.321839928627014*x_16 - 7.42136001586914) - 0.0128624733714394*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.0401659584279508*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.00963543431360318*std::sin(0.331919848918915*x_16 - 1.13143992424011) - 0.00347252062660037*std::sin(0.337999850511551*x_17 + 2.00311970710754) + 0.0328415813199779*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.0146749736282789*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.0386565107690044*std::sin(0.331439822912216*x_18 + 2.01263976097107) - 0.00269377996993047*std::sin(0.334559857845306*x_18 + 2.01887989044189) + 0.0051221680396111*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.0011254806993477*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.0806861751444272*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.00322034291853599*std::sin(0.36695984005928*x_2 - 7.40399980545044) - 0.00197354078548567*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.111512352636305*std::sin(0.377119839191437*x_2 + 5.18016004562378) - 0.0304814070766393*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.0029070895555348*std::sin(0.257119953632355*x_20 + 1.97903978824615) - 0.00248153860041848*std::sin(0.273119956254959*x_20 - 1.17575979232788) - 0.0323901457310594*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.0345967741868355*std::sin(0.301119923591614*x_20 - 7.42543983459473) + 0.00353593314390429*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.0115014380995285*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.00544070922760783*std::sin(0.294639945030212*x_22 - 1.14359986782074) - 0.00314880929165704*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.0158823345572077*std::sin(0.3018399477005*x_23 + 2.02303981781006) + 0.0136929272720952*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.0346246283855188*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.00696239296620325*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.00412694129486695*std::sin(0.314239919185638*x_24 - 1.16023993492126) + 0.00939347589371709*std::sin(0.347999840974808*x_24 + 2.00127983093262) + 0.00289276986148192*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.00594516727620061*std::sin(0.37527984380722*x_25 - 4.39687967300415) + 0.00251546251677324*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.0174134439114924*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.0124361504169855*std::sin(0.203599989414215*x_28 - 4.38679981231689) - 0.0292422203783412*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.00214687968747975*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.0367491928482453*std::sin(0.361279845237732*x_28 - 1.1632798910141) + 0.00456157071130152*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.035294165452399*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.00268755367503496*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.0106312211088016*std::sin(0.301919937133789*x_29 + 2.01615977287292) + 0.0354253672556639*std::sin(0.3504798412323*x_29 - 1.14943993091583) - 0.0272512869842416*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.0569691281123812*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.00430088585501326*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.0251817698846375*std::sin(0.363599836826324*x_3 - 7.40783977508545) - 0.0618533122345903*std::sin(0.299279928207397*x_30 + 1.98919987678528) - 0.0128953116924542*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.00469297357024154*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.0561027562342484*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.00124339128781945*std::sin(0.372399836778641*x_31 + 5.19208002090454) + 0.0383322787152368*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.0893785709542078*std::sin(0.378239840269089*x_31 + 5.16991996765137) + 0.00517456099385379*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.0153791851018497*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.0285832165010105*std::sin(0.305999934673309*x_32 - 1.13367986679077) - 0.00534486225867981*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.0877384673792325*std::sin(0.311199933290482*x_32 - 1.14927983283997) - 0.0475585951695029*std::sin(0.311919927597046*x_32 - 1.14735984802246) + 0.0366614282470745*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.0961301385775476*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.0193411753610646*std::sin(0.213759988546371*x_34 - 1.18095993995667) - 0.021905817390515*std::sin(0.236879989504814*x_35 + 1.97175979614258) + 0.0026208003523667*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.0253980490897016*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.0236204263404178*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.0364074972152418*std::sin(0.228959992527962*x_37 + 1.97391974925995) + 0.00261027183457506*std::sin(0.234239995479584*x_38 + 1.95567977428436) + 0.0277844348755898*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.0122735599642041*std::sin(0.30583992600441*x_4 + 2.03351974487305) - 0.00273550054189378*std::sin(0.333039849996567*x_4 + 2.02287983894348) + 0.0194608395976628*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.00071365682477682*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.0110053998569792*std::sin(0.244799971580505*x_41 + 1.98759984970093) - 0.00390927305703757*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.0023053527868795*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.0129017787122894*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.0026544998873177*std::sin(0.231039986014366*x_46 + 1.98183989524841) - 0.032643790155733*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.00369729312042597*std::sin(0.202639997005463*x_47 + 1.9793598651886) - 0.00444529863730391*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.0240657681877591*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.0136512149040544*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00152676027359636*std::sin(0.285279929637909*x_5 - 1.16967988014221) - 0.00259042034294644*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.0450162825882166*std::sin(0.34911984205246*x_5 + 1.99775981903076) + 0.0107037592479012*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.00948229788005282*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.00344325880265741*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.0030235242756062*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.0156570169008665*std::sin(0.227119997143745*x_52 - 7.40711975097656) - 0.00198984565431106*std::sin(0.203919991850853*x_53 + 2.00807976722717) - 0.0669287710239996*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.00718854097977101*std::sin(0.245759963989258*x_56 + 5.15263986587524) - 0.0207579674150761*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.0106271153633345*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.046476785324515*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.0311760807623111*std::sin(0.180560007691383*x_6 + 8.18007946014404) - 0.0226431598884283*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.000803319182638677*std::sin(0.433199852705002*x_6 - 7.42935991287231) - 0.00299230071707758*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.0208612055167764*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.0529667294673708*std::sin(0.327359855175018*x_7 + 2.03519988059998) + 0.0711115749538038*std::sin(0.361599832773209*x_7 + 1.99375987052917) + 0.00248545458136953*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.00178545735710492*std::sin(0.316959917545319*x_8 - 7.4203200340271) - 0.0439585024638024*std::sin(0.327199846506119*x_8 - 1.14231991767883) - 0.00272163603200738*std::sin(0.332799851894379*x_8 - 1.1379998922348) - 0.00335597696572937*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.0596960410944863*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00141952663873438*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.00293240304470288*std::sin(0.342559844255447*x_9 - 1.12967991828918) - 0.00155063053445861*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.0158978524995293*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.0156830199554916*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.00513980176689919*std::sin(0.365199834108353*x_91 + 2.00367975234985) + 0.00987428542459951*std::sin(0.374399840831757*x_91 + 1.98335981369019) + 0.0233150713275704*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.0086699488888596*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.0224201476296541*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.00216845995817424*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.0335268152877115*std::sin(0.29479992389679*x_94 + 1.96527981758118) + 0.00244845660337122*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.010318727855648*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.0187894394353496*std::sin(0.265119940042496*x_95 - 7.42375993728638) + 0.00211030454172512*std::sin(0.281519949436188*x_96 + 1.96807980537415) + 0.0318489423538673*std::sin(0.281999945640564*x_96 - 7.44087982177734) - 0.00314164935638498*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00109089632978352*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.0446114459094302*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.0110323136846401*std::sin(0.276719957590103*x_97 - 1.20031988620758) + 0.00434542890164291*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.00580245884713102*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.227114639979529);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00169487298402333*x_10 - 0.00861167212647248*x_100 - 0.0128112901284391*x_101 - 0.00437470715545777*x_102 - 0.0190400238183748*x_103 - 0.00781299482851359*x_104 + 0.00170808988230128*x_105 - 0.00581215889194563*x_106 - 0.00507991091022727*x_107 - 0.00561939517997429*x_108 - 0.00315321110256624*x_109 - 0.00430589052772192*x_11 + 0.0129062033566377*x_110 + 0.00870443616358753*x_111 - 0.00148369508150761*x_112 - 0.00492038278947898*x_113 - 0.00324074418220219*x_114 + 0.0128714584577201*x_115 - 0.00748893751471859*x_116 - 0.0165627926281555*x_117 - 0.0145393091659348*x_118 - 0.0138443446296298*x_119 - 0.00219239033170733*x_12 + 0.000808525178936749*x_120 + 0.00109525658259469*x_13 - 0.000334272828375522*x_14 - 0.00287896444201434*x_15 - 0.00172813508519931*x_17 - 0.00206111195895958*x_18 - 0.00327307525773693*x_19 - 0.00263414846148625*x_2 + 0.00307304513346824*x_20 + 0.00359560259209947*x_21 + 0.00174037332660858*x_22 - 4.18685049029239e-5*x_23 + 0.00154303069741932*x_24 + 0.00164819637208449*x_25 + 0.00164545740009014*x_26 - 0.00279990261851884*x_27 + 0.00157750693719149*x_28 + 0.000746196001810181*x_3 + 0.00162179666078225*x_30 + 3.65979143297144e-5*x_32 + 0.00120677708549787*x_33 + 0.00223174923963427*x_34 - 0.000412751161036691*x_35 + 0.0122487087794979*x_36 + 0.00144763801252933*x_37 + 0.0136547764849231*x_38 + 0.0096365209499642*x_39 + 0.00320164927280107*x_4 + 0.00676362481515537*x_40 - 0.00188978048988464*x_41 + 0.0031919399422359*x_42 + 0.0234807699695863*x_43 - 0.00807446613962854*x_44 + 0.00696984957301563*x_45 + 0.0101565023155626*x_46 + 0.0271844826881918*x_47 + 0.0113328836030537*x_48 - 0.000879506320125069*x_49 - 0.00944875391742096*x_50 - 0.0366462516161333*x_51 - 0.00428520041250171*x_52 + 0.029500917270887*x_53 - 0.00713377124362412*x_54 - 0.0219940192069055*x_55 + 0.00855496243088226*x_56 - 0.000584621933765607*x_57 - 0.00454003832624682*x_58 - 0.00794046030845337*x_59 - 0.000519557953021615*x_6 + 0.011203719909113*x_60 - 0.00370166859501296*x_61 + 0.00222420748118033*x_62 + 0.0036093452843306*x_63 - 0.00488511493359558*x_64 + 0.00574604731921806*x_65 + 0.00129783888081773*x_66 - 0.00265849481406948*x_67 - 0.00400041856288879*x_68 - 0.00808195891180512*x_69 - 0.000751437181411052*x_7 - 0.00222067815112233*x_70 + 0.00413199494303941*x_71 + 0.00567906856332942*x_72 - 0.00507308223011314*x_73 + 0.00388344889927028*x_74 + 0.000739047570857404*x_75 + 0.00200066430206717*x_76 + 0.00346210450750502*x_77 + 0.00786051028232325*x_78 + 0.0108206929996773*x_79 - 0.0058865588357535*x_8 - 0.000347944455787708*x_80 - 0.00426537623796884*x_81 + 0.00390948052676409*x_82 - 0.00114057201472598*x_83 - 0.0037810191704727*x_84 + 0.00306366072870085*x_85 - 0.00142220112592472*x_86 - 0.0064696042368889*x_87 + 0.00506120736735545*x_88 - 0.00291429801415006*x_89 - 0.00266575570679183*x_9 - 0.00116025827778025*x_90 - 0.000132794547408048*x_92 + 0.0132543474959289*x_93 - 0.000788543728136601*x_94 + 0.00544057270488706*x_95 - 0.00568451191759287*x_96 + 0.00226575957184797*x_97 + 0.00261660110644563*x_98 + 0.00181258757400571*x_99 + 0.0395437064612797*std::sin(0.248799979686737*x_1 + 5.06423997879028) + 0.0553091301837461*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.026013282879161*std::sin(0.290159940719604*x_1 - 4.30847978591919) - 0.382240585577874*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.0659477641675225*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.0306852458887857*std::sin(0.25519996881485*x_10 + 1.97087979316711) + 0.0760293245267577*std::sin(0.308879911899567*x_10 - 7.43832015991211) + 0.00635457456491071*std::sin(0.235679984092712*x_101 + 1.99255979061127) + 0.0129975495668154*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.0328810324882045*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.0175588278800147*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.00948579492067982*std::sin(0.262639969587326*x_108 - 7.44599962234497) - 0.052760981486369*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.0169218721365736*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.00685922068350698*std::sin(0.261039972305298*x_11 + 1.96351981163025) - 0.0335490353306187*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.0404081947059346*std::sin(0.284479945898056*x_11 + 5.16048002243042) + 0.012097583638283*std::sin(0.209519997239113*x_111 + 1.9819997549057) + 0.0730691031429161*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.0541895438796698*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.0176241672276384*std::sin(0.280879944562912*x_112 - 7.43415975570679) + 0.0201645610992192*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.00858014621626455*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.0608039131454457*std::sin(0.256719976663589*x_116 + 5.1450400352478) - 0.0584118617605062*std::sin(0.26463994383812*x_12 - 4.23848009109497) - 0.225405546953802*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.00742800035395889*std::sin(0.292879939079285*x_12 - 7.44807958602905) - 0.200160024032124*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.0533746749988564*std::sin(0.269039958715439*x_120 + 5.15144014358521) + 0.0462159975333952*std::sin(0.270159959793091*x_120 + 5.14448022842407) - 0.211900794076259*std::sin(0.291599929332733*x_13 + 5.1430401802063) - 0.0271177124782521*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.0485304716344702*std::sin(0.286319941282272*x_14 + 5.15823984146118) - 0.123228509552914*std::sin(0.291999936103821*x_14 - 7.42631959915161) + 0.0291053104906688*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.0254632112839607*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.00438495455181933*std::sin(0.328799843788147*x_15 - 4.33783960342407) - 0.0265033759192791*std::sin(0.332719832658768*x_15 + 5.06071949005127) - 0.00666630785424252*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.00522237938568624*std::sin(0.292719930410385*x_16 - 7.40079975128174) + 0.0430518342908246*std::sin(0.321839928627014*x_16 - 7.42136001586914) - 0.0249708234443017*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.0375384243444641*std::sin(0.32535982131958*x_16 - 1.15327990055084) + 0.0674900054322332*std::sin(0.331919848918915*x_16 - 1.13143992424011) - 0.0195323395027432*std::sin(0.337999850511551*x_17 + 2.00311970710754) + 0.0637576697024543*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.013714981762238*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.0361277201321165*std::sin(0.331439822912216*x_18 + 2.01263976097107) - 0.015152055401866*std::sin(0.334559857845306*x_18 + 2.01887989044189) + 0.00994402476689915*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.00479766219325534*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.0754079324843285*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.0137275721196572*std::sin(0.36695984005928*x_2 - 7.40399980545044) - 0.0111008321590174*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.104217555779727*std::sin(0.377119839191437*x_2 + 5.18016004562378) - 0.0591756975866512*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.012392245963063*std::sin(0.257119953632355*x_20 + 1.97903978824615) - 0.0139582336995328*std::sin(0.273119956254959*x_20 - 1.17575979232788) - 0.0628812660698226*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.0323335590934458*std::sin(0.301119923591614*x_20 - 7.42543983459473) + 0.0198890241563103*std::sin(0.268319964408875*x_21 - 1.17343986034393) + 0.0805601589457983*std::sin(0.341759830713272*x_21 + 8.24199962615967) + 0.0381086605310624*std::sin(0.294639945030212*x_22 - 1.14359986782074) - 0.0177115181528094*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.0148433608339924*std::sin(0.3018399477005*x_23 + 2.02303981781006) + 0.026583041960373*std::sin(0.311359941959381*x_23 + 5.05335998535156) + 0.242523199450245*std::sin(0.322639942169189*x_23 - 1.15719985961914) + 0.0487670740951461*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.0175921899288392*std::sin(0.314239919185638*x_24 - 1.16023993492126) + 0.0182362148629323*std::sin(0.347999840974808*x_24 + 2.00127983093262) + 0.0162713397884363*std::sin(0.263039946556091*x_25 - 7.39647960662842) + 0.0416420639389186*std::sin(0.37527984380722*x_25 - 4.39687967300415) + 0.0141490499747273*std::sin(0.284639924764633*x_26 - 1.17999982833862) - 0.121969948206832*std::sin(0.308879911899567*x_26 - 1.17639982700348) + 0.0871072161234587*std::sin(0.203599989414215*x_28 - 4.38679981231689) - 0.0567699773675183*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.00915164828331494*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.0343451731129115*std::sin(0.361279845237732*x_28 - 1.1632798910141) + 0.0256580615004551*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.0329853291565902*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.0114564156155967*std::sin(0.282079964876175*x_29 + 1.99119985103607) - 0.074464849951946*std::sin(0.301919937133789*x_29 + 2.01615977287292) + 0.0687737549105411*std::sin(0.3504798412323*x_29 - 1.14943993091583) - 0.0529048384601123*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.0532423820896189*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.0183336750919522*std::sin(0.35455983877182*x_3 - 7.410719871521) + 0.1763820634331*std::sin(0.363599836826324*x_3 - 7.40783977508545) - 0.120080181676783*std::sin(0.299279928207397*x_30 + 1.98919987678528) - 0.0725339409192505*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.0200050537383216*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.0524326856084607*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.00530028758063275*std::sin(0.372399836778641*x_31 + 5.19208002090454) + 0.0744171464052431*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.0835316983609202*std::sin(0.378239840269089*x_31 + 5.16991996765137) + 0.0291060278621165*std::sin(0.381119847297668*x_31 - 7.3982400894165) - 0.107721276725617*std::sin(0.385039836168289*x_31 - 7.40535974502563) + 0.200207004078731*std::sin(0.305999934673309*x_32 - 1.13367986679077) - 0.0300639435896279*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.0819988853427338*std::sin(0.311199933290482*x_32 - 1.14927983283997) - 0.0923288429015254*std::sin(0.311919927597046*x_32 - 1.14735984802246) + 0.0711734069752394*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.0898415990916571*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.018075934857292*std::sin(0.213759988546371*x_34 - 1.18095993995667) - 0.0425273026940738*std::sin(0.236879989504814*x_35 + 1.97175979614258) + 0.0147415574321444*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.0237365864419979*std::sin(0.244559973478317*x_35 - 7.43903970718384) + 0.165445858499172*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.0340258301625535*std::sin(0.228959992527962*x_37 + 1.97391974925995) + 0.0146823363054528*std::sin(0.234239995479584*x_38 + 1.95567977428436) + 0.0539398759276431*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.0114706612312008*std::sin(0.30583992600441*x_4 + 2.03351974487305) - 0.0153867265423608*std::sin(0.333039849996567*x_4 + 2.02287983894348) + 0.0377806954881753*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.00304215289446973*std::sin(0.388719856739044*x_4 - 1.17711985111237) + 0.077085730851054*std::sin(0.244799971580505*x_41 + 1.98759984970093) - 0.0219889978403783*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.00982718221124355*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.0120577838312771*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.0113155150139543*std::sin(0.231039986014366*x_46 + 1.98183989524841) - 0.0633736838158699*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.0157606997894602*std::sin(0.202639997005463*x_47 + 1.9793598651886) - 0.0250040508067208*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.0224914592795812*std::sin(0.208159998059273*x_48 + 8.21032047271729) - 0.0956179595070774*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00650822359463188*std::sin(0.285279929637909*x_5 - 1.16967988014221) - 0.0145706750323258*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.0420714551412485*std::sin(0.34911984205246*x_5 + 1.99775981903076) + 0.0207799600163325*std::sin(0.369679838418961*x_5 + 1.99015974998474) + 0.0664173834417957*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.0146778106356488*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.012888580067053*std::sin(0.216719999909401*x_52 + 1.99559986591339) + 0.109667309360433*std::sin(0.227119997143745*x_52 - 7.40711975097656) - 0.0111925442804676*std::sin(0.203919991850853*x_53 + 2.00807976722717) - 0.129933526493853*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.0306430766012271*std::sin(0.245759963989258*x_56 + 5.15263986587524) - 0.0402989008735594*std::sin(0.201920002698898*x_57 - 7.38839960098267) + 0.0744360918519101*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.0434364162580053*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.0291366369646622*std::sin(0.180560007691383*x_6 + 8.18007946014404) - 0.0439587575007564*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.00342436265135074*std::sin(0.433199852705002*x_6 - 7.42935991287231) - 0.0168311839683674*std::sin(0.305199921131134*x_60 + 8.297119140625) - 0.146119295490654*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.0495018081157247*std::sin(0.327359855175018*x_7 + 2.03519988059998) + 0.138053897702177*std::sin(0.361599832773209*x_7 + 1.99375987052917) + 0.0139802604281391*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.00761098903323403*std::sin(0.316959917545319*x_8 - 7.4203200340271) - 0.0853397299415888*std::sin(0.327199846506119*x_8 - 1.14231991767883) - 0.0153087410259996*std::sin(0.332799851894379*x_8 - 1.1379998922348) - 0.0188768011789137*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.0557909087694019*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00605111157474485*std::sin(0.321279913187027*x_9 + 5.14111995697021) + 0.0205395928170141*std::sin(0.342559844255447*x_9 - 1.12967991828918) - 0.00872203373260231*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.0148578636400157*std::sin(0.359999865293503*x_91 - 7.40871953964233) - 0.109849443993993*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.0219097783126544*std::sin(0.365199834108353*x_91 + 2.00367975234985) + 0.0191696441933022*std::sin(0.374399840831757*x_91 + 1.98335981369019) + 0.0452631863949906*std::sin(0.269919961690903*x_92 + 2.01959991455078) + 0.0607274024773572*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.0209534901824182*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.00924363995308872*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.0313335936311875*std::sin(0.29479992389679*x_94 + 1.96527981758118) + 0.0137721530776335*std::sin(0.300399929285049*x_94 + 1.94839978218079) - 0.0722760361770344*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.0175602918074012*std::sin(0.265119940042496*x_95 - 7.42375993728638) + 0.0118701050894865*std::sin(0.281519949436188*x_96 + 1.96807980537415) + 0.0618305899215375*std::sin(0.281999945640564*x_96 - 7.44087982177734) - 0.017671244731399*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00465023707754096*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.041693101639097*std::sin(0.27167996764183*x_97 - 7.43623971939087) - 0.0772742448625574*std::sin(0.276719957590103*x_97 - 1.20031988620758) + 0.0244423004839043*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.0247345311696015*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.318558530326286);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000585318850085751*x_10 + 0.00334382666575083*x_100 + 0.0136308955581012*x_101 - 5.96720791207107e-5*x_102 + 0.0157508830711779*x_103 + 0.0131921621398948*x_104 - 0.000180771046348227*x_105 + 0.005917082742197*x_106 + 0.0043283884183503*x_107 + 0.00204087763054815*x_108 + 0.0027749468899818*x_109 + 0.0013971365445914*x_11 - 0.0151865515880466*x_110 - 0.00893105928235402*x_111 + 0.00111563366763037*x_112 + 0.00307025000526733*x_113 - 0.000718187715456023*x_114 - 0.00663053916581999*x_115 + 0.00911310608698827*x_116 + 0.00156955326660006*x_117 + 0.00474079605079246*x_118 - 0.00103363070443683*x_119 - 0.00267903605571813*x_12 + 0.00254172428429767*x_120 + 0.000869995101214918*x_13 + 0.000202263283618446*x_14 + 0.00229297412001474*x_15 + 0.0014988575191589*x_17 + 0.00106118130208657*x_18 + 0.00192356697297933*x_19 + 0.00158724095507578*x_2 - 0.00185170394302113*x_20 - 0.00110392944661691*x_21 - 0.00210528000655058*x_22 + 0.000138380767373744*x_23 - 0.00593034394947043*x_24 + 0.00049452027023423*x_25 - 0.00306953461128803*x_26 + 0.00966963218764846*x_27 + 0.000135104875553717*x_28 + 6.39076225824596e-5*x_3 - 0.000977235003431175*x_30 + 2.43186992069431e-5*x_32 - 0.00374114888980171*x_33 - 0.00128468314324265*x_34 - 0.000274266212061657*x_35 - 0.0131411946013769*x_36 + 0.000757888390333728*x_37 - 0.0157053439178066*x_38 - 0.0172806400967243*x_39 - 0.00192919606615916*x_4 - 0.00530848624798952*x_40 + 0.00890868777616967*x_41 + 0.00100119274643444*x_42 - 0.0132226316858124*x_43 + 0.00486124156578095*x_44 - 0.00612381493489457*x_45 - 0.00941995634917535*x_46 - 0.0157385701003457*x_47 - 0.00879656294999886*x_48 - 0.00700307802905698*x_49 + 0.0138436057912293*x_50 + 0.0453561627817027*x_51 + 0.00784009379272618*x_52 - 0.0243085393055015*x_53 - 0.00160268701687793*x_54 + 0.0130798211518062*x_55 - 0.0124659738965356*x_56 + 5.55000337150572e-5*x_57 + 0.00741455709398721*x_58 - 0.0017047608776846*x_59 + 4.15101843794033e-5*x_6 - 0.0124288636671958*x_60 + 0.00135038675562565*x_61 + 0.00117303767246872*x_62 - 0.00498499628415292*x_63 + 0.00811808125407709*x_64 - 0.0044477625751554*x_65 - 0.00285522515402842*x_66 + 0.000117729110002976*x_67 + 0.00125355444550697*x_68 + 0.0103682812323938*x_69 - 0.000499317382488421*x_7 + 0.0046994291711753*x_70 + 0.00169189915465753*x_71 - 0.00378696649532674*x_72 + 0.00285634172877098*x_73 - 0.00217724294480397*x_74 + 0.00153490335741878*x_75 + 0.000211819892510305*x_76 - 0.00571355415719231*x_77 - 0.0052477752389519*x_78 - 0.00817022313395599*x_79 + 0.00508051026915816*x_8 + 0.00165701694523564*x_80 - 0.00188621567638345*x_81 + 0.00198653417539755*x_82 - 0.00528782278800197*x_83 - 8.16838354669018e-5*x_84 + 0.000444552060820647*x_85 + 0.00264760089184008*x_86 - 0.000392848299125484*x_87 - 0.0103371764260044*x_88 + 9.81044252203473e-5*x_89 + 0.00212316232765921*x_9 - 0.00175154760736537*x_90 + 8.42965360904382e-5*x_92 - 0.0104364729612542*x_93 + 0.000628041921855788*x_94 - 0.00265403432888731*x_95 + 0.000760196502246093*x_96 - 0.00180458222567974*x_97 - 0.00536349187142272*x_98 - 0.00232349702938453*x_99 + 0.00338670304036538*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.044051396488635*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.0172853894356983*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.230324114601739*std::sin(0.332159847021103*x_1 - 4.25568008422852) + 0.153957981341352*std::sin(0.362959831953049*x_1 - 4.21336030960083) - 0.0716360679340061*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.0458124739133075*std::sin(0.308879911899567*x_10 - 7.43832015991211) + 0.000544234694344713*std::sin(0.235679984092712*x_101 + 1.99255979061127) + 0.00111316931502958*std::sin(0.231359988451004*x_107 + 5.18703985214233) + 0.0767622291704078*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.011667546128274*std::sin(0.257119953632355*x_107 - 7.43703985214233) - 0.022145009096838*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.0420219031986982*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.0112442997379653*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.00455783690549861*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.0267203959319292*std::sin(0.272159963846207*x_11 - 4.23663997650146) + 0.0943347233239142*std::sin(0.284479945898056*x_11 + 5.16048002243042) + 0.00103609213589943*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.0581964681585879*std::sin(0.2743199467659*x_112 + 1.97775983810425) - 0.126507894404572*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.0117109630270329*std::sin(0.280879944562912*x_112 - 7.43415975570679) + 0.00172698480981363*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.00570136300951762*std::sin(0.291439920663834*x_113 - 7.43760013580322) - 0.141949432914025*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.0465225917222537*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.135821090138735*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.00493578144070164*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.120609066784901*std::sin(0.263919949531555*x_120 + 5.15687990188599) - 0.124605546849176*std::sin(0.269039958715439*x_120 + 5.15144014358521) + 0.00395814842276177*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.127683622881737*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.0215981177117723*std::sin(0.301519930362701*x_13 + 8.32544040679932) + 0.113296539173141*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.0742529663969563*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.0231811559518263*std::sin(0.32367992401123*x_14 + 5.12024021148682) + 0.0594449964639976*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.00291372863002826*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.0159699592949723*std::sin(0.332719832658768*x_15 + 5.06071949005127) - 0.000570932952379703*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.0034701833629336*std::sin(0.292719930410385*x_16 - 7.40079975128174) + 0.0036871550781111*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.0198882108711212*std::sin(0.322159916162491*x_16 + 5.16720008850098) + 0.0876351170924898*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.0406669943803724*std::sin(0.331919848918915*x_16 - 1.13143992424011) - 0.0016728384741618*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.0507803029612574*std::sin(0.352239847183228*x_17 + 1.99975979328156) + 0.0320182334140068*std::sin(0.373839855194092*x_17 - 1.17871987819672) + 0.0843417655203112*std::sin(0.331439822912216*x_18 + 2.01263976097107) - 0.00129769100292941*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.00791999758890102*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.00318796592404641*std::sin(0.275839954614639*x_19 + 2.01927995681763) + 0.176043163994475*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.00912174104272697*std::sin(0.36695984005928*x_2 - 7.40399980545044) - 0.00095072580159734*std::sin(0.369359821081161*x_2 - 4.22071981430054) + 0.243300507768817*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.0471309548391199*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.00823443924588627*std::sin(0.257119953632355*x_20 + 1.97903978824615) - 0.00119544667758006*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.0500822843199068*std::sin(0.295519918203354*x_20 + 1.97047984600067) - 0.0754841282406925*std::sin(0.301119923591614*x_20 - 7.42543983459473) + 0.00170338657166678*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.0485425880491336*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.022962876854653*std::sin(0.294639945030212*x_22 - 1.14359986782074) - 0.00151689504463475*std::sin(0.363759845495224*x_22 + 2.0052797794342) + 0.0346524844196033*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.0211722751267303*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.146135557790941*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.029385244755475*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.0116897146492171*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.0145243783207252*std::sin(0.347999840974808*x_24 + 2.00127983093262) + 0.00139355161323267*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.0250919757576774*std::sin(0.37527984380722*x_25 - 4.39687967300415) + 0.00121178905206095*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.0734946036310817*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.0524876038443869*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.0452148998431059*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.00608111653152257*std::sin(0.316079914569855*x_28 - 1.18503987789154) + 0.0801803304180428*std::sin(0.361279845237732*x_28 - 1.1632798910141) + 0.00219747319282172*std::sin(0.220639988780022*x_29 - 1.18039989471436) - 0.0770057143700652*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.00761259570246108*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.0448697790900571*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.054775403907306*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.0421364792292192*std::sin(0.346159845590591*x_3 - 7.39567947387695) - 0.124296703183146*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.0121824190827458*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.106281342496479*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.0956388154342339*std::sin(0.299279928207397*x_30 + 1.98919987678528) - 0.00621213690429966*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.0132930221131749*std::sin(0.345839858055115*x_30 - 1.15679979324341) + 0.122406430824228*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.0035219520495749*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.0592701279329383*std::sin(0.375599831342697*x_31 + 5.19080018997192) + 0.195008455858998*std::sin(0.378239840269089*x_31 + 5.16991996765137) + 0.00249277272857845*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.0649088783915698*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.120637375232636*std::sin(0.305999934673309*x_32 - 1.13367986679077) - 0.00257481299230419*std::sin(0.306239932775497*x_32 - 1.14095985889435) + 0.19143003586201*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.073536041020353*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.0566866258734735*std::sin(0.235679984092712*x_33 + 1.98999989032745) + 0.209739199065104*std::sin(0.241439983248711*x_33 + 1.98831987380981) + 0.0421990718960108*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.033871208358279*std::sin(0.236879989504814*x_35 + 1.97175979614258) + 0.00126253408804888*std::sin(0.242319971323013*x_35 + 1.98367977142334) + 0.05541411416559*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.0996915877358684*std::sin(0.248479977250099*x_35 + 1.97895979881287) - 0.0794348101322025*std::sin(0.228959992527962*x_37 + 1.97391974925995) + 0.00125746212116038*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.0429608430496466*std::sin(0.237199977040291*x_38 + 1.97767984867096) + 0.0267787675609462*std::sin(0.30583992600441*x_4 + 2.03351974487305) - 0.00131778930771978*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.0300907353096485*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.00202145948852812*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.0464490255001448*std::sin(0.244799971580505*x_41 + 1.98759984970093) - 0.00188323787790395*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.00652999747728844*std::sin(0.203439995646477*x_44 + 1.98855984210968) - 0.0281494313195842*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.00751896961987755*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.0504744743488786*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.0104727202216445*std::sin(0.202639997005463*x_47 + 1.9793598651886) - 0.00214146073968787*std::sin(0.215279996395111*x_47 + 1.98183989524841) - 0.0525073095626013*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.0576158647052034*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00432460523688585*std::sin(0.285279929637909*x_5 - 1.16967988014221) - 0.00124789894140229*std::sin(0.347439825534821*x_5 + 2.02791976928711) + 0.0982176786037231*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.0165503643730499*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.0400206718296773*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.00975315857207209*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.00856424491930085*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.0660814860646204*std::sin(0.227119997143745*x_52 - 7.40711975097656) - 0.00095858044518918*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.103486590256112*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.0203618095809224*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.0320963800106743*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.0448524505169587*std::sin(0.211840003728867*x_57 + 5.19672012329102) + 0.101404240889769*std::sin(0.247519969940186*x_57 - 7.42671966552734) + 0.0680207716937938*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.0350113019203229*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.00227543145064078*std::sin(0.433199852705002*x_6 - 7.42935991287231) - 0.00144149921744018*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.0880461118728016*std::sin(0.29751992225647*x_7 - 4.18368005752563) - 0.115564167283736*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.109954124468716*std::sin(0.361599832773209*x_7 + 1.99375987052917) + 0.00119733314689253*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.0050573743437692*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0679695064341247*std::sin(0.327199846506119*x_8 - 1.14231991767883) - 0.00131111027307685*std::sin(0.332799851894379*x_8 - 1.1379998922348) - 0.0016166951878322*std::sin(0.30991992354393*x_9 - 7.43063974380493) - 0.130246351787112*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00402086197940504*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.0123764029994538*std::sin(0.342559844255447*x_9 - 1.12967991828918) - 0.00074699467510203*std::sin(0.356239855289459*x_91 - 7.3982400894165) - 0.034686341863708*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.066191233694244*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.0145586795923954*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.0152678155324413*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.0360502246844352*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.036592098629493*std::sin(0.271199941635132*x_92 - 7.38695955276489) + 0.0489168524704835*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.00614224345057644*std::sin(0.291919946670532*x_94 - 7.43031978607178) + 0.0731496645037676*std::sin(0.29479992389679*x_94 + 1.96527981758118) + 0.001179509886006*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.0435508804336718*std::sin(0.30447992682457*x_94 + 1.94823980331421) - 0.0409952803186008*std::sin(0.265119940042496*x_95 - 7.42375993728638) + 0.00101660983740571*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.049245464947852*std::sin(0.281999945640564*x_96 - 7.44087982177734) - 0.00151344584548418*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00309000441147749*std::sin(0.270639955997467*x_97 + 1.98279988765717) + 0.0973343955666104*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.0465626171082256*std::sin(0.276719957590103*x_97 - 1.20031988620758) + 0.00209334988472611*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.0164356804084303*std::sin(0.253519982099533*x_98 - 7.43039989471436) + 0.615672230125951);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000495363382581982*x_10 + 0.00340900674032314*x_100 - 0.0118461566819204*x_101 + 0.00466033093103195*x_102 + 0.00662899932972381*x_103 - 0.0154348533231985*x_104 + 0.00177910262832483*x_105 - 0.0051709114772205*x_106 + 0.0044392567423599*x_107 - 0.00154982016856505*x_108 - 0.00454956493875624*x_109 + 0.000998423756580613*x_11 + 0.0131351287795207*x_110 + 0.0193975098254556*x_111 - 0.000349164500264582*x_112 + 0.00189922572179371*x_113 + 0.0278564959375558*x_114 + 0.00373716835684622*x_115 + 0.000678708956665559*x_116 + 0.0197110082389105*x_117 + 0.0208610120729316*x_118 + 0.0330463648395901*x_119 + 0.00669948260163473*x_12 + 0.00406750022932096*x_120 - 0.00107070033832194*x_13 + 0.00107628350966172*x_14 + 0.00190895695624915*x_15 + 0.00037234751037281*x_17 - 0.000344882308052161*x_18 + 0.00127191039066475*x_19 - 0.000189865718690107*x_2 + 0.00022150077391761*x_20 - 0.00107646081330617*x_21 + 0.00306338907886568*x_22 + 0.000550453766797128*x_23 + 0.011625115326959*x_24 - 0.00280005115621926*x_25 + 0.00519376873892757*x_26 + 0.0147991881532347*x_27 - 0.00107290482915573*x_28 - 0.000507507938611149*x_3 + 0.00011689682380123*x_30 + 5.29984411409008e-5*x_32 + 0.000789806273226854*x_33 + 0.00458446713434811*x_34 - 0.000597716250083703*x_35 - 0.00522598139077867*x_36 - 0.000467715360147045*x_37 + 0.00559589045473544*x_38 + 0.00411594709121599*x_39 + 0.000230770379521834*x_4 + 0.00107154575886169*x_40 - 0.014927917542271*x_41 - 0.0198767768318578*x_42 - 0.00872851695432369*x_43 + 0.00248175373387275*x_44 + 0.0137888643938697*x_45 + 0.0202825905131683*x_46 + 0.000363216406063487*x_47 + 0.000155018272262207*x_48 + 0.0116031026755415*x_49 - 0.0186133140021957*x_50 - 0.0701504742705033*x_51 - 0.00570453506256097*x_52 + 0.0172019943146073*x_53 + 0.0211724785349594*x_54 + 0.00906440708607047*x_55 + 0.0212502506284307*x_56 + 0.000785772216734629*x_57 - 0.0255009228935642*x_58 + 0.0337065745865662*x_59 + 0.000259359830682137*x_6 + 0.00713131874875443*x_60 + 0.0103885361998132*x_61 - 0.00300277345272776*x_62 + 0.0088546731465893*x_63 - 0.00327571647843714*x_64 + 0.00468991131725793*x_65 + 0.00399820626541255*x_66 + 0.000424334809267463*x_67 - 0.00389606046023118*x_68 - 0.00314788265085263*x_69 - 0.0010881767433879*x_7 - 0.00510521521340553*x_70 - 0.0033171678390421*x_71 - 0.000531223779813383*x_72 + 0.00030972361372044*x_73 - 0.00053962543370086*x_74 - 0.00663045544500007*x_75 + 0.00854435249905774*x_76 + 0.00826338297559861*x_77 + 0.00469307293930368*x_78 + 0.00469978897901522*x_79 - 0.00423819186109903*x_8 - 0.0154277316804946*x_80 - 0.000517540967175897*x_81 - 0.00232288578598291*x_82 + 0.00915880903007689*x_83 - 0.00291080045386749*x_84 - 0.0068316983423884*x_85 - 0.00241584339435185*x_86 + 0.000942831504577543*x_87 + 0.0109600101076571*x_88 - 0.00123694824603889*x_89 + 0.00176758449179755*x_9 - 0.00155605752189697*x_90 + 0.000442072104750457*x_92 - 0.00624696226917279*x_93 + 0.000522860238621005*x_94 - 0.00101554712053691*x_95 + 0.0099030664199566*x_96 - 0.00150235877621365*x_97 + 0.0128130249437586*x_98 - 0.00465936166124718*x_99 - 0.0268947366409417*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.0366738634446205*std::sin(0.289279937744141*x_1 - 4.30231952667236) + 0.037670546718381*std::sin(0.290159940719604*x_1 - 4.30847978591919) - 0.0275513641521641*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.288827918749205*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.134390541032629*std::sin(0.25519996881485*x_10 + 1.97087979316711) + 0.00548008684926266*std::sin(0.308879911899567*x_10 - 7.43832015991211) - 0.00432191680250929*std::sin(0.235679984092712*x_101 + 1.99255979061127) - 0.00883998248670427*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.144007310934282*std::sin(0.247759968042374*x_107 - 7.41655969619751) + 0.0254274191014925*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.041544432009281*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.034984260714407*std::sin(0.240399971604347*x_109 - 7.43703985214233) + 0.0245050260608948*std::sin(0.240639984607697*x_109 + 1.97959983348846) - 0.00993302515526519*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.0222453822059099*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.176973623361676*std::sin(0.284479945898056*x_11 + 5.16048002243042) - 0.0082278914917086*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.0484499810751264*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.237331066099155*std::sin(0.280559957027435*x_112 - 7.44392013549805) - 0.0255220387986158*std::sin(0.280879944562912*x_112 - 7.43415975570679) - 0.0137144594873701*std::sin(0.278159946203232*x_113 - 7.40975999832153) - 0.0124251445075878*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.266299667733926*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.0387311938306416*std::sin(0.26463994383812*x_12 - 4.23848009109497) - 0.0162469150068229*std::sin(0.277199953794479*x_12 + 5.15424013137817) + 0.0107566905591189*std::sin(0.292879939079285*x_12 - 7.44807958602905) - 0.0144272531983432*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.233762228157948*std::sin(0.269039958715439*x_120 + 5.15144014358521) - 0.0314327409717184*std::sin(0.270159959793091*x_120 + 5.14448022842407) - 0.0152735114009455*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.0179809604861615*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.212546328068*std::sin(0.286319941282272*x_14 + 5.15823984146118) - 0.00888213776537624*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.01929887848357*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.111519873534083*std::sin(0.310479938983917*x_15 - 7.44432020187378) + 0.00634997266856369*std::sin(0.328799843788147*x_15 - 4.33783960342407) - 0.00191032608457794*std::sin(0.332719832658768*x_15 + 5.06071949005127) + 0.00453393498363258*std::sin(0.385759830474854*x_15 + 5.02367973327637) + 0.00756267048428565*std::sin(0.292719930410385*x_16 - 7.40079975128174) - 0.0292807085824124*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.0165574212802423*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.164405042587866*std::sin(0.32535982131958*x_16 - 1.15327990055084) + 0.00486458473132536*std::sin(0.331919848918915*x_16 - 1.13143992424011) + 0.0132844686024088*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.0422758424232493*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.0600667769116169*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.158226656303411*std::sin(0.331439822912216*x_18 + 2.01263976097107) + 0.0103053197605836*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.00659359142296466*std::sin(0.371599853038788*x_18 - 1.17215991020203) - 0.00694762589672285*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.330260115283108*std::sin(0.317199915647507*x_19 + 1.98535978794098) + 0.0198792728032707*std::sin(0.36695984005928*x_2 - 7.40399980545044) + 0.00754997404465377*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.456436091700158*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.0392376709834929*std::sin(0.381119847297668*x_2 - 7.39511966705322) - 0.0179455504584237*std::sin(0.257119953632355*x_20 + 1.97903978824615) + 0.00949336956284654*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.0416947248566065*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.141609570795935*std::sin(0.301119923591614*x_20 - 7.42543983459473) - 0.0135270594134383*std::sin(0.268319964408875*x_21 - 1.17343986034393) + 0.0058066630258961*std::sin(0.341759830713272*x_21 + 8.24199962615967) + 0.00274681868764718*std::sin(0.294639945030212*x_22 - 1.14359986782074) + 0.0120460791073668*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.0650086787784809*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.0176264361337549*std::sin(0.311359941959381*x_23 + 5.05335998535156) + 0.0174807313391381*std::sin(0.322639942169189*x_23 - 1.15719985961914) + 0.00351506215646797*std::sin(0.279199957847595*x_24 - 1.16119992733002) + 0.0254757315972548*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.0120918996810852*std::sin(0.347999840974808*x_24 + 2.00127983093262) - 0.0110665751283019*std::sin(0.263039946556091*x_25 - 7.39647960662842) + 0.00300150143892847*std::sin(0.37527984380722*x_25 - 4.39687967300415) - 0.00962314883564147*std::sin(0.284639924764633*x_26 - 1.17999982833862) - 0.00879142243251506*std::sin(0.308879911899567*x_26 - 1.17639982700348) + 0.00627856570507931*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.0376425084034752*std::sin(0.23879998922348*x_28 + 8.20119953155518) + 0.0132527522884465*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.150419729834732*std::sin(0.361279845237732*x_28 - 1.1632798910141) - 0.0174507366285333*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.144464093511259*std::sin(0.26063996553421*x_29 + 2.00991988182068) - 0.0165903489258656*std::sin(0.282079964876175*x_29 + 1.99119985103607) - 0.00536732172084942*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.0456018615332373*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.0350796480581076*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.233182831932425*std::sin(0.350639849901199*x_3 - 7.40711975097656) + 0.026549496550636*std::sin(0.35455983877182*x_3 - 7.410719871521) + 0.0127133712193558*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.0796216496370383*std::sin(0.299279928207397*x_30 + 1.98919987678528) + 0.0493322809904789*std::sin(0.317359924316406*x_30 + 1.98943984508514) - 0.0289698657010673*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.229636647275164*std::sin(0.377519845962524*x_30 - 1.15831983089447) - 0.00767549147312856*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.0493438290592798*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.365839341056122*std::sin(0.378239840269089*x_31 + 5.16991996765137) - 0.0197957911401662*std::sin(0.381119847297668*x_31 - 7.3982400894165) - 0.00776439821929605*std::sin(0.385039836168289*x_31 - 7.40535974502563) + 0.0144306394540701*std::sin(0.305999934673309*x_32 - 1.13367986679077) + 0.0204472953495873*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.359126161322691*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.0612205501211343*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.0471930004978709*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.393474478025183*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.0791662114733069*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.0281986081952314*std::sin(0.236879989504814*x_35 + 1.97175979614258) - 0.0100261290681756*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.103957866453783*std::sin(0.244559973478317*x_35 - 7.43903970718384) + 0.0119251049390449*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.149021120482567*std::sin(0.228959992527962*x_37 + 1.97391974925995) - 0.00998585118963357*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.0357659510720617*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.0502374455283886*std::sin(0.30583992600441*x_4 + 2.03351974487305) + 0.0104649259049145*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.0250512720517039*std::sin(0.343119859695435*x_4 + 1.99575984477997) + 0.00440542484652657*std::sin(0.388719856739044*x_4 - 1.17711985111237) + 0.00555623113229146*std::sin(0.244799971580505*x_41 + 1.98759984970093) + 0.0149553079070695*std::sin(0.232479989528656*x_42 + 1.96527981758118) + 0.0142310114535853*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.0528088351846002*std::sin(0.260159969329834*x_44 + 1.9625598192215) + 0.0163863069092746*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.0420212326341878*std::sin(0.188880011439323*x_47 - 1.1975998878479) + 0.0228235006127911*std::sin(0.202639997005463*x_47 + 1.9793598651886) + 0.0170059263934188*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.098504649177373*std::sin(0.208159998059273*x_48 + 8.21032047271729) - 0.00689200812593896*std::sin(0.264479964971542*x_49 - 7.47544002532959) - 0.00942473666680696*std::sin(0.285279929637909*x_5 - 1.16967988014221) + 0.00990990735931295*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.184258116716891*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.0137785825503293*std::sin(0.369679838418961*x_5 + 1.99015974998474) + 0.00478727164587295*std::sin(0.410559862852097*x_5 + 1.96807980537415) + 0.0212553391989098*std::sin(0.18384000658989*x_51 + 1.98735988140106) + 0.0186643054552127*std::sin(0.216719999909401*x_52 + 1.99559986591339) + 0.00790466551637738*std::sin(0.227119997143745*x_52 - 7.40711975097656) + 0.00761234992121961*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.0861551138425587*std::sin(0.243119969964027*x_53 - 7.4256796836853) - 0.0443750776887214*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.0267210202491946*std::sin(0.201920002698898*x_57 - 7.38839960098267) + 0.00536524887741964*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.190236164396036*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.127608180809243*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.0291477639301529*std::sin(0.407519847154617*x_6 - 7.41775989532471) + 0.00495891325357194*std::sin(0.433199852705002*x_6 - 7.42935991287231) + 0.0114473401887029*std::sin(0.305199921131134*x_60 + 8.297119140625) - 0.0105320734417421*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.216800438845331*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.0915394940312245*std::sin(0.361599832773209*x_7 + 1.99375987052917) - 0.00950835053246075*std::sin(0.398479849100113*x_7 - 1.17207992076874) - 0.011021681472553*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0565862741265523*std::sin(0.327199846506119*x_8 - 1.14231991767883) + 0.0104118858610735*std::sin(0.332799851894379*x_8 - 1.1379998922348) + 0.0128386193850447*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.244344478822056*std::sin(0.312959939241409*x_9 - 7.42560005187988) + 0.00876278024321067*std::sin(0.321279913187027*x_9 + 5.14111995697021) + 0.00148046498093133*std::sin(0.342559844255447*x_9 - 1.12967991828918) + 0.00593208935640469*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.0650721959474495*std::sin(0.359999865293503*x_91 - 7.40871953964233) - 0.00791779352476601*std::sin(0.360959857702255*x_91 - 7.41048002243042) + 0.0317281494746441*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.0127108293168155*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.0300126925049007*std::sin(0.269919961690903*x_92 + 2.01959991455078) + 0.0043771458154797*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.0917688876388045*std::sin(0.309759914875031*x_92 + 1.98343980312347) - 0.0133859679425419*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.137230075191634*std::sin(0.29479992389679*x_94 + 1.96527981758118) - 0.00936681113502531*std::sin(0.300399929285049*x_94 + 1.94839978218079) - 0.00520955510042974*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.0769078770051492*std::sin(0.265119940042496*x_95 - 7.42375993728638) - 0.00807317722213613*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.0409980522917205*std::sin(0.281999945640564*x_96 - 7.44087982177734) + 0.0120186880719937*std::sin(0.265919953584671*x_97 + 1.98175978660583) - 0.00673413555277898*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.182601061986418*std::sin(0.27167996764183*x_97 - 7.43623971939087) - 0.00556981895727573*std::sin(0.276719957590103*x_97 - 1.20031988620758) - 0.0166238649140552*std::sin(0.246239975094795*x_98 - 7.40775966644287) - 0.0358187513782873*std::sin(0.253519982099533*x_98 - 7.43039989471436) - 0.346679360435494);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00119351318665717*x_10 - 0.00155983164104854*x_100 + 0.00554377716645842*x_101 - 0.0027077132820368*x_102 - 0.00669775250308014*x_103 + 0.0075535741445019*x_104 - 0.00152009567580512*x_105 + 0.00250462086832084*x_106 - 0.00139142871842114*x_107 + 0.00109011700266509*x_108 + 0.00243520324439099*x_109 - 0.00153205251747093*x_11 - 0.00928615522889808*x_110 - 0.0137859806158814*x_111 - 0.000375751298037085*x_112 - 0.0018525753882816*x_113 - 0.0194674461566531*x_114 + 0.000454714449360964*x_115 - 0.00315848487759236*x_116 - 0.0185316747260614*x_117 - 0.0210676064529772*x_118 - 0.0213789712060041*x_119 - 0.00390969261657232*x_12 - 0.00432420042062592*x_120 + 0.000263221892647333*x_13 - 0.00105442095766271*x_14 - 0.000798310801317622*x_15 - 0.00125707998046509*x_17 - 0.00029656772436984*x_18 - 0.00101120863692519*x_19 - 0.000761499772463457*x_2 + 0.000888379377290546*x_20 - 0.000690885386311968*x_21 - 0.00199961130554843*x_22 - 0.000573988274491368*x_23 - 0.00639018791462643*x_24 + 0.000759676574507707*x_25 - 0.00292445256065193*x_26 - 0.0110227963955111*x_27 + 0.000716493229537133*x_28 + 0.000338917294497941*x_3 + 0.000468841375580958*x_30 - 6.61905078375274e-5*x_32 + 0.00188001122571979*x_33 + 0.00162024409903057*x_34 + 0.000746496336196019*x_35 + 0.00415345482785418*x_36 + 0.00445344994718068*x_37 + 0.00494300310338459*x_38 + 0.00523908869629254*x_39 + 0.000925557244928483*x_4 + 0.00298390929933876*x_40 + 0.00651254791560856*x_41 + 0.00968007442917703*x_42 + 0.00742834950648355*x_43 - 0.00244737246916478*x_44 + 0.00278065796664545*x_45 - 0.00555422724252097*x_46 + 0.00884648562679656*x_47 + 0.00289785111927873*x_48 - 0.00391578349257236*x_49 - 0.00111555541090724*x_50 + 0.0272894824268137*x_51 + 0.00365792838395374*x_52 - 0.00047869114306322*x_53 - 0.0140760883561346*x_54 - 0.00866735350538683*x_55 - 0.00977728833147463*x_56 - 0.000678221685499654*x_57 + 0.0129233870643817*x_58 - 0.0177672185803104*x_59 - 0.000215346004149018*x_6 + 0.00184946629259779*x_60 - 0.00883366072262346*x_61 + 5.4641384236114e-5*x_62 - 0.00656172828573208*x_63 - 0.000106398301360472*x_64 + 0.00111241450962905*x_65 - 0.0018097603874311*x_66 - 0.00283230643921536*x_67 + 0.00204752664830338*x_68 - 0.00323211431705431*x_69 + 0.00135903943043046*x_7 - 0.000896576841798392*x_70 + 0.00171166809231524*x_71 + 0.00342293118969841*x_72 - 0.00222889169948194*x_73 - 0.000887253667911508*x_74 + 0.000957493937647955*x_75 - 0.00835009217123765*x_76 - 0.00388172073213589*x_77 - 0.000671301289932937*x_78 - 0.00147108992248849*x_79 + 0.000658444748069188*x_8 + 0.0111373206428483*x_80 - 0.000346479934511856*x_81 + 0.00401941396510123*x_82 - 0.00662236742876952*x_83 + 0.00249350724020085*x_84 + 0.00440884476076011*x_85 + 0.00041335830450161*x_86 + 0.00298906459514557*x_87 - 0.00271598150441869*x_88 + 0.000665065039138563*x_89 - 0.000739189947381577*x_9 + 0.00329471369691721*x_90 - 0.000434303658185429*x_92 + 0.00335812808646013*x_93 - 0.000218656043921914*x_94 + 0.00179486911715258*x_95 - 0.00903941247746394*x_96 + 0.000628274636879317*x_97 - 0.00582674838607141*x_98 - 0.000539047125064605*x_99 + 0.0179604902408562*std::sin(0.248799979686737*x_1 + 5.06423997879028) + 0.0153367215630748*std::sin(0.289279937744141*x_1 - 4.30231952667236) - 0.0470472822243572*std::sin(0.290159940719604*x_1 - 4.30847978591919) - 0.11050103029486*std::sin(0.332159847021103*x_1 - 4.25568008422852) + 0.156730798574596*std::sin(0.362959831953049*x_1 - 4.21336030960083) - 0.0729262493325844*std::sin(0.25519996881485*x_10 + 1.97087979316711) + 0.0219791382961801*std::sin(0.308879911899567*x_10 - 7.43832015991211) + 0.00288620578775605*std::sin(0.235679984092712*x_101 + 1.99255979061127) + 0.00590340114876219*std::sin(0.231359988451004*x_107 + 5.18703985214233) + 0.0781447338645558*std::sin(0.247759968042374*x_107 - 7.41655969619751) - 0.0317566658017524*std::sin(0.257119953632355*x_107 - 7.43703985214233) - 0.0225438455996233*std::sin(0.262639969587326*x_108 - 7.44599962234497) - 0.0146301429757213*std::sin(0.240399971604347*x_109 - 7.43703985214233) - 0.030604675998493*std::sin(0.240639984607697*x_109 + 1.97959983348846) + 0.0124054965624742*std::sin(0.261039972305298*x_11 + 1.96351981163025) - 0.00930284406690357*std::sin(0.272159963846207*x_11 - 4.23663997650146) + 0.0960337125172445*std::sin(0.284479945898056*x_11 + 5.16048002243042) + 0.00549464256938274*std::sin(0.209519997239113*x_111 + 1.9819997549057) + 0.0202614014366805*std::sin(0.2743199467659*x_112 + 1.97775983810425) - 0.128786329511932*std::sin(0.280559957027435*x_112 - 7.44392013549805) + 0.0318748376888721*std::sin(0.280879944562912*x_112 - 7.43415975570679) + 0.00915861044002789*std::sin(0.278159946203232*x_113 - 7.40975999832153) + 0.0155179399093156*std::sin(0.291439920663834*x_113 - 7.43760013580322) - 0.144505973538968*std::sin(0.256719976663589*x_116 + 5.1450400352478) - 0.0161970809670221*std::sin(0.26463994383812*x_12 - 4.23848009109497) - 0.0651619584951088*std::sin(0.277199953794479*x_12 + 5.15424013137817) - 0.0134341840143246*std::sin(0.292879939079285*x_12 - 7.44807958602905) - 0.057863789754182*std::sin(0.263919949531555*x_120 + 5.15687990188599) - 0.126849720257083*std::sin(0.269039958715439*x_120 + 5.15144014358521) + 0.0209910007672841*std::sin(0.270159959793091*x_120 + 5.14448022842407) - 0.0612579013040338*std::sin(0.291599929332733*x_13 + 5.1430401802063) - 0.00751949640728021*std::sin(0.301519930362701*x_13 + 8.32544040679932) + 0.115337034856113*std::sin(0.286319941282272*x_14 + 5.15823984146118) - 0.0356238394902803*std::sin(0.291999936103821*x_14 - 7.42631959915161) + 0.00807063935952853*std::sin(0.32367992401123*x_14 + 5.12024021148682) + 0.0605156139739795*std::sin(0.310479938983917*x_15 - 7.44432020187378) - 0.00793057128924275*std::sin(0.328799843788147*x_15 - 4.33783960342407) - 0.00766179850039933*std::sin(0.332719832658768*x_15 + 5.06071949005127) - 0.00302779298839634*std::sin(0.385759830474854*x_15 + 5.02367973327637) - 0.00944512686008859*std::sin(0.292719930410385*x_16 - 7.40079975128174) + 0.0195538587256216*std::sin(0.321839928627014*x_16 - 7.42136001586914) - 0.0069241834954494*std::sin(0.322159916162491*x_16 + 5.16720008850098) + 0.0892134448985207*std::sin(0.32535982131958*x_16 - 1.15327990055084) + 0.019510526658473*std::sin(0.331919848918915*x_16 - 1.13143992424011) - 0.00887145956749436*std::sin(0.337999850511551*x_17 + 2.00311970710754) + 0.0176794251597975*std::sin(0.352239847183228*x_17 + 1.99975979328156) + 0.0325948888664549*std::sin(0.373839855194092*x_17 - 1.17871987819672) + 0.0858607793374544*std::sin(0.331439822912216*x_18 + 2.01263976097107) - 0.00688196346593352*std::sin(0.334559857845306*x_18 + 2.01887989044189) + 0.00275738813030675*std::sin(0.371599853038788*x_18 - 1.17215991020203) + 0.00867698891645978*std::sin(0.275839954614639*x_19 + 2.01927995681763) + 0.179213740243046*std::sin(0.317199915647507*x_19 + 1.98535978794098) - 0.0248275068844198*std::sin(0.36695984005928*x_2 - 7.40399980545044) - 0.00504192463224558*std::sin(0.369359821081161*x_2 - 4.22071981430054) + 0.24768240362716*std::sin(0.377119839191437*x_2 + 5.18016004562378) - 0.0164088857331895*std::sin(0.381119847297668*x_2 - 7.39511966705322) + 0.0224124535117761*std::sin(0.257119953632355*x_20 + 1.97903978824615) - 0.00633973753536545*std::sin(0.273119956254959*x_20 - 1.17575979232788) - 0.0174364063589976*std::sin(0.295519918203354*x_20 + 1.97047984600067) - 0.0768436140549301*std::sin(0.301119923591614*x_20 - 7.42543983459473) + 0.0090334633808124*std::sin(0.268319964408875*x_21 - 1.17343986034393) + 0.0232889465433669*std::sin(0.341759830713272*x_21 + 8.24199962615967) + 0.0110167428858272*std::sin(0.294639945030212*x_22 - 1.14359986782074) - 0.00804445453907474*std::sin(0.363759845495224*x_22 + 2.0052797794342) + 0.0352765833142255*std::sin(0.3018399477005*x_23 + 2.02303981781006) + 0.00737123710843653*std::sin(0.311359941959381*x_23 + 5.05335998535156) + 0.0701104603247267*std::sin(0.322639942169189*x_23 - 1.15719985961914) + 0.0140979585509806*std::sin(0.279199957847595*x_24 - 1.16119992733002) - 0.0318170039656789*std::sin(0.314239919185638*x_24 - 1.16023993492126) + 0.00505673744620544*std::sin(0.347999840974808*x_24 + 2.00127983093262) + 0.00739033504009091*std::sin(0.263039946556091*x_25 - 7.39647960662842) + 0.0120382061520191*std::sin(0.37527984380722*x_25 - 4.39687967300415) + 0.00642640502698723*std::sin(0.284639924764633*x_26 - 1.17999982833862) - 0.0352600049560141*std::sin(0.308879911899567*x_26 - 1.17639982700348) + 0.0251816198774586*std::sin(0.203599989414215*x_28 - 4.38679981231689) - 0.0157418012746755*std::sin(0.23879998922348*x_28 + 8.20119953155518) - 0.016551551051947*std::sin(0.316079914569855*x_28 - 1.18503987789154) + 0.0816243958702745*std::sin(0.361279845237732*x_28 - 1.1632798910141) + 0.0116537220310758*std::sin(0.220639988780022*x_29 - 1.18039989471436) - 0.0783926042864132*std::sin(0.26063996553421*x_29 + 2.00991988182068) + 0.0207199230197237*std::sin(0.282079964876175*x_29 + 1.99119985103607) - 0.0215268680273769*std::sin(0.301919937133789*x_29 + 2.01615977287292) + 0.0190703402206113*std::sin(0.3504798412323*x_29 - 1.14943993091583) - 0.014670033213443*std::sin(0.346159845590591*x_3 - 7.39567947387695) - 0.126535314248444*std::sin(0.350639849901199*x_3 - 7.40711975097656) - 0.0331580443063464*std::sin(0.35455983877182*x_3 - 7.410719871521) + 0.0509898751474158*std::sin(0.363599836826324*x_3 - 7.40783977508545) - 0.0332971483279893*std::sin(0.299279928207397*x_30 + 1.98919987678528) - 0.0329444367913932*std::sin(0.317359924316406*x_30 + 1.98943984508514) + 0.0361808778043244*std::sin(0.345839858055115*x_30 - 1.15679979324341) + 0.124610997667027*std::sin(0.377519845962524*x_30 - 1.15831983089447) + 0.00958603059962294*std::sin(0.372399836778641*x_31 + 5.19208002090454) + 0.0206352016411061*std::sin(0.375599831342697*x_31 + 5.19080018997192) + 0.198520601201014*std::sin(0.378239840269089*x_31 + 5.16991996765137) + 0.0132197655745676*std::sin(0.381119847297668*x_31 - 7.3982400894165) - 0.0311408900885365*std::sin(0.385039836168289*x_31 - 7.40535974502563) + 0.0578773711051669*std::sin(0.305999934673309*x_32 - 1.13367986679077) - 0.013654844569815*std::sin(0.306239932775497*x_32 - 1.14095985889435) + 0.194877733069873*std::sin(0.311199933290482*x_32 - 1.14927983283997) - 0.0256019530793074*std::sin(0.311919927597046*x_32 - 1.14735984802246) + 0.0197357420347832*std::sin(0.235679984092712*x_33 + 1.98999989032745) + 0.213516648344366*std::sin(0.241439983248711*x_33 + 1.98831987380981) + 0.0429590864971424*std::sin(0.213759988546371*x_34 - 1.18095993995667) - 0.0117924364039137*std::sin(0.236879989504814*x_35 + 1.97175979614258) + 0.00669551799991997*std::sin(0.242319971323013*x_35 + 1.98367977142334) + 0.0564121345954801*std::sin(0.244559973478317*x_35 - 7.43903970718384) + 0.047828353429653*std::sin(0.248479977250099*x_35 + 1.97895979881287) - 0.0808654485994978*std::sin(0.228959992527962*x_37 + 1.97391974925995) + 0.00666862015540362*std::sin(0.234239995479584*x_38 + 1.95567977428436) + 0.0149570397419154*std::sin(0.237199977040291*x_38 + 1.97767984867096) + 0.0272610590766644*std::sin(0.30583992600441*x_4 + 2.03351974487305) - 0.00698854954766046*std::sin(0.333039849996567*x_4 + 2.02287983894348) + 0.0104762451558449*std::sin(0.343119859695435*x_4 + 1.99575984477997) - 0.00550199782398163*std::sin(0.388719856739044*x_4 - 1.17711985111237) + 0.0222845323114919*std::sin(0.244799971580505*x_41 + 1.98759984970093) - 0.00998725755525805*std::sin(0.232479989528656*x_42 + 1.96527981758118) - 0.0177733128536782*std::sin(0.203439995646477*x_44 + 1.98855984210968) - 0.0286564087921968*std::sin(0.260159969329834*x_44 + 1.9625598192215) - 0.0204650920396492*std::sin(0.231039986014366*x_46 + 1.98183989524841) - 0.0175729493463625*std::sin(0.188880011439323*x_47 - 1.1975998878479) - 0.0285045949214702*std::sin(0.202639997005463*x_47 + 1.9793598651886) - 0.0113566746945109*std::sin(0.215279996395111*x_47 + 1.98183989524841) - 0.0534529777998568*std::sin(0.208159998059273*x_48 + 8.21032047271729) - 0.0276419706302266*std::sin(0.264479964971542*x_49 - 7.47544002532959) + 0.0117706878312217*std::sin(0.285279929637909*x_5 - 1.16967988014221) - 0.00661790434280665*std::sin(0.347439825534821*x_5 + 2.02791976928711) + 0.0999866006788823*std::sin(0.34911984205246*x_5 + 1.99775981903076) + 0.00576209497064151*std::sin(0.369679838418961*x_5 + 1.99015974998474) + 0.0192004448944419*std::sin(0.410559862852097*x_5 + 1.96807980537415) - 0.0265460958010893*std::sin(0.18384000658989*x_51 + 1.98735988140106) - 0.0233101168623214*std::sin(0.216719999909401*x_52 + 1.99559986591339) + 0.0317034640779244*std::sin(0.227119997143745*x_52 - 7.40711975097656) - 0.00508357967193911*std::sin(0.203919991850853*x_53 + 2.00807976722717) - 0.0360293917283524*std::sin(0.243119969964027*x_53 - 7.4256796836853) + 0.0554206664255914*std::sin(0.245759963989258*x_56 + 5.15263986587524) - 0.0111745207336015*std::sin(0.201920002698898*x_57 - 7.38839960098267) + 0.021518554415994*std::sin(0.211840003728867*x_57 + 5.19672012329102) + 0.103230553655197*std::sin(0.247519969940186*x_57 - 7.42671966552734) + 0.0692458408089373*std::sin(0.180560007691383*x_6 + 8.18007946014404) - 0.0121893658751833*std::sin(0.407519847154617*x_6 - 7.41775989532471) - 0.00619325737720356*std::sin(0.433199852705002*x_6 - 7.42935991287231) - 0.00764461256816982*std::sin(0.305199921131134*x_60 + 8.297119140625) - 0.0422412828644718*std::sin(0.29751992225647*x_7 - 4.18368005752563) - 0.117645503449604*std::sin(0.327359855175018*x_7 + 2.03519988059998) + 0.0382810972206849*std::sin(0.361599832773209*x_7 + 1.99375987052917) + 0.00634974192998536*std::sin(0.398479849100113*x_7 - 1.17207992076874) + 0.0137651349395774*std::sin(0.316959917545319*x_8 - 7.4203200340271) - 0.0236639352677215*std::sin(0.327199846506119*x_8 - 1.14231991767883) - 0.00695312904131756*std::sin(0.332799851894379*x_8 - 1.1379998922348) - 0.00857371839143199*std::sin(0.30991992354393*x_9 - 7.43063974380493) - 0.132592117337271*std::sin(0.312959939241409*x_9 - 7.42560005187988) - 0.0109439610275471*std::sin(0.321279913187027*x_9 + 5.14111995697021) + 0.00593774249452262*std::sin(0.342559844255447*x_9 - 1.12967991828918) - 0.00396149010179944*std::sin(0.356239855289459*x_91 - 7.3982400894165) - 0.0353110505383733*std::sin(0.359999865293503*x_91 - 7.40871953964233) - 0.0317561169500164*std::sin(0.360959857702255*x_91 - 7.41048002243042) - 0.0396257376870458*std::sin(0.365199834108353*x_91 + 2.00367975234985) + 0.00531556895722596*std::sin(0.374399840831757*x_91 + 1.98335981369019) + 0.0125510722098018*std::sin(0.269919961690903*x_92 + 2.01959991455078) + 0.0175555417034894*std::sin(0.271199941635132*x_92 - 7.38695955276489) + 0.0497978557828451*std::sin(0.309759914875031*x_92 + 1.98343980312347) + 0.0167179259793347*std::sin(0.291919946670532*x_94 - 7.43031978607178) + 0.0744671061107239*std::sin(0.29479992389679*x_94 + 1.96527981758118) + 0.00625522094618565*std::sin(0.300399929285049*x_94 + 1.94839978218079) - 0.0208941090102107*std::sin(0.30447992682457*x_94 + 1.94823980331421) - 0.0417336143676624*std::sin(0.265119940042496*x_95 - 7.42375993728638) + 0.00539132331528946*std::sin(0.281519949436188*x_96 + 1.96807980537415) + 0.0171450633657941*std::sin(0.281999945640564*x_96 - 7.44087982177734) - 0.00802616261712463*std::sin(0.265919953584671*x_97 + 1.98175978660583) + 0.00841035778581039*std::sin(0.270639955997467*x_97 + 1.98279988765717) + 0.0990874095192689*std::sin(0.27167996764183*x_97 - 7.43623971939087) - 0.0223390293829231*std::sin(0.276719957590103*x_97 - 1.20031988620758) + 0.0111015314089258*std::sin(0.246239975094795*x_98 - 7.40775966644287) + 0.0447345486545885*std::sin(0.253519982099533*x_98 - 7.43039989471436) + 0.507099032928564);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000152690766346236*x_10 + 0.00401506909728707*x_100 + 0.00308966163323672*x_101 - 0.00154918058461304*x_102 + 0.00266033906197042*x_103 + 0.00184312420937228*x_104 + 0.00363447037029006*x_105 + 0.0046411588098713*x_106 - 0.00407988117521288*x_107 + 0.00396594921421304*x_108 - 0.00239558566086353*x_109 + 0.00132328385549558*x_11 + 0.000317087077320603*x_110 + 0.000719713787444567*x_111 + 0.00211899255953428*x_112 + 0.00234428428041831*x_113 + 0.00912482355547115*x_114 - 0.0111652984133073*x_115 + 0.00938131537844715*x_116 + 0.0279158749240171*x_117 + 0.0310069783909682*x_118 + 0.0170658566872834*x_119 - 0.00234011078477526*x_12 - 0.00159443930542802*x_120 + 0.000500093665641809*x_13 - 0.000756111513724508*x_14 - 0.00113189162136542*x_15 + 0.00199084005973772*x_17 + 0.00205753745287921*x_18 + 0.000288217494868441*x_19 + 0.00273035682725505*x_2 - 0.00318528354923997*x_20 + 0.000558896839842252*x_21 + 0.000257955564490877*x_22 - 0.000339198983963219*x_23 - 0.000411696614006153*x_24 + 0.000268057753623535*x_25 + 0.000262132245366448*x_26 - 0.00927898612805882*x_27 + 0.00121163848706522*x_28 + 0.000573132056266609*x_3 - 0.00168103037848058*x_30 - 1.7706904794295e-5*x_32 - 0.0065543459041412*x_33 - 0.0127514937165236*x_34 + 0.00019969841577222*x_35 + 0.00422759782717393*x_36 - 0.0043193502329976*x_37 - 0.0134596076782794*x_38 - 0.00805321215232537*x_39 - 0.00331858476402516*x_4 - 0.00878962835060852*x_40 - 0.00120604146306683*x_41 + 0.00583203266591909*x_42 - 0.00800019607045263*x_43 + 0.00209807882721231*x_44 - 0.0273944952519826*x_45 - 0.0167586283890601*x_46 - 0.0286098410318941*x_47 - 0.0111391546216312*x_48 + 0.000803823746811418*x_49 + 0.025394183985013*x_50 + 0.0335746629292653*x_51 - 0.000463298601922043*x_52 - 0.0265402309203621*x_53 - 0.000809616141767664*x_54 + 0.00611851260792784*x_55 - 0.00448101476054304*x_56 - 0.000677354537157261*x_57 + 0.00973325570350774*x_58 - 0.00571375300154202*x_59 - 0.000173531822752404*x_6 - 0.0109993905686986*x_60 + 0.00474004329747924*x_61 + 0.00158299130568955*x_62 + 0.00159953000787127*x_63 - 0.00136851400495405*x_64 - 0.0103337983125243*x_65 + 0.00217260112172727*x_66 + 0.00512272349996372*x_67 + 0.00532666353826952*x_68 + 0.00904641321481379*x_69 + 0.000363562429002568*x_7 + 0.00827321155871517*x_70 - 0.00462709233199881*x_71 - 0.00744970097575215*x_72 + 0.00380627382084167*x_73 + 0.0045140457874051*x_74 + 0.00172782098810204*x_75 + 0.00136362022049792*x_76 - 0.00184550776561435*x_77 - 0.00991721561403474*x_78 - 0.00229473223598768*x_79 + 0.0050681950043752*x_8 + 0.00154228764070482*x_80 + 0.0116124367832403*x_81 - 0.0107957490251498*x_82 + 0.00850218235437882*x_83 + 0.00644728206148698*x_84 - 0.00352186834528862*x_85 + 0.00237424373393359*x_86 - 0.00111400667149728*x_87 - 0.00701942673775109*x_88 + 0.00217904981883067*x_89 - 0.00104806662600305*x_9 + 0.00032959528985374*x_90 - 0.000308907164146761*x_92 + 0.00519033712965331*x_93 - 0.000310023293769331*x_94 - 0.00257516479624557*x_95 + 0.00883272935581757*x_96 + 0.000890804428834429*x_97 - 0.00358170005133231*x_98 + 0.00336291885737279*x_99 + 0.0303724031508838*std::sin(0.248799979686737*x_1 + 5.06423997879028) + 0.0217452984574512*std::sin(0.289279937744141*x_1 - 4.30231952667236) - 0.0125858189398074*std::sin(0.290159940719604*x_1 - 4.30847978591919) + 0.396201356053282*std::sin(0.332159847021103*x_1 - 4.25568008422852) - 0.00861255427965763*std::sin(0.362959831953049*x_1 - 4.21336030960083) + 0.0040073890167145*std::sin(0.25519996881485*x_10 + 1.97087979316711) - 0.0788061828436569*std::sin(0.308879911899567*x_10 - 7.43832015991211) + 0.0048807690985367*std::sin(0.235679984092712*x_101 + 1.99255979061127) + 0.00998305042051283*std::sin(0.231359988451004*x_107 + 5.18703985214233) - 0.00429415129763127*std::sin(0.247759968042374*x_107 - 7.41655969619751) - 0.00849536098614227*std::sin(0.257119953632355*x_107 - 7.43703985214233) + 0.00123881263711271*std::sin(0.262639969587326*x_108 - 7.44599962234497) - 0.0207434701199896*std::sin(0.240399971604347*x_109 - 7.43703985214233) - 0.00818718728515808*std::sin(0.240639984607697*x_109 + 1.97959983348846) + 0.00331864724617122*std::sin(0.261039972305298*x_11 + 1.96351981163025) - 0.0131901149737891*std::sin(0.272159963846207*x_11 - 4.23663997650146) - 0.00527717314818726*std::sin(0.284479945898056*x_11 + 5.16048002243042) + 0.00929181203014564*std::sin(0.209519997239113*x_111 + 1.9819997549057) + 0.0287277968498579*std::sin(0.2743199467659*x_112 + 1.97775983810425) + 0.00707697059854816*std::sin(0.280559957027435*x_112 - 7.44392013549805) + 0.00852697365120486*std::sin(0.280879944562912*x_112 - 7.43415975570679) + 0.0154878293886236*std::sin(0.278159946203232*x_113 - 7.40975999832153) + 0.00415127022823741*std::sin(0.291439920663834*x_113 - 7.43760013580322) + 0.00794078478612981*std::sin(0.256719976663589*x_116 + 5.1450400352478) - 0.022965166207059*std::sin(0.26463994383812*x_12 - 4.23848009109497) + 0.233638150250358*std::sin(0.277199953794479*x_12 + 5.15424013137817) - 0.00359383580972949*std::sin(0.292879939079285*x_12 - 7.44807958602905) + 0.20747057204638*std::sin(0.263919949531555*x_120 + 5.15687990188599) + 0.00697055148706803*std::sin(0.269039958715439*x_120 + 5.15144014358521) + 0.0354972013177114*std::sin(0.270159959793091*x_120 + 5.14448022842407) + 0.219640156303278*std::sin(0.291599929332733*x_13 + 5.1430401802063) - 0.0106615806353113*std::sin(0.301519930362701*x_13 + 8.32544040679932) - 0.0063379149611125*std::sin(0.286319941282272*x_14 + 5.15823984146118) + 0.127729248100324*std::sin(0.291999936103821*x_14 - 7.42631959915161) + 0.011443023262412*std::sin(0.32367992401123*x_14 + 5.12024021148682) - 0.00332540901250908*std::sin(0.310479938983917*x_15 - 7.44432020187378) - 0.00212154091833958*std::sin(0.328799843788147*x_15 - 4.33783960342407) + 0.027471372416755*std::sin(0.332719832658768*x_15 + 5.06071949005127) - 0.00512020262630699*std::sin(0.385759830474854*x_15 + 5.02367973327637) - 0.00252670613273051*std::sin(0.292719930410385*x_16 - 7.40079975128174) + 0.0330668969725013*std::sin(0.321839928627014*x_16 - 7.42136001586914) - 0.00981751126298194*std::sin(0.322159916162491*x_16 + 5.16720008850098) - 0.00490239087436319*std::sin(0.32535982131958*x_16 - 1.15327990055084) - 0.0699549777841329*std::sin(0.331919848918915*x_16 - 1.13143992424011) - 0.0150022378513795*std::sin(0.337999850511551*x_17 + 2.00311970710754) + 0.0250669202720332*std::sin(0.352239847183228*x_17 + 1.99975979328156) - 0.00179113009156359*std::sin(0.373839855194092*x_17 - 1.17871987819672) - 0.00471815768989128*std::sin(0.331439822912216*x_18 + 2.01263976097107) - 0.0116378654509946*std::sin(0.334559857845306*x_18 + 2.01887989044189) + 0.00390958573577524*std::sin(0.371599853038788*x_18 - 1.17215991020203) + 0.00232121827833744*std::sin(0.275839954614639*x_19 + 2.01927995681763) - 0.00984802016923988*std::sin(0.317199915647507*x_19 + 1.98535978794098) - 0.00664171215850499*std::sin(0.36695984005928*x_2 - 7.40399980545044) - 0.0085262353940977*std::sin(0.369359821081161*x_2 - 4.22071981430054) - 0.0136104592381037*std::sin(0.377119839191437*x_2 + 5.18016004562378) - 0.0232654753595775*std::sin(0.381119847297668*x_2 - 7.39511966705322) + 0.00599565094006698*std::sin(0.257119953632355*x_20 + 1.97903978824615) - 0.0107209247471928*std::sin(0.273119956254959*x_20 - 1.17575979232788) - 0.024722354040428*std::sin(0.295519918203354*x_20 + 1.97047984600067) + 0.00422265312951975*std::sin(0.301119923591614*x_20 - 7.42543983459473) + 0.0152761972513786*std::sin(0.268319964408875*x_21 - 1.17343986034393) - 0.0835024992700325*std::sin(0.341759830713272*x_21 + 8.24199962615967) - 0.0395005228368274*std::sin(0.294639945030212*x_22 - 1.14359986782074) - 0.0136037164416559*std::sin(0.363759845495224*x_22 + 2.0052797794342) - 0.00193849257043138*std::sin(0.3018399477005*x_23 + 2.02303981781006) + 0.0104513699531138*std::sin(0.311359941959381*x_23 + 5.05335998535156) - 0.251380999616514*std::sin(0.322639942169189*x_23 - 1.15719985961914) - 0.0505482191485167*std::sin(0.279199957847595*x_24 - 1.16119992733002) - 0.00851150230547964*std::sin(0.314239919185638*x_24 - 1.16023993492126) + 0.00716973732205263*std::sin(0.347999840974808*x_24 + 2.00127983093262) + 0.0124975561495054*std::sin(0.263039946556091*x_25 - 7.39647960662842) - 0.0431629785636558*std::sin(0.37527984380722*x_25 - 4.39687967300415) + 0.0108674853343657*std::sin(0.284639924764633*x_26 - 1.17999982833862) + 0.126424719667687*std::sin(0.308879911899567*x_26 - 1.17639982700348) - 0.0902886780009641*std::sin(0.203599989414215*x_28 - 4.38679981231689) - 0.0223196441017657*std::sin(0.23879998922348*x_28 + 8.20119953155518) - 0.00442777594929671*std::sin(0.316079914569855*x_28 - 1.18503987789154) - 0.00448536309628009*std::sin(0.361279845237732*x_28 - 1.1632798910141) + 0.0197072317620267*std::sin(0.220639988780022*x_29 - 1.18039989471436) + 0.00430777208870733*std::sin(0.26063996553421*x_29 + 2.00991988182068) + 0.00554287489613972*std::sin(0.282079964876175*x_29 + 1.99119985103607) + 0.0771845681553208*std::sin(0.301919937133789*x_29 + 2.01615977287292) + 0.0270390407804462*std::sin(0.3504798412323*x_29 - 1.14943993091583) - 0.0208000288259183*std::sin(0.346159845590591*x_3 - 7.39567947387695) + 0.00695327448191093*std::sin(0.350639849901199*x_3 - 7.40711975097656) - 0.00887024972128427*std::sin(0.35455983877182*x_3 - 7.410719871521) - 0.182824156702306*std::sin(0.363599836826324*x_3 - 7.40783977508545) - 0.0472106391966724*std::sin(0.299279928207397*x_30 + 1.98919987678528) - 0.0557112697030316*std::sin(0.317359924316406*x_30 + 1.98943984508514) + 0.00967890079084678*std::sin(0.345839858055115*x_30 - 1.15679979324341) - 0.00684753086827895*std::sin(0.377519845962524*x_30 - 1.15831983089447) + 0.00256439989249466*std::sin(0.372399836778641*x_31 + 5.19208002090454) + 0.0292577925842958*std::sin(0.375599831342697*x_31 + 5.19080018997192) - 0.0109089564337301*std::sin(0.378239840269089*x_31 + 5.16991996765137) + 0.0223555172607472*std::sin(0.381119847297668*x_31 - 7.3982400894165) + 0.111655636593266*std::sin(0.385039836168289*x_31 - 7.40535974502563) - 0.207519267969512*std::sin(0.305999934673309*x_32 - 1.13367986679077) - 0.023091265253643*std::sin(0.306239932775497*x_32 - 1.14095985889435) - 0.0107087762534565*std::sin(0.311199933290482*x_32 - 1.14927983283997) - 0.0362999424951148*std::sin(0.311919927597046*x_32 - 1.14735984802246) + 0.0279824862869575*std::sin(0.235679984092712*x_33 + 1.98999989032745) - 0.0117330080635121*std::sin(0.241439983248711*x_33 + 1.98831987380981) - 0.00236065577171835*std::sin(0.213759988546371*x_34 - 1.18095993995667) - 0.0167200042127*std::sin(0.236879989504814*x_35 + 1.97175979614258) + 0.0113225735639984*std::sin(0.242319971323013*x_35 + 1.98367977142334) - 0.00309991766553581*std::sin(0.244559973478317*x_35 - 7.43903970718384) - 0.171488523102989*std::sin(0.248479977250099*x_35 + 1.97895979881287) + 0.00444365799029959*std::sin(0.228959992527962*x_37 + 1.97391974925995) + 0.0112770874905903*std::sin(0.234239995479584*x_38 + 1.95567977428436) + 0.0212069634237203*std::sin(0.237199977040291*x_38 + 1.97767984867096) - 0.00149802944382357*std::sin(0.30583992600441*x_4 + 2.03351974487305) - 0.0118181097205592*std::sin(0.333039849996567*x_4 + 2.02287983894348) + 0.014853831484804*std::sin(0.343119859695435*x_4 + 1.99575984477997) - 0.00147186288231537*std::sin(0.388719856739044*x_4 - 1.17711985111237) - 0.0799011728421593*std::sin(0.244799971580505*x_41 + 1.98759984970093) - 0.0168891276781512*std::sin(0.232479989528656*x_42 + 1.96527981758118) - 0.00475461465489574*std::sin(0.203439995646477*x_44 + 1.98855984210968) + 0.00157470566364393*std::sin(0.260159969329834*x_44 + 1.9625598192215) - 0.00547470397480622*std::sin(0.231039986014366*x_46 + 1.98183989524841) - 0.0249159526527723*std::sin(0.188880011439323*x_47 - 1.1975998878479) - 0.00762538564764203*std::sin(0.202639997005463*x_47 + 1.9793598651886) - 0.019204904635091*std::sin(0.215279996395111*x_47 + 1.98183989524841) + 0.00293730828208273*std::sin(0.208159998059273*x_48 + 8.21032047271729) + 0.099110263664123*std::sin(0.264479964971542*x_49 - 7.47544002532959) + 0.00314882685750662*std::sin(0.285279929637909*x_5 - 1.16967988014221) - 0.0111913236230308*std::sin(0.347439825534821*x_5 + 2.02791976928711) - 0.00549438931860905*std::sin(0.34911984205246*x_5 + 1.99775981903076) + 0.00816983436528253*std::sin(0.369679838418961*x_5 + 1.99015974998474) - 0.0688431798663335*std::sin(0.410559862852097*x_5 + 1.96807980537415) - 0.00710145920263846*std::sin(0.18384000658989*x_51 + 1.98735988140106) - 0.00623578868798168*std::sin(0.216719999909401*x_52 + 1.99559986591339) - 0.113672745183847*std::sin(0.227119997143745*x_52 - 7.40711975097656) - 0.00859667688215687*std::sin(0.203919991850853*x_53 + 2.00807976722717) - 0.0510845732675851*std::sin(0.243119969964027*x_53 - 7.4256796836853) + 0.0148258186270925*std::sin(0.245759963989258*x_56 + 5.15263986587524) - 0.015843887330926*std::sin(0.201920002698898*x_57 - 7.38839960098267) - 0.0771547597083332*std::sin(0.211840003728867*x_57 + 5.19672012329102) - 0.00567264860997527*std::sin(0.247519969940186*x_57 - 7.42671966552734) - 0.0038051459447114*std::sin(0.180560007691383*x_6 + 8.18007946014404) - 0.0172827939708512*std::sin(0.407519847154617*x_6 - 7.41775989532471) - 0.00165678467090615*std::sin(0.433199852705002*x_6 - 7.42935991287231) - 0.012927556638994*std::sin(0.305199921131134*x_60 + 8.297119140625) + 0.151456086044408*std::sin(0.29751992225647*x_7 - 4.18368005752563) + 0.00646476821041092*std::sin(0.327359855175018*x_7 + 2.03519988059998) + 0.0542771726616394*std::sin(0.361599832773209*x_7 + 1.99375987052917) + 0.0107378428548058*std::sin(0.398479849100113*x_7 - 1.17207992076874) + 0.00368236990195036*std::sin(0.316959917545319*x_8 - 7.4203200340271) - 0.033552107792928*std::sin(0.327199846506119*x_8 - 1.14231991767883) - 0.0117582112498589*std::sin(0.332799851894379*x_8 - 1.1379998922348) - 0.0144987373949491*std::sin(0.30991992354393*x_9 - 7.43063974380493) + 0.00728610342069087*std::sin(0.312959939241409*x_9 - 7.42560005187988) - 0.00292766564751122*std::sin(0.321279913187027*x_9 + 5.14111995697021) - 0.0212897709817507*std::sin(0.342559844255447*x_9 - 1.12967991828918) - 0.00669914756426787*std::sin(0.356239855289459*x_91 - 7.3982400894165) + 0.00194038658769883*std::sin(0.359999865293503*x_91 - 7.40871953964233) + 0.113861532014769*std::sin(0.360959857702255*x_91 - 7.41048002243042) - 0.0106004499368778*std::sin(0.365199834108353*x_91 + 2.00367975234985) + 0.00753672373659936*std::sin(0.374399840831757*x_91 + 1.98335981369019) + 0.017795642311214*std::sin(0.269919961690903*x_92 + 2.01959991455078) - 0.0629453807861555*std::sin(0.271199941635132*x_92 - 7.38695955276489) - 0.00273645473538621*std::sin(0.309759914875031*x_92 + 1.98343980312347) + 0.00447228361505814*std::sin(0.291919946670532*x_94 - 7.43031978607178) - 0.00409206103242294*std::sin(0.29479992389679*x_94 + 1.96527981758118) + 0.0105780014814533*std::sin(0.300399929285049*x_94 + 1.94839978218079) + 0.074915811203578*std::sin(0.30447992682457*x_94 + 1.94823980331421) + 0.00229331453866561*std::sin(0.265119940042496*x_95 - 7.42375993728638) + 0.00911709218695163*std::sin(0.281519949436188*x_96 + 1.96807980537415) + 0.0243092709499748*std::sin(0.281999945640564*x_96 - 7.44087982177734) - 0.0135727835650794*std::sin(0.265919953584671*x_97 + 1.98175978660583) + 0.00224989064844234*std::sin(0.270639955997467*x_97 + 1.98279988765717) - 0.00544497763475118*std::sin(0.27167996764183*x_97 - 7.43623971939087) + 0.080096572048342*std::sin(0.276719957590103*x_97 - 1.20031988620758) + 0.018773440091133*std::sin(0.246239975094795*x_98 - 7.40775966644287) + 0.0119671297278288*std::sin(0.253519982099533*x_98 - 7.43039989471436) + 0.289356030299767);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00106002031958605*x_10 - 0.00111709717477094*x_100 + 0.00470457222832914*x_101 + 0.000864595879262396*x_102 + 0.00259052496975561*x_103 + 0.00548889006119768*x_104 - 0.00359974115306068*x_105 - 0.000356039761756191*x_106 + 0.00555254982610436*x_107 - 0.0013403554199534*x_108 + 0.00363688153695026*x_109 - 0.000990391287658428*x_11 - 0.0104929563706014*x_110 - 0.00954685127266526*x_111 - 0.00145125672541708*x_112 - 0.00101144485590083*x_113 - 0.0134395963347267*x_114 + 0.00631443773985305*x_115 - 0.00517711910305275*x_116 - 0.0275079718873548*x_117 - 0.0304312320750474*x_118 - 0.0184885950151313*x_119 - 5.53954524288912e-5*x_12 - 1.69530833323225e-5*x_120 - 0.000267445205153129*x_13 + 0.000181399666787331*x_14 + 0.00198569074805798*x_15 - 0.00165692959255525*x_17 - 0.0013119597995634*x_18 + 0.000420708718654872*x_19 - 0.00188794577679071*x_2 + 0.00220251161483325*x_20 - 0.00207421005731252*x_21 - 0.00177800736039162*x_22 + 3.17062612191429e-5*x_23 - 0.00348976623536608*x_24 - 0.000455763480338402*x_25 - 0.00219844415538768*x_26 + 0.00701912174349571*x_27 - 0.000769455892615244*x_28 - 0.000363969816615191*x_3 + 0.001162373420217*x_30 - 1.61674276658981e-5*x_32 + 0.00514587223686229*x_33 + 0.011741081729442*x_34 + 0.000182336197630206*x_35 - 0.00777398797590998*x_36 + 0.00687599210308706*x_37 + 0.00863910407030097*x_38 + 0.00403319296530573*x_39 + 0.00229468471945555*x_4 + 0.00672665624027127*x_40 + 0.00492456428476761*x_41 - 0.0030035464930947*x_42 + 0.00195538490586217*x_43 - 0.000140645865133244*x_44 + 0.0244453204066424*x_45 + 0.0102603791131302*x_46 + 0.0203348836588166*x_47 + 0.00636541479420722*x_48 - 0.00263289851340781*x_49 - 0.0199279101576154*x_50 - 0.00540350191733193*x_51 + 0.00487814050934194*x_52 + 0.013214100731965*x_53 - 0.00381038497996072*x_54 - 0.00160831264023359*x_55 - 0.0031569168274328*x_56 + 0.000293550498858666*x_57 - 0.00199554884256835*x_58 + 0.0010633529900483*x_59 + 0.000102894757564711*x_6 + 0.00628993737203198*x_60 - 0.00644201337329278*x_61 - 0.00186531082377165*x_62 - 0.00586056898734019*x_63 + 0.00348156889611644*x_64 + 0.00799714428101925*x_65 - 0.00301920335765594*x_66 - 0.00573947128702509*x_67 - 0.00281389755293199*x_68 - 0.00569875828062619*x_69 + 0.000331953514248918*x_7 - 0.00660543154741424*x_70 + 0.0040962272694206*x_71 + 0.00623431230812122*x_72 - 0.0030127658758231*x_73 - 0.00548701327693601*x_74 - 0.00217109249364647*x_75 - 0.00504456514148878*x_76 - 0.00156697928066999*x_77 + 0.00574885659145617*x_78 - 0.00204777039457589*x_79 - 0.00218511408982452*x_8 + 0.0034328833284782*x_80 - 0.00959106849600194*x_81 + 0.0110753632399417*x_82 - 0.0107324048000524*x_83 - 0.00351952042812803*x_84 + 0.00388258950871173*x_85 - 0.00108862860644422*x_86 + 0.00395901616898512*x_87 + 0.00220752152454229*x_88 - 0.00122781819185603*x_89 + 0.00183863557545562*x_9 + 0.00130784690434479*x_90 + 7.23770874764293e-5*x_92 - 0.00849829012032893*x_93 + 0.000543877500725381*x_94 + 0.00154973941658231*x_95 - 0.0099194738909992*x_96 - 0.00156274865833161*x_97 - 0.000120246110217796*x_98 - 0.00557545827669311*x_99 - 0.019288116733515*std::sin(0.248799979686737*x_1 + 5.06423997879028) - 0.038148032148725*std::sin(0.289279937744141*x_1 - 4.30231952667236) - 0.0114915802445036*std::sin(0.290159940719604*x_1 - 4.30847978591919) - 0.273959311637501*std::sin(0.332159847021103*x_1 - 4.25568008422852) + 0.10422689970273*std::sin(0.362959831953049*x_1 - 4.21336030960083) - 0.0484963832508385*std::sin(0.25519996881485*x_10 + 1.97087979316711) + 0.0544917054794832*std::sin(0.308879911899567*x_10 - 7.43832015991211) - 0.003099552039206*std::sin(0.235679984092712*x_101 + 1.99255979061127) - 0.00633977630649928*std::sin(0.231359988451004*x_107 + 5.18703985214233) + 0.0519667060518492*std::sin(0.247759968042374*x_107 - 7.41655969619751) - 0.00775675567439658*std::sin(0.257119953632355*x_107 - 7.43703985214233) - 0.0149917894606238*std::sin(0.262639969587326*x_108 - 7.44599962234497) + 0.0363905129452168*std::sin(0.240399971604347*x_109 - 7.43703985214233) - 0.00747537527070235*std::sin(0.240639984607697*x_109 + 1.97959983348846) + 0.00303011677785673*std::sin(0.261039972305298*x_11 + 1.96351981163025) + 0.0231395734139978*std::sin(0.272159963846207*x_11 - 4.23663997650146) + 0.0638629817090593*std::sin(0.284479945898056*x_11 + 5.16048002243042) - 0.00590080258756583*std::sin(0.209519997239113*x_111 + 1.9819997549057) - 0.0503975109808114*std::sin(0.2743199467659*x_112 + 1.97775983810425) - 0.085643663984359*std::sin(0.280559957027435*x_112 - 7.44392013549805) + 0.00778561986504216*std::sin(0.280879944562912*x_112 - 7.43415975570679) - 0.00983560832221615*std::sin(0.278159946203232*x_113 - 7.40975999832153) + 0.0037903496921861*std::sin(0.291439920663834*x_113 - 7.43760013580322) - 0.0960973194003278*std::sin(0.256719976663589*x_116 + 5.1450400352478) + 0.040288060450488*std::sin(0.26463994383812*x_12 - 4.23848009109497) - 0.161552568755568*std::sin(0.277199953794479*x_12 + 5.15424013137817) - 0.00328137984429871*std::sin(0.292879939079285*x_12 - 7.44807958602905) - 0.143458608191187*std::sin(0.263919949531555*x_120 + 5.15687990188599) - 0.0843558074787819*std::sin(0.269039958715439*x_120 + 5.15144014358521) - 0.0225426404136604*std::sin(0.270159959793091*x_120 + 5.14448022842407) - 0.151873447956365*std::sin(0.291599929332733*x_13 + 5.1430401802063) + 0.0187037359651744*std::sin(0.301519930362701*x_13 + 8.32544040679932) + 0.0766998042075116*std::sin(0.286319941282272*x_14 + 5.15823984146118) - 0.0883202855086502*std::sin(0.291999936103821*x_14 - 7.42631959915161) - 0.0200746299319484*std::sin(0.32367992401123*x_14 + 5.12024021148682) + 0.0402432379945613*std::sin(0.310479938983917*x_15 - 7.44432020187378) - 0.0019370894990382*std::sin(0.328799843788147*x_15 - 4.33783960342407) - 0.0189954884354801*std::sin(0.332719832658768*x_15 + 5.06071949005127) + 0.00325160526366138*std::sin(0.385759830474854*x_15 + 5.02367973327637) - 0.00230702876129222*std::sin(0.292719930410385*x_16 - 7.40079975128174) - 0.0209992658681721*std::sin(0.321839928627014*x_16 - 7.42136001586914) + 0.0172229751646555*std::sin(0.322159916162491*x_16 + 5.16720008850098) + 0.0593274637667822*std::sin(0.32535982131958*x_16 - 1.15327990055084) + 0.0483714082916476*std::sin(0.331919848918915*x_16 - 1.13143992424011) + 0.00952723146416367*std::sin(0.337999850511551*x_17 + 2.00311970710754) - 0.0439751922595194*std::sin(0.352239847183228*x_17 + 1.99975979328156) + 0.0216757921455285*std::sin(0.373839855194092*x_17 - 1.17871987819672) + 0.0570979215176004*std::sin(0.331439822912216*x_18 + 2.01263976097107) + 0.0073906732448069*std::sin(0.334559857845306*x_18 + 2.01887989044189) - 0.00685863211435689*std::sin(0.371599853038788*x_18 - 1.17215991020203) + 0.00211940647152925*std::sin(0.275839954614639*x_19 + 2.01927995681763) + 0.119178187692146*std::sin(0.317199915647507*x_19 + 1.98535978794098) - 0.00606426714029331*std::sin(0.36695984005928*x_2 - 7.40399980545044) + 0.00541462006683518*std::sin(0.369359821081161*x_2 - 4.22071981430054) + 0.164710250159878*std::sin(0.377119839191437*x_2 + 5.18016004562378) + 0.0408148963192736*std::sin(0.381119847297668*x_2 - 7.39511966705322) + 0.005474375900792*std::sin(0.257119953632355*x_20 + 1.97903978824615) + 0.00680836636428841*std::sin(0.273119956254959*x_20 - 1.17575979232788) + 0.0433707156777719*std::sin(0.295519918203354*x_20 + 1.97047984600067) - 0.0511014537521581*std::sin(0.301119923591614*x_20 - 7.42543983459473) - 0.00970121048258962*std::sin(0.268319964408875*x_21 - 1.17343986034393) + 0.0577390432175921*std::sin(0.341759830713272*x_21 + 8.24199962615967) + 0.0273132231385986*std::sin(0.294639945030212*x_22 - 1.14359986782074) + 0.0086390948201496*std::sin(0.363759845495224*x_22 + 2.0052797794342) + 0.0234591346715868*std::sin(0.3018399477005*x_23 + 2.02303981781006) - 0.0183349608996967*std::sin(0.311359941959381*x_23 + 5.05335998535156) + 0.173821125449216*std::sin(0.322639942169189*x_23 - 1.15719985961914) + 0.0349523168228805*std::sin(0.279199957847595*x_24 - 1.16119992733002) - 0.00777149363203801*std::sin(0.314239919185638*x_24 - 1.16023993492126) - 0.0125779542826121*std::sin(0.347999840974808*x_24 + 2.00127983093262) - 0.0079366232792911*std::sin(0.263039946556091*x_25 - 7.39647960662842) + 0.0298456825421191*std::sin(0.37527984380722*x_25 - 4.39687967300415) - 0.00690144025442082*std::sin(0.284639924764633*x_26 - 1.17999982833862) - 0.0874182499503251*std::sin(0.308879911899567*x_26 - 1.17639982700348) + 0.0624314472827742*std::sin(0.203599989414215*x_28 - 4.38679981231689) + 0.0391556134494213*std::sin(0.23879998922348*x_28 + 8.20119953155518) - 0.00404281539956786*std::sin(0.316079914569855*x_28 - 1.18503987789154) + 0.0542807016810926*std::sin(0.361279845237732*x_28 - 1.1632798910141) - 0.0125151567635946*std::sin(0.220639988780022*x_29 - 1.18039989471436) - 0.0521315413352343*std::sin(0.26063996553421*x_29 + 2.00991988182068) + 0.00506096519891687*std::sin(0.282079964876175*x_29 + 1.99119985103607) - 0.0533704159206002*std::sin(0.301919937133789*x_29 + 2.01615977287292) - 0.0474349063997188*std::sin(0.3504798412323*x_29 - 1.14943993091583) + 0.0364897345464415*std::sin(0.346159845590591*x_3 - 7.39567947387695) - 0.0841467256402005*std::sin(0.350639849901199*x_3 - 7.40711975097656) - 0.0080990507608942*std::sin(0.35455983877182*x_3 - 7.410719871521) + 0.126416478277108*std::sin(0.363599836826324*x_3 - 7.40783977508545) + 0.0828221781071663*std::sin(0.299279928207397*x_30 + 1.98919987678528) + 0.0353796658126191*std::sin(0.317359924316406*x_30 + 1.98943984508514) + 0.00883739593335569*std::sin(0.345839858055115*x_30 - 1.15679979324341) + 0.0828670438345071*std::sin(0.377519845962524*x_30 - 1.15831983089447) + 0.00234144534293211*std::sin(0.372399836778641*x_31 + 5.19208002090454) - 0.0513272887144022*std::sin(0.375599831342697*x_31 + 5.19080018997192) + 0.132017363393041*std::sin(0.378239840269089*x_31 + 5.16991996765137) - 0.014196961117015*std::sin(0.381119847297668*x_31 - 7.3982400894165) - 0.0772059481225614*std::sin(0.385039836168289*x_31 - 7.40535974502563) + 0.143492279710421*std::sin(0.305999934673309*x_32 - 1.13367986679077) + 0.0146642008379856*std::sin(0.306239932775497*x_32 - 1.14095985889435) + 0.129594834733786*std::sin(0.311199933290482*x_32 - 1.14927983283997) + 0.063681414904931*std::sin(0.311919927597046*x_32 - 1.14735984802246) - 0.0490900039180806*std::sin(0.235679984092712*x_33 + 1.98999989032745) + 0.141989822640121*std::sin(0.241439983248711*x_33 + 1.98831987380981) + 0.0285680443178979*std::sin(0.213759988546371*x_34 - 1.18095993995667) + 0.0293320995101971*std::sin(0.236879989504814*x_35 + 1.97175979614258) - 0.00719044586433577*std::sin(0.242319971323013*x_35 + 1.98367977142334) + 0.0375144001560205*std::sin(0.244559973478317*x_35 - 7.43903970718384) + 0.118578286079133*std::sin(0.248479977250099*x_35 + 1.97895979881287) - 0.0537759972975872*std::sin(0.228959992527962*x_37 + 1.97391974925995) - 0.00716155975054077*std::sin(0.234239995479584*x_38 + 1.95567977428436) - 0.0372036246845674*std::sin(0.237199977040291*x_38 + 1.97767984867096) + 0.0181287640719917*std::sin(0.30583992600441*x_4 + 2.03351974487305) + 0.0075051380928677*std::sin(0.333039849996567*x_4 + 2.02287983894348) - 0.0260582508040897*std::sin(0.343119859695435*x_4 + 1.99575984477997) - 0.00134389589600216*std::sin(0.388719856739044*x_4 - 1.17711985111237) + 0.0552488525756666*std::sin(0.244799971580505*x_41 + 1.98759984970093) + 0.0107255084349142*std::sin(0.232479989528656*x_42 + 1.96527981758118) - 0.00434123803144933*std::sin(0.203439995646477*x_44 + 1.98855984210968) - 0.0190566798114232*std::sin(0.260159969329834*x_44 + 1.9625598192215) - 0.00499872120696114*std::sin(0.231039986014366*x_46 + 1.98183989524841) + 0.0437103479942522*std::sin(0.188880011439323*x_47 - 1.1975998878479) - 0.00696241789940332*std::sin(0.202639997005463*x_47 + 1.9793598651886) + 0.0121961519020229*std::sin(0.215279996395111*x_47 + 1.98183989524841) - 0.0355465435423422*std::sin(0.208159998059273*x_48 + 8.21032047271729) - 0.0685312636991149*std::sin(0.264479964971542*x_49 - 7.47544002532959) + 0.00287506094614445*std::sin(0.285279929637909*x_5 - 1.16967988014221) + 0.00710709506163266*std::sin(0.347439825534821*x_5 + 2.02791976928711) + 0.0664916755057227*std::sin(0.34911984205246*x_5 + 1.99775981903076) - 0.0143324362563422*std::sin(0.369679838418961*x_5 + 1.99015974998474) + 0.0476026391100515*std::sin(0.410559862852097*x_5 + 1.96807980537415) - 0.00648404276833155*std::sin(0.18384000658989*x_51 + 1.98735988140106) - 0.00569363554635769*std::sin(0.216719999909401*x_52 + 1.99559986591339) + 0.0786007078136396*std::sin(0.227119997143745*x_52 - 7.40711975097656) + 0.00545935421703786*std::sin(0.203919991850853*x_53 + 2.00807976722717) + 0.0896182660876731*std::sin(0.243119969964027*x_53 - 7.4256796836853) + 0.013536829447373*std::sin(0.245759963989258*x_56 + 5.15263986587524) + 0.0277951173879536*std::sin(0.201920002698898*x_57 - 7.38839960098267) + 0.0533498044272448*std::sin(0.211840003728867*x_57 + 5.19672012329102) + 0.0686489232488447*std::sin(0.247519969940186*x_57 - 7.42671966552734) + 0.0460488900105315*std::sin(0.180560007691383*x_6 + 8.18007946014404) + 0.0303194081842507*std::sin(0.407519847154617*x_6 - 7.41775989532471) - 0.0015127401788185*std::sin(0.433199852705002*x_6 - 7.42935991287231) + 0.00820969681896202*std::sin(0.305199921131134*x_60 + 8.297119140625) - 0.104726559972844*std::sin(0.29751992225647*x_7 - 4.18368005752563) - 0.0782349493528747*std::sin(0.327359855175018*x_7 + 2.03519988059998) - 0.0952190806527476*std::sin(0.361599832773209*x_7 + 1.99375987052917) - 0.00681911027654744*std::sin(0.398479849100113*x_7 - 1.17207992076874) + 0.00336221658841494*std::sin(0.316959917545319*x_8 - 7.4203200340271) + 0.0588608562557356*std::sin(0.327199846506119*x_8 - 1.14231991767883) + 0.00746709932822708*std::sin(0.332799851894379*x_8 - 1.1379998922348) + 0.00920748147497901*std::sin(0.30991992354393*x_9 - 7.43063974380493) - 0.0881745351951799*std::sin(0.312959939241409*x_9 - 7.42560005187988) - 0.00267312797668187*std::sin(0.321279913187027*x_9 + 5.14111995697021) + 0.0147211283201567*std::sin(0.342559844255447*x_9 - 1.12967991828918) + 0.00425432059467712*std::sin(0.356239855289459*x_91 - 7.3982400894165) - 0.0234820555776688*std::sin(0.359999865293503*x_91 - 7.40871953964233) - 0.0787312472715575*std::sin(0.360959857702255*x_91 - 7.41048002243042) - 0.00967882357596815*std::sin(0.365199834108353*x_91 + 2.00367975234985) - 0.013221762854275*std::sin(0.374399840831757*x_91 + 1.98335981369019) - 0.0312191040432827*std::sin(0.269919961690903*x_92 + 2.01959991455078) + 0.0435245183477274*std::sin(0.271199941635132*x_92 - 7.38695955276489) + 0.0331158659771603*std::sin(0.309759914875031*x_92 + 1.98343980312347) + 0.00408345347127691*std::sin(0.291919946670532*x_94 - 7.43031978607178) + 0.0495210620397683*std::sin(0.29479992389679*x_94 + 1.96527981758118) - 0.00671760236975611*std::sin(0.300399929285049*x_94 + 1.94839978218079) - 0.0518016502329616*std::sin(0.30447992682457*x_94 + 1.94823980331421) - 0.0277530981688995*std::sin(0.265119940042496*x_95 - 7.42375993728638) - 0.00578984604868263*std::sin(0.281519949436188*x_96 + 1.96807980537415) - 0.0426460391668682*std::sin(0.281999945640564*x_96 - 7.44087982177734) + 0.00861945077251378*std::sin(0.265919953584671*x_97 + 1.98175978660583) + 0.00205428022217591*std::sin(0.270639955997467*x_97 + 1.98279988765717) + 0.0658937081141254*std::sin(0.27167996764183*x_97 - 7.43623971939087) - 0.0553839642586592*std::sin(0.276719957590103*x_97 - 1.20031988620758) - 0.0119221486086749*std::sin(0.246239975094795*x_98 - 7.40775966644287) + 0.010926681229202*std::sin(0.253519982099533*x_98 - 7.43039989471436) + 0.392485280958287);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
