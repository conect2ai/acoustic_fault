
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.85290213094669e-5*x_1 - 0.000309697704524856*x_10 + 7.33946608854121e-5*x_100 - 4.21149418772415e-5*x_101 - 3.51257626815746e-5*x_102 + 0.000220231320632362*x_103 + 6.58521473645467e-5*x_104 + 0.000318741412245888*x_105 + 6.59491648169024e-5*x_106 + 4.3645775311595e-5*x_107 + 0.000113481867431887*x_108 - 2.69387679946901e-5*x_109 - 1.27181945952826e-5*x_11 + 3.66940889281786e-5*x_110 + 0.000162472098205665*x_111 + 4.28087636308187e-5*x_112 + 5.83461160369517e-5*x_113 + 9.92211542953314e-5*x_114 - 8.84304351203918e-5*x_115 - 2.42143776217602e-5*x_116 - 5.20701321734662e-5*x_117 + 8.53097936998384e-5*x_118 + 9.62548269186572e-5*x_119 - 2.94996572226604e-5*x_12 - 2.93947163326688e-6*x_120 - 0.000315764451615536*x_13 + 0.000194685411948192*x_14 - 0.000184330322005127*x_15 - 0.000133174228228809*x_16 + 5.94548378714401e-5*x_17 + 3.00002731328554e-5*x_18 + 0.00028536973593749*x_19 - 7.97774572523e-5*x_2 + 5.43032704895405e-5*x_20 + 9.49223377199316e-5*x_21 + 9.49577876622027e-5*x_22 + 0.000205871868322965*x_23 + 4.94367748455283e-5*x_24 - 0.000307572922947465*x_25 + 0.00020083936562873*x_26 - 6.71476277770432e-5*x_27 + 0.00012060594936345*x_28 + 0.000244392417228159*x_29 - 0.000143985961376038*x_3 + 0.000683962924815824*x_30 + 3.4834035088439e-5*x_31 + 8.28424504007034e-5*x_32 + 0.000194486026300765*x_33 - 0.000179286149589463*x_34 - 0.00020913470269435*x_35 + 5.61043135011185e-5*x_36 - 0.000295390434097977*x_37 - 5.74396312056857e-5*x_38 + 0.000117199248653841*x_39 + 3.086414725156e-5*x_4 + 8.42714175604792e-5*x_40 - 6.32464486661145e-5*x_41 - 0.000134389112065438*x_42 + 0.000175097011045956*x_43 + 0.000216224376248625*x_44 - 0.000330646846194026*x_45 - 0.000211064838134171*x_46 - 3.15382726545342e-5*x_47 - 0.000195075238914052*x_48 - 0.000593901676983061*x_49 + 9.4173564056924e-5*x_5 - 7.65014299945003e-5*x_50 - 9.05216766621652e-5*x_51 + 9.91498406288088e-5*x_52 - 7.1358444948521e-5*x_53 + 5.65093599398033e-5*x_54 - 0.000104518256479127*x_55 + 0.000422095113650404*x_56 + 0.000170165905261169*x_57 - 0.000423346141646752*x_58 - 0.000471369560661491*x_59 + 0.000265132018710731*x_6 + 9.18398941589944e-5*x_60 - 1.94932754764096e-5*x_61 - 8.97736822653617e-6*x_62 - 2.65723132870053e-5*x_63 - 9.3053100454525e-6*x_64 + 6.23889764042714e-5*x_65 + 0.000176304579348699*x_66 + 0.000119869086333787*x_67 + 7.39656232178307e-6*x_68 - 3.02613760656445e-5*x_69 - 7.28912367952467e-6*x_7 - 3.82064881799176e-5*x_70 + 2.05165389151878e-5*x_71 + 2.04651291840479e-5*x_72 + 8.9470310370333e-5*x_73 - 2.57228613757363e-5*x_74 - 6.98374307708178e-6*x_75 - 3.93496947171829e-5*x_76 - 6.7193320086048e-5*x_77 + 4.05365539666478e-5*x_78 - 4.26091102532244e-5*x_79 + 0.000210444760747516*x_8 - 3.92741024417612e-5*x_80 + 5.13995633202614e-5*x_81 - 2.25836227902227e-5*x_82 - 4.85443885060688e-6*x_83 + 4.01143170411048e-5*x_84 - 7.91441902272442e-5*x_85 - 9.21877195048765e-6*x_86 + 2.38315393655957e-5*x_87 - 5.74909724862386e-6*x_88 + 4.65329631003339e-6*x_89 + 3.25655758604479e-5*x_9 + 9.96020912151487e-6*x_90 - 5.00253300773629e-6*x_91 - 5.0183803728306e-6*x_92 + 4.77240682639784e-5*x_93 + 2.16184554367964e-5*x_94 - 9.48574879956081e-5*x_95 + 0.000246390910540494*x_96 + 0.000185606359060482*x_97 - 0.000239549759094225*x_98 + 0.000517315904736453*x_99 - 3.17335920602051e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 9.18634659028451e-5*std::sin(1.2617598772049*x_120 - 5.20279979705811) - 0.000155558599902784*std::sin(0.510879814624786*x_14 - 2.01327991485596) + 3.90945927013226e-7*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 0.0001773878526838*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 4.17328112726334e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 2.67911420067954e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 9.17004119030666e-5*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0361458107946528);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.44057071342346e-5*x_1 - 7.00416657636463e-7*x_10 - 5.22867050091095e-5*x_100 - 5.65884801714736e-5*x_101 - 7.71067283483946e-7*x_102 - 0.000150171227893144*x_103 - 5.45870806932655e-5*x_104 - 0.000350331958926429*x_105 + 0.00015183474874781*x_106 + 1.79056071703126e-5*x_107 - 0.000161686282411241*x_108 - 0.00019145271896975*x_109 + 2.38636961498384e-6*x_11 + 9.40933831625432e-5*x_110 - 4.25558517477351e-6*x_111 + 5.82427839581201e-5*x_112 - 0.000143424710139098*x_113 - 0.000134778253266491*x_114 + 0.000172082744096698*x_115 - 0.000296914418004953*x_116 + 9.84477301018756e-5*x_117 + 6.7071539927917e-5*x_118 + 3.44617488968139e-6*x_119 + 0.000102648983577492*x_12 + 3.60859357130991e-5*x_120 - 4.59403660994651e-5*x_13 - 3.60920099604767e-5*x_14 - 4.12160770889227e-5*x_15 - 1.15422999505738e-5*x_16 - 0.000135949033791843*x_17 - 0.000227997735738253*x_18 - 0.000636174414533026*x_19 + 1.98036546240513e-5*x_2 + 0.000102485957168382*x_20 + 3.11808907609443e-6*x_21 + 1.51544940326648e-5*x_22 - 0.000163096021205563*x_23 + 0.000107554927920207*x_24 + 8.59088085769802e-5*x_25 + 0.000325615108149886*x_26 + 0.000316666982771976*x_27 - 5.44466926994402e-5*x_28 + 0.00011374958594175*x_29 - 4.62136774173309e-7*x_3 + 0.000368369312890222*x_30 + 4.39837038061314e-5*x_31 + 4.94544093626149e-5*x_32 - 0.000170623591153676*x_33 - 0.00032144011165354*x_34 - 1.50724827166466e-5*x_35 - 1.80395915069057e-5*x_36 - 0.000246514433630545*x_37 - 4.77038286099622e-5*x_38 - 5.68370286712406e-5*x_39 + 4.15727045462583e-5*x_4 + 2.90802231321422e-6*x_40 - 3.82322686087882e-5*x_41 - 0.000104894759368443*x_42 + 0.000150963218421801*x_43 - 7.96064385038029e-5*x_44 + 1.37146660647206e-5*x_45 - 3.34824062640652e-5*x_46 - 0.000208698744201881*x_47 + 0.000207530958284537*x_48 + 0.00033505874860849*x_49 - 1.78465988048972e-5*x_5 - 0.000336368810823717*x_50 + 0.00019696566013027*x_51 - 0.000150612195492393*x_52 + 0.00015681889675869*x_53 - 0.000421780965593146*x_54 - 7.15863537550005e-5*x_55 + 0.000854774467481983*x_56 + 9.14810792405961e-5*x_57 + 0.000364179886050623*x_58 + 8.59587431084113e-5*x_59 - 4.29618220272927e-5*x_6 + 0.000179445307885349*x_60 + 4.41400108885146e-5*x_61 + 5.58002881349669e-5*x_62 + 4.03420589160623e-6*x_63 + 3.90112986880205e-5*x_64 + 0.000120906221649108*x_65 + 0.000124175729496988*x_66 - 1.92900240646275e-5*x_67 - 0.000150187965256001*x_68 - 3.93475515743913e-6*x_69 + 2.2093004021327e-5*x_7 + 6.9289210172419e-5*x_70 + 1.60528365844951e-5*x_71 - 3.55860419734677e-5*x_72 + 2.23200511265181e-5*x_73 + 7.7134132535858e-5*x_74 - 1.77195198299793e-5*x_75 + 2.54295660099361e-5*x_76 + 1.50239865029583e-5*x_77 + 3.10353542931972e-6*x_78 - 0.000110091654410459*x_79 - 2.95641280502198e-5*x_8 - 2.6227550356452e-5*x_80 - 3.2703797867614e-5*x_81 - 7.27953428248804e-6*x_82 + 0.000259008923767816*x_83 + 5.16871640228114e-5*x_84 + 9.71163830901994e-5*x_85 + 6.22579162158107e-5*x_86 + 1.04783772087789e-5*x_87 + 5.45194829206524e-7*x_88 - 3.85690314074717e-5*x_89 + 6.68614587880802e-5*x_9 - 0.000164824024503589*x_90 + 3.60803910892515e-5*x_91 - 8.44617149497996e-5*x_92 + 4.37637553977945e-5*x_93 + 5.26632134853038e-5*x_94 + 8.36886007706925e-5*x_95 - 0.000198965426534099*x_96 - 7.89067728155288e-5*x_97 + 1.19522737284682e-5*x_98 - 0.000572280478136304*x_99 - 4.03546108074036e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) + 6.67603080547931e-5*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000173681464355953*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 0.00029072599852299*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 4.70845665619001e-5*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 7.43053173433209e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) - 3.06355134182834e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) + 6.66418111621733e-5*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0713570608624778);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.60121252218267e-5*x_1 + 3.7403360327215e-5*x_10 + 4.04408089545096e-5*x_100 - 0.000100750128528738*x_101 + 1.02684733915535e-5*x_102 + 0.000133107434771548*x_103 - 9.3665787168163e-6*x_104 + 9.17238087643228e-5*x_105 + 6.36063730510286e-5*x_106 + 3.46119430956915e-5*x_107 - 6.52358308457796e-5*x_108 + 9.44894681376447e-5*x_109 + 4.74233528752831e-5*x_11 + 2.77975668659314e-5*x_110 + 7.82554968648878e-5*x_111 - 0.000171272040209524*x_112 + 5.56508454651498e-6*x_113 + 2.1811315694213e-6*x_114 - 2.60813847897901e-5*x_115 + 0.000174458318183949*x_116 - 8.21650908286113e-6*x_117 - 3.00178615222536e-5*x_118 + 5.10598255391154e-5*x_119 - 2.41183259511791e-5*x_12 + 2.44492258874622e-5*x_120 - 0.000165210356561353*x_13 + 1.45773514141251e-5*x_14 + 4.79773789693669e-5*x_15 - 2.5466283012519e-5*x_16 + 8.08673607049411e-5*x_17 + 4.16653281117649e-5*x_18 + 0.000293223996293276*x_19 + 4.70615604012323e-6*x_2 - 0.000234495029869404*x_20 - 2.30831711029727e-5*x_21 + 9.77160069285944e-5*x_22 + 0.000179577776954232*x_23 - 0.000243916891811703*x_24 - 6.84470569273617e-5*x_25 - 8.15901838740474e-6*x_26 - 0.00014633235309666*x_27 + 5.14742152560919e-5*x_28 - 0.000262048469243095*x_29 - 3.83897192971753e-6*x_3 - 0.000178592229057127*x_30 - 5.62393395592274e-5*x_31 + 2.34507809401255e-5*x_32 + 0.00012355507461617*x_33 - 3.08221629772084e-5*x_34 + 2.91487711407476e-5*x_35 + 2.95037308701953e-5*x_36 - 0.000169371271638566*x_37 + 8.15157207099574e-5*x_38 + 6.50187225051466e-5*x_39 + 0.000134549066179389*x_4 + 6.33651834058306e-5*x_40 + 0.000158501320667742*x_41 + 5.17875789690306e-5*x_42 - 8.9168960132562e-5*x_43 - 0.000103689362653706*x_44 + 0.000114708628631037*x_45 + 7.33791826507691e-5*x_46 - 0.000184356345558483*x_47 + 1.16352870187374e-5*x_48 + 0.00034161152914425*x_49 + 8.96703099057047e-5*x_5 - 0.000139280045376283*x_50 + 0.000171975911544742*x_51 + 6.33387516290052e-7*x_52 + 3.25926094583784e-5*x_53 + 0.000186647159425932*x_54 + 0.000157175342103707*x_55 + 7.75673628931101e-5*x_56 + 8.36830177863925e-5*x_57 + 0.000772802294675523*x_58 + 0.000243243662425031*x_59 + 4.59743510138223e-5*x_6 + 0.000369055507169484*x_60 + 2.73585247470744e-5*x_61 + 5.48018161001382e-6*x_62 - 3.25650650807211e-5*x_63 - 4.61464850180304e-5*x_64 - 0.000110440346091245*x_65 - 0.000197031670421086*x_66 - 5.50882126650105e-5*x_67 + 4.49259509634268e-5*x_68 + 4.66718747865778e-5*x_69 - 1.54938154066523e-5*x_7 + 5.85756252519368e-5*x_70 + 2.75502349671472e-5*x_71 - 5.57583477290036e-6*x_72 + 5.19944037529529e-5*x_73 + 9.91465819617465e-5*x_74 - 1.23988153899697e-7*x_75 - 2.73356283205676e-5*x_76 - 5.56362389509773e-5*x_77 + 8.38665587414413e-5*x_78 - 3.83425456018929e-5*x_79 + 2.38859236661478e-5*x_8 - 1.00311851444496e-5*x_80 + 7.35716192707999e-6*x_81 + 4.41038536850856e-6*x_82 + 3.66540804194741e-5*x_83 + 0.000109464262495369*x_84 + 3.070596301342e-5*x_85 + 3.19100235427196e-5*x_86 + 2.07015666169328e-5*x_87 + 2.36947603486572e-5*x_88 + 1.53101074007329e-5*x_89 - 7.50239961535075e-5*x_9 - 8.23214580998955e-5*x_90 - 2.17843185873448e-5*x_91 - 3.85933032451391e-5*x_92 + 7.65589224361799e-6*x_93 + 4.36295407312984e-5*x_94 + 5.67394372772383e-5*x_95 + 0.000109601039599822*x_96 + 0.000190640971560704*x_97 - 5.0148848765279e-5*x_98 + 0.000167921555068392*x_99 + 8.8888067180027e-8*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) + 8.76090262527458e-6*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000355143234956804*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 2.26552359890907e-5*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 0.000268675024659592*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 4.97572689450643e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 3.97624800278529e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) + 8.74535237142033e-6*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0355864017586596);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.72854038051488e-5*x_1 - 0.000195007065383474*x_10 - 8.19281221655875e-6*x_100 - 5.02132840178486e-5*x_101 - 1.59627362028769e-5*x_102 + 0.000275195555807468*x_103 + 4.05762178893125e-5*x_104 - 4.95948988039241e-6*x_105 + 0.000116826204700876*x_106 - 7.79649699536141e-5*x_107 - 4.64614012627729e-5*x_108 + 0.000198129854727257*x_109 + 3.49485303652435e-5*x_11 + 9.28263207337518e-5*x_110 + 0.000282764513943109*x_111 + 0.000256426149450079*x_112 + 0.00019846761401383*x_113 + 0.000129719763881052*x_114 + 6.77756559041107e-5*x_115 - 0.000193732585920975*x_116 + 4.76500049022971e-5*x_117 + 0.000136521323728653*x_118 + 0.000184567197160622*x_119 + 1.38637601432032e-5*x_12 + 9.25774789184323e-5*x_120 - 0.000124240504457289*x_13 + 0.000151154150836525*x_14 + 0.000176414326325688*x_15 - 4.36343833547142e-5*x_16 + 1.70093531187927e-5*x_17 + 8.92733609205831e-5*x_18 + 0.000112457687347856*x_19 + 1.94789353319882e-5*x_2 - 9.39635847563211e-5*x_20 + 0.000110855195831021*x_21 - 0.000180499080701246*x_22 + 0.000151095226729967*x_23 - 0.000220970026820848*x_24 - 5.93637880627752e-5*x_25 - 4.67414875109145e-5*x_26 + 3.60604277769068e-6*x_27 + 6.83586216880794e-5*x_28 - 0.000134992053175933*x_29 + 1.1358486087336e-5*x_3 - 8.03527368017291e-5*x_30 + 9.2498730798755e-5*x_31 + 7.87009712622067e-5*x_32 + 0.000180036724865147*x_33 - 0.000286737685581144*x_34 + 0.000103844096116477*x_35 + 0.000137001164942083*x_36 - 0.000428951282701338*x_37 - 0.000121049213261176*x_38 + 5.35824808147831e-5*x_39 + 0.000189055081146872*x_4 + 3.27334255746987e-5*x_40 + 1.87198963265489e-5*x_41 - 2.66344818588982e-6*x_42 + 0.000216916131246019*x_43 - 0.000304996189518177*x_44 - 6.44240103632476e-5*x_45 + 6.09659426048154e-5*x_46 - 0.00030266728590036*x_47 + 0.000101532290432788*x_48 + 0.000167003927086283*x_49 + 9.02071315034357e-5*x_5 - 0.000117660268166915*x_50 + 0.000205006990432715*x_51 + 0.000159851275190296*x_52 + 8.36794705860213e-6*x_53 + 0.000158206156707795*x_54 + 0.000100257711849848*x_55 - 0.000231592452037715*x_56 + 1.56776751256362e-5*x_57 + 0.000635653366542254*x_58 + 3.69465432362326e-6*x_59 + 0.00023034706920979*x_6 + 0.00023399003405501*x_60 - 1.90778434874198e-5*x_61 + 1.18695062831592e-5*x_62 - 2.3618620864847e-5*x_63 - 8.51158301130414e-5*x_64 + 9.61872869485612e-5*x_65 + 0.000126477635544206*x_66 - 8.60393404427652e-5*x_67 - 3.34572811702671e-5*x_68 - 1.64031052241302e-5*x_69 + 3.69627466749101e-5*x_7 + 1.57868468507938e-5*x_70 - 3.8650508765998e-5*x_71 + 4.51050879968577e-6*x_72 + 9.02230882718427e-5*x_73 + 4.18654116944695e-6*x_74 - 2.99120588691017e-5*x_75 - 8.56107411422066e-5*x_76 - 9.78987953494538e-5*x_77 + 6.51121458604217e-5*x_78 - 5.96397322244638e-5*x_79 + 0.000174189793228173*x_8 - 2.26328704217078e-5*x_80 + 9.97884909232023e-5*x_81 + 2.26617587484059e-5*x_82 + 0.000196755127851409*x_83 + 0.000205915035574873*x_84 + 7.145733030997e-5*x_85 + 9.46567351091927e-5*x_86 + 4.12930505189465e-5*x_87 - 5.91590517981586e-6*x_88 - 1.35650749647757e-5*x_89 + 0.000144679641630382*x_9 - 5.33455784399313e-6*x_90 + 0.000126687026451838*x_91 + 1.96894932579429e-5*x_92 + 0.000102822893634515*x_93 - 2.91292634571631e-5*x_94 + 3.82028463478213e-5*x_95 + 7.5929587665422e-5*x_96 + 0.000238938339876089*x_97 - 0.000123245148735627*x_98 + 0.000622199205715756*x_99 - 5.707639830289e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 5.5146602187545e-7*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000334440807696731*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 0.000289050840903026*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 8.85827617141237e-5*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 4.01166849848268e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) - 5.89284330176052e-6*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 5.50487191611155e-7*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0686689690892329);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.0688979595075e-5*x_1 - 0.000127196302576775*x_10 - 7.33094571312469e-5*x_100 + 6.1935152476003e-5*x_101 - 0.000101663660432833*x_102 + 2.53222004269305e-6*x_103 + 4.97544415051301e-5*x_104 - 0.000145382860351898*x_105 - 0.000171261645348057*x_106 - 7.45823546999234e-5*x_107 + 9.22813606998277e-5*x_108 + 3.313516763292e-5*x_109 + 2.73975437918393e-6*x_11 + 5.64941916702504e-6*x_110 + 3.24164812653014e-5*x_111 + 0.000564587103159322*x_112 + 0.000243878381728029*x_113 + 0.000185501540452904*x_114 + 4.96561834038288e-5*x_115 + 5.2364573209552e-6*x_116 - 2.33212524024356e-5*x_117 + 0.000150790437058603*x_118 + 0.000103691548788366*x_119 + 8.02714003956251e-5*x_12 + 1.0982156427251e-5*x_120 - 0.000563553208659816*x_13 + 0.00020166354709901*x_14 + 9.40640934262893e-5*x_15 + 4.64956887402213e-6*x_16 - 0.000138193434350608*x_17 - 3.63791272974427e-5*x_18 - 1.25822617820669e-5*x_19 - 3.2383310355165e-5*x_2 + 0.000210399114470021*x_20 + 2.60791006750132e-5*x_21 - 0.000571160822331304*x_22 + 6.34646928043934e-5*x_23 + 8.45757349979866e-5*x_24 + 6.31008177393986e-5*x_25 - 0.000202297984054459*x_26 - 0.000310574270058225*x_27 + 7.67947564235179e-5*x_28 + 0.000354709711921126*x_29 + 0.000108157465943856*x_3 + 0.000466018775412822*x_30 + 0.000173385668342903*x_31 - 7.20723094302976e-6*x_32 - 2.48284073267274e-5*x_33 + 3.15183984417402e-5*x_34 + 7.63403858682996e-5*x_35 - 0.000272581587519115*x_36 + 1.56689421380282e-5*x_37 - 0.000269804753839689*x_38 - 0.000118354238073685*x_39 - 0.000125866456539255*x_4 - 4.19056062789731e-5*x_40 - 0.000125106594954897*x_41 - 9.57703889708722e-5*x_42 + 0.000306110473284222*x_43 + 4.02148336049195e-5*x_44 - 5.55224877960098e-5*x_45 + 7.73424236726525e-5*x_46 - 9.63603825196208e-7*x_47 - 2.2092892203105e-5*x_48 - 9.71272101020183e-5*x_49 - 1.5669763828842e-5*x_5 + 0.000163711313506665*x_50 - 0.000382666232340667*x_51 + 0.000209009287471406*x_52 - 2.82415105072023e-5*x_53 - 0.000137818219826875*x_54 + 1.80398479654744e-5*x_55 - 0.000513611432413745*x_56 - 0.000316693410596673*x_57 - 0.000499914224272559*x_58 - 0.000453721615225553*x_59 + 2.8978788959606e-5*x_6 - 0.00035988000125254*x_60 - 8.78139287901871e-5*x_61 - 1.66412434101259e-5*x_62 - 1.41596061668795e-5*x_63 + 0.000108913150479918*x_64 + 0.000283983432856372*x_65 + 0.00053611606876135*x_66 + 6.10660265082817e-5*x_67 - 2.30601519492988e-5*x_68 - 4.65991362068948e-5*x_69 + 0.000117505324732987*x_7 - 0.000257201754361975*x_70 + 4.61325291813406e-6*x_71 + 0.000167157410289524*x_72 - 5.97406123862939e-5*x_73 - 0.000195888388138601*x_74 - 1.34546680819097e-5*x_75 + 0.000144652803752893*x_76 + 0.000133491993662537*x_77 + 3.61398682640142e-5*x_78 + 0.000147428183162631*x_79 + 2.04748315868864e-5*x_8 + 2.74832759130891e-5*x_80 + 0.00011246229007696*x_81 + 0.000105437552729567*x_82 + 0.000114805420054303*x_83 + 2.70126209022907e-5*x_84 + 5.49472569600029e-5*x_85 + 1.1103626165004e-5*x_86 + 3.66256174081815e-5*x_87 - 2.30578836339991e-5*x_88 + 3.78559893065543e-5*x_89 + 0.000257881234317037*x_9 + 0.000403239086694457*x_90 + 4.42488895934343e-5*x_91 + 7.7262353402488e-5*x_92 + 2.78371106445374e-5*x_93 - 0.000122468289817622*x_94 - 9.04068289354477e-5*x_95 + 9.3687237849267e-5*x_96 - 0.000319694684889991*x_97 + 4.51247020452456e-5*x_98 + 0.000442144700112639*x_99 - 2.65953129148985e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 0.000103068997953635*std::sin(1.2617598772049*x_120 - 5.20279979705811) - 0.000277584550114366*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 3.28947547488413e-5*std::sin(0.736559867858887*x_14 + 4.41551971435547) - 7.06176891799608e-6*std::sin(0.436479866504669*x_32 + 4.59007978439331) + 0.000225641882574247*std::sin(2.63504004478455*x_63 + 1.17031991481781) - 2.00014142958467e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 0.000102886054579962*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0500611282101976);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000108368661724428*x_1 - 0.000289705901751691*x_10 - 3.28041711591781e-5*x_100 - 0.00016858436428538*x_101 + 4.30997268185938e-5*x_102 + 9.81473788284215e-5*x_103 - 3.576401923002e-5*x_104 + 0.000112423309569316*x_105 + 0.000161081982427274*x_106 + 4.97361284233475e-5*x_107 - 5.01259573773846e-5*x_108 - 0.000111870056126359*x_109 - 7.24128877636963e-5*x_11 + 0.000199827626672784*x_110 + 5.83222150718443e-5*x_111 + 5.12832100131369e-5*x_112 - 5.39118717811969e-5*x_113 + 8.12449886780728e-6*x_114 + 8.26615253758451e-5*x_115 - 0.000145442232643778*x_116 + 9.61202088078948e-5*x_117 + 7.05888047678917e-5*x_118 + 7.7910284095854e-5*x_119 + 4.32309434143606e-5*x_12 + 7.18772703153701e-5*x_120 - 0.000604220898164351*x_13 + 0.000136881564139893*x_14 - 4.99040183266082e-5*x_15 - 0.000146297232854827*x_16 - 3.91489944885952e-5*x_17 - 0.000349571322575434*x_18 - 7.17222302946265e-5*x_19 - 9.50722457064452e-5*x_2 - 0.000330293258762219*x_20 - 5.48088935659015e-5*x_21 + 0.00022904136911072*x_22 + 5.88002364925955e-6*x_23 + 2.04539556486639e-5*x_24 - 0.00032009895519037*x_25 + 5.19857265397682e-5*x_26 - 0.000195541409279284*x_27 + 2.1523683490833e-5*x_28 + 0.000174799007838901*x_29 - 1.30989252083947e-5*x_3 + 5.27529925489634e-5*x_30 + 8.18386881532647e-5*x_31 + 5.10609292497313e-5*x_32 - 0.000247537683455615*x_33 - 0.000366026842536316*x_34 + 0.000114142316029443*x_35 + 2.90764518851022e-5*x_36 - 0.000179189724128112*x_37 + 4.37011449171946e-5*x_38 + 4.85534901798033e-5*x_39 + 2.1806622743991e-5*x_4 + 9.28180846227451e-5*x_40 + 5.7191254653252e-5*x_41 - 8.37848905602669e-5*x_42 + 0.000414659031918413*x_43 + 0.000166643921355107*x_44 + 0.000508888589125672*x_45 + 6.58336293165075e-5*x_46 + 0.00017773327074225*x_47 + 0.000222690819160636*x_48 + 0.000164908421956425*x_49 + 7.18432316295908e-5*x_5 - 0.000114391358868766*x_50 + 0.000269952807339571*x_51 + 6.56714343330552e-5*x_52 + 4.34755196163874e-5*x_53 - 0.000270384890556449*x_54 - 0.000155505997828298*x_55 + 0.000701746435177638*x_56 - 6.92143985080204e-5*x_57 + 0.000167892700407113*x_58 - 0.000557555932578292*x_59 - 2.53015279988024e-6*x_6 + 0.000241725994530742*x_60 - 2.29395658689053e-5*x_61 + 5.45837519221218e-5*x_62 - 5.70174593269475e-5*x_63 - 1.73225871519056e-5*x_64 + 6.13113486770692e-5*x_65 - 4.53006129076168e-5*x_66 - 4.68758037016284e-5*x_67 - 3.54714284680733e-5*x_68 - 4.36823382925964e-7*x_69 - 7.6372914838859e-5*x_7 + 1.71438425613361e-5*x_70 - 0.0001109652402061*x_71 + 4.02352208834744e-6*x_72 + 5.08842366185689e-5*x_73 + 4.16257048348617e-5*x_74 + 3.58070593611688e-6*x_75 + 0.000126796234474643*x_76 + 2.96959411319604e-5*x_77 - 8.23644765779296e-6*x_78 + 4.29698562793129e-5*x_79 - 7.58209169308691e-5*x_8 + 3.28413232512435e-5*x_80 + 4.8827317633166e-5*x_81 + 3.74355526170088e-5*x_82 + 0.000215972411155355*x_83 + 9.39110308671812e-5*x_84 + 8.15403355317629e-5*x_85 - 9.03278406726257e-6*x_86 + 3.78908267021935e-5*x_87 + 3.92774369687933e-6*x_88 + 5.02102704244433e-5*x_89 - 8.56216287900363e-6*x_9 - 8.93194817595787e-5*x_90 + 4.32423398977901e-5*x_91 - 5.3877062764033e-5*x_92 + 0.00010906458523838*x_93 - 3.34815923781651e-5*x_94 + 7.14275556571232e-5*x_95 + 0.000143241520481972*x_96 - 3.86833376029704e-5*x_97 - 1.91958953310056e-5*x_98 - 0.000594070494471982*x_99 - 1.90408447441945e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 6.23275486474098e-5*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000329436224557853*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 0.000138075542446589*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 0.000202795365345317*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 5.03567585298151e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 5.52887855944575e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 6.22169197265057e-5*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.050268792038608);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.94988830322531e-5*x_1 - 7.54863655420882e-5*x_10 - 2.54350767890447e-5*x_100 + 0.000130830078160721*x_101 - 0.000142165557602753*x_102 + 9.54978220959498e-5*x_103 - 4.35051077608439e-5*x_104 + 0.000316421279580081*x_105 - 3.62005261682479e-5*x_106 - 0.000117197463131976*x_107 + 5.97295478139497e-5*x_108 - 0.000259168208835424*x_109 - 6.29209417179511e-6*x_11 + 8.35581866115802e-5*x_110 - 2.19714374598016e-5*x_111 + 0.00025433662582907*x_112 + 0.000139048334370242*x_113 + 0.000197649916921897*x_114 + 4.83872056612276e-5*x_115 + 0.000225929399578237*x_116 - 6.48663251486696e-5*x_117 + 8.67916826555641e-5*x_118 + 0.000169836988455248*x_119 + 6.54592277248433e-5*x_12 + 1.77065892959779e-5*x_120 - 0.000937987166922507*x_13 + 0.000335846143807984*x_14 - 0.000392794914112346*x_15 - 0.000335626599501979*x_16 - 0.000102082851131398*x_17 - 0.00023112275476871*x_18 + 0.000231092598897969*x_19 - 0.00016081273303792*x_2 - 0.000210228785224506*x_20 - 0.000207090524627124*x_21 - 0.000286224630077766*x_22 + 0.000197547690985986*x_23 - 0.000199405575095009*x_24 - 0.000303966496488203*x_25 + 0.000154280445369922*x_26 - 0.000171212781765488*x_27 + 2.03882349887251e-5*x_28 + 0.000226413322850572*x_29 - 7.76602231555418e-5*x_3 + 0.00195381527141018*x_30 + 0.000137426150757913*x_31 + 0.000127984460830964*x_32 + 7.51192849708847e-5*x_33 - 2.54076817576536e-5*x_34 - 1.07604579413352e-5*x_35 + 5.84451381642079e-5*x_36 - 0.000224007398218513*x_37 - 0.000151210126111267*x_38 + 4.0049065839129e-5*x_39 - 6.55575504222935e-5*x_4 - 7.44897887125306e-6*x_40 + 7.7997072825519e-5*x_41 - 0.000253778508256686*x_42 + 5.25177020962549e-5*x_43 + 0.00020257358021052*x_44 + 0.00037505250583923*x_45 - 0.00016951779628992*x_46 - 0.000217489817784573*x_47 - 7.33235315802113e-5*x_48 - 0.000190360640077366*x_49 + 0.00013048642454292*x_5 - 0.00012149632395755*x_50 - 0.00023718489265895*x_51 + 0.000310362121940815*x_52 - 0.000206078142269744*x_53 + 0.00032176677691235*x_54 + 0.000296039184069921*x_55 - 5.49581587969323e-6*x_56 - 0.000171110534762125*x_57 - 1.67764568898806e-5*x_58 - 0.00056050794291556*x_59 + 0.000254641771455636*x_6 + 0.000256500531291416*x_60 - 8.96960826465704e-5*x_61 - 2.51240951321143e-5*x_62 - 0.000117878834293249*x_63 + 0.000108622881013165*x_64 + 0.000266264140648856*x_65 + 0.000354367760665465*x_66 + 7.3323222759687e-5*x_67 + 1.84890622443261e-5*x_68 - 5.44985863097098e-5*x_69 + 8.05483047112876e-5*x_7 - 0.000155342886901002*x_70 + 0.000118673104752348*x_71 + 0.00019559004728091*x_72 + 8.37505744094891e-5*x_73 - 2.83015703497203e-5*x_74 + 6.11587349736771e-5*x_75 + 0.000141646889350264*x_76 + 8.25985584200117e-5*x_77 + 0.000152248590661535*x_78 + 8.19884101543221e-5*x_79 + 2.34736542414062e-5*x_8 - 3.80417710975045e-5*x_80 + 0.000134681083278855*x_81 + 9.0964805354395e-5*x_82 + 0.000128213420521495*x_83 + 0.000214257257875879*x_84 + 4.06993170045807e-5*x_85 + 2.95935310354469e-5*x_86 + 7.11635346133245e-5*x_87 + 2.05039696040852e-5*x_88 + 0.000136447167025662*x_89 + 0.000128348476068983*x_9 + 0.000314811042025541*x_90 - 5.77058450677482e-5*x_91 - 2.1345458651021e-5*x_92 + 0.000112736113484269*x_93 + 2.71568007436299e-5*x_94 - 1.60614195971567e-5*x_95 + 0.000842546719248645*x_96 - 8.98287177046333e-5*x_97 - 5.46596870721199e-5*x_98 + 0.000598682462650209*x_99 - 5.14297834713904e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 0.000158732705985118*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000331950673420068*std::sin(0.510879814624786*x_14 - 2.01327991485596) + 0.000434137351055244*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 0.000304863070150531*std::sin(0.436479866504669*x_32 + 4.59007978439331) + 0.000171626345162669*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 4.0887327033078e-7*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 0.000158450961742702*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0344548636338326);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.22094316975882e-6*x_1 + 1.88022556468222e-5*x_10 - 2.57704442343779e-5*x_100 + 0.000179183487839285*x_101 - 9.75690562946358e-5*x_102 - 0.000217350215262176*x_103 - 0.000167355430647606*x_104 - 0.000247669862017465*x_105 + 0.0001091680189023*x_106 - 7.72470428822614e-5*x_107 - 0.00017034766709541*x_108 - 0.000128257630735425*x_109 + 3.67684384972049e-5*x_11 - 7.96529644623059e-6*x_110 - 2.49504993530802e-5*x_111 + 0.000112139428792704*x_112 - 5.3618652408385e-5*x_113 - 4.4196671817909e-5*x_114 + 0.000176618605270862*x_115 - 8.92304747518067e-5*x_116 + 4.3420802625856e-5*x_117 + 8.82097127625366e-5*x_118 + 5.44066519558483e-5*x_119 + 0.00017169087927033*x_12 + 1.4731082624773e-6*x_120 + 0.000186279889540486*x_13 - 1.31915265206192e-5*x_14 - 0.000230450323256899*x_15 - 9.21442390294101e-5*x_16 - 6.31839087482729e-5*x_17 - 0.000144161956633788*x_18 - 0.000653479817069278*x_19 + 3.72139314491126e-6*x_2 + 0.000172145364287009*x_20 - 4.03084108831222e-5*x_21 - 0.000279457604851662*x_22 - 5.05654648867452e-5*x_23 + 1.59127743325731e-5*x_24 + 0.000113724092965229*x_25 + 0.000436286090225716*x_26 + 0.00043545462680866*x_27 - 6.31076530869803e-5*x_28 + 0.000163384438198646*x_29 - 2.85215526365489e-5*x_3 + 0.00102438260299482*x_30 + 4.95697053640904e-5*x_31 + 0.000131992963521154*x_32 + 0.000117593152386586*x_33 - 0.000174054649605482*x_34 - 7.30546737184671e-5*x_35 - 5.65151158261831e-5*x_36 - 0.000412571635408999*x_37 - 6.9393313930108e-5*x_38 - 8.94205231121114e-5*x_39 + 5.68588440020658e-5*x_4 - 4.20666875266856e-5*x_40 + 6.34159631849914e-5*x_41 - 0.000143256907541007*x_42 - 0.000207580532384102*x_43 - 0.000220614666472872*x_44 - 8.35605193002306e-5*x_45 - 0.000172573448908309*x_46 - 0.00038140337099148*x_47 + 5.31224786285196e-5*x_48 + 0.000173526681033536*x_49 + 2.22440200749869e-5*x_5 - 0.000383995141188954*x_50 + 5.14389749793068e-5*x_51 - 2.59867951889203e-5*x_52 + 9.45562468893588e-5*x_53 - 0.000155337916805975*x_54 + 0.00041035527074397*x_55 + 0.000886455918515667*x_56 + 8.48481957651706e-5*x_57 + 0.000485451778839659*x_58 + 0.000386957930259992*x_59 + 0.000240179447472316*x_6 + 0.000178239301851318*x_60 + 5.90499341721936e-5*x_61 + 7.99262158976963e-6*x_62 - 2.96624840777074e-5*x_63 + 9.03847460943192e-5*x_64 + 0.000201698846054973*x_65 + 0.000301836190636664*x_66 + 4.99150791856467e-5*x_67 - 0.000107265661980182*x_68 - 2.16646009606445e-5*x_69 + 0.000125942527123883*x_7 + 7.72997655986159e-5*x_70 + 0.000142326787215495*x_71 - 1.68005576662616e-5*x_72 + 3.15010612837199e-5*x_73 + 5.86221467985556e-5*x_74 + 1.17297224220095e-5*x_75 + 5.27069752862589e-6*x_76 + 1.54920505711214e-5*x_77 + 0.000102365620744159*x_78 - 0.000142181676000165*x_79 + 9.38529054960257e-5*x_8 - 7.66259152329229e-5*x_80 + 1.40238353446018e-5*x_81 - 2.48639533036013e-6*x_82 + 8.75071452626879e-5*x_83 + 0.000144109406099035*x_84 + 8.81055172707934e-5*x_85 + 8.89319438890316e-5*x_86 + 3.64865610564523e-5*x_87 + 9.40294744329801e-6*x_88 - 4.40612282180016e-5*x_89 + 0.000163947260640002*x_9 - 4.44996195351566e-5*x_90 - 1.80789189835638e-5*x_91 - 5.66253526952739e-5*x_92 + 8.04096611001177e-5*x_93 + 0.000164317152654208*x_94 + 4.07465657097604e-5*x_95 + 9.86600956449793e-5*x_96 - 6.09612524748252e-5*x_97 + 2.6636422678052e-5*x_98 - 0.000182974989837408*x_99 - 6.48804597096356e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) + 7.66876082856375e-5*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000146324775049038*std::sin(0.510879814624786*x_14 - 2.01327991485596) + 4.00304687000719e-5*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 0.000175543510933824*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 2.07461859309546e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 4.83238233487139e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) + 7.65514908297858e-5*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0268747224430142);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.85726218886749e-5*x_1 - 0.000144775724838742*x_10 - 5.05152063778686e-5*x_100 - 0.000107772598916155*x_101 - 3.31369992645222e-5*x_102 - 3.863258297778e-6*x_103 + 3.04204755291419e-6*x_104 - 0.000471147820546311*x_105 + 6.14336140252406e-5*x_106 + 6.5450744939554e-5*x_107 - 0.000147138599609829*x_108 + 0.000273763365199082*x_109 + 6.05937558076713e-5*x_11 + 0.000115510730454168*x_110 + 0.000196434926990005*x_111 + 0.000361069714359953*x_112 + 0.000118637283438115*x_113 + 1.80018073234947e-5*x_114 + 0.000161419457140237*x_115 - 0.000188948969159568*x_116 + 0.000120061914530143*x_117 + 0.000188553063410664*x_118 + 0.000135740580919263*x_119 + 0.000160192688227964*x_12 + 6.56384036773122e-5*x_120 - 0.000421931552282884*x_13 + 0.000102373303828154*x_14 + 0.000429357107031286*x_15 + 0.000193221945072576*x_16 - 8.87053345732403e-5*x_17 - 8.45041408170575e-5*x_18 - 0.000141770240954893*x_19 + 8.03883633184694e-5*x_2 + 0.000245880670801254*x_20 + 0.000175870227260602*x_21 - 0.000319450847361167*x_22 + 2.57880617873802e-5*x_23 + 2.1369124967281e-5*x_24 + 0.000223705298935993*x_25 - 0.000103921023180194*x_26 - 0.00024679745092479*x_27 + 3.71378887053912e-5*x_28 + 0.00014951886714213*x_29 + 0.00021376169585971*x_3 - 0.000740307233423889*x_30 + 0.000127828009885151*x_31 - 9.80291729829128e-6*x_32 - 5.59814397960788e-6*x_33 - 0.000336817459238742*x_34 + 0.000154123181119913*x_35 - 0.000363630652220759*x_36 - 0.000354953026502845*x_37 - 0.000145514612953512*x_38 - 0.000140977216278468*x_39 + 0.000119628029601073*x_4 + 0.000113444162706452*x_40 - 1.4270661476098e-5*x_41 + 2.46561413631967e-5*x_42 + 0.000418389017494045*x_43 - 0.000272940685913941*x_44 - 0.000186091651099829*x_45 + 0.00035421742739094*x_46 - 0.000125646997108588*x_47 + 0.000224518885688327*x_48 + 0.00072212862666951*x_49 + 3.23876179935417e-5*x_5 - 0.000163827282374334*x_50 + 0.0002015371783212*x_51 - 3.16304141220002e-5*x_52 + 0.000278294205950893*x_53 - 0.000587668298903825*x_54 - 3.77562617011637e-5*x_55 + 0.000650431873854579*x_56 - 9.50732375958342e-5*x_57 + 0.000754686401813135*x_58 + 0.000123160045941826*x_59 - 7.32049348260469e-5*x_6 + 1.92317989677288e-5*x_60 + 1.12526517488869e-5*x_61 + 5.4555924707666e-5*x_62 + 8.65637972574349e-6*x_63 + 2.67859727679146e-6*x_64 + 0.000219487556464618*x_65 + 0.000375017096933148*x_66 - 3.00199899550209e-5*x_67 - 0.000102659045130766*x_68 + 2.79676068721294e-5*x_69 + 8.83704759602696e-5*x_7 - 8.39389956724313e-5*x_70 - 5.07633124294658e-5*x_71 + 7.37391423312465e-5*x_72 - 4.22602920515033e-5*x_73 - 5.59666235247424e-5*x_74 - 5.65071248253475e-5*x_75 + 0.00011115876975789*x_76 + 6.42503688084206e-5*x_77 + 3.89873913787599e-5*x_78 - 9.75681819098129e-6*x_79 + 3.83094959538543e-5*x_8 + 4.42949394318053e-5*x_80 + 4.75549843985882e-5*x_81 + 8.27504728447751e-5*x_82 + 0.000275490602745162*x_83 + 5.95588204154864e-5*x_84 + 0.000155051420491327*x_85 + 9.54339667274163e-5*x_86 + 5.7277108521818e-5*x_87 - 5.37466507376486e-6*x_88 - 5.15611356410174e-5*x_89 + 0.000210541940759215*x_9 - 5.7410402525601e-5*x_90 + 0.000126762233036693*x_91 + 1.84272973899834e-5*x_92 + 7.66543964356628e-5*x_93 - 4.52283414397298e-5*x_94 + 3.75735236756852e-5*x_95 - 0.000405006166942759*x_96 - 0.000163924860767115*x_97 - 3.45929975866016e-5*x_98 - 0.000352148443858607*x_99 - 4.33615470371299e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) + 1.93541916972014e-5*std::sin(1.2617598772049*x_120 - 5.20279979705811) - 4.65315730872954e-6*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 0.000569323984946271*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 0.000229538986250304*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 2.23415792984416e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 2.81842942728723e-6*std::sin(1.35359978675842*x_77 + 1.21511995792389) + 1.93198387764e-5*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0531158585821946);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.12977491466365e-5*x_1 - 8.21964867495233e-5*x_10 - 1.18998468300017e-5*x_100 - 2.34493827849968e-5*x_101 - 3.90247022699096e-5*x_102 + 0.000122414267873984*x_103 + 1.56335552625802e-5*x_104 + 5.82004728380551e-5*x_105 + 7.40087555749917e-5*x_106 - 0.000116906452343398*x_107 + 3.04423633372209e-6*x_108 - 0.000259447012758394*x_109 + 2.03312187910596e-6*x_11 + 1.58100636067514e-8*x_110 + 5.94112174921592e-5*x_111 + 0.000126185545704055*x_112 + 2.32571639352317e-5*x_113 + 4.40450487674167e-5*x_114 + 2.28307220164236e-5*x_115 - 0.000127511042813572*x_116 - 4.26938939206033e-5*x_117 + 4.07279356219869e-5*x_118 + 5.48039010116073e-5*x_119 - 3.78309343521789e-5*x_12 + 3.60963894707267e-5*x_120 + 2.36046598478189e-5*x_13 + 4.54855025643408e-5*x_14 - 0.000283943009076907*x_15 - 0.000230027386821892*x_16 - 4.65633704717008e-5*x_17 + 6.88430192875065e-6*x_18 - 0.000351821238441416*x_19 - 5.33355887643159e-5*x_2 - 0.000152242310081595*x_20 - 5.66532395883958e-5*x_21 - 0.000133000047269335*x_22 + 0.000102595766150518*x_23 - 8.65895755287085e-5*x_24 - 0.000165974520880766*x_25 + 0.00031195292631396*x_26 + 0.000327557149006526*x_27 + 9.98772655971093e-5*x_28 - 2.5902979176025e-5*x_29 - 0.000177947383170328*x_3 + 0.00124153418491612*x_30 + 2.28638379358258e-5*x_31 + 0.000124220110267933*x_32 + 5.4750018414099e-5*x_33 - 0.000138417038167651*x_34 - 0.000120046687943007*x_35 + 0.000236086555114588*x_36 - 0.00026490888677868*x_37 - 0.000117781536160071*x_38 + 9.09112543201605e-5*x_39 + 4.30184408211014e-5*x_4 - 0.000104405351324346*x_40 - 3.60112857530566e-5*x_41 - 0.000155525883039962*x_42 - 4.08670735706456e-5*x_43 - 3.8532423145087e-5*x_44 + 1.26723646729381e-5*x_45 - 0.000347001782197136*x_46 - 0.0004423730616518*x_47 - 4.61768283270345e-5*x_48 - 0.000323099540038472*x_49 + 3.01517636814689e-5*x_5 - 0.000223862701578937*x_50 - 0.000118084240721916*x_51 + 9.34352096313546e-5*x_52 - 0.000108859154655019*x_53 + 0.00028863721735294*x_54 + 0.000138216587720125*x_55 - 0.000365428986241682*x_56 + 9.30674296222769e-5*x_57 - 4.19347967377044e-5*x_58 - 0.000129080657044118*x_59 + 0.000281391960489708*x_6 + 0.000218826310015558*x_60 - 1.37108190446882e-6*x_61 - 8.07795214522084e-6*x_62 - 3.0418977024627e-5*x_63 + 4.02534685216408e-5*x_64 + 2.79479417520268e-5*x_65 + 4.51488138076435e-5*x_66 - 1.39061728727752e-5*x_67 - 5.67832704605898e-5*x_68 - 4.31300685200082e-5*x_69 + 3.28716801333038e-5*x_7 + 4.04890192835491e-5*x_70 + 8.17460578464744e-5*x_71 - 4.07756811557661e-5*x_72 + 0.000115133393819325*x_73 + 6.10243736628546e-5*x_74 - 7.11343079752189e-6*x_75 - 0.000113967078600256*x_76 - 8.83871405521433e-5*x_77 + 8.39318764665462e-5*x_78 - 9.32270060752587e-5*x_79 + 0.000133990723622888*x_8 - 9.30912725108132e-5*x_80 + 5.18936504834805e-5*x_81 - 3.03525252162973e-5*x_82 + 0.00015616444730747*x_83 + 0.000194582323263433*x_84 + 1.74611132592412e-5*x_85 + 4.20033675248333e-5*x_86 + 4.50229277800023e-7*x_87 - 8.86413805139671e-6*x_88 + 6.98587953763278e-6*x_89 + 7.91716069364062e-5*x_9 + 0.000146337164561218*x_90 - 1.31328592264663e-5*x_91 - 6.69581119189331e-5*x_92 + 9.55337946061781e-6*x_93 + 2.64098266184548e-5*x_94 + 7.06064822148018e-6*x_95 + 0.00029027899924543*x_96 + 0.000186898215871274*x_97 - 3.84459100589079e-5*x_98 + 0.000775211712848844*x_99 - 4.66478419974505e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) + 1.98681799820941e-6*std::sin(1.2617598772049*x_120 - 5.20279979705811) + 0.000291221969006846*std::sin(0.510879814624786*x_14 - 2.01327991485596) + 1.30151898238453e-5*std::sin(0.736559867858887*x_14 + 4.41551971435547) + 4.13723460703341e-6*std::sin(0.436479866504669*x_32 + 4.59007978439331) + 5.05809581931555e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 8.28344507307609e-6*std::sin(1.35359978675842*x_77 + 1.21511995792389) + 1.98329147525215e-6*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0543920607552002);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.62642449749976e-5*x_1 + 2.93151956299132e-5*x_10 + 4.81734737953275e-5*x_100 + 0.000388289635292086*x_101 - 0.000170696984912783*x_102 - 5.34167583946885e-5*x_103 + 4.47784716804198e-5*x_104 + 0.000220202790179953*x_105 - 9.05045490547651e-5*x_106 + 0.00011987855701401*x_107 + 0.000110157268522445*x_108 - 0.000132267274071032*x_109 + 2.60677206635881e-5*x_11 + 1.28529156796164e-5*x_110 - 0.000184680731558938*x_111 - 0.00014102524920044*x_112 - 0.00014717355504402*x_113 - 8.10315123361433e-5*x_114 - 0.00012894262769822*x_115 + 7.29593650669595e-5*x_116 - 4.24862615939883e-5*x_117 - 2.49919331530316e-5*x_118 - 4.33492501547883e-5*x_119 + 4.77534715432374e-5*x_12 - 7.99423258264497e-5*x_120 - 0.000275366475996534*x_13 + 0.000201337723029036*x_14 - 4.12929342293307e-5*x_15 - 1.22386196371591e-5*x_16 - 8.28181923721025e-5*x_17 - 0.000136961703355806*x_18 + 0.000493595908777707*x_19 + 4.26237656579236e-5*x_2 + 0.000219947651167956*x_20 - 9.54440781066011e-5*x_21 + 0.000100189518706204*x_22 - 6.39829695029096e-5*x_23 + 0.000112010593651344*x_24 + 4.26979660959414e-5*x_25 + 0.000174725599305258*x_26 - 3.89220744327593e-5*x_27 - 0.000213077481406927*x_28 + 0.00035695754890521*x_29 + 6.72675801616935e-5*x_3 + 0.000856943322274563*x_30 + 2.29198651789097e-6*x_31 - 1.35083678234644e-5*x_32 - 7.7793119814989e-5*x_33 - 4.9025089688804e-5*x_34 - 0.000170297334354075*x_35 - 0.000209754739249311*x_36 + 2.05260427701185e-5*x_37 + 4.45213810494912e-5*x_38 + 4.48177158472167e-5*x_39 - 2.35397085593783e-8*x_4 + 0.000186507107573282*x_40 - 0.000123398048910509*x_41 - 2.84766326337737e-5*x_42 - 0.000211612145977948*x_43 + 0.000362200550688696*x_44 - 0.000246775874450713*x_45 + 6.45994214948386e-5*x_46 + 0.000243446907826869*x_47 - 0.000272901312189557*x_48 - 0.000390753080302948*x_49 - 5.42551611421208e-6*x_5 + 1.91267208734983e-5*x_50 + 0.000112035467315909*x_51 + 3.05345570102435e-6*x_52 - 0.000231353384192877*x_53 - 0.00052869198942034*x_54 - 0.000276342258940613*x_55 + 0.000579910089421211*x_56 - 0.000144256996455582*x_57 - 0.000390132016580981*x_58 - 0.000119855130531002*x_59 - 8.76836813533564e-5*x_6 - 0.00011238636355532*x_60 - 6.17772761047221e-5*x_61 + 4.97267066771715e-6*x_62 - 1.93534975197201e-5*x_63 + 3.97405299357053e-5*x_64 + 0.000156107041717426*x_65 + 7.96746183967998e-5*x_66 + 0.000141632725338878*x_67 - 2.02934600014897e-5*x_68 - 1.33590799636511e-6*x_69 - 1.91618105586096e-5*x_7 - 0.000108303438788985*x_70 + 7.83845238284439e-5*x_71 + 0.000250348042079705*x_72 - 6.30019751748073e-6*x_73 - 5.80831608483409e-5*x_74 + 7.20308022115911e-5*x_75 + 0.000137054583839949*x_76 + 9.24291241113499e-5*x_77 - 6.74860055703601e-5*x_78 + 6.2023683871052e-7*x_79 - 8.19847257117197e-5*x_8 + 4.884145061569e-5*x_80 - 5.18316500631986e-5*x_81 + 2.35525935958776e-5*x_82 - 0.00036014919789371*x_83 - 0.000149590980895017*x_84 - 4.7327646720063e-5*x_85 - 1.06011328369439e-5*x_86 + 7.26850432665619e-6*x_87 + 1.11156003822178e-5*x_88 + 5.32533094410111e-5*x_89 - 5.81138734794854e-5*x_9 - 7.04277541734209e-5*x_90 - 7.35391689204981e-5*x_91 + 1.10759863951342e-6*x_92 - 5.78528414915868e-5*x_93 + 1.60080969121186e-6*x_94 - 6.38009437897213e-5*x_95 + 0.000230719558483059*x_96 - 0.000176208939246341*x_97 - 0.000204022716193452*x_98 - 0.000349339966356725*x_99 + 7.91253934828833e-7*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 0.000130421222590442*std::sin(1.2617598772049*x_120 - 5.20279979705811) - 0.000222936123648832*std::sin(0.510879814624786*x_14 - 2.01327991485596) + 0.000205664319177478*std::sin(0.736559867858887*x_14 + 4.41551971435547) - 8.94838704583546e-5*std::sin(0.436479866504669*x_32 + 4.59007978439331) - 3.61269511591336e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) + 4.17857465421843e-5*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 0.000130189730105477*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0410492964344534);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.58159043038625e-5*x_1 - 0.000394613588636094*x_10 - 3.63068215947587e-5*x_100 + 0.000129763878589344*x_101 - 9.67510100579757e-5*x_102 + 0.000268774290883426*x_103 + 0.000148821534232676*x_104 + 0.000134803908167335*x_105 - 4.62429973587174e-5*x_106 - 5.35927441195248e-5*x_107 + 0.000176189245704804*x_108 + 4.50926909795048e-5*x_109 - 3.28487372682649e-5*x_11 + 9.71948217686245e-5*x_110 + 0.000165975894210816*x_111 + 0.00052237916940474*x_112 + 0.000219274681256696*x_113 + 0.000185245890821278*x_114 - 3.09070144786605e-5*x_115 - 0.000323779808581154*x_116 + 9.13612362485714e-6*x_117 + 0.000185799709925946*x_118 + 0.00014316535282604*x_119 + 6.59624592231387e-6*x_12 + 4.99637650359336e-5*x_120 - 0.000409825568148222*x_13 + 0.000324546817394847*x_14 + 0.000153204503054582*x_15 - 6.81874349637625e-5*x_16 - 0.000106512463207348*x_17 - 1.7334140790028e-5*x_18 + 0.000227590080097791*x_19 - 1.24643961051439e-5*x_2 + 0.000116983502526097*x_20 + 9.93918933270133e-5*x_21 - 0.00027952555736072*x_22 + 4.36927789273059e-5*x_23 + 0.00010284374376946*x_24 - 0.000130959576423364*x_25 - 0.000126963480048434*x_26 - 0.000148758607735367*x_27 + 2.66823953463225e-5*x_28 + 0.000394896138677021*x_29 + 3.92980928767188e-5*x_3 + 0.000436764307666968*x_30 + 0.000192641519117568*x_31 + 3.370477046199e-5*x_32 - 5.88574505624143e-5*x_33 - 0.000289844999776979*x_34 + 2.55770075391725e-5*x_35 - 2.93721998104079e-5*x_36 - 0.000168915705053007*x_37 - 0.000239023119700287*x_38 + 4.73759482193287e-5*x_39 + 5.33285629442764e-6*x_4 + 5.83350002949734e-5*x_40 - 0.000253585497134998*x_41 - 7.82219529233595e-5*x_42 + 0.000443292665382728*x_43 + 0.000115678529201812*x_44 - 0.000187926016552499*x_45 + 2.74669196280056e-5*x_46 + 0.000122350760814486*x_47 - 6.93439146114899e-5*x_48 - 0.000580158270678526*x_49 + 5.0283158212971e-6*x_5 + 0.000190338691732149*x_50 - 5.40809349557696e-5*x_51 + 0.000280239603653405*x_52 - 0.00019748979496024*x_53 - 0.000252197876307355*x_54 - 0.000332229933444589*x_55 - 0.000523757986179632*x_56 - 0.000264613823560555*x_57 - 0.000736597387322929*x_58 - 0.00075053710581594*x_59 + 0.000148499186872056*x_6 - 0.000311311088343146*x_60 - 0.000126789047866048*x_61 + 4.8666245652874e-6*x_62 - 1.0411690577547e-5*x_63 - 1.39458637940591e-5*x_64 + 0.000273742049967031*x_65 + 0.000377921002115818*x_66 + 3.1666249507286e-5*x_67 - 5.54967131610581e-5*x_68 - 7.49393590803643e-5*x_69 + 1.64325197723363e-5*x_7 - 0.000190249883972174*x_70 - 9.31464672735039e-5*x_71 + 0.000163611394772709*x_72 + 3.70633951528181e-5*x_73 - 0.000192458603259191*x_74 - 9.89938560761993e-6*x_75 + 4.54651962272255e-5*x_76 + 1.67672253719061e-5*x_77 - 6.19746159932339e-5*x_78 + 7.6252051649306e-5*x_79 + 0.00011359685336717*x_8 + 3.57951066234636e-5*x_80 + 0.000122287449993219*x_81 + 5.85558732322521e-5*x_82 + 2.3976916150578e-5*x_83 + 3.50124937605815e-5*x_84 + 1.10438159978889e-5*x_85 + 1.81434171384293e-5*x_86 + 2.57935523725366e-5*x_87 - 4.00114244993631e-5*x_88 + 3.09361868087786e-5*x_89 + 0.000217594489323907*x_9 + 0.00022587191346365*x_90 + 0.00012885941193918*x_91 + 8.29956977768537e-5*x_92 + 5.53160299507806e-5*x_93 - 0.000180390018618378*x_94 - 9.5574860554776e-5*x_95 + 0.000147082784743706*x_96 - 6.56870673752712e-5*x_97 - 0.000174351648935469*x_98 + 0.000590065736070035*x_99 - 4.51456915949802e-6*std::pow(1.44607985019684 - 3.71663975715637*x_1, 2) - 0.00014920262922374*std::sin(1.2617598772049*x_120 - 5.20279979705811) - 0.000190794197949826*std::sin(0.510879814624786*x_14 - 2.01327991485596) - 0.000213639188601052*std::sin(0.736559867858887*x_14 + 4.41551971435547) - 0.000236231541660324*std::sin(0.436479866504669*x_32 + 4.59007978439331) + 7.88593898184955e-5*std::sin(2.63504004478455*x_63 + 1.17031991481781) - 6.6094636583466e-7*std::sin(1.35359978675842*x_77 + 1.21511995792389) - 0.00014893780048869*std::sin(2.59975981712341*x_88 + 7.40727996826172) + 0.0475730117175428);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
