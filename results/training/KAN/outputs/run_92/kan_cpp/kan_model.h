
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.32271981802236e-5*x_1 + 4.27629714595672e-6*x_10 - 9.98805709557213e-6*x_100 - 5.25542182914796e-7*x_101 - 4.18902496563437e-6*x_102 - 2.65166433434983e-6*x_103 + 9.39505244576798e-6*x_104 - 3.97772870601889e-6*x_105 + 3.68028203631485e-6*x_106 - 7.68332115024625e-6*x_107 + 5.91142918115341e-6*x_108 - 1.67844015991589e-5*x_109 + 8.39153095948454e-6*x_11 + 1.25787334472692e-5*x_110 - 5.99756189324744e-6*x_111 - 3.02885072047527e-6*x_112 - 6.06877329325784e-6*x_113 - 1.61141601468692e-6*x_114 - 2.06315988798988e-6*x_115 + 3.29753918870235e-7*x_116 - 5.74797950290503e-6*x_117 + 3.74574066124139e-6*x_118 + 1.57359816142508e-7*x_119 - 1.15444172159347e-5*x_12 + 5.64854094744656e-6*x_120 + 4.920161607028e-6*x_13 - 1.13214298715707e-5*x_14 - 3.2030004954865e-6*x_15 - 6.88382723418567e-6*x_16 - 1.7393462663277e-6*x_17 - 7.63510565860708e-6*x_18 + 1.38305257135423e-5*x_19 - 1.85188618167923e-5*x_2 - 6.02436994394069e-6*x_20 - 5.6702176405277e-6*x_21 + 2.74292045297575e-5*x_22 + 2.25050545787657e-6*x_23 + 1.1211057512647e-5*x_24 - 1.90438509258477e-5*x_25 + 8.59664731814896e-6*x_26 + 9.84151479305451e-6*x_27 + 1.05317287140357e-5*x_28 + 7.16727674418183e-6*x_29 - 1.42658363628675e-5*x_3 + 2.42116454469149e-6*x_30 - 3.85054013078095e-5*x_31 - 4.22640079618972e-5*x_32 - 4.05194917814612e-5*x_33 - 4.38603401599578e-5*x_34 + 9.27298843887491e-6*x_35 - 1.00946315710935e-5*x_36 - 1.24728924353998e-5*x_37 + 3.67506917418579e-6*x_38 - 2.72282210734158e-5*x_39 - 6.29969183348031e-6*x_4 - 2.57965425019615e-5*x_40 + 1.95759154476385e-5*x_41 - 7.23626760627511e-7*x_42 + 5.6862204500828e-6*x_43 + 1.80685339844825e-5*x_44 + 2.95625499523702e-7*x_45 - 1.76498018291283e-6*x_46 - 1.2877109095658e-6*x_47 - 4.03572826059523e-6*x_48 - 1.85984498613602e-6*x_49 + 9.35815252262545e-6*x_5 + 6.51607403032722e-6*x_50 - 1.24963257029687e-5*x_51 + 1.20250500833494e-5*x_52 - 5.17355450086291e-6*x_53 + 2.35748319228044e-5*x_54 - 7.27744194437583e-6*x_55 - 1.36666326434017e-5*x_56 + 7.42037787036102e-6*x_57 + 6.80798038963153e-6*x_58 + 1.24774064667207e-5*x_59 - 1.84033494546273e-6*x_6 - 2.4346631347124e-7*x_60 + 7.68240351272552e-6*x_61 - 2.51995205829209e-5*x_62 - 1.15216137685138e-5*x_63 - 4.28906338457018e-6*x_64 - 2.50546897930503e-5*x_65 + 1.65092563204921e-6*x_66 + 1.24600444191701e-5*x_67 - 6.47604169192935e-6*x_68 - 7.77828307524115e-6*x_69 + 8.23639047102828e-7*x_7 - 8.25471124544431e-6*x_70 + 2.50150445243618e-6*x_71 + 4.15787661760802e-6*x_72 - 7.29894266786902e-6*x_73 - 6.60463965117437e-6*x_74 + 2.10984491302867e-5*x_75 - 2.16169271130207e-5*x_76 + 2.03083459404568e-5*x_77 - 3.98531612651356e-8*x_78 + 5.92159189504746e-6*x_79 - 2.12015831015393e-5*x_8 - 3.65881996276151e-6*x_80 - 1.83077648657244e-5*x_81 - 1.27214104662943e-5*x_82 - 3.66422262011642e-5*x_83 + 8.00832382954922e-6*x_84 + 1.19465618180515e-6*x_85 - 2.98591964442586e-6*x_86 - 1.77308254997373e-5*x_87 - 1.12979063139172e-5*x_88 - 2.38600302257447e-6*x_89 - 4.04672275985418e-5*x_9 + 4.41110889145962e-6*x_90 - 0.000112909834741114*x_91 - 2.90751814246683e-5*x_92 - 2.41028527269513e-5*x_93 + 9.48791019183219e-7*x_94 - 1.27225105336386e-5*x_95 + 4.42597655607074e-6*x_96 - 3.6511395474566e-6*x_97 - 8.17642518870773e-6*x_98 - 1.99765612988532e-6*x_99 - 1.51848342608699e-5*std::sin(0.689039826393127*x_103 + 4.35960006713867) + 2.40473881233202e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 3.744444855182e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) + 1.20989731351663e-5*std::sin(1.57671976089478*x_105 + 0.992959797382355) + 7.45818534907451e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) + 4.35650689792431e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) + 1.72865312400703e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) + 2.25386022234731e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 1.88157574426255e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 1.77962208610661e-5*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 5.91611617139296e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) + 2.74075404327914e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 1.62712069554386e-5*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 3.45595774081584e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 1.30259454743709e-5*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 2.71573212269426e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 1.20733928969577e-5*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 1.13554975963447e-5*std::sin(1.0862398147583*x_13 - 8.42704010009766) - 2.30865736202905e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) - 1.62297473326926e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) - 4.07810938406847e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 1.43120322140325e-5*std::sin(0.779839873313904*x_19 + 1.41111993789673) - 2.03249498720266e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) + 2.21766118247492e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) + 7.10538749008741e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) - 3.5051172566694e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) - 1.40227293480731e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 9.22681646156007e-6*std::sin(1.67151987552643*x_24 + 0.984959840774536) - 5.64623025037057e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 3.4145460224758e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 3.67481530540678e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) - 2.40450832709744e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 2.44763847632777e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) - 5.4583034845774e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) + 3.87457465967825e-6*std::sin(1.57583975791931*x_29 + 0.990559816360474) - 2.38719353166098e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 1.91136028304708e-5*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 2.82870264131525e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000261604288936422*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 7.69202211238454e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) - 6.50227520837021e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) - 3.26548226453181e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 1.97147987920233e-5*std::sin(1.52671980857849*x_39 - 2.19400000572205) + 4.23216184125292e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 2.28942805576278e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) + 1.9131308497552e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 4.90882084726925e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 9.00156381143776e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 2.45395085080882e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) + 1.66186081726814e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) - 4.18491168115371e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 1.67112153265817e-5*std::sin(2.02023983001709*x_44 + 1.80927991867065) - 3.84147808125906e-6*std::sin(1.22071981430054*x_46 + 7.38047981262207) + 5.20848117209277e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 5.57672673070568e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 3.41520842159755e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 6.78044828920681e-6*std::sin(1.8439998626709*x_53 + 9.98999977111816) - 2.86986463653678e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 1.64315031959175e-5*std::sin(0.448479861021042*x_55 - 1.61047983169556) - 3.05745328048992e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) + 3.99997057589067e-6*std::sin(1.33343982696533*x_57 + 7.58480024337769) - 7.61173743037508e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 2.0483010600047e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 4.01260165161678e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) - 9.26214649467023e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) - 1.73982284046684e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) - 7.24891570869773e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 8.29660534735202e-6*std::sin(1.38559985160828*x_6 + 1.37687981128693) + 2.95106559628803e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) - 6.43279434694216e-6*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 8.19145866671306e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) + 5.77167295633822e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.17536237678428e-5*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 8.82837078794092e-6*std::sin(1.63535988330841*x_70 - 1.97663974761963) + 4.63806604068284e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 5.60463892500788e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 3.93122084644855e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) - 2.28257946865747e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 6.0405103782889e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) + 1.00745495692419e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) + 1.27473222826327e-5*std::sin(1.48247992992401*x_76 + 1.18263983726501) - 3.35494000292059e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 5.99544396268346e-6*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 1.90255584813792e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 2.28519471007073e-6*std::sin(2.01543974876404*x_78 - 7.38951969146729) - 8.25713347463652e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) + 2.47272657936639e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 3.99739924486175e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) - 1.0804059440823e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 1.63528016956673e-5*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 5.03821931776758e-6*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 5.39884022061134e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 1.29312005643263e-5*std::sin(1.28871989250183*x_84 - 8.22535991668701) - 1.30775491986312e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 7.58983260782923e-6*std::sin(1.4935998916626*x_84 + 4.40592002868652) + 9.67912646568928e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 2.74914659458304e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) + 1.68899090564641e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) - 6.59648837089876e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) - 1.56155249971014e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) + 1.69658703456205e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) - 1.65788664350987e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) + 4.1521464017849e-6*std::sin(1.13935983181*x_87 + 4.41120004653931) + 6.31928368129883e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) - 1.71024402139727e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 7.07716858117607e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 6.19017280802089e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 3.70583154836012e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) - 3.58459792562946e-6*std::sin(1.69847989082336*x_92 + 4.02615976333618) + 2.86509842844433e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 1.19946784335556e-5*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 4.93667216770901e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 6.09923413644308e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) + 6.38708424024708e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 3.01212647295794e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 4.43637136092472e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0520705892095154);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.09358312992737e-5*x_1 + 1.24700383501484e-7*x_10 - 1.95465485349382e-5*x_100 + 1.02182292762423e-5*x_101 + 5.53128356366704e-6*x_102 - 1.76549171392487e-5*x_103 - 1.32158146224462e-6*x_104 - 6.39131387809013e-6*x_105 + 2.2552202397434e-5*x_106 - 5.33470017968489e-6*x_107 + 3.43359382955179e-6*x_108 - 2.56372149255746e-7*x_109 + 9.47453136235086e-6*x_11 + 8.16113354389422e-6*x_110 + 2.25520949858212e-6*x_111 + 1.66115762671567e-5*x_112 - 7.49844668826567e-7*x_113 + 1.42218629439871e-6*x_114 - 2.30954283370903e-6*x_115 - 8.07317514417584e-6*x_116 + 4.40045852379678e-6*x_117 - 8.0020776973923e-6*x_118 + 2.64816192279872e-6*x_119 - 2.09125636349784e-5*x_12 + 1.16669774773646e-6*x_120 + 1.24717757513333e-5*x_13 + 1.14233607738313e-6*x_14 + 1.45229766619525e-5*x_15 - 7.57740393613416e-6*x_16 - 2.05704553373512e-6*x_17 + 5.87576469435348e-7*x_18 + 9.61918205937826e-6*x_19 - 2.24090307136132e-5*x_2 - 7.68000704698515e-6*x_20 - 1.12536922179822e-5*x_21 + 2.06875658450795e-5*x_22 - 2.84556809207522e-6*x_23 - 2.51309565570332e-6*x_24 - 2.37760543189404e-5*x_25 + 5.88410899729453e-6*x_26 + 9.31759978207682e-6*x_27 + 4.93868904393908e-6*x_28 + 7.64647146132793e-6*x_29 - 1.09108224024083e-5*x_3 + 6.24630856342332e-6*x_30 - 1.16736637585337e-5*x_31 - 3.64565822140884e-5*x_32 - 5.15345211514852e-5*x_33 - 3.69317243859902e-5*x_34 + 4.29219471089502e-6*x_35 - 1.35133526566146e-7*x_36 + 4.55082137622648e-6*x_37 - 1.07921205754854e-5*x_38 + 7.75212163401213e-7*x_39 - 7.16283961630782e-6*x_4 - 4.39221982839336e-6*x_40 + 7.86256003948536e-6*x_41 + 2.8894640958414e-6*x_42 - 6.26482841758444e-6*x_43 + 5.01288129974069e-6*x_44 + 2.2701998560621e-6*x_45 + 2.42093313384826e-5*x_46 + 7.04320800474236e-6*x_47 + 9.81103602771948e-7*x_48 - 1.42132813065344e-5*x_49 - 3.01686004210225e-6*x_5 + 2.88438818774113e-5*x_50 - 3.24537133212788e-6*x_51 + 8.46486015138626e-6*x_52 - 1.8034675627768e-6*x_53 - 7.35882751638367e-6*x_54 + 2.1490104875388e-6*x_55 - 1.21785456612601e-5*x_56 + 6.84569211872988e-6*x_57 + 1.92497072958534e-6*x_58 + 1.05493353917352e-5*x_59 - 3.71594857608689e-6*x_6 + 7.31407536598579e-6*x_60 + 3.01752465536174e-7*x_61 - 2.89425619513953e-5*x_62 - 2.01202029134925e-5*x_63 - 2.25728684894344e-6*x_64 + 1.97546452278727e-5*x_65 + 5.02626623653875e-6*x_66 - 1.57289144831844e-5*x_67 + 3.34674984002528e-6*x_68 + 5.77956309611776e-8*x_69 + 3.45669096026459e-6*x_7 - 1.61127528931203e-7*x_70 - 9.39982459997931e-6*x_71 + 5.9054469669654e-6*x_72 - 6.13409610728344e-6*x_73 + 8.72354738223436e-6*x_74 + 1.48729246966458e-5*x_75 - 2.05200371269022e-5*x_76 + 4.10617861603079e-6*x_77 - 2.68793793467915e-6*x_78 + 9.09809885988261e-6*x_79 - 1.96847632580166e-5*x_8 + 8.03548839680099e-8*x_80 + 4.53055327388619e-6*x_81 - 1.77398988862859e-5*x_82 + 1.47651185991485e-6*x_83 + 1.25513557443125e-5*x_84 + 6.42980550439277e-6*x_85 + 1.30500330505014e-6*x_86 - 2.20095648348127e-5*x_87 - 3.83736281246735e-6*x_88 + 8.47244306431271e-6*x_89 - 2.24332075662389e-5*x_9 + 1.25058905952674e-5*x_90 - 7.37455825010318e-5*x_91 - 2.37901405799419e-5*x_92 - 2.43767454815672e-5*x_93 - 1.01506799428128e-6*x_94 - 3.3160041031388e-6*x_95 + 1.15569604265187e-5*x_96 - 1.43451781861895e-6*x_97 + 3.18268437802949e-6*x_98 - 4.03901568028492e-6*x_99 - 6.00278353677348e-6*std::sin(0.689039826393127*x_103 + 4.35960006713867) - 8.38833591198105e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 9.88571180998825e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 7.18628933781506e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) + 2.94832801323344e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 2.58758480748051e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 4.02647670013951e-6*std::sin(1.6522399187088*x_112 - 5.60143995285034) - 7.86203330970782e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 4.96754960370211e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 3.89535015333628e-6*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 1.33496352388822e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) - 9.56044184476341e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 1.31931969160113e-5*std::sin(1.77847993373871*x_118 + 0.977119863033295) - 5.01252256801863e-6*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 1.05618387210765e-5*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 6.12801239769227e-7*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 2.64270112399784e-6*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 2.48556362884345e-6*std::sin(1.0862398147583*x_13 - 8.42704010009766) + 4.1806074495964e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) + 5.66134549394909e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 1.28458388697401e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 2.19887743812666e-5*std::sin(0.779839873313904*x_19 + 1.41111993789673) + 7.08985549891792e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) - 7.73576192231904e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 4.22030611942158e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) + 6.34720403120461e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) + 4.89148191775396e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 2.20128175701279e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 1.77853405063288e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) + 4.95245899423462e-6*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 2.15500103192697e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) + 8.38753192131043e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 6.46201226826158e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 1.71933806726565e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 1.81078752580028e-7*std::sin(1.57583975791931*x_29 + 0.990559816360474) + 8.32713354472857e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 1.54978992405075e-5*std::sin(1.67927992343903*x_29 + 0.961359798908234) - 4.10275150657931e-6*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000690661689169586*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 6.23692899297072e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 1.51454674513931e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) - 1.29089213885396e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 1.59853674859545e-5*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 1.33310963398339e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 5.46198814524999e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 4.45617266059799e-6*std::sin(1.00759983062744*x_40 + 7.39007997512817) - 7.11975583170438e-6*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 1.38298567784253e-5*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 6.47867757309843e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) - 3.0093628561483e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 2.4856643500233e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 9.79986292659433e-6*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 1.79531979666556e-7*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 3.09362226819311e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 8.56799258369717e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) + 4.95341973820079e-6*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 1.79010668662574e-5*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 1.34123498474738e-7*std::sin(1.146479845047*x_54 - 2.15255975723267) - 2.52450952538968e-5*std::sin(0.448479861021042*x_55 - 1.61047983169556) + 5.53655651611079e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 1.8693914709576e-7*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 2.39765889878656e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 5.40772124104782e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) + 5.81987913152255e-6*std::sin(1.48991990089417*x_57 + 7.59232044219971) - 3.66145981827829e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 8.13108475984659e-8*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 4.30555594149756e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 1.97935724335117e-5*std::sin(1.38559985160828*x_6 + 1.37687981128693) + 1.16659870453677e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) + 1.16487567236535e-5*std::sin(0.613759875297546*x_67 - 1.79879987239838) + 1.18808951125074e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) + 2.28162539061937e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.80580771010274e-5*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 2.10622283867919e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) + 1.83349426099591e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 1.26467910918118e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 9.37888465445033e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) + 4.13338457577713e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 1.36303290656737e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) - 1.82433901510115e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 7.57138190009845e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) + 6.07525716021877e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 1.43035915748736e-5*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 5.02293919246009e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 5.00197970893468e-7*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 4.90439557033372e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 1.15563199522997e-7*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 2.3441720962212e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) + 1.95644152861599e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 1.32593564503406e-5*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 1.20198990824577e-5*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 1.21824091296027e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 1.98672870096737e-5*std::sin(1.28871989250183*x_84 - 8.22535991668701) + 2.36813398564308e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 1.81073939510989e-5*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 2.25451692132789e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 6.20341169657216e-7*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 5.32023616412784e-6*std::sin(1.41647982597351*x_86 - 5.0099196434021) - 2.60768679546196e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) + 2.82772061397907e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) - 5.91812377994478e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 7.74815487361873e-8*std::sin(2.03999972343445*x_86 + 6.57639980316162) - 1.44837346140385e-5*std::sin(1.13935983181*x_87 + 4.41120004653931) + 2.49810379189011e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 3.98359717636505e-6*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 1.54909572841857e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 1.35494444495548e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 9.7837687882494e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 1.67526652055232e-7*std::sin(1.69847989082336*x_92 + 4.02615976333618) - 9.9941864436302e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 1.84284295833754e-5*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 2.8949845724343e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 1.37628384229113e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 2.01189932075379e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) + 4.36878950952212e-6*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 1.00106113093152e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.101921493363422);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.25594880892533e-5*x_1 + 2.20651123664402e-6*x_10 - 2.16748383858022e-5*x_100 - 8.37404195366754e-6*x_101 - 1.06266464501619e-5*x_102 + 1.69062337262287e-5*x_103 + 1.96136604148592e-6*x_104 - 4.90588543626097e-6*x_105 - 1.83085849968189e-6*x_106 - 1.69512258387889e-6*x_107 - 8.01805545044288e-6*x_108 - 9.47096892112867e-6*x_109 - 1.17006266215486e-5*x_11 - 1.16412670674019e-5*x_110 - 4.81137474719364e-6*x_111 - 1.56262256396813e-5*x_112 - 6.2280171862592e-6*x_113 - 1.24996189439596e-5*x_114 + 1.08996102298144e-6*x_115 + 7.24788027055256e-7*x_116 + 1.46423755342694e-5*x_117 + 5.12540981179432e-6*x_118 + 5.43780799875158e-6*x_119 + 5.12168760023217e-6*x_12 + 2.49985646869949e-6*x_120 - 3.97905202714281e-6*x_13 - 2.46660497859499e-5*x_14 - 7.47467828045682e-6*x_15 - 1.32442642343974e-6*x_16 - 1.58808739461584e-6*x_17 - 7.60776876112871e-6*x_18 - 1.69461710449136e-5*x_19 - 7.07908197683153e-6*x_2 - 6.95660156807733e-6*x_20 + 3.01040907920087e-6*x_21 - 1.69099451099032e-5*x_22 + 3.59166788510012e-6*x_23 + 1.08823060548502e-5*x_24 - 9.75264359383537e-6*x_25 + 2.4136936010669e-6*x_26 + 9.84365225295245e-6*x_27 + 6.35178181708446e-6*x_28 - 4.02015575372918e-7*x_29 - 1.96773089901624e-6*x_3 - 4.08431726491061e-6*x_30 - 2.3846344046317e-5*x_31 - 2.40206460148449e-5*x_32 - 1.53764374273559e-5*x_33 - 8.53220665313718e-6*x_34 + 2.44974222950807e-6*x_35 - 1.0225033362017e-5*x_36 - 9.82032219701753e-6*x_37 + 1.19877259903098e-5*x_38 - 2.18798004699478e-5*x_39 - 5.93934642946963e-6*x_4 - 1.60430978329302e-5*x_40 + 1.40750622727016e-5*x_41 + 1.66319366359279e-5*x_42 - 1.75240038366172e-5*x_43 - 3.76059247594967e-5*x_44 - 1.55932323290212e-5*x_45 - 1.7062809331111e-5*x_46 + 4.79482282275018e-6*x_47 - 3.91149178413531e-6*x_48 + 1.20211252879573e-5*x_49 + 4.84889630870823e-6*x_5 - 1.37014640429237e-5*x_50 - 3.69410410353673e-6*x_51 + 4.20123158091669e-6*x_52 - 4.94085118662152e-6*x_53 + 2.83100034412774e-5*x_54 + 3.84579276661571e-6*x_55 + 3.48685294892091e-6*x_56 + 1.37031651105409e-5*x_57 - 1.29715716350409e-5*x_58 - 5.07531693941608e-6*x_59 + 3.3203916117004e-6*x_6 - 1.0696231990229e-5*x_60 - 3.54311382882779e-6*x_61 - 4.81228232399978e-6*x_62 + 1.9872294803295e-6*x_63 + 4.88004560664598e-6*x_64 - 1.35219354391084e-5*x_65 - 9.68610060864268e-6*x_66 + 5.75201363110322e-6*x_67 - 1.94904051173386e-5*x_68 + 8.41581850665989e-6*x_69 - 9.74128529594738e-6*x_7 + 4.1597027364998e-8*x_70 + 4.18092645811342e-6*x_71 - 5.74554452424929e-6*x_72 - 7.51807402049539e-6*x_73 - 1.44633157964159e-5*x_74 + 1.4012763458599e-5*x_75 - 1.16231855727314e-5*x_76 + 3.67470791508353e-6*x_77 - 1.39798732210752e-5*x_78 - 4.35375294022938e-6*x_79 + 9.30684162994269e-5*x_8 - 4.42326193433158e-6*x_80 - 1.42212605817362e-5*x_81 - 2.43670953542913e-7*x_82 + 6.42213325228053e-6*x_83 - 1.41383121722764e-6*x_84 + 3.14766907041077e-6*x_85 + 3.16891676107097e-6*x_86 - 1.22392518921904e-5*x_87 + 1.19914354770381e-5*x_88 - 7.82047748902283e-7*x_89 - 3.29102394043358e-5*x_9 - 7.05653626068271e-6*x_90 + 1.0261360627323e-6*x_91 + 2.67925547684206e-6*x_92 - 1.3594326940184e-5*x_93 + 1.87659210886894e-5*x_94 - 4.94336101076963e-6*x_95 + 6.50880775079812e-6*x_96 - 4.65820292250945e-6*x_97 - 6.19406481984118e-6*x_98 - 3.22866531538425e-7*x_99 + 1.52716200030848e-5*std::sin(0.689039826393127*x_103 + 4.35960006713867) - 2.34274334539438e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) - 2.67213757809256e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) + 1.81130484895129e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) - 7.50081104652868e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) + 6.52200974458281e-7*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 1.41021630718741e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) - 2.19575448704666e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) + 1.3427435699349e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 1.47982226540579e-5*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 6.29487362460148e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) - 2.67009592198841e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) - 6.76841408564882e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 2.77191633577545e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) - 5.4184666859121e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 2.88959682592001e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 1.003947735162e-5*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 9.44252058289309e-6*std::sin(1.0862398147583*x_13 - 8.42704010009766) - 5.01169959239311e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) + 1.58113356702658e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 9.3222354913283e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 3.88473937403818e-6*std::sin(0.779839873313904*x_19 + 1.41111993789673) + 1.98009616736666e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) - 2.1604886779967e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) + 1.06372852230457e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) - 7.60900903506142e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) + 1.36612158027285e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 2.5825800655108e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 1.29068357601789e-5*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 2.73870128305545e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 1.8259844344437e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) + 2.34251880219379e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) - 1.74670131438289e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 1.24772500377626e-5*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 4.19697900622719e-6*std::sin(1.57583975791931*x_29 + 0.990559816360474) + 2.32565039154661e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) - 7.95077949531056e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 2.26881450774393e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) - 0.000186687927875284*std::sin(0.565119862556458*x_31 - 4.73639965057373) - 3.19968831784687e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 5.30448498042734e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) + 3.28414544498859e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) + 8.20086194005797e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 9.674387223575e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 6.40809458264047e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 1.5607112176758e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 3.93721269656747e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 2.44330985587943e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) + 1.75120599630776e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) + 3.60761510889463e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) - 6.26511914343746e-7*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 8.30366060086861e-6*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 4.16112845306871e-6*std::sin(1.22071981430054*x_46 + 7.38047981262207) + 7.79747760184893e-7*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 1.51370047139655e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 2.73923257281189e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) + 4.8387121110433e-6*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 3.10866680557367e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 4.46003100644431e-6*std::sin(0.448479861021042*x_55 - 1.61047983169556) - 6.63720724071634e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 4.33280914863922e-6*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 1.73998297106303e-5*std::sin(1.37671983242035*x_57 + 4.39111995697021) - 1.46172328485776e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 3.21838312306748e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) + 9.3150823545047e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 1.8845939431711e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) - 1.08521574732986e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 2.32221456563565e-5*std::sin(1.38559985160828*x_6 + 1.37687981128693) - 2.96793179408109e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) - 1.39644944012758e-5*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 6.57011450803538e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) - 5.80465974517846e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 3.19030619521677e-6*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 2.47105537460957e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) - 4.66457393644695e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 5.963455199721e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 1.10034621729561e-5*std::sin(1.02143979072571*x_73 - 8.19176006317139) - 4.95508895378974e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 6.42723171043976e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) + 2.18701210496383e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) + 1.90836746257144e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) - 7.28299994693144e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 1.67812095606542e-5*std::sin(1.83695995807648*x_76 + 3.98943996429443) - 1.35771554204982e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 1.90022479443853e-6*std::sin(2.01543974876404*x_78 - 7.38951969146729) - 1.23615332755605e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 2.67848278928312e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 1.98627364717765e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) - 2.34537619944497e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) + 6.80235545155924e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 1.41019438610768e-5*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 5.74448099455798e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 3.50993787846355e-6*std::sin(1.28871989250183*x_84 - 8.22535991668701) - 2.83891187433192e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 2.12438932487765e-5*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 7.89612548155656e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 2.92515053576595e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 3.86089961849914e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) + 6.63418921961699e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) - 3.38986293722666e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) - 1.6528481033864e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 1.79583981434834e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) - 4.04510182228545e-6*std::sin(1.13935983181*x_87 + 4.41120004653931) - 6.35540022462925e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 1.39519836267302e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 5.88493013444614e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 5.14736000386436e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) - 2.64458207329447e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 3.88287323411176e-6*std::sin(1.69847989082336*x_92 + 4.02615976333618) - 2.79123464166516e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 3.25573607527756e-6*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 2.4529903646927e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 6.48971503998113e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 1.46003693827197e-5*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 2.41593306457584e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 4.72039362645698e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0613570496188305);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.78920208451506e-5*x_1 + 6.49587454280369e-6*x_10 + 1.02414104113123e-5*x_100 + 1.05379308435377e-5*x_101 - 3.75321309908698e-7*x_102 - 1.83964316308068e-5*x_103 + 9.64906617217471e-6*x_104 + 1.34749736131261e-6*x_105 - 4.59208976414418e-6*x_106 - 1.17164741826758e-5*x_107 + 7.90459315928006e-6*x_108 - 2.10744332232525e-5*x_109 - 5.75182873633196e-6*x_11 + 2.25556665807995e-5*x_110 - 4.4010065400277e-6*x_111 - 9.31281784454242e-6*x_112 - 5.63893525848127e-6*x_113 + 7.54855160285631e-6*x_114 - 3.5392601737294e-7*x_115 + 2.21569533978111e-5*x_116 - 2.83833432304931e-5*x_117 - 3.98470598739216e-6*x_118 + 5.42548461132257e-6*x_119 - 8.6815885477949e-6*x_12 - 1.88066609795262e-6*x_120 + 9.04470269705862e-6*x_13 + 8.95676707775969e-6*x_14 - 2.76511588735959e-6*x_15 - 6.15309445906465e-7*x_16 - 1.48209177753181e-6*x_17 + 4.78043655868205e-6*x_18 + 7.33511233114602e-6*x_19 + 1.81813565962242e-5*x_2 - 1.72779508618936e-5*x_20 + 4.06144189679853e-6*x_21 + 2.08366164762372e-5*x_22 + 8.11599963334236e-6*x_23 + 8.01129737006801e-6*x_24 - 9.25306939528379e-6*x_25 + 4.13020263374338e-6*x_26 - 4.18600926080853e-6*x_27 + 6.46827036994272e-6*x_28 + 3.80663108181521e-6*x_29 + 7.31446236461192e-6*x_3 - 3.96021321902259e-6*x_30 - 2.83134992798592e-5*x_31 - 2.23875582974967e-5*x_32 - 2.00368003725919e-5*x_33 - 1.79709342971148e-5*x_34 + 1.35849982171286e-6*x_35 - 6.31354351282515e-6*x_36 + 4.42107973624346e-7*x_37 + 1.49362677742517e-5*x_38 - 1.2744267626335e-5*x_39 - 3.38969436142088e-7*x_4 - 1.1041157449419e-5*x_40 - 1.81425924147973e-5*x_41 + 3.02802146548915e-7*x_42 + 1.61662471648998e-5*x_43 + 1.76086335513683e-5*x_44 + 1.66836124750094e-5*x_45 - 8.96281978397011e-6*x_46 + 1.00260897389964e-5*x_47 + 2.32328604709349e-6*x_48 - 1.68984786512895e-5*x_49 - 4.47594877348656e-6*x_5 - 2.66047752780015e-5*x_50 - 5.0060653653171e-6*x_51 + 1.44766872547793e-5*x_52 - 4.66669505356819e-6*x_53 + 1.19159619691125e-5*x_54 - 3.93386041655876e-6*x_55 - 2.05623037063487e-5*x_56 - 1.37850871257803e-5*x_57 - 2.42257062059069e-5*x_58 + 1.04392223510187e-5*x_59 + 1.44684975805156e-6*x_6 + 1.12557759151359e-5*x_60 + 1.84872439412007e-5*x_61 - 4.09498994797639e-5*x_62 - 8.73261167849188e-7*x_63 - 4.15818048401029e-6*x_64 - 2.04861832724295e-6*x_65 + 5.3968566356051e-6*x_66 - 1.76578490049557e-5*x_67 + 1.07827188710117e-5*x_68 - 1.40184477456677e-5*x_69 + 7.61657399186856e-6*x_7 - 2.83250651036198e-6*x_70 - 6.14752375946862e-8*x_71 - 2.64930397324332e-7*x_72 - 1.3557668942178e-5*x_73 - 8.85553388432198e-6*x_74 + 1.56662891767695e-5*x_75 - 7.51817683664064e-6*x_76 + 2.95405520925625e-5*x_77 + 3.81256302297576e-6*x_78 + 4.98877129360263e-6*x_79 - 1.14265869248272e-5*x_8 - 1.20390173074418e-6*x_80 - 3.29152897022185e-6*x_81 - 2.24144455632157e-5*x_82 - 5.25151074579366e-5*x_83 + 1.09424308407663e-5*x_84 - 6.71759066756149e-6*x_85 - 2.18288460732552e-5*x_86 + 6.62752094600479e-6*x_87 - 1.7143595514079e-5*x_88 + 5.07742472553517e-6*x_89 - 3.96361232427412e-5*x_9 + 7.18790354906941e-7*x_90 - 8.41667194898625e-5*x_91 - 3.23092886690319e-5*x_92 - 2.47701013527902e-5*x_93 + 5.86009125399412e-6*x_94 - 9.514551420804e-6*x_95 + 2.1223592888848e-7*x_96 + 5.28716538941988e-7*x_97 + 5.83335985656711e-6*x_98 + 2.47079767456175e-6*x_99 + 1.09454512993812e-5*std::sin(0.689039826393127*x_103 + 4.35960006713867) - 7.5458388422767e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 3.25601775420857e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) + 1.74394331690342e-7*std::sin(1.57671976089478*x_105 + 0.992959797382355) - 5.37596941248255e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) + 6.2794594258551e-8*std::sin(0.84391987323761*x_110 - 8.43544006347656) + 2.78343249090792e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) - 7.07239635491133e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 1.63614214286761e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) - 1.43446482478111e-6*std::sin(1.34247982501984*x_118 - 8.56151962280273) + 4.25812735161608e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) - 8.60022228228886e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) - 5.12518817879624e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 3.82182117200612e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) - 4.10297908112929e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) + 1.95464945181834e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) + 9.73176134509399e-7*std::sin(1.88767993450165*x_120 - 8.40639972686768) - 9.15310165962225e-7*std::sin(1.0862398147583*x_13 - 8.42704010009766) + 1.16380038143915e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) + 5.09273843776009e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 3.1843830003617e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 8.33314140913745e-6*std::sin(0.779839873313904*x_19 + 1.41111993789673) + 6.37777356214974e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) - 6.95880725337505e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) + 1.02416898433561e-7*std::sin(1.42887985706329*x_24 + 4.19280004501343) + 1.76693903018835e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) + 4.40019744542693e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) - 1.99772996359483e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 4.40884682878975e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 3.77602542049795e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) + 1.00915579412495e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) + 7.54511560180388e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 2.12836739304039e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 4.26210461519377e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 1.69388714165618e-5*std::sin(1.57583975791931*x_29 + 0.990559816360474) + 7.49078344095527e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) - 6.02050060264229e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 3.12816199000633e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000227480505735128*std::sin(0.565119862556458*x_31 - 4.73639965057373) - 2.42287255698972e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) - 1.04697951419253e-5*std::sin(1.55423986911774*x_36 - 9.61367988586426) + 2.35380752146441e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) + 6.20986838855561e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 3.30467453244726e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) - 4.95691991441069e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) + 3.08047374722777e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 5.42849098590247e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 5.24113578157957e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 2.13385637850457e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) - 8.37748504756726e-7*std::sin(1.37295985221863*x_43 - 2.38127994537354) - 6.03212245919147e-8*std::sin(1.5007199048996*x_44 - 2.24311971664429) - 4.58913397603335e-6*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 1.67941797444655e-5*std::sin(1.22071981430054*x_46 + 7.38047981262207) + 7.50749326394272e-8*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 3.24703380708738e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 3.77675794420851e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 5.89600351053305e-6*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 1.25464786024465e-5*std::sin(1.146479845047*x_54 - 2.15255975723267) - 9.56719756136536e-6*std::sin(0.448479861021042*x_55 - 1.61047983169556) + 1.54127041655902e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 1.74870774746329e-5*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 5.94360891132396e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 1.78111973210389e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 4.43739394317811e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) + 6.67629107065011e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 7.60616015196682e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) - 1.04485711008283e-7*std::sin(1.33967983722687*x_6 + 4.59503984451294) - 1.79632673604995e-5*std::sin(1.38559985160828*x_6 + 1.37687981128693) - 2.12717137444737e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) + 3.24278892044471e-6*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 9.05864380004443e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) - 4.16030653836959e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 6.84351512507086e-6*std::sin(1.5759197473526*x_7 - 1.98911988735199) - 1.91146111188743e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) - 3.34318604335559e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) - 4.03394145941679e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) + 8.51162230350792e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) + 1.15065444529802e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) + 4.34766013958388e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) - 5.07860751636467e-7*std::sin(1.69783985614777*x_75 - 6.22496032714844) + 1.83739621989877e-7*std::sin(1.48247992992401*x_76 + 1.18263983726501) + 1.69123427292513e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) + 1.29809432096163e-5*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 1.65438559238958e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) + 1.8419817639732e-7*std::sin(2.01543974876404*x_78 - 7.38951969146729) - 1.19018139630525e-7*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 1.08102698373814e-5*std::sin(1.72735989093781*x_79 - 2.38631987571716) - 1.09774186567899e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) + 5.44635540341514e-7*std::sin(1.45807981491089*x_80 - 2.38295984268188) + 5.15088930835702e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) + 1.09084230039673e-5*std::sin(1.67911994457245*x_81 - 5.6167197227478) + 3.88581774670888e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 7.52915597735984e-6*std::sin(1.28871989250183*x_84 - 8.22535991668701) + 6.5924277010426e-7*std::sin(1.31399989128113*x_84 - 8.18455982208252) - 1.64330092426764e-5*std::sin(1.4935998916626*x_84 + 4.40592002868652) + 1.55850787610625e-5*std::sin(1.72663986682892*x_84 + 4.0079197883606) - 1.97869953342042e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 1.31884494043175e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) + 4.75484558936969e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) + 7.87182812265691e-7*std::sin(1.7351199388504*x_86 + 0.988639831542969) - 5.32372675113367e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 7.24795136093235e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) - 1.30290356011778e-5*std::sin(1.13935983181*x_87 + 4.41120004653931) - 4.5550323824653e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) - 2.75379063065219e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) - 5.70455349368761e-7*std::sin(1.26719987392426*x_87 + 1.2060798406601) + 4.98959033029809e-6*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 3.22244118480423e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 1.56711506876354e-5*std::sin(1.69847989082336*x_92 + 4.02615976333618) - 8.99040298989285e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 6.98386854146047e-6*std::sin(1.54863977432251*x_93 - 1.80103993415833) - 1.35567937643263e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) - 4.38992659168553e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 4.98734108407608e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 3.33100390411406e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) - 3.1930803396364e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0853119649988773);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.89517692076244e-5*x_1 + 4.57864015387372e-6*x_10 + 1.02631299230527e-5*x_100 + 4.1535731106534e-6*x_101 - 8.72427284531342e-6*x_102 - 2.180146632808e-5*x_103 - 5.82160854426746e-6*x_104 + 7.91775263317503e-6*x_105 + 1.05320387524899e-5*x_106 - 1.46858368611354e-5*x_107 + 7.92445211064618e-6*x_108 - 2.20733870309082e-5*x_109 + 5.19220690668891e-6*x_11 + 7.02994133347259e-6*x_110 - 1.07594102901678e-5*x_111 + 3.08717740897751e-6*x_112 - 1.66343577331192e-5*x_113 - 2.19776019962576e-6*x_114 + 2.12181564428132e-6*x_115 + 2.67474169909272e-5*x_116 + 6.33442995887e-6*x_117 - 1.45422013411649e-5*x_118 + 1.88610119125561e-5*x_119 - 1.51280685627626e-5*x_12 - 6.24069198732186e-6*x_120 + 1.38096032460311e-5*x_13 + 3.65214795446862e-6*x_14 + 3.93527164815549e-6*x_15 - 6.74610397843018e-6*x_16 - 1.27613346630296e-5*x_17 + 4.12407816073549e-6*x_18 - 1.19362375256051e-6*x_19 - 1.1293869887002e-5*x_2 - 1.89209507001927e-5*x_20 - 1.46834163739355e-5*x_21 - 9.5871920315549e-6*x_22 - 2.3046703032099e-7*x_23 + 5.52394381498132e-6*x_24 - 4.57248012902371e-6*x_25 + 3.65212907842496e-6*x_26 - 5.4887834280418e-6*x_27 + 1.50832595468053e-5*x_28 + 1.7232964782505e-6*x_29 + 6.67591745364454e-6*x_3 - 7.09562838691787e-6*x_30 - 2.65046693544594e-5*x_31 - 3.26880121214518e-5*x_32 - 5.390238982364e-5*x_33 - 2.43741420799232e-5*x_34 - 2.95120000520929e-6*x_35 - 1.21137367545504e-5*x_36 - 1.15852076327116e-5*x_37 + 3.07341398375775e-6*x_38 - 1.26422207268068e-5*x_39 + 3.58151639333023e-7*x_4 + 6.98899257200773e-7*x_40 - 3.60511251866856e-6*x_41 + 1.09046963879816e-5*x_42 - 1.59572196643189e-5*x_43 + 5.19192296938598e-7*x_44 - 1.96904591969918e-7*x_45 + 3.92447505528445e-6*x_46 + 1.18540900301765e-5*x_47 + 2.95065187797441e-6*x_48 - 2.90123895093898e-5*x_49 - 8.07228162586248e-6*x_5 + 2.73258289204759e-5*x_50 - 8.24511621388837e-6*x_51 + 8.38803818122867e-6*x_52 - 8.98681673790714e-6*x_53 + 1.80829635352623e-5*x_54 + 5.75334828171602e-6*x_55 - 2.67591907234892e-5*x_56 + 1.05003735919524e-5*x_57 - 2.76074734992336e-5*x_58 + 9.77286502902627e-6*x_59 - 9.03794671863669e-6*x_6 + 7.43319849731039e-6*x_60 + 4.17398117688638e-6*x_61 - 5.98827871267905e-5*x_62 - 3.32564864672517e-5*x_63 - 1.69208447315191e-6*x_64 + 1.70272619110925e-5*x_65 - 1.66742900584925e-6*x_66 - 4.22812053097706e-5*x_67 + 3.90046145952389e-7*x_68 - 9.77635947563392e-7*x_69 - 5.57412521776072e-6*x_7 - 1.16488112902271e-5*x_70 + 3.58543842045241e-6*x_71 - 2.35900593700669e-7*x_72 - 1.7929674588447e-5*x_73 - 5.06725568182152e-6*x_74 + 1.72458799613134e-5*x_75 - 1.70743378531089e-5*x_76 + 2.50943392539336e-5*x_77 - 6.08086943206277e-6*x_78 - 3.28778678895055e-6*x_79 + 2.14650546581061e-5*x_8 - 2.83277548486573e-6*x_80 - 1.25382939773653e-5*x_81 - 6.30480162192664e-7*x_82 - 1.09668377561228e-5*x_83 + 1.85505764442616e-5*x_84 - 5.50683044296789e-6*x_85 - 2.49162754435467e-5*x_86 - 1.32392419380174e-6*x_87 - 1.63817694837541e-5*x_88 - 3.10630601780675e-6*x_89 - 6.919297338174e-5*x_9 + 1.41648154335734e-5*x_90 - 0.000130169310052557*x_91 - 4.07213098043236e-5*x_92 - 4.79334532576362e-5*x_93 + 1.23329038400527e-5*x_94 - 1.15991462403251e-5*x_95 + 2.95904064881662e-6*x_96 + 1.22451364155474e-6*x_97 - 1.81927133564168e-5*x_98 - 7.41012786494406e-6*x_99 + 1.78295788332496e-5*std::sin(0.689039826393127*x_103 + 4.35960006713867) + 7.38947207255619e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 8.85809697862104e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 9.17132378919409e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) - 8.75717846832087e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 3.30234102550325e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 1.07575105794401e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) + 6.92584037945043e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 4.45117529030579e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 3.44452638782975e-5*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 3.74813292514143e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) + 8.4220063138235e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 8.87551348760945e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 4.00216469176713e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 7.10530909374248e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 1.72054176930369e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 2.33685121964235e-5*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 2.19789984755243e-5*std::sin(1.0862398147583*x_13 - 8.42704010009766) - 5.31584045206221e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) - 4.9872054313987e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 7.04162530007845e-7*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 1.61149028239707e-5*std::sin(0.779839873313904*x_19 + 1.41111993789673) - 6.24561173484766e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) + 6.8146050998356e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 5.38606116331253e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) - 8.07077066033243e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) - 4.30901544763246e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 7.84504868781523e-6*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 9.74928184525865e-7*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 3.95420793725925e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) + 2.07388584191425e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) - 7.38876381925429e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 5.79028930334234e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 9.42479082651826e-7*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 3.80130476620806e-6*std::sin(1.57583975791931*x_29 + 0.990559816360474) - 7.33555754310338e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 1.04259653376206e-5*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 3.27577322514014e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000618867749705288*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 4.1957948290148e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 4.04640430014863e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) + 3.83423173831288e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 1.07539018502634e-5*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 7.3076259336777e-7*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 1.94657329963539e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 1.19055263721093e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 5.68464979797862e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 1.01354806861645e-5*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 5.80522225802083e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) + 3.82654745716224e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 3.17226756587171e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) - 9.43099176058914e-6*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 3.76883405849418e-6*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 3.94815880203434e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 6.27922072820999e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 3.95497502718793e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 1.60402598588676e-5*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 2.8155942469683e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 1.850136118296e-5*std::sin(0.448479861021042*x_55 - 1.61047983169556) - 7.03999393588406e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 3.92432939105834e-6*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 1.31431008389998e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 4.84559130462933e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 4.64678501781567e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) + 1.08753357629581e-5*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 1.70692203318478e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 5.49485913740964e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 7.05414193126367e-6*std::sin(1.38559985160828*x_6 + 1.37687981128693) - 3.46505307777353e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) - 1.48119460997963e-5*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 9.48610171438315e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) - 6.77692599121405e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.3234214541705e-5*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 7.50627249973193e-6*std::sin(1.63535988330841*x_70 - 1.97663974761963) - 5.44587861056016e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 3.55079769899197e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 3.34249836565282e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) - 5.25579433055053e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 3.82694240234847e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) + 2.31973349607035e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 9.66278863446919e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) - 7.72497732885429e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 5.09759243486317e-6*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 4.50080715883026e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 4.42308147421813e-6*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 6.25911338263699e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 2.42596624333866e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) - 2.25593642385242e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) - 2.4877081011075e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 8.92002126256437e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 4.28371757609395e-6*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 3.42041471164802e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 1.45601293635351e-5*std::sin(1.28871989250183*x_84 - 8.22535991668701) - 3.01119456647385e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 6.45321239333729e-6*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 6.02337761742698e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 1.7417113810277e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 2.91636147359468e-6*std::sin(1.41647982597351*x_86 - 5.0099196434021) + 7.74539961457675e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) - 3.59558073991646e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) + 5.21340714686575e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 1.62653528538023e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) + 1.27590446495933e-5*std::sin(1.13935983181*x_87 + 4.41120004653931) - 7.41991414787629e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 1.06429496456518e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 1.36981295744159e-5*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 0.000119813154427084*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 8.76675088334604e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 3.516811618431e-6*std::sin(1.69847989082336*x_92 + 4.02615976333618) + 8.80410159870239e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 1.35056345926897e-5*std::sin(1.54863977432251*x_93 - 1.80103993415833) - 2.7860160753441e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 3.86414661623629e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 1.1028506041441e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 3.48818681282935e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 2.81064622199962e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0650199068264199);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.6134743114257e-5*x_1 + 5.25077416347457e-6*x_10 - 1.13678633018988e-5*x_100 + 3.91837596325218e-6*x_101 + 1.43605874218417e-6*x_102 - 5.47254590205639e-6*x_103 + 1.03255983950392e-5*x_104 - 9.89430563990447e-6*x_105 - 3.70482959703981e-7*x_106 - 6.13102711244978e-6*x_107 + 9.66533786683193e-6*x_108 - 2.46671872003158e-5*x_109 + 4.76868397599326e-6*x_11 + 2.80741003604982e-5*x_110 - 6.50796759753862e-6*x_111 - 2.98989328319853e-6*x_112 - 8.26088877545999e-6*x_113 + 3.47806937328698e-6*x_114 - 8.95788016274215e-7*x_115 + 3.41481422091672e-6*x_116 - 1.37475965094226e-5*x_117 + 7.71989323215368e-6*x_118 + 6.19237543166226e-7*x_119 - 1.29195709300009e-5*x_12 + 7.39977599138422e-6*x_120 + 1.36260597377567e-5*x_13 - 1.42153202651103e-5*x_14 - 6.11193003300449e-6*x_15 - 8.63220098105795e-6*x_16 + 1.36190808673999e-7*x_17 - 9.68615391663613e-6*x_18 + 1.55854520395218e-5*x_19 - 1.81799879283301e-5*x_2 - 1.77277765837287e-5*x_20 - 3.64986851487591e-6*x_21 + 3.76736572014843e-5*x_22 + 5.78862471018581e-8*x_23 + 1.24596059389676e-5*x_24 - 1.72336076660329e-5*x_25 + 8.881342120951e-6*x_26 + 1.24691038303468e-5*x_27 + 1.07323663147908e-5*x_28 + 9.80712376266286e-6*x_29 - 2.21061935977187e-5*x_3 - 8.41136282466536e-8*x_30 - 3.61958523895456e-5*x_31 - 4.85542702630364e-5*x_32 - 3.94360624320127e-5*x_33 - 5.47276861225073e-5*x_34 + 1.51545201714398e-5*x_35 - 9.24388824398136e-6*x_36 - 1.44677878620422e-5*x_37 + 6.15374862283701e-6*x_38 - 3.62307243320131e-5*x_39 - 9.51256959464939e-6*x_4 - 3.13367022408851e-5*x_40 + 2.94666092189554e-5*x_41 - 7.77763041557196e-6*x_42 + 7.93096771207815e-7*x_43 + 2.43245984620532e-5*x_44 + 6.84003602014179e-6*x_45 + 5.8348927160735e-6*x_46 + 9.78818703801987e-6*x_47 - 1.71089956145891e-6*x_48 - 1.08803835732727e-5*x_49 + 2.98589953863964e-6*x_5 - 1.30010527794319e-6*x_50 - 1.76291815158919e-5*x_51 + 1.68214329081376e-5*x_52 - 1.04877467554737e-5*x_53 - 3.28276942278711e-7*x_54 - 2.16537293238664e-5*x_55 - 2.20084943499245e-5*x_56 + 6.41512833284217e-6*x_57 + 1.01148033394772e-5*x_58 + 8.50405539702672e-6*x_59 - 5.75908226189969e-6*x_6 + 3.84996628081149e-7*x_60 + 3.20673086749096e-6*x_61 - 2.17954212278094e-5*x_62 - 2.51652484314543e-5*x_63 - 4.09499475317232e-6*x_64 - 3.64587201695855e-5*x_65 + 6.53221846953341e-6*x_66 + 2.600869189808e-5*x_67 + 8.96000939876558e-6*x_68 - 1.27919726568062e-5*x_69 + 1.65911030954021e-6*x_7 + 4.36354933420054e-6*x_70 + 4.30681339419596e-6*x_71 + 1.03418113693235e-5*x_72 - 6.57328027902481e-6*x_73 - 7.01036350505881e-6*x_74 + 2.38965956786778e-5*x_75 - 2.44521044223513e-5*x_76 + 2.35747967567767e-5*x_77 + 1.124948289271e-6*x_78 + 9.35283842269292e-6*x_79 - 2.89580826035266e-5*x_8 - 2.09320531103958e-6*x_80 - 1.79810263032616e-5*x_81 - 2.81065800265395e-6*x_82 - 5.99567792745048e-5*x_83 + 3.74325569057691e-6*x_84 + 2.59546448282651e-6*x_85 - 9.74810467339061e-8*x_86 - 1.87338217022039e-5*x_87 - 1.45303409860619e-5*x_88 - 1.51656275866095e-5*x_89 - 5.51714445969952e-5*x_9 - 1.64051941520056e-6*x_90 - 0.000126559254497961*x_91 - 2.18823220604898e-5*x_92 - 1.89419117032488e-5*x_93 - 2.51365275294609e-6*x_94 - 1.48553610268448e-5*x_95 + 1.05686805869672e-5*x_96 - 9.41158415957774e-6*x_97 - 4.09838697780187e-6*x_98 - 1.04999725695362e-6*x_99 - 8.95608768008113e-6*std::sin(0.689039826393127*x_103 + 4.35960006713867) + 2.01419099626128e-7*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 5.14705831638028e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 1.8237816026336e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) + 4.39887329509654e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 6.56693509723337e-7*std::sin(0.84391987323761*x_110 - 8.43544006347656) + 1.14794472594729e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) + 1.88781623326526e-7*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 2.58638608844869e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 7.47318542249882e-6*std::sin(1.34247982501984*x_118 - 8.56151962280273) + 2.77672125394008e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) + 2.2956348060046e-7*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 5.72355055045426e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 4.2128629505612e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 4.58199920843013e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) + 1.27462525863779e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 5.06999235972843e-6*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 4.7685258440392e-6*std::sin(1.0862398147583*x_13 - 8.42704010009766) + 3.08711966920226e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) - 1.35939133104454e-7*std::sin(1.96007990837097*x_14 - 8.7958402633667) - 1.01862175870836e-5*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 4.80849957453536e-6*std::sin(0.779839873313904*x_19 + 1.41111993789673) - 1.70240239071941e-7*std::sin(1.18447983264923*x_2 + 1.39767980575562) + 1.85749619193256e-7*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 1.0710557697115e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) + 4.68701705324266e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) - 1.17453317803389e-7*std::sin(1.5759197473526*x_24 - 2.1976797580719) - 7.60199589000112e-6*std::sin(1.67151987552643*x_24 + 0.984959840774536) - 1.41030375746494e-5*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 4.16238146120344e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 5.8451205518404e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) - 2.01399794357636e-7*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 3.36448751745948e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) - 1.36336379714204e-5*std::sin(1.88831984996796*x_28 - 4.98519992828369) + 4.89069862930631e-6*std::sin(1.57583975791931*x_29 + 0.990559816360474) - 1.99949520220113e-7*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 6.72339011488878e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 3.44822982497999e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000359597372386865*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 2.70574134518825e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) - 4.31795854729041e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) - 1.92599701626386e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 6.93486646609606e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) + 1.05710066402747e-5*std::sin(1.57751977443695*x_4 - 2.00047969818115) - 1.88626518614191e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) + 1.27045064074672e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 5.98392429229217e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 3.02430955367839e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 3.37316441372191e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) - 2.22222807976841e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 6.3082749647164e-7*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 2.65806741383484e-5*std::sin(2.02023983001709*x_44 + 1.80927991867065) - 4.84892232998914e-6*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 7.85118871924474e-7*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 1.873646433356e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 4.16318893540533e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 9.3203035711557e-6*std::sin(1.8439998626709*x_53 + 9.98999977111816) - 3.62249905525646e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 5.52059099259697e-6*std::sin(0.448479861021042*x_55 - 1.61047983169556) + 4.08840407204117e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) + 5.04898016712848e-6*std::sin(1.33343982696533*x_57 + 7.58480024337769) - 1.90124409081439e-5*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 2.81556423264119e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 4.89142000604046e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) - 5.46285818382521e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) - 2.19609890852215e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 1.09269100450672e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) - 6.83559275447724e-6*std::sin(1.38559985160828*x_6 + 1.37687981128693) + 1.740552565538e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) + 8.60188535683121e-6*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 9.98550772785269e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) + 3.40416024104545e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 3.94893569562449e-6*std::sin(1.5759197473526*x_7 - 1.98911988735199) - 7.27371555779113e-6*std::sin(1.63535988330841*x_70 - 1.97663974761963) + 2.73555347478534e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) - 2.63052982275448e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) + 3.23894214671911e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) + 3.05224850170774e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) + 2.83510550944628e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) - 1.34716136942146e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 1.92151280957343e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) + 4.48620113246554e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) + 4.93966045091846e-6*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 2.61522502781263e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 9.5962417685172e-7*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 1.24466828327453e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) + 3.12120982419286e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 6.35821899557107e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) + 1.44471089368069e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 5.75225227010106e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) + 4.15100080359868e-6*std::sin(1.67911994457245*x_81 - 5.6167197227478) + 2.53393847465108e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 4.34457325709687e-6*std::sin(1.28871989250183*x_84 - 8.22535991668701) + 1.74872027439239e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) - 6.25328102394688e-6*std::sin(1.4935998916626*x_84 + 4.40592002868652) + 6.4276065705474e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) - 1.29030829656246e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) + 4.21872668122401e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) - 3.89064030699669e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) + 2.08809653421687e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) + 1.42104843647224e-7*std::sin(1.89959990978241*x_86 - 2.79887986183167) - 2.09267458937861e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) + 3.47780634418401e-7*std::sin(1.13935983181*x_87 + 4.41120004653931) + 3.72714365877945e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) - 1.13571981398734e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 2.97192271810473e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 2.59944566617831e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 5.09398103798868e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) - 4.52467424203566e-6*std::sin(1.69847989082336*x_92 + 4.02615976333618) + 2.39978472022855e-7*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 4.0299242820241e-6*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 7.85221611075778e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) - 2.86266742720685e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) + 1.59535274047217e-5*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 3.67182615413968e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) - 2.08220499587491e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0813717390398316);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.6516716259076e-5*x_1 - 2.61148499690808e-6*x_10 + 1.78262848918531e-5*x_100 + 2.37775450290459e-6*x_101 - 6.19237962361527e-6*x_102 - 1.40616123976842e-5*x_103 - 8.38417037652945e-6*x_104 + 1.00809877093352e-5*x_105 + 4.26741284062873e-6*x_106 - 1.14588141144188e-5*x_107 + 4.23409346356256e-6*x_108 - 2.22293864472805e-6*x_109 + 3.4879806020758e-6*x_11 + 3.41419834670778e-6*x_110 - 2.27636694374373e-6*x_111 + 4.55698602668515e-6*x_112 + 3.10853274397337e-6*x_113 + 3.27638505514689e-6*x_114 - 4.83615463088438e-6*x_115 + 1.39322022328204e-5*x_116 + 4.55429185829248e-6*x_117 - 1.18774973491231e-5*x_118 + 8.77080797001013e-6*x_119 - 1.00567183599452e-5*x_12 - 7.91187851892283e-6*x_120 + 2.1368688326894e-6*x_13 + 7.48289559195743e-6*x_14 + 3.87070608368037e-6*x_15 - 2.3135073284773e-6*x_16 - 8.06603491099822e-6*x_17 + 6.0618802120145e-6*x_18 - 2.70347346517347e-6*x_19 + 4.63096265668885e-8*x_2 - 1.82621013265348e-6*x_20 - 7.38222021298901e-6*x_21 - 1.26004049285737e-5*x_22 + 1.01787423382838e-6*x_23 - 2.52095450748062e-6*x_24 + 9.01303497868097e-6*x_25 + 7.77970455285979e-6*x_26 - 1.01763243174822e-5*x_27 + 6.88407628121127e-6*x_28 - 4.01322024374082e-7*x_29 + 1.54161630771973e-5*x_3 - 1.92646040030751e-6*x_30 + 3.0708688183391e-7*x_31 - 5.86637700684733e-9*x_32 - 2.0966482746534e-5*x_33 + 5.9021734945494e-6*x_34 - 1.0361630662274e-5*x_35 - 2.63138664973368e-6*x_36 - 4.8959265868011e-6*x_37 - 1.1232577134189e-5*x_38 + 5.24711528513979e-6*x_39 + 6.65267013152761e-6*x_4 + 8.32923653234846e-6*x_40 - 1.87799338644981e-5*x_41 + 1.16943259927669e-6*x_42 + 1.26100120572162e-5*x_43 + 7.62773397816583e-6*x_44 + 3.13710392714631e-6*x_45 - 2.46116298034717e-7*x_46 - 6.00236742606061e-6*x_47 - 1.58023676767047e-6*x_48 - 1.70000785769809e-5*x_49 - 1.1553413121268e-6*x_5 + 2.81115966533466e-5*x_50 - 2.95557175868675e-7*x_51 - 1.02380757986633e-6*x_52 + 4.19359679655157e-6*x_53 + 9.88548664836981e-6*x_54 + 1.63241925942465e-5*x_55 - 1.0609798408862e-5*x_56 - 3.50280831702883e-6*x_57 - 1.61539336136593e-5*x_58 + 8.91430143698658e-6*x_59 - 8.49512029041677e-6*x_6 + 9.08917033583595e-6*x_60 + 9.91759519316594e-6*x_61 - 3.22497080889195e-5*x_62 - 8.36843721063701e-6*x_63 - 1.91077850371609e-6*x_64 + 5.18943274532215e-6*x_65 - 1.86929015762379e-6*x_66 - 2.75327071128579e-5*x_67 + 8.92827132175156e-7*x_68 - 1.91448479015315e-6*x_69 + 4.45627277253888e-6*x_7 - 1.35826542578152e-5*x_70 + 2.85897262002883e-8*x_71 - 1.16827574528795e-6*x_72 - 7.93491893026479e-6*x_73 - 3.65673950037658e-6*x_74 + 1.19025417392044e-6*x_75 - 5.98786998746081e-6*x_76 + 4.38993208309182e-6*x_77 - 1.70474511750813e-6*x_78 - 3.05277192333743e-6*x_79 - 1.74318109369235e-5*x_8 - 5.4365377754873e-7*x_80 - 5.6419318974321e-6*x_81 - 9.10246435212843e-6*x_82 - 1.78540565899323e-6*x_83 + 2.06257245112104e-5*x_84 - 1.02709576521083e-5*x_85 - 2.24594738711476e-5*x_86 + 9.52352560552785e-6*x_87 - 5.7990155952152e-6*x_88 + 3.77112157499401e-6*x_89 - 2.71641192271229e-5*x_9 + 8.8741400774926e-6*x_90 - 6.3154224847867e-5*x_91 - 2.06888134035179e-5*x_92 - 2.30403707323153e-5*x_93 - 3.52379247504703e-7*x_94 - 1.07409539398384e-6*x_95 - 5.74973970816736e-6*x_96 + 6.88030589326218e-6*x_97 - 7.13420047761855e-6*x_98 - 9.93407613071615e-6*x_99 - 2.07582002924852e-6*std::sin(0.689039826393127*x_103 + 4.35960006713867) + 8.00814905951427e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 4.66556945201129e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) + 1.31684884734442e-5*std::sin(1.57671976089478*x_105 + 0.992959797382355) + 1.01956005995747e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) + 4.74160990597222e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 2.71337494581326e-6*std::sin(1.6522399187088*x_112 - 5.60143995285034) + 7.50570021463737e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 2.34443893650293e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 8.92458355495636e-6*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 9.16473760623681e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) + 9.12713131317623e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 1.19550581887251e-5*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 1.3557302623711e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 9.57064442335131e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 4.20697829323749e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 6.05465646565708e-6*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 5.69464089583191e-6*std::sin(1.0862398147583*x_13 - 8.42704010009766) + 1.49969646414968e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) - 5.40475477718997e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 2.67275819157635e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 1.83150994880453e-5*std::sin(0.779839873313904*x_19 + 1.41111993789673) - 6.76852003085113e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) + 7.38515186002073e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) + 7.73348384340259e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) + 2.27691299831394e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) - 4.66978393930833e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) - 4.22527723707846e-6*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 3.70049126493728e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 1.33948494805278e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) + 3.65917934375187e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) - 8.00738150833364e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 3.04975176464903e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 3.57732566161816e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) + 1.12502634331406e-5*std::sin(1.57583975791931*x_29 + 0.990559816360474) - 7.94972058396252e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 1.40434716773166e-5*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 1.10966570244428e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000325958326582855*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 5.65161344172935e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 1.02062758549718e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) - 4.46402863107879e-7*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 1.44851926094435e-5*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 2.7737228612541e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) - 1.04840800618978e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 3.00293982852692e-6*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 1.925670819583e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 1.15192960921948e-5*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 3.05761696835411e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) - 1.07953949016301e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) - 4.55484615264393e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) - 1.66401108219093e-5*std::sin(2.02023983001709*x_44 + 1.80927991867065) - 1.11541637941721e-5*std::sin(1.22071981430054*x_46 + 7.38047981262207) + 5.66889631976291e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 7.13653402696876e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 1.33974479918594e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 8.44842256530652e-6*std::sin(1.8439998626709*x_53 + 9.98999977111816) - 8.33297484611488e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 2.10273852986647e-5*std::sin(0.448479861021042*x_55 - 1.61047983169556) + 1.98611190619627e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) + 1.16143645835225e-5*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 4.98866794712286e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 2.55217828641671e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 1.57409491027309e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) - 1.2661678670419e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) - 5.05177135594858e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) - 7.88969955454343e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) - 3.79930151046515e-6*std::sin(1.38559985160828*x_6 + 1.37687981128693) + 4.03421003295823e-7*std::sin(2.05831980705261*x_64 + 0.966399788856506) + 4.17872270497185e-6*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 3.2134097811055e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) + 7.89007908760179e-7*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.50411056538868e-5*std::sin(1.5759197473526*x_7 - 1.98911988735199) - 4.04281523168697e-6*std::sin(1.63535988330841*x_70 - 1.97663974761963) + 6.34039872864261e-7*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 8.68222388427244e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) + 1.8002415053587e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) + 1.48275634773177e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 9.35743839724729e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) - 6.5443952902625e-7*std::sin(1.69783985614777*x_75 - 6.22496032714844) + 1.38741498696467e-5*std::sin(1.48247992992401*x_76 + 1.18263983726501) + 2.17935833292832e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) + 2.74552040860935e-6*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 2.37058009641492e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 1.14599674215038e-6*std::sin(2.01543974876404*x_78 - 7.38951969146729) - 8.98704094716932e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) + 7.17983981712989e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) - 3.98039072167963e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) + 7.01828257772506e-7*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 1.20150088654019e-5*std::sin(1.65983986854553*x_80 - 8.40263938903809) + 2.30717425533063e-6*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 8.36341825726028e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 1.65480500109058e-5*std::sin(1.28871989250183*x_84 - 8.22535991668701) + 8.49513427826016e-7*std::sin(1.31399989128113*x_84 - 8.18455982208252) - 3.47564591586928e-6*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 1.51928104514579e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 4.25874111503473e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 1.10695026872007e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) - 9.01763064895786e-7*std::sin(1.43367981910706*x_86 - 2.21943998336792) + 1.01437952678312e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) + 5.64989503040313e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) - 4.81386038985762e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) + 1.38272843320451e-5*std::sin(1.13935983181*x_87 + 4.41120004653931) + 8.63868212901519e-7*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 2.68447915573108e-6*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 3.54911207431678e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 3.10429471942909e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 4.61745736284539e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) - 1.04082833620167e-5*std::sin(1.69847989082336*x_92 + 4.02615976333618) + 9.54121718645692e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 1.53495831725623e-5*std::sin(1.54863977432251*x_93 - 1.80103993415833) - 4.91566713472039e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 9.44840818538929e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 4.18604066631921e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 1.18162064461881e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 6.87244439913116e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0426829519128644);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.58733559958903e-5*x_1 + 1.11015339406855e-6*x_10 - 8.24278839574459e-6*x_100 + 8.20792964918935e-6*x_101 - 1.59389797112779e-6*x_102 - 1.37953404906061e-5*x_103 + 3.54083565857534e-6*x_104 + 1.6979222537534e-6*x_105 - 7.11211940165517e-7*x_106 - 1.27298982355649e-5*x_107 + 5.76634783814652e-6*x_108 - 1.97868408620115e-5*x_109 - 2.0677336189372e-7*x_11 + 1.78433335364803e-5*x_110 - 5.45572592437328e-6*x_111 - 9.09140834878803e-6*x_112 - 1.48689231248754e-5*x_113 + 1.20827607289229e-6*x_114 - 2.02281521019641e-6*x_115 + 1.56495464949276e-5*x_116 - 6.36847192139289e-6*x_117 - 5.43283568768824e-6*x_118 + 1.34917117081724e-5*x_119 - 1.39435667491859e-5*x_12 - 2.07478107037017e-6*x_120 + 8.56331660190191e-6*x_13 - 1.14256044362992e-5*x_14 - 1.99064441644945e-6*x_15 - 6.73428441654981e-6*x_16 - 3.97787977280069e-6*x_17 + 3.55227247552995e-6*x_18 + 7.77051418526585e-6*x_19 + 7.32457824547769e-6*x_2 - 1.98714141005213e-5*x_20 - 4.58201010410375e-7*x_21 + 1.78197993883002e-5*x_22 - 5.60174819103589e-7*x_23 + 1.19982099643148e-5*x_24 - 7.10294472820256e-6*x_25 + 4.28208485487381e-6*x_26 + 2.41421609126851e-6*x_27 + 1.04747597674675e-5*x_28 + 4.06450305272674e-6*x_29 - 4.09425368390025e-6*x_3 - 6.31510183401974e-6*x_30 - 2.38447879257155e-5*x_31 - 4.50969757402661e-5*x_32 - 4.70355350762167e-5*x_33 - 2.95797935023528e-5*x_34 - 6.6919966143689e-8*x_35 - 7.98128772359779e-6*x_36 - 8.33537476860936e-6*x_37 + 1.37934098423726e-5*x_38 - 1.43148249650346e-5*x_39 - 5.91780991106575e-6*x_4 - 1.89976402405933e-5*x_40 - 6.27659074289139e-6*x_41 + 1.02002853513701e-5*x_42 - 8.67597380267347e-7*x_43 + 1.60787592063439e-6*x_44 + 4.80100513271709e-6*x_45 - 2.54796507974183e-6*x_46 + 7.80549076841977e-6*x_47 - 6.10338168489617e-7*x_48 - 9.42479721398049e-6*x_49 - 2.28931526558727e-6*x_5 + 4.16658144273176e-7*x_50 - 6.87917294694643e-6*x_51 + 1.11936018737767e-5*x_52 - 9.14334720489213e-6*x_53 - 1.06596666898274e-6*x_54 - 4.84617999254975e-6*x_55 - 1.41940152931789e-5*x_56 + 2.47973917607634e-6*x_57 - 2.36648469220572e-5*x_58 + 2.09038706438811e-6*x_59 - 2.69298564336428e-7*x_6 + 5.79562196797464e-6*x_60 + 3.05889581948875e-6*x_61 - 4.70890723574022e-5*x_62 - 1.82151614939998e-5*x_63 + 2.10316767560783e-6*x_64 - 5.54867931049346e-6*x_65 + 2.84967218951087e-6*x_66 - 9.90225610782279e-6*x_67 + 8.71282084079401e-7*x_68 - 5.64496436678753e-6*x_69 - 1.42689370688305e-6*x_7 + 2.84712077348386e-8*x_70 - 5.90983562293869e-6*x_71 + 1.51950752236783e-6*x_72 - 1.13909034400316e-5*x_73 - 8.79099964802478e-6*x_74 + 2.37447576803114e-5*x_75 - 1.7792115604144e-5*x_76 + 2.24345313943092e-5*x_77 - 5.31251993672026e-6*x_78 + 2.61182157491025e-6*x_79 - 8.75400884652681e-6*x_8 - 1.58763614098222e-6*x_80 - 1.28316966385688e-5*x_81 - 8.6934786809867e-6*x_82 - 2.28497313156619e-5*x_83 + 1.20530191142113e-5*x_84 - 3.20882393739247e-6*x_85 - 1.57116891284016e-5*x_86 - 1.53191276235728e-5*x_87 - 9.82115787736318e-6*x_88 - 2.04344184042041e-5*x_89 - 5.71239917356821e-5*x_9 + 1.29900447380866e-6*x_90 - 0.000122532336857238*x_91 - 3.50478544547804e-5*x_92 - 3.83630633608468e-5*x_93 + 7.49226964482864e-6*x_94 - 1.72900223248554e-5*x_95 + 5.85198448162685e-6*x_96 - 5.90256155366792e-6*x_97 - 6.62707590203562e-6*x_98 - 8.29719768181976e-7*x_99 + 1.77780723126867e-5*std::sin(0.689039826393127*x_103 + 4.35960006713867) + 3.01351148465786e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 5.84804378710613e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) + 3.12103925727326e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) - 8.73188051837657e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) + 1.1238002515671e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 1.95760557277106e-6*std::sin(1.6522399187088*x_112 - 5.60143995285034) + 2.82443716133584e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 2.93862982812425e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 4.02009430377402e-6*std::sin(1.34247982501984*x_118 - 8.56151962280273) + 1.36394765122499e-5*std::sin(1.37247979640961*x_118 - 8.37928009033203) + 3.43459079368152e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 4.47026094931697e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 4.23381945388407e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 3.57867585001426e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) + 6.26106104544757e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 2.72733061649459e-6*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 2.56516097209472e-6*std::sin(1.0862398147583*x_13 - 8.42704010009766) - 1.87862425368447e-5*std::sin(1.44215977191925*x_13 - 5.4029598236084) - 2.0338395891209e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 4.60015552922302e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 4.27824408871425e-6*std::sin(0.779839873313904*x_19 + 1.41111993789673) - 2.54703211635072e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) + 2.77907413819602e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) + 1.83289879619989e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) - 2.85221982208734e-5*std::sin(1.55111992359161*x_24 - 8.38472080230713) - 1.75726593341284e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) - 6.0548043116567e-7*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 6.36901437881402e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 4.18308684895197e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 1.21195464388438e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) - 3.01322265083613e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 3.82270203946555e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 6.15703076843572e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 9.73508158209438e-6*std::sin(1.57583975791931*x_29 + 0.990559816360474) - 2.99152452102898e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 5.25116499149739e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 3.4653827304111e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000408571469406938*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 2.11326339616017e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 7.36347275622944e-7*std::sin(1.55423986911774*x_36 - 9.61367988586426) + 3.82315531650173e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 5.41633422800059e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 4.77392851958859e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) - 1.50236421424562e-6*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 2.16651655610336e-6*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 6.01369077907013e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 2.6908049527522e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 3.83256065503968e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) + 1.35230636166119e-5*std::sin(1.37295985221863*x_43 - 2.38127994537354) - 1.07953571755101e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 5.51136134384872e-6*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 9.65192461151073e-6*std::sin(1.22071981430054*x_46 + 7.38047981262207) + 1.34357470070097e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 1.66703077614818e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 4.18389833986079e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 1.05896494741042e-5*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 7.21069248116469e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 4.91180989291641e-6*std::sin(0.448479861021042*x_55 - 1.61047983169556) - 2.48794211809212e-5*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 1.00501457069629e-5*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 8.58612968159314e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 3.19902008211072e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 4.9157519296784e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) + 1.08439188287533e-5*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 4.37140041888942e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) - 1.86992319486619e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) - 5.44438290699102e-7*std::sin(1.38559985160828*x_6 + 1.37687981128693) - 3.45504314824737e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) - 5.23455913289304e-5*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 0.000100351797272353*std::sin(0.586479842662811*x_68 + 1.38839983940125) - 6.75734864274249e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 3.51346829393256e-6*std::sin(1.5759197473526*x_7 - 1.98911988735199) - 5.79333703389725e-7*std::sin(1.63535988330841*x_70 - 1.97663974761963) - 5.43014642410409e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) - 1.29213725293172e-5*std::sin(0.83847987651825*x_73 + 7.38327980041504) + 2.57973842118962e-7*std::sin(1.02143979072571*x_73 - 8.19176006317139) - 1.85740388388053e-5*std::sin(1.14959990978241*x_73 - 1.98639988899231) + 1.39262646371047e-5*std::sin(1.44831991195679*x_75 + 7.37551975250244) + 8.19796539625535e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) + 3.28828676820298e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) - 2.73001605296835e-5*std::sin(1.54287981987*x_76 + 0.981839835643768) + 3.93431906950646e-7*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 2.97139638521518e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 5.16216241003625e-7*std::sin(2.01543974876404*x_78 - 7.38951969146729) - 2.13000206207429e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 6.21286130600564e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 1.31834287593777e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) - 8.79158962157129e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 4.49267783467237e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) + 3.30617089603767e-7*std::sin(1.67911994457245*x_81 - 5.6167197227478) + 1.24469081149027e-5*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 3.86547707180712e-6*std::sin(1.28871989250183*x_84 - 8.22535991668701) - 1.06415969330798e-5*std::sin(1.31399989128113*x_84 - 8.18455982208252) - 4.98058581636368e-7*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 1.09610838899061e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) - 6.3380973799773e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 1.90520168089888e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) + 7.7230245159697e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) - 1.27068245275635e-5*std::sin(1.7351199388504*x_86 + 0.988639831542969) + 2.12608724371871e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 4.16553122498702e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) + 5.20328478236082e-6*std::sin(1.13935983181*x_87 + 4.41120004653931) - 7.39847931959421e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 1.93675826606847e-6*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 1.59870375413682e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 1.39833499702986e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 5.78773783581222e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 9.00649911541694e-6*std::sin(1.69847989082336*x_92 + 4.02615976333618) + 3.590413634327e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 3.58552589436417e-6*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 1.62811522804612e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) - 1.40616509778814e-5*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 7.20470642552352e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 3.69009131916006e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) - 1.02279571975855e-5*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0679747032682405);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.63036189847906e-5*x_1 - 4.00530919401527e-6*x_10 - 5.37097475751402e-5*x_100 + 1.18824959123348e-5*x_101 + 7.519187674374e-6*x_102 - 5.21226749019366e-6*x_103 - 3.58500328934146e-6*x_104 - 1.93894549296085e-5*x_105 + 1.73592717369351e-5*x_106 - 3.54738198858795e-6*x_107 + 1.17934855537641e-6*x_108 - 6.19009725238455e-6*x_109 + 3.24099753670802e-6*x_11 + 1.45230131667877e-5*x_110 + 7.38900728198284e-6*x_111 + 9.67662081115352e-6*x_112 - 1.5248047004116e-6*x_113 + 2.5961643297618e-6*x_114 - 4.72896539239867e-6*x_115 - 1.88350040875583e-5*x_116 + 1.79955284580643e-5*x_117 + 1.84901667236272e-6*x_118 + 3.73606909792704e-6*x_119 - 2.5013712192089e-5*x_12 + 5.79511451015567e-6*x_120 + 1.43521941112428e-5*x_13 - 2.70357253064551e-5*x_14 + 6.50367447693861e-6*x_15 - 1.5494258681626e-5*x_16 - 3.77995802234849e-7*x_17 - 1.09984009589183e-5*x_18 + 1.16482602425227e-5*x_19 - 2.74454689651442e-5*x_2 - 1.26602091950058e-5*x_20 - 9.38411034548553e-6*x_21 + 3.51616786376821e-5*x_22 - 1.19961611398512e-5*x_23 + 2.84120320558062e-6*x_24 - 2.53400636098224e-5*x_25 + 3.60161565502438e-6*x_26 + 2.65347725229977e-5*x_27 + 6.68511806595842e-6*x_28 + 1.3005391408825e-5*x_29 - 3.40370666228741e-5*x_3 + 8.22675261326916e-6*x_30 - 6.31016188255516e-6*x_31 - 5.19045473177218e-5*x_32 - 5.95477399090619e-5*x_33 - 5.61511430768335e-5*x_34 + 1.46019414965645e-5*x_35 - 9.87186988138738e-7*x_36 - 4.46023432667652e-6*x_37 - 1.56041203813852e-5*x_38 - 2.00396187916387e-5*x_39 - 2.27223734174416e-5*x_4 - 2.38775155940398e-5*x_40 + 4.31781576447331e-5*x_41 + 2.55667515949469e-6*x_42 - 1.89801294130568e-5*x_43 - 3.25159584864002e-6*x_44 - 8.18028154001992e-6*x_45 + 3.07370289785304e-5*x_46 + 7.9512581059572e-6*x_47 - 5.15199720457073e-6*x_48 - 7.00543319977396e-6*x_49 + 1.55946495857836e-6*x_5 + 3.04733071380624e-5*x_50 - 1.10319317332091e-5*x_51 + 1.50181773800755e-5*x_52 - 7.40307441787141e-6*x_53 - 3.4065511852578e-5*x_54 - 1.68719896596623e-5*x_55 - 1.12253490855256e-5*x_56 + 1.74897744531636e-5*x_57 + 2.43673656210021e-5*x_58 + 3.43736067097037e-6*x_59 - 2.89197814720309e-6*x_6 - 9.74830644265144e-7*x_60 - 8.77697444067535e-6*x_61 - 1.39459986790909e-5*x_62 - 3.2312035087659e-5*x_63 - 3.13213584322815e-6*x_64 - 4.99940054571919e-6*x_65 + 1.77502692977963e-6*x_66 + 1.98894688628024e-5*x_67 - 1.70344734706654e-6*x_68 - 4.1480290891105e-6*x_69 + 2.03242064004448e-6*x_7 + 3.56758094977404e-6*x_70 - 1.18159241548028e-5*x_71 + 1.22982653360338e-5*x_72 + 3.69187348759369e-7*x_73 + 4.39602395564716e-6*x_74 + 1.71475135687025e-5*x_75 - 3.09658176820266e-5*x_76 - 3.94357292292912e-6*x_77 - 9.15102809614627e-6*x_78 + 7.75223422769298e-6*x_79 - 1.49028929153289e-5*x_8 + 1.74854345308294e-6*x_80 - 8.51640065839821e-6*x_81 - 8.57524882685268e-6*x_82 - 8.21762667470936e-6*x_83 - 6.92223884137374e-7*x_84 + 1.33480964772236e-5*x_85 + 1.74661440239041e-5*x_86 - 4.61111727927027e-5*x_87 + 4.68666274962176e-6*x_88 - 1.77895285337995e-5*x_89 - 2.55448608095051e-5*x_9 + 4.99597312495135e-6*x_90 - 0.000106909254938445*x_91 - 1.16299618081326e-5*x_92 - 2.15504510987012e-5*x_93 - 3.71592215288294e-8*x_94 - 1.0954509471782e-5*x_95 + 2.4506265129323e-5*x_96 - 1.6457909591665e-5*x_97 - 9.21407168666813e-6*x_98 + 1.00701997429096e-6*x_99 + 2.86748241389799e-5*std::sin(0.689039826393127*x_103 + 4.35960006713867) + 5.46805011296257e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 9.9819320077112e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 2.56196134392629e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) - 1.40839306907507e-5*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 9.22491697629256e-7*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 1.61137451174188e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) + 5.12497264992223e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 5.01590005273946e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 1.58779894107692e-6*std::sin(1.34247982501984*x_118 - 8.56151962280273) + 7.15944962377684e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) + 6.23210320351662e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) + 9.90586350519529e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) - 6.66480488465943e-7*std::sin(1.42791986465454*x_12 - 5.5927996635437) + 7.93015774727794e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) + 3.28647152301004e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 1.07720176135455e-6*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 1.01315033116517e-6*std::sin(1.0862398147583*x_13 - 8.42704010009766) + 1.00842818570194e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) - 3.69042456007196e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) - 1.37788591487615e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 1.86786981559832e-5*std::sin(0.779839873313904*x_19 + 1.41111993789673) - 4.62161810978201e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) + 5.04266093979043e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 1.50456802241434e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) + 1.53104531402145e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) - 3.1885785850238e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 2.66609552722207e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) - 1.90771271720323e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) + 6.58494250109634e-7*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 8.29300661026851e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) - 5.46752602077987e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 6.52490871012549e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) - 1.84421720513428e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) + 1.11913651355008e-5*std::sin(1.57583975791931*x_29 + 0.990559816360474) - 5.42815452286221e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) + 1.16363058530131e-5*std::sin(1.67927992343903*x_29 + 0.961359798908234) - 5.45514517102759e-7*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000697384078570461*std::sin(0.565119862556458*x_31 - 4.73639965057373) + 4.68288070656964e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 6.06113533917769e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) + 6.16649006869326e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) - 1.20023122071406e-5*std::sin(1.52671980857849*x_39 - 2.19400000572205) + 1.42993618889179e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 6.61531951436892e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 1.78333654456757e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) - 9.46664734189572e-7*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 1.1747981757672e-5*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 6.54173622269784e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) - 7.25905591886516e-7*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 8.86156356831519e-7*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 3.77124311431542e-5*std::sin(2.02023983001709*x_44 + 1.80927991867065) - 1.10957686052082e-5*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 1.10289751654087e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 7.27821134996629e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) + 6.58621993595908e-7*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 1.80753025941877e-5*std::sin(1.8439998626709*x_53 + 9.98999977111816) - 8.28934937586452e-6*std::sin(1.146479845047*x_54 - 2.15255975723267) - 2.14448293474837e-5*std::sin(0.448479861021042*x_55 - 1.61047983169556) + 1.33550439975341e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) + 1.15535601138137e-5*std::sin(1.33343982696533*x_57 + 7.58480024337769) - 2.57180590447677e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 5.46035599482635e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) + 7.73829111740666e-7*std::sin(1.48991990089417*x_57 + 7.59232044219971) + 1.74905051527986e-5*std::sin(0.847199857234955*x_58 + 7.5874400138855) - 5.02532391009996e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 1.53496016757693e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 2.39731032906685e-5*std::sin(1.38559985160828*x_6 + 1.37687981128693) - 5.57275012307611e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) + 2.80986310007443e-6*std::sin(0.613759875297546*x_67 - 1.79879987239838) + 1.57972052405673e-6*std::sin(0.586479842662811*x_68 + 1.38839983940125) - 1.08991447761263e-5*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.53397076889801e-5*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 2.550964351404e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) - 8.75845766748173e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) - 6.78251218883772e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 1.1359292079672e-5*std::sin(1.02143979072571*x_73 - 8.19176006317139) + 9.97037286761217e-7*std::sin(1.14959990978241*x_73 - 1.98639988899231) + 7.30998656929316e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) - 4.40059227106178e-7*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 2.69924947859852e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) + 1.46544745700618e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 1.73238802345466e-5*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 5.07182876273469e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 2.03887655088785e-7*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 1.748450594718e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) + 7.14225133352964e-6*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 9.0209862554851e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) + 4.71924428428369e-7*std::sin(1.45807981491089*x_80 - 2.38295984268188) - 9.95553814590638e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 1.45579724536895e-5*std::sin(1.67911994457245*x_81 - 5.6167197227478) + 6.53346274253204e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 1.68765685070714e-5*std::sin(1.28871989250183*x_84 - 8.22535991668701) + 5.71231115916351e-7*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 2.19308781662667e-5*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 9.02245653921869e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) - 3.32690839430569e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) + 5.70665609984785e-6*std::sin(1.41647982597351*x_86 - 5.0099196434021) + 1.24567144244557e-5*std::sin(1.43367981910706*x_86 - 2.21943998336792) + 6.82090629844279e-7*std::sin(1.7351199388504*x_86 + 0.988639831542969) + 3.85780895555612e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) - 4.78865847492265e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) + 9.44141812195374e-6*std::sin(1.13935983181*x_87 + 4.41120004653931) - 1.1933245047825e-5*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 1.59421435490218e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 6.31432980448022e-7*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 5.5229421495671e-6*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 9.87899674809442e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) - 1.03537930671877e-5*std::sin(1.69847989082336*x_92 + 4.02615976333618) + 6.51484548133157e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 1.56543092265261e-5*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 0.000111406564730761*std::sin(1.03871977329254*x_94 - 5.01327991485596) - 7.38105173705586e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) + 2.15802779742608e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) + 5.80887751985154e-7*std::sin(1.16727983951569*x_96 + 4.21439981460571) - 5.36872102418984e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0807011086706953);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.60546397049271e-5*x_1 + 1.78489958910493e-5*x_10 - 3.41125786041664e-5*x_100 + 2.19264241533881e-5*x_101 + 9.46499894663877e-6*x_102 - 1.63297194423803e-5*x_103 + 5.96116928628259e-6*x_104 - 1.40174386040182e-5*x_105 + 2.60590823902926e-5*x_106 - 1.5324742027002e-5*x_107 + 2.14446420290654e-6*x_108 - 2.77791312363146e-5*x_109 + 1.92238886751474e-6*x_11 + 4.46006281912853e-5*x_110 - 6.80595317503171e-6*x_111 + 1.22648409915686e-5*x_112 - 5.65225891384767e-6*x_113 + 1.03385439574833e-5*x_114 + 8.36161971072255e-6*x_115 - 1.42497299670747e-5*x_116 - 9.92090490479377e-6*x_117 - 7.92682976598192e-7*x_118 + 6.79889994607403e-6*x_119 - 3.16926975463738e-5*x_12 + 1.31636113224669e-5*x_120 + 2.61643260558803e-5*x_13 + 1.51796912700047e-5*x_14 + 8.75529702964125e-6*x_15 - 1.71354972090263e-5*x_16 - 3.79066857995271e-6*x_17 - 1.31834754384616e-5*x_18 + 2.05665420594208e-5*x_19 - 2.22613375461007e-5*x_2 - 1.15291937053169e-5*x_20 - 8.87905938788704e-6*x_21 + 6.81648806202653e-5*x_22 + 1.16354154681108e-5*x_23 + 1.83073157746985e-5*x_24 - 2.74228013602678e-5*x_25 + 1.49083588425667e-5*x_26 + 2.54188086935695e-5*x_27 + 2.5722996320136e-6*x_28 + 1.88887254857467e-5*x_29 - 2.36471197893601e-5*x_3 + 1.11253821375161e-5*x_30 - 5.48453639794129e-5*x_31 - 4.71086427999174e-5*x_32 - 6.72754696083989e-5*x_33 - 7.1892843148873e-5*x_34 + 2.61516248027826e-5*x_35 - 1.15352261592149e-5*x_36 + 6.48280218390953e-6*x_37 + 1.56912218183866e-6*x_38 - 2.04641689150087e-5*x_39 - 8.55700997873234e-6*x_4 - 2.68661439910029e-5*x_40 + 1.70978139412137e-5*x_41 - 6.20685105965485e-6*x_42 - 9.41687340160235e-8*x_43 + 3.28902875625294e-5*x_44 + 6.39519171914062e-6*x_45 + 1.15745754287393e-5*x_46 + 1.87006418202765e-5*x_47 - 9.95961124769818e-6*x_48 - 1.37113419343282e-5*x_49 + 2.46192316379356e-6*x_5 + 1.08770839671587e-5*x_50 - 2.37396929960703e-5*x_51 + 3.92646086465153e-5*x_52 - 7.20153708620413e-6*x_53 + 2.78301871453873e-5*x_54 - 6.35951047069602e-6*x_55 - 4.02299227271308e-5*x_56 + 7.93476092530781e-6*x_57 + 5.13134081145752e-6*x_58 + 3.14038398918803e-5*x_59 + 1.49919753696907e-6*x_6 + 1.81599520179461e-5*x_60 + 2.48456029397274e-5*x_61 - 4.81870584526913e-5*x_62 - 8.45767388057788e-6*x_63 + 3.72621478218204e-6*x_64 + 1.61657581298792e-5*x_65 + 3.03332067900231e-6*x_66 - 3.28790177304274e-5*x_67 + 3.68847520958631e-6*x_68 - 2.32665228337764e-5*x_69 + 1.66450264814574e-5*x_7 - 4.65079683196859e-6*x_70 - 2.55929043232306e-6*x_71 - 3.54159083347437e-6*x_72 - 1.52744301421578e-5*x_73 + 4.12263090591053e-6*x_74 + 2.75585422171873e-5*x_75 - 3.66383889413575e-5*x_76 + 4.59772154363393e-5*x_77 - 6.45780353811972e-7*x_78 + 1.50384413151933e-5*x_79 + 2.60876216262222e-5*x_8 + 7.94265311053481e-6*x_80 - 5.31806756296906e-6*x_81 - 4.20524499558615e-5*x_82 - 7.8227772415037e-5*x_83 + 1.58138163606214e-5*x_84 + 1.22305072079011e-5*x_85 - 7.50340136012003e-6*x_86 - 3.77076511589248e-5*x_87 - 2.34485730651016e-5*x_88 + 1.6139958635649e-5*x_89 - 5.44355156597604e-5*x_9 + 2.96401403386709e-5*x_90 - 0.000159963038028791*x_91 - 5.70364147697717e-5*x_92 - 5.2248247195028e-5*x_93 + 8.62547070224824e-6*x_94 - 1.73108179117274e-5*x_95 + 2.50108087488147e-5*x_96 - 4.40217640972918e-6*x_97 + 1.25636913233267e-5*x_98 + 2.96961664185358e-6*x_99 - 1.54024390462678e-6*std::sin(0.689039826393127*x_103 + 4.35960006713867) - 9.37293658470656e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 0.000137045024036594*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 1.29489002936848e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) + 7.56506414633112e-7*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 4.66254225211953e-7*std::sin(0.84391987323761*x_110 - 8.43544006347656) + 4.54421419392794e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) - 8.78485797564333e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 6.8864839267769e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 2.4887946862461e-5*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 3.36531803817955e-5*std::sin(1.37247979640961*x_118 - 8.37928009033203) - 1.06826212103349e-5*std::sin(1.77047991752625*x_118 - 8.39016056060791) - 7.12315891890458e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 3.20524235276686e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) - 5.70245833250349e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 1.54481454295289e-5*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 1.68845938255622e-5*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 1.58806199912322e-5*std::sin(1.0862398147583*x_13 - 8.42704010009766) + 7.93701019632432e-7*std::sin(1.44215977191925*x_13 - 5.4029598236084) + 6.32585924737572e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 7.12338727382152e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 2.42050702191728e-6*std::sin(0.779839873313904*x_19 + 1.41111993789673) + 7.92204397670537e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) - 8.6437651869333e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 7.6045258658947e-7*std::sin(1.42887985706329*x_24 + 4.19280004501343) + 1.20503595999393e-6*std::sin(1.55111992359161*x_24 - 8.38472080230713) + 5.46563112176549e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 2.28040187597183e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 9.86248305837019e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 3.16683488268795e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 6.17367167255974e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) + 9.3720382237385e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 8.95824846657881e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 9.53422429780551e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) + 8.44605985298304e-7*std::sin(1.57583975791931*x_29 + 0.990559816360474) + 9.30455044553538e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) - 8.36749423980257e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 2.62349200693258e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000957460116304087*std::sin(0.565119862556458*x_31 - 4.73639965057373) - 3.3673897741144e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) - 1.70929210055803e-5*std::sin(1.55423986911774*x_36 - 9.61367988586426) - 3.31227793942601e-7*std::sin(1.66479980945587*x_36 + 0.970319807529449) + 8.63068395813571e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 7.39247650357481e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 5.65830701739269e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) + 5.02916186108351e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 4.55270627183596e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 1.52237977723798e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 8.98135147773108e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) - 5.71336676826587e-7*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 4.47889283592424e-7*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 2.80747597094116e-5*std::sin(2.02023983001709*x_44 + 1.80927991867065) - 8.37391369325962e-7*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 5.57436590903189e-7*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 9.43157897433465e-7*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 3.16744922750311e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 2.48161405685346e-5*std::sin(1.8439998626709*x_53 + 9.98999977111816) - 6.25592500317491e-7*std::sin(1.146479845047*x_54 - 2.15255975723267) - 2.77896026724833e-6*std::sin(0.448479861021042*x_55 - 1.61047983169556) + 1.05113206754534e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) + 8.71940635077324e-7*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 1.3295708485659e-5*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 7.49669120147533e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 3.72150405852711e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) - 9.39487678106461e-7*std::sin(0.847199857234955*x_58 + 7.5874400138855) - 3.79258347944446e-7*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 7.75813663693719e-7*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 2.05050078508883e-5*std::sin(1.38559985160828*x_6 + 1.37687981128693) + 2.99335555380374e-7*std::sin(2.05831980705261*x_64 + 0.966399788856506) + 2.21155183797668e-6*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 7.59720234405694e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) + 5.85438335234742e-7*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.98781895104618e-6*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 2.18192627874072e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) + 4.70453139342263e-7*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 3.18813761011243e-5*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 9.71598755697483e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) + 7.84735613635286e-7*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 3.43607832350596e-5*std::sin(1.44831991195679*x_75 + 7.37551975250244) - 3.46356302020368e-7*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 1.36427945913451e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) + 1.15340602071127e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 1.48177019850199e-5*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 6.96327017817304e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 3.19583606871522e-6*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 8.83717955897799e-7*std::sin(1.70567989349365*x_79 - 6.1908802986145) + 5.39021661054399e-7*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 6.71561110720445e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) + 3.71436365369263e-7*std::sin(1.45807981491089*x_80 - 2.38295984268188) + 7.15887921323722e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 1.24519273052193e-5*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 3.07107126589685e-5*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 2.18697535749563e-6*std::sin(1.28871989250183*x_84 - 8.22535991668701) + 4.49597428529815e-7*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 1.8758223477526e-5*std::sin(1.4935998916626*x_84 + 4.40592002868652) + 2.54441005308535e-5*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 1.56382200016397e-5*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 2.95022403515794e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) - 6.69101870370772e-7*std::sin(1.43367981910706*x_86 - 2.21943998336792) + 5.36851345554462e-7*std::sin(1.7351199388504*x_86 + 0.988639831542969) - 6.61277748911299e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) - 3.61397341655776e-7*std::sin(2.03999972343445*x_86 + 6.57639980316162) - 1.61837970571974e-5*std::sin(1.13935983181*x_87 + 4.41120004653931) + 6.40984155935752e-7*std::sin(1.17527985572815*x_87 - 8.20096015930176) - 4.49582108126992e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 9.89739321399034e-6*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 8.65693301506071e-5*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 0.000135631794100996*std::sin(1.08591985702515*x_89 + 4.57520008087158) - 7.81394895904765e-7*std::sin(1.69847989082336*x_92 + 4.02615976333618) - 1.11672776024723e-5*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 2.02858706156314e-6*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 8.29358500647844e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 3.46948269165233e-5*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 1.11565606286931e-5*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 2.79360920100137e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 2.52358137204528e-5*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0767642197019586);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.03216602894241e-5*x_1 + 1.33906002938881e-5*x_10 - 2.0542160515816e-5*x_100 + 1.6570343387537e-5*x_101 + 1.740141940934e-5*x_102 - 2.02801072054658e-5*x_103 + 1.69604828968633e-5*x_104 - 8.76205132095804e-6*x_105 + 7.0039981483361e-6*x_106 - 1.04490562215828e-5*x_107 + 1.4514728166558e-5*x_108 - 1.62921983065974e-5*x_109 + 8.14070411977107e-6*x_11 + 3.37552693269164e-5*x_110 + 6.46374030642326e-6*x_111 + 4.7755043217607e-6*x_112 - 5.19496153218023e-6*x_113 + 1.45331002144902e-5*x_114 + 7.22473339335962e-6*x_115 + 2.36760283798834e-5*x_116 - 3.36496890242086e-5*x_117 + 2.84474014479483e-6*x_118 - 2.2695659053423e-7*x_119 - 1.80335581237169e-5*x_12 + 1.3626669410021e-5*x_120 + 1.84038177012653e-5*x_13 + 2.38157302438102e-5*x_14 + 1.01164256233408e-5*x_15 - 4.38732478207515e-6*x_16 + 6.23195318132247e-6*x_17 + 3.26940270756392e-6*x_18 + 3.38400991241602e-5*x_19 + 1.35580089833751e-5*x_2 - 9.780498495775e-6*x_20 - 1.19164959104244e-6*x_21 + 7.53734968841188e-5*x_22 + 1.16953204994016e-5*x_23 + 7.72601329235498e-6*x_24 - 4.60883399381094e-5*x_25 + 4.95303977360167e-7*x_26 + 1.34853106116289e-5*x_27 + 1.40258890454856e-6*x_28 + 1.0384631523626e-5*x_29 - 1.68755004335047e-5*x_3 + 1.05815249849199e-5*x_30 - 4.09958207903958e-5*x_31 - 3.33467117875752e-5*x_32 - 3.24153358138202e-5*x_33 - 5.61775575871545e-5*x_34 + 1.30807715426157e-5*x_35 - 3.15302122192292e-6*x_36 + 2.07415436617045e-5*x_37 + 1.89792149463919e-5*x_38 + 4.45868961417458e-6*x_39 - 1.05808351719848e-5*x_4 - 1.3284462922252e-5*x_40 + 1.49145773496559e-5*x_41 - 6.26746450883419e-6*x_42 + 1.32182994365257e-5*x_43 + 4.83417801244198e-5*x_44 + 2.45863084210561e-5*x_45 - 1.78120373911036e-7*x_46 + 1.52423541062083e-5*x_47 + 2.03488232153405e-6*x_48 - 1.08803062852004e-5*x_49 + 1.64992337859524e-6*x_5 - 3.46924121707442e-5*x_50 - 1.47715398518399e-5*x_51 + 3.41568840588362e-5*x_52 - 5.55083512416569e-6*x_53 + 1.13047042159052e-5*x_54 - 1.75495603875029e-5*x_55 - 4.12254501119237e-5*x_56 - 1.69473455596674e-5*x_57 + 5.04696510335556e-6*x_58 + 2.42063422508067e-5*x_59 + 8.57174236986213e-6*x_6 + 1.85705838527589e-5*x_60 + 1.87613555525828e-5*x_61 - 4.07883946290173e-5*x_62 - 1.56801982555401e-7*x_63 - 1.09901444813854e-5*x_64 + 2.6283830175891e-5*x_65 + 1.90012035292113e-5*x_66 - 2.18472405824486e-5*x_67 + 5.9070363054459e-6*x_68 - 1.81974577778179e-5*x_69 + 2.14375746024112e-5*x_7 - 6.87807026258265e-6*x_70 - 4.54869479865812e-6*x_71 - 6.22528100876818e-8*x_72 - 4.68726939253805e-6*x_73 + 3.01932421740715e-7*x_74 + 1.93658060946916e-5*x_75 - 7.54454173739912e-6*x_76 + 3.72153812075248e-5*x_77 + 1.56366144149308e-5*x_78 + 1.01941716877891e-5*x_79 - 7.53966958060322e-5*x_8 + 3.18883766865335e-6*x_80 + 7.40410032104457e-6*x_81 - 3.96089059734991e-5*x_82 - 6.54559697342482e-5*x_83 + 1.95800012999715e-6*x_84 + 7.81076973842686e-6*x_85 - 4.13239515627197e-6*x_86 - 1.67474148652778e-5*x_87 - 3.53728605467591e-5*x_88 + 9.50047250919496e-6*x_89 + 5.87084246305369e-7*x_9 + 2.20439394002959e-5*x_90 - 0.00011881587344301*x_91 - 6.35790988254984e-5*x_92 - 3.19423773695122e-5*x_93 - 6.53071862306056e-6*x_94 - 1.40580822926341e-5*x_95 + 1.12416739462626e-5*x_96 - 5.95756982769257e-6*x_97 + 1.42355169793141e-5*x_98 + 1.65277072270674e-5*x_99 + 9.25884173785243e-6*std::sin(0.689039826393127*x_103 + 4.35960006713867) - 1.525822166447e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) + 6.93430925132995e-5*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 1.92873367617878e-5*std::sin(1.57671976089478*x_105 + 0.992959797382355) - 4.54757402104793e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 6.94483859965714e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) + 7.40904644570397e-5*std::sin(1.6522399187088*x_112 - 5.60143995285034) - 1.43008873549794e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) - 3.48447596242772e-5*std::sin(1.61815977096558*x_115 + 0.991919815540314) - 6.27375242083456e-7*std::sin(1.34247982501984*x_118 - 8.56151962280273) + 6.97883483706491e-6*std::sin(1.37247979640961*x_118 - 8.37928009033203) - 1.73902598093767e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) - 2.95166416461533e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) + 1.86438236890197e-5*std::sin(1.42791986465454*x_12 - 5.5927996635437) - 2.36296032446951e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) + 3.20356216763278e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) + 4.25626758098334e-7*std::sin(1.88767993450165*x_120 - 8.40639972686768) - 4.00318590621158e-7*std::sin(1.0862398147583*x_13 - 8.42704010009766) - 6.63731495353927e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) + 1.02978785509107e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) + 9.11838895130643e-7*std::sin(1.10735988616943*x_15 + 1.41959989070892) + 1.23169554586318e-5*std::sin(0.779839873313904*x_19 + 1.41111993789673) + 1.28963107708932e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) - 1.40712021302966e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 1.13269117811316e-5*std::sin(1.42887985706329*x_24 + 4.19280004501343) - 1.00770983014792e-5*std::sin(1.55111992359161*x_24 - 8.38472080230713) + 8.89751151503547e-7*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 1.06167885703128e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) + 1.26246058363811e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) - 1.84204202699695e-5*std::sin(1.52031981945038*x_27 - 8.2088794708252) - 2.52779302331169e-5*std::sin(1.6490398645401*x_28 + 1.36279988288879) + 1.52567592209059e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) + 4.53276327646326e-5*std::sin(1.7415999174118*x_28 - 5.58680009841919) + 1.22044137366896e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 1.73243115245185e-5*std::sin(1.57583975791931*x_29 + 0.990559816360474) + 1.51468957357367e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) - 3.4672865194265e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) + 1.52599763274004e-5*std::sin(1.70247995853424*x_29 + 4.00583982467651) + 0.000484463014176571*std::sin(0.565119862556458*x_31 - 4.73639965057373) - 1.39536459002295e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) - 2.78688988279459e-5*std::sin(1.55423986911774*x_36 - 9.61367988586426) + 1.99110395053675e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) + 3.57634595063439e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) - 9.46284028677084e-7*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 2.63431853405112e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) + 8.19972215691768e-5*std::sin(1.00759983062744*x_40 + 7.39007997512817) + 2.64815710321352e-5*std::sin(1.3796797990799*x_41 + 4.18576002120972) + 7.74675873177564e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) - 4.54445311526573e-5*std::sin(1.12143981456757*x_43 + 1.4015998840332) + 4.77779588888862e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 6.67129350656597e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) + 1.14951337694281e-5*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 1.71763274268325e-5*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 8.30299639988445e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) + 4.79933902606202e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) - 1.84239937084673e-5*std::sin(1.73727989196777*x_48 + 7.20183992385864) - 1.25566611656578e-5*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 1.28319708261064e-5*std::sin(1.146479845047*x_54 - 2.15255975723267) - 1.4140975226708e-5*std::sin(0.448479861021042*x_55 - 1.61047983169556) - 8.79007890564927e-6*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 1.7884991884862e-5*std::sin(1.33343982696533*x_57 + 7.58480024337769) + 1.70193528296524e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) + 3.79323332008562e-5*std::sin(1.48703980445862*x_57 + 0.973119854927063) - 2.16467455152828e-5*std::sin(1.48991990089417*x_57 + 7.59232044219971) + 5.6475261483719e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 7.77923656998859e-6*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 1.15557144287803e-5*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 9.54644596986703e-6*std::sin(1.38559985160828*x_6 + 1.37687981128693) - 1.79939068445826e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) - 1.84940748740977e-5*std::sin(0.613759875297546*x_67 - 1.79879987239838) - 4.41903873228606e-5*std::sin(0.586479842662811*x_68 + 1.38839983940125) - 3.51923541260416e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) + 1.01151854789772e-5*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 1.01583191197505e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) - 2.8280268788347e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) - 6.61140657922638e-6*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 4.52343890483039e-6*std::sin(1.02143979072571*x_73 - 8.19176006317139) - 6.56234185684732e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) + 7.12557411659635e-6*std::sin(1.44831991195679*x_75 + 7.37551975250244) + 2.89640028901182e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 2.03208896267046e-5*std::sin(1.48247992992401*x_76 + 1.18263983726501) - 9.64534357321913e-6*std::sin(1.54287981987*x_76 + 0.981839835643768) - 6.89862654168437e-6*std::sin(1.83695995807648*x_76 + 3.98943996429443) + 3.52332885892464e-5*std::sin(1.74199986457825*x_78 - 2.00735974311829) + 8.05606198996437e-8*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 1.31629446758133e-5*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 1.10562550314768e-5*std::sin(1.72735989093781*x_79 - 2.38631987571716) + 2.7496886463072e-5*std::sin(0.975919842720032*x_8 + 1.39087986946106) - 3.10613200836683e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) + 2.9664657875935e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 5.79720096204882e-6*std::sin(1.67911994457245*x_81 - 5.6167197227478) + 6.36864001987277e-6*std::sin(1.70943987369537*x_81 + 7.20424032211304) - 1.11286097596454e-5*std::sin(1.28871989250183*x_84 - 8.22535991668701) - 3.75975293169676e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 8.73320157793237e-6*std::sin(1.4935998916626*x_84 + 4.40592002868652) + 4.14849552765699e-5*std::sin(1.72663986682892*x_84 + 4.0079197883606) - 3.24297891904937e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) - 3.77647447934289e-6*std::sin(1.41647982597351*x_86 - 5.0099196434021) + 4.02216058486217e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) - 4.48941273292867e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) - 1.07649533137071e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 7.41287682062331e-6*std::sin(2.03999972343445*x_86 + 6.57639980316162) - 2.63456346514103e-6*std::sin(1.13935983181*x_87 + 4.41120004653931) - 3.85313705086087e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) - 7.33014461492878e-5*std::sin(1.25079989433289*x_87 - 1.80279994010925) - 2.49493439452335e-7*std::sin(1.26719987392426*x_87 + 1.2060798406601) + 2.18223924859623e-6*std::sin(0.512479841709137*x_89 + 4.61567974090576) + 6.86280155898168e-5*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 1.60277441031178e-5*std::sin(1.69847989082336*x_92 + 4.02615976333618) - 1.81792328911322e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) - 1.03226374701605e-5*std::sin(1.54863977432251*x_93 - 1.80103993415833) + 3.3957857543348e-5*std::sin(1.03871977329254*x_94 - 5.01327991485596) - 7.19484649010913e-6*std::sin(1.20311987400055*x_94 + 4.59887981414795) - 1.42811074648592e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) - 1.62494911982342e-5*std::sin(1.16727983951569*x_96 + 4.21439981460571) - 5.23328178602835e-6*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.080419412979455);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.05419513932959e-5*x_1 + 8.59368758776456e-6*x_10 + 1.73578031073361e-6*x_100 - 6.76147276911675e-6*x_101 - 7.36417832539367e-6*x_102 + 7.93697201511427e-6*x_103 - 2.56445946369732e-6*x_104 + 2.47473603768559e-6*x_105 + 1.13523476654046e-5*x_106 + 3.97825994384774e-6*x_107 - 6.34053310553314e-6*x_108 - 6.28568976909898e-6*x_109 + 8.07885032068307e-6*x_11 - 1.88632658049004e-5*x_110 - 1.10959413480115e-5*x_111 + 4.92703008021657e-6*x_112 - 1.01949911113419e-5*x_113 - 1.43272262835092e-5*x_114 + 1.00991407590687e-5*x_115 - 9.20231110260005e-6*x_116 + 1.7150907409314e-5*x_117 - 1.66337794927266e-6*x_118 + 2.18048004977792e-6*x_119 + 5.57598625583904e-6*x_12 + 3.80771729856211e-6*x_120 + 7.88912816794027e-7*x_13 + 8.347149559266e-6*x_14 + 1.30564705791717e-6*x_15 + 8.33074046400003e-7*x_16 - 4.61017687829412e-6*x_17 - 7.51070529718644e-6*x_18 - 1.96743648145789e-6*x_19 - 2.31468358214768e-5*x_2 + 9.41193263478664e-6*x_20 - 1.03306387909169e-5*x_21 - 1.00700227837318e-5*x_22 + 5.26042955359874e-7*x_23 + 1.56902336098145e-6*x_24 + 3.4120284655069e-6*x_25 - 2.54825674090469e-6*x_26 + 3.14278916589748e-6*x_27 - 6.51395424390446e-7*x_28 - 2.60224843713773e-6*x_29 - 1.88890953537557e-6*x_3 + 6.92588584071412e-7*x_30 - 2.07035361389833e-5*x_31 + 4.90323070320273e-6*x_32 - 3.85170565877741e-6*x_33 - 5.14434044420931e-6*x_34 + 6.56439353121948e-6*x_35 - 7.90939641802871e-6*x_36 - 8.04861187564864e-6*x_37 + 4.99982599198299e-6*x_38 - 4.86747180042894e-6*x_39 + 5.20626768827129e-6*x_4 + 4.23856829537356e-7*x_40 + 1.20770002471645e-5*x_41 + 8.29572172588934e-6*x_42 - 2.45034827902086e-5*x_43 - 8.49019783847811e-6*x_44 - 1.72782379709444e-5*x_45 + 8.86917507526232e-7*x_46 + 3.27981020810662e-6*x_47 + 2.84711314116227e-7*x_48 + 6.82299391326599e-6*x_49 + 1.13639828385509e-6*x_5 + 1.06606217056301e-5*x_50 - 3.13749880881391e-6*x_51 - 2.64397967662151e-6*x_52 - 4.25012229682187e-6*x_53 + 3.99548086046059e-5*x_54 + 4.62523974322739e-6*x_55 + 9.64116468331809e-7*x_56 + 1.91960591362639e-5*x_57 + 1.94833837548091e-6*x_58 + 2.5425866914465e-6*x_59 + 5.60452768510435e-7*x_6 - 5.65370897453949e-6*x_60 - 8.61382381011238e-6*x_61 + 6.07717343482412e-6*x_62 + 1.47101698340202e-6*x_63 + 7.09576978337253e-6*x_64 + 1.44820993246732e-5*x_65 - 7.36361472484807e-6*x_66 - 1.4434796957226e-5*x_67 - 1.32521478227845e-5*x_68 + 6.46226924044208e-6*x_69 - 1.43114253042972e-5*x_7 - 4.6627337379815e-6*x_70 + 8.27759942104914e-6*x_71 - 4.73237467764952e-6*x_72 - 6.39532298668708e-6*x_73 + 6.81130319989483e-6*x_74 - 5.86389800594195e-7*x_75 - 1.80543839012396e-7*x_76 + 1.17033587564339e-5*x_77 - 3.53057505501077e-6*x_78 - 2.94500229477043e-6*x_79 + 6.37174171252987e-5*x_8 - 1.23970462771019e-6*x_80 - 3.40359313701341e-7*x_81 + 1.4882264211048e-5*x_82 + 1.5876751673008e-5*x_83 - 3.79313793957978e-6*x_84 + 7.27448189991283e-6*x_85 + 3.16601443432437e-6*x_86 - 2.96405804958309e-6*x_87 - 4.8035792353945e-6*x_88 + 1.58977389572464e-5*x_89 + 3.97203164132924e-6*x_9 + 1.25683453422913e-5*x_90 + 2.51812883122824e-5*x_91 - 3.95408519356427e-6*x_92 - 6.10844621359675e-6*x_93 + 1.46718012678754e-5*x_94 + 1.50182575767309e-6*x_95 + 8.23016009948656e-7*x_96 + 7.92229645550505e-6*x_97 - 9.59695069375452e-6*x_98 + 1.93027655742502e-7*x_99 - 7.48102206275924e-6*std::sin(0.689039826393127*x_103 + 4.35960006713867) - 6.06282540324097e-6*std::sin(1.01855981349945*x_105 + 1.18175983428955) - 3.2554724818012e-6*std::sin(1.44247984886169*x_105 - 8.40312004089355) - 5.42462691021126e-6*std::sin(1.57671976089478*x_105 + 0.992959797382355) + 3.67437985729965e-6*std::sin(1.63823986053467*x_105 - 5.41559982299805) - 1.95325870129526e-6*std::sin(0.84391987323761*x_110 - 8.43544006347656) - 4.32046909271035e-6*std::sin(1.6522399187088*x_112 - 5.60143995285034) - 5.68243043332847e-6*std::sin(1.1794399023056*x_115 - 5.20423984527588) + 1.6358681446181e-6*std::sin(1.61815977096558*x_115 + 0.991919815540314) + 3.94793458303996e-5*std::sin(1.34247982501984*x_118 - 8.56151962280273) - 2.06228642019058e-5*std::sin(1.37247979640961*x_118 - 8.37928009033203) - 6.90998671141086e-6*std::sin(1.77047991752625*x_118 - 8.39016056060791) - 2.22953945349114e-6*std::sin(1.77847993373871*x_118 + 0.977119863033295) - 2.01838315310679e-6*std::sin(1.42791986465454*x_12 - 5.5927996635437) - 1.78486202244678e-6*std::sin(1.30591988563538*x_120 - 1.97535979747772) - 9.46671315311416e-6*std::sin(1.46455991268158*x_120 - 2.20839977264404) - 2.67837569136984e-5*std::sin(1.88767993450165*x_120 - 8.40639972686768) + 2.51911695287595e-5*std::sin(1.0862398147583*x_13 - 8.42704010009766) - 8.46851855503385e-6*std::sin(1.44215977191925*x_13 - 5.4029598236084) + 4.09184248668604e-6*std::sin(1.96007990837097*x_14 - 8.7958402633667) - 3.48572705515164e-6*std::sin(1.10735988616943*x_15 + 1.41959989070892) - 6.63376986410381e-6*std::sin(0.779839873313904*x_19 + 1.41111993789673) + 5.1243245949119e-6*std::sin(1.18447983264923*x_2 + 1.39767980575562) - 5.59116544546959e-6*std::sin(1.47983980178833*x_20 - 1.80695986747742) - 3.18573119847471e-6*std::sin(1.42887985706329*x_24 + 4.19280004501343) - 1.28573217550074e-5*std::sin(1.55111992359161*x_24 - 8.38472080230713) + 3.53540930425719e-6*std::sin(1.5759197473526*x_24 - 2.1976797580719) + 2.88033723880892e-5*std::sin(1.67151987552643*x_24 + 0.984959840774536) - 4.82606416105926e-6*std::sin(0.960159778594971*x_27 - 1.97439980506897) + 1.99419746540246e-6*std::sin(1.52031981945038*x_27 - 8.2088794708252) + 3.24727951861488e-6*std::sin(1.6490398645401*x_28 + 1.36279988288879) + 6.06224430406791e-6*std::sin(1.66247987747192*x_28 + 3.78631997108459) - 2.12801096377625e-6*std::sin(1.7415999174118*x_28 - 5.58680009841919) - 4.66543546030115e-6*std::sin(1.88831984996796*x_28 - 4.98519992828369) - 2.53844528633719e-7*std::sin(1.57583975791931*x_29 + 0.990559816360474) + 6.01859025686505e-6*std::sin(1.67303991317749*x_29 + 7.40367984771729) - 2.61901478640163e-6*std::sin(1.67927992343903*x_29 + 0.961359798908234) - 1.65204732944205e-6*std::sin(1.70247995853424*x_29 + 4.00583982467651) - 2.27442410475103e-5*std::sin(0.565119862556458*x_31 - 4.73639965057373) - 1.05398860844526e-6*std::sin(1.51455986499786*x_36 + 7.42104005813599) + 1.62513107343021e-6*std::sin(1.55423986911774*x_36 - 9.61367988586426) - 1.60878574285551e-6*std::sin(1.66479980945587*x_36 + 0.970319807529449) + 2.70139282505799e-6*std::sin(1.52671980857849*x_39 - 2.19400000572205) + 3.61740199747129e-6*std::sin(1.57751977443695*x_4 - 2.00047969818115) + 7.14691238528491e-5*std::sin(0.635759830474854*x_40 + 1.57735979557037) - 4.78153921795385e-6*std::sin(1.00759983062744*x_40 + 7.39007997512817) - 2.86689885779933e-6*std::sin(1.3796797990799*x_41 + 4.18576002120972) - 4.17231472436006e-6*std::sin(1.09759986400604*x_42 - 8.44288063049316) + 2.13349903002176e-6*std::sin(1.12143981456757*x_43 + 1.4015998840332) + 6.09596703191588e-6*std::sin(1.37295985221863*x_43 - 2.38127994537354) + 1.87632324403304e-6*std::sin(1.5007199048996*x_44 - 2.24311971664429) - 1.4766997182506e-6*std::sin(2.02023983001709*x_44 + 1.80927991867065) + 2.5167619118093e-7*std::sin(1.22071981430054*x_46 + 7.38047981262207) - 2.33524505028788e-6*std::sin(1.33975982666016*x_46 - 2.16207981109619) - 2.58486853391969e-6*std::sin(1.64639985561371*x_46 - 2.18959999084473) + 1.994584326391e-6*std::sin(1.73727989196777*x_48 + 7.20183992385864) + 5.89501613015901e-7*std::sin(1.8439998626709*x_53 + 9.98999977111816) + 1.88020492542207e-7*std::sin(1.146479845047*x_54 - 2.15255975723267) + 7.6161658311619e-6*std::sin(0.448479861021042*x_55 - 1.61047983169556) - 1.12152198341904e-5*std::sin(1.21447992324829*x_57 - 5.01223993301392) - 2.62059899361967e-7*std::sin(1.33343982696533*x_57 + 7.58480024337769) - 6.50606361894568e-6*std::sin(1.37671983242035*x_57 + 4.39111995697021) - 1.78082145503126e-6*std::sin(1.48703980445862*x_57 + 0.973119854927063) + 2.34347992109414e-6*std::sin(1.48991990089417*x_57 + 7.59232044219971) - 4.56312667525728e-6*std::sin(0.847199857234955*x_58 + 7.5874400138855) + 1.13985288098993e-7*std::sin(1.2119197845459*x_58 - 4.99671936035156) + 3.25008269577536e-6*std::sin(1.33967983722687*x_6 + 4.59503984451294) + 2.58995303929983e-5*std::sin(1.38559985160828*x_6 + 1.37687981128693) + 1.45388395126387e-6*std::sin(2.05831980705261*x_64 + 0.966399788856506) - 2.35965020984829e-5*std::sin(0.613759875297546*x_67 - 1.79879987239838) + 4.78405796951708e-6*std::sin(0.586479842662811*x_68 + 1.38839983940125) + 2.84349581849986e-6*std::sin(1.51575982570648*x_7 + 1.19143986701965) - 5.4479219987139e-6*std::sin(1.5759197473526*x_7 - 1.98911988735199) + 2.75595436892646e-5*std::sin(1.63535988330841*x_70 - 1.97663974761963) + 2.28500843557412e-6*std::sin(1.69815981388092*x_71 + 7.19112014770508) + 1.95370922582709e-5*std::sin(0.83847987651825*x_73 + 7.38327980041504) - 1.22721003990721e-5*std::sin(1.02143979072571*x_73 - 8.19176006317139) - 8.37286073784293e-6*std::sin(1.14959990978241*x_73 - 1.98639988899231) - 2.10564873360699e-5*std::sin(1.44831991195679*x_75 + 7.37551975250244) + 3.69550334163705e-6*std::sin(1.69783985614777*x_75 - 6.22496032714844) - 5.71531705335541e-6*std::sin(1.48247992992401*x_76 + 1.18263983726501) - 1.23064479524098e-5*std::sin(1.54287981987*x_76 + 0.981839835643768) - 1.87159900501472e-5*std::sin(1.83695995807648*x_76 + 3.98943996429443) - 1.65410853898178e-6*std::sin(1.74199986457825*x_78 - 2.00735974311829) - 5.06950284293547e-6*std::sin(2.01543974876404*x_78 - 7.38951969146729) + 3.70212148975929e-6*std::sin(1.70567989349365*x_79 - 6.1908802986145) - 1.62001811324356e-7*std::sin(1.72735989093781*x_79 - 2.38631987571716) - 3.53233336011952e-6*std::sin(0.975919842720032*x_8 + 1.39087986946106) - 3.96309904402119e-6*std::sin(1.45807981491089*x_80 - 2.38295984268188) + 2.24071985904037e-6*std::sin(1.65983986854553*x_80 - 8.40263938903809) - 1.57278198593307e-5*std::sin(1.67911994457245*x_81 - 5.6167197227478) - 1.88197029084437e-5*std::sin(1.70943987369537*x_81 + 7.20424032211304) + 5.99374060423111e-6*std::sin(1.28871989250183*x_84 - 8.22535991668701) - 4.79705086880635e-6*std::sin(1.31399989128113*x_84 - 8.18455982208252) + 2.36931964429262e-5*std::sin(1.4935998916626*x_84 + 4.40592002868652) - 2.41913002433421e-6*std::sin(1.72663986682892*x_84 + 4.0079197883606) + 9.58319195376257e-6*std::sin(1.21975982189178*x_85 + 4.38168001174927) + 1.44364967715587e-5*std::sin(1.41647982597351*x_86 - 5.0099196434021) - 3.2498527275069e-6*std::sin(1.43367981910706*x_86 - 2.21943998336792) - 5.72802033595507e-6*std::sin(1.7351199388504*x_86 + 0.988639831542969) - 4.27743375671515e-6*std::sin(1.89959990978241*x_86 - 2.79887986183167) + 1.08617200729034e-7*std::sin(2.03999972343445*x_86 + 6.57639980316162) - 1.04683878987692e-5*std::sin(1.13935983181*x_87 + 4.41120004653931) + 3.11328394030971e-6*std::sin(1.17527985572815*x_87 - 8.20096015930176) + 4.27445872906631e-6*std::sin(1.25079989433289*x_87 - 1.80279994010925) + 1.57000740830068e-5*std::sin(1.26719987392426*x_87 + 1.2060798406601) - 0.000137323522193663*std::sin(0.512479841709137*x_89 + 4.61567974090576) - 3.22190153533206e-6*std::sin(1.08591985702515*x_89 + 4.57520008087158) + 2.34846570448685e-7*std::sin(1.69847989082336*x_92 + 4.02615976333618) - 7.22348366719825e-6*std::sin(1.23031985759735*x_93 + 0.958479821681976) + 5.55965324366175e-6*std::sin(1.54863977432251*x_93 - 1.80103993415833) - 4.36232928406808e-6*std::sin(1.03871977329254*x_94 - 5.01327991485596) + 2.12611912422737e-5*std::sin(1.20311987400055*x_94 + 4.59887981414795) + 5.4593023980026e-6*std::sin(1.83951985836029*x_95 - 1.97279977798462) + 1.75917235799593e-6*std::sin(1.16727983951569*x_96 + 4.21439981460571) + 1.54646530722254e-5*std::sin(1.73151993751526*x_99 + 1.00799989700317) + 0.0538250179799083);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
