
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.23961950540497e-7*x_1 - 1.59524080285758e-6*x_10 + 3.63153568652951e-6*x_100 - 7.56226799954178e-6*x_101 - 2.17374821902767e-6*x_102 + 2.04470038814922e-6*x_103 + 2.64666997652273e-6*x_104 - 1.3539059513274e-6*x_105 + 5.51030067954357e-7*x_106 - 1.32844916584486e-6*x_107 - 1.16616067465857e-6*x_108 - 1.70818271805851e-6*x_109 + 1.20591498946554e-6*x_11 + 2.62842551563147e-6*x_110 + 3.32651993718969e-7*x_111 + 2.59454366868163e-7*x_112 + 3.28096181053044e-6*x_113 + 6.89238726610788e-7*x_114 + 8.25668651682461e-7*x_115 - 1.71584367579837e-6*x_116 - 9.21319243687164e-7*x_117 - 1.50709429481765e-6*x_118 - 2.95134970212999e-6*x_119 + 1.9036685312266e-7*x_12 + 2.56574402195498e-7*x_120 - 1.24827479943016e-6*x_13 + 1.68166564469891e-6*x_14 - 1.06681021910654e-6*x_15 - 1.03512382215045e-6*x_16 - 1.45096384524633e-6*x_17 - 7.17468167589769e-7*x_18 - 3.40368975075704e-7*x_19 - 4.78781364102437e-7*x_2 + 1.99170771090889e-6*x_20 + 2.23911036323653e-7*x_21 - 1.35613697740051e-6*x_22 - 4.30068419870851e-6*x_23 - 5.70793037720187e-7*x_24 - 2.95078604878005e-7*x_25 + 1.98926016658844e-6*x_26 - 7.32199890097997e-7*x_27 + 8.00025164684495e-7*x_28 + 6.47791232775379e-7*x_29 + 2.94368333970787e-6*x_3 - 7.37468227030674e-7*x_30 + 1.63053500075841e-5*x_31 + 1.63317309645412e-6*x_32 - 5.44839815329773e-6*x_33 - 9.37116799235455e-6*x_34 + 2.00576950327693e-6*x_35 - 5.03900232025376e-6*x_36 + 6.10369237406273e-7*x_37 + 4.88177366847783e-7*x_38 - 1.01106734472241e-6*x_39 - 1.05836294058277e-6*x_4 + 4.11042361481785e-7*x_40 - 1.97676082212654e-6*x_41 + 5.30941207296681e-7*x_42 + 8.49476707863184e-7*x_43 - 4.46767405615544e-6*x_44 - 3.02098933858085e-6*x_45 + 2.91496261983061e-7*x_46 + 2.48619159071782e-6*x_47 + 5.81501093025169e-7*x_48 + 8.9333458750934e-7*x_49 - 4.13222918104791e-9*x_5 + 3.4639020578037e-6*x_50 - 1.07223284510897e-6*x_51 - 2.11820924549905e-6*x_52 + 6.08910617164936e-7*x_53 - 4.17940520681255e-6*x_54 - 4.14849619785957e-7*x_55 - 1.54455228802199e-8*x_56 - 2.06909331962164e-6*x_57 - 2.67184189786319e-6*x_58 - 1.05570310802059e-6*x_59 + 6.34091147635844e-7*x_6 + 8.80413932214417e-7*x_60 + 1.01920793377407e-6*x_61 - 3.21577563001202e-6*x_62 + 1.24597004179047e-5*x_63 - 5.52445738196291e-6*x_64 - 2.52676265169351e-6*x_65 + 4.97840720813396e-8*x_66 - 9.82101150297278e-7*x_67 - 5.58580666046396e-8*x_68 - 5.49991489238685e-7*x_69 - 1.65362063689129e-6*x_7 + 1.35750793770307e-6*x_70 - 8.0067988654941e-7*x_71 + 2.01724475345398e-6*x_72 - 2.51111551436168e-7*x_73 - 1.19294149692597e-6*x_74 + 8.09923642522521e-7*x_75 + 7.0762835165953e-7*x_76 + 6.0961452939757e-7*x_77 + 7.37018873007943e-7*x_78 + 4.48434589509998e-6*x_79 - 1.93000902316971e-6*x_8 - 5.16769555686783e-6*x_80 - 4.21601536551363e-7*x_81 + 4.81392239033645e-7*x_82 - 1.58086916276485e-6*x_83 + 1.86513292749566e-7*x_84 + 9.51556347818993e-7*x_85 + 1.42435592510975e-6*x_86 - 1.86577023453377e-7*x_87 - 1.60204523447743e-6*x_88 - 1.7578809591928e-7*x_89 + 1.79135973817576e-6*x_9 - 7.44407785858922e-7*x_90 + 2.48872102155264e-5*x_91 - 2.33283303797833e-6*x_92 - 3.87780109910383e-6*x_93 + 5.49206318339526e-7*x_94 - 2.14644055238094e-6*x_95 - 2.4803727176317e-6*x_96 + 2.80783285250296e-6*x_97 + 4.20574878592304e-7*x_98 - 6.59422289499937e-7*x_99 - 5.19644911224609e-11*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) - 1.01329709027885e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) - 8.35947953758406e-6*std::sin(0.272319942712784*x_33 - 7.58688020706177) - 0.000193422818354019*std::sin(0.331999838352203*x_34 - 1.19063985347748) + 2.78693621483076e-6*std::sin(0.411919862031937*x_86 - 7.59344005584717) + 0.00020116106394043*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0672019438382665);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.59020356510173e-8*x_1 + 1.87100683391887e-7*x_10 - 1.32892992612979e-6*x_100 + 1.04933986126613e-5*x_101 + 4.4594845634485e-7*x_102 - 3.47222526428763e-6*x_103 + 1.00659547118416e-6*x_104 - 1.02681816546215e-6*x_105 + 6.20863306375307e-7*x_106 - 6.14340605095788e-9*x_107 - 3.32762620013113e-7*x_108 + 5.00568626268256e-7*x_109 + 1.76778094626116e-7*x_11 + 9.53240612793128e-8*x_110 - 1.48520684234405e-6*x_111 - 3.13613192557872e-7*x_112 - 6.89453165596348e-7*x_113 - 4.22482553041616e-7*x_114 - 3.22859718608275e-7*x_115 + 8.6947084473814e-7*x_116 - 5.53700421014663e-8*x_117 + 1.48888269300481e-6*x_118 - 2.81219852990712e-7*x_119 - 9.73962280954605e-7*x_12 + 6.51331086577388e-7*x_120 + 2.69227694100698e-6*x_13 - 7.02253531343987e-7*x_14 + 8.42105213820144e-7*x_15 + 3.01513930905353e-6*x_16 - 4.36076934939474e-7*x_17 + 2.19606188523827e-7*x_18 + 1.39019891046712e-7*x_19 + 1.02751713774283e-6*x_2 - 1.34116073635593e-6*x_20 - 3.66765451226503e-7*x_21 + 1.36381943003345e-6*x_22 + 3.70703214409361e-7*x_23 + 3.73028093319574e-7*x_24 - 7.5792640225806e-8*x_25 - 1.8651471985858e-7*x_26 + 4.49864471073211e-8*x_27 - 1.36239025133958e-6*x_28 - 1.60884600844641e-7*x_29 + 9.79088894425064e-7*x_3 - 5.1776532949549e-8*x_30 - 1.88309435198467e-5*x_31 - 1.69129657703708e-6*x_32 + 5.75995407976608e-6*x_33 - 5.45183197563607e-7*x_34 - 4.67119083709371e-6*x_35 + 6.75449349153858e-6*x_36 + 1.86404141258754e-7*x_37 + 4.16459635650807e-7*x_38 + 1.90772106468222e-6*x_39 + 1.50432635848463e-7*x_4 + 1.65078084626816e-6*x_40 + 7.03038136603067e-7*x_41 - 2.58375548571449e-7*x_42 + 1.76177497470441e-6*x_43 + 1.8471453491544e-6*x_44 + 6.1471038008739e-7*x_45 + 1.54833155214542e-7*x_46 + 8.24573838490945e-7*x_47 - 9.97788088533099e-7*x_48 - 1.04278582195517e-6*x_49 - 2.85197304954639e-7*x_5 - 1.3715718745126e-6*x_50 - 1.87831260310387e-7*x_51 + 2.71452810411116e-6*x_52 - 1.73521683352328e-7*x_53 + 2.04691592408666e-6*x_54 - 6.98153604587199e-7*x_55 - 4.4426511432722e-7*x_56 + 3.12228250172733e-6*x_57 + 1.94346871941637e-6*x_58 + 1.71323903882541e-6*x_59 + 2.41435483629912e-7*x_6 + 3.62431151571453e-7*x_60 + 3.08678447697747e-7*x_61 + 6.73284408957377e-6*x_62 - 2.80307614133268e-6*x_63 + 9.11181083495017e-7*x_64 + 1.09695519749127e-6*x_65 - 3.89495748772836e-7*x_66 + 7.13429868880188e-7*x_67 - 3.25087221251214e-7*x_68 + 8.88239923961963e-7*x_69 + 6.99273691723114e-7*x_7 - 3.21936928101907e-7*x_70 + 2.11247589317229e-7*x_71 + 8.52234044984365e-8*x_72 - 1.17631011089399e-8*x_73 + 4.79935984528954e-7*x_74 - 2.46015941775126e-7*x_75 + 6.273942083341e-7*x_76 + 3.39852304921441e-7*x_77 - 2.36222024371884e-6*x_78 - 7.60422556504537e-7*x_79 + 4.04622161732876e-6*x_8 + 7.64899406871971e-7*x_80 - 7.03331532248447e-7*x_81 - 4.41898910916668e-7*x_82 + 8.7605785953462e-7*x_83 - 9.66717748716238e-9*x_84 - 4.35812297512535e-7*x_85 + 2.10456419920967e-7*x_86 + 5.69025008274651e-7*x_87 + 2.92915940507122e-6*x_88 + 1.12675865020514e-7*x_89 + 2.1387283802167e-7*x_9 + 3.70725617313396e-7*x_90 - 2.83138021546363e-5*x_91 + 2.37133231692227e-6*x_92 + 6.59833938045061e-7*x_93 - 4.00313763263303e-7*x_94 + 6.28213887093222e-7*x_95 + 1.06560109539351e-6*x_96 - 1.9645086466501e-6*x_97 - 1.6865075839198e-7*x_98 - 6.87548184056617e-8*x_99 + 1.28704754640189e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) + 2.50971674243118e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) - 3.61876960149402e-5*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 0.000318311303381443*std::sin(0.331999838352203*x_34 - 1.19063985347748) + 1.20644832135651e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 0.000331045948959753*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0630469942965507);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.48146987354303e-7*x_1 + 6.98872640051847e-7*x_10 - 7.33112016907919e-7*x_100 - 6.53585477375321e-7*x_101 + 2.14703061758196e-6*x_102 - 1.43429208141764e-6*x_103 + 2.48301755712812e-7*x_104 + 1.24620072871674e-6*x_105 - 3.29423741938416e-7*x_106 + 3.36568804749206e-7*x_107 + 6.90473686686158e-7*x_108 + 1.59585789714758e-6*x_109 - 9.22530846970199e-7*x_11 - 1.23131088500595e-6*x_110 + 8.17972903830618e-7*x_111 - 2.45939844476158e-6*x_112 - 1.3854017950109e-6*x_113 + 1.29342667922941e-7*x_114 + 1.72801963992829e-7*x_115 - 1.00457674334264e-6*x_116 - 4.42777980309533e-8*x_117 + 2.8936526536392e-7*x_118 + 3.9154336372739e-6*x_119 - 2.69033102706836e-6*x_12 - 9.44508568217945e-7*x_120 - 3.90851527796467e-7*x_13 - 6.55143837860625e-7*x_14 - 1.11381282735573e-6*x_15 - 3.67086296365936e-7*x_16 - 1.98570748769267e-6*x_17 - 3.14982905924638e-7*x_18 - 1.21881662148936e-6*x_19 - 5.33467357696764e-7*x_2 - 7.19206380794632e-7*x_20 - 1.08082274943323e-7*x_21 + 5.32745347090198e-7*x_22 + 1.43995708086854e-6*x_23 - 8.02140389876666e-7*x_24 - 1.92560280902284e-6*x_25 - 1.82800699058066e-7*x_26 + 1.09665564588442e-7*x_27 + 1.04080557595843e-6*x_28 + 1.02061144880447e-6*x_29 + 2.4254830816112e-7*x_3 + 7.0362180697286e-7*x_30 - 7.94309091159174e-6*x_31 - 2.92671421512026e-6*x_32 + 4.59783741522373e-6*x_33 + 5.98989428734395e-6*x_34 + 4.91073419861705e-7*x_35 - 1.36547335776451e-6*x_36 - 9.99764761936304e-7*x_37 - 8.87601260855795e-8*x_38 + 9.4126796586933e-7*x_39 - 3.46089416110407e-7*x_4 - 3.95704722690447e-7*x_40 - 1.06059403360142e-7*x_41 + 3.2891866771654e-7*x_42 - 3.83044376815872e-7*x_43 - 4.27138667983312e-7*x_44 - 1.73506335287891e-6*x_45 - 1.26247995908408e-8*x_46 + 9.08218133947616e-7*x_47 + 2.03167227175403e-7*x_48 - 1.37529966152049e-7*x_49 + 6.02581565356784e-7*x_5 + 2.85710283654998e-6*x_50 + 1.56678218884676e-6*x_51 + 2.92087748250205e-6*x_52 + 6.29014015573206e-8*x_53 + 1.56868692557963e-6*x_54 - 4.88819498410375e-6*x_55 + 8.95641346887634e-7*x_56 + 1.44585476907878e-7*x_57 + 1.09554632845007e-6*x_58 + 1.25192276864343e-6*x_59 + 1.41760145349605e-7*x_6 - 1.14488371458378e-6*x_60 - 1.80146421769615e-6*x_61 + 5.97942937678966e-9*x_62 - 9.95026723805369e-6*x_63 + 2.7920379268978e-8*x_64 + 1.63646513052109e-6*x_65 - 4.06549029445592e-7*x_66 + 8.46188280457604e-7*x_67 - 1.07785545466213e-6*x_68 + 2.61480662570082e-7*x_69 + 4.25880972574379e-7*x_7 - 9.9289262909263e-7*x_70 - 8.78356454304271e-7*x_71 + 5.22082609068248e-7*x_72 + 7.45108650112379e-7*x_73 - 2.28665903918724e-7*x_74 - 1.39532763634899e-6*x_75 + 2.58974618059968e-6*x_76 - 7.83279825715445e-7*x_77 + 8.25339515993591e-7*x_78 - 1.16808742548666e-6*x_79 + 3.82244662510395e-6*x_8 + 1.48991051596762e-6*x_80 - 1.52642997867138e-7*x_81 + 8.50754038019065e-7*x_82 - 9.40636727727472e-7*x_83 + 3.92962359985672e-7*x_84 - 4.31177273660766e-7*x_85 + 3.7961711281327e-7*x_86 + 2.36068552969438e-7*x_87 + 8.20323733917223e-7*x_88 - 1.55067834412057e-7*x_89 - 2.23000174112193e-6*x_9 - 4.21386582556328e-7*x_90 - 1.91751838202505e-5*x_91 + 5.36765548065196e-6*x_92 + 1.34661809845953e-5*x_93 + 1.0781753515952e-6*x_94 + 4.38363403124812e-7*x_95 + 7.44575303415142e-8*x_96 + 9.59853073833321e-7*x_97 - 4.86029387958293e-7*x_98 + 9.27344449074089e-7*x_99 - 1.1529640997356e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) - 2.24825672728098e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) - 0.000132194708316762*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 1.58148135337209e-6*std::sin(0.331999838352203*x_34 - 1.19063985347748) + 4.40719088264495e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 1.64475150529556e-6*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0605584283707175);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.43978374517892e-7*x_1 - 1.07404499275277e-6*x_10 + 9.85737570350814e-7*x_100 + 1.31744937908447e-6*x_101 - 2.19372821635129e-6*x_102 + 3.51733213380437e-7*x_103 + 1.73535198080325e-6*x_104 - 1.87754951586481e-6*x_105 + 3.34833915327332e-7*x_106 - 1.29036114889152e-6*x_107 - 1.1810099183171e-6*x_108 - 1.62106872321928e-6*x_109 + 1.4000370882265e-6*x_11 + 2.17850110030735e-6*x_110 - 1.03324729570351e-6*x_111 + 2.25030897831665e-6*x_112 + 2.20042964934424e-6*x_113 - 4.78939750542425e-8*x_114 + 1.53442108552415e-7*x_115 + 5.44985043092753e-7*x_116 - 5.5704918598386e-8*x_117 + 2.76359635600098e-7*x_118 - 3.76899300744426e-6*x_119 + 2.05766562551209e-6*x_12 + 1.89755560663063e-6*x_120 + 7.47761710793893e-7*x_13 + 4.29663444738702e-7*x_14 + 7.96041222924908e-7*x_15 + 1.17117604286505e-6*x_16 + 1.36128991924132e-6*x_17 + 3.81731628974307e-7*x_18 + 9.43871795220663e-7*x_19 + 7.34993608835118e-7*x_2 - 1.02703652121428e-7*x_20 + 2.59164614536315e-7*x_21 - 3.35017093342009e-7*x_22 - 2.76764697267829e-6*x_23 + 3.75128075924531e-7*x_24 + 1.05070179085343e-6*x_25 + 7.49074136688184e-7*x_26 - 1.0246767774987e-7*x_27 - 4.73640502840687e-7*x_28 - 7.37884679308822e-7*x_29 + 1.12595782747893e-6*x_3 - 7.02959925511784e-7*x_30 + 9.19559794120275e-7*x_31 + 8.91984219013103e-7*x_32 - 1.24644845346352e-5*x_33 - 8.39410021026556e-6*x_34 - 1.34347953395041e-6*x_35 + 1.92167217447412e-6*x_36 - 2.60158373237449e-6*x_37 - 7.64675501348419e-8*x_38 - 2.69601329685409e-7*x_39 + 1.37117873872772e-7*x_4 + 8.21282102218829e-7*x_40 - 5.53100259614496e-7*x_41 - 5.38904395318738e-8*x_42 + 1.24574358699303e-6*x_43 - 1.43534223406928e-7*x_44 + 6.09285336521181e-7*x_45 + 2.94541159637918e-7*x_46 - 5.69912075874481e-8*x_47 - 3.59551396498075e-7*x_48 - 3.53165166780831e-8*x_49 + 4.0454849468717e-8*x_5 - 5.22901052934173e-7*x_50 - 2.07748449544405e-6*x_51 - 1.57812737550086e-6*x_52 + 1.09718776891084e-7*x_53 - 1.75028495131803e-6*x_54 + 3.02919275809289e-6*x_55 - 1.10274364829852e-6*x_56 + 7.0524104835083e-7*x_57 - 1.25100647626236e-6*x_58 - 8.04436855948679e-7*x_59 + 2.60679819467257e-7*x_6 + 1.7205131228638e-6*x_60 + 1.50964298778341e-6*x_61 + 1.59275441645476e-6*x_62 + 1.15024642494502e-5*x_63 - 2.55005570217052e-6*x_64 - 1.16550601126213e-6*x_65 + 2.66498745630144e-7*x_66 - 6.97366203677745e-7*x_67 + 8.38306886482075e-7*x_68 - 1.67663065828323e-7*x_69 - 3.19352251877422e-7*x_7 + 1.51569150761035e-6*x_70 + 2.31632616196357e-7*x_71 + 4.92227741498298e-7*x_72 - 1.97931149033058e-7*x_73 - 1.57427484864792e-7*x_74 + 1.15817461972691e-6*x_75 - 2.78121579017607e-6*x_76 + 8.48195566971124e-7*x_77 - 1.71106786680764e-6*x_78 + 1.55202049834883e-6*x_79 - 1.81849149547466e-6*x_8 - 3.05086217521373e-6*x_80 - 2.0463627495637e-7*x_81 - 3.79018616411132e-7*x_82 + 1.50935755866826e-7*x_83 + 1.51724516339303e-7*x_84 + 5.4551642432909e-7*x_85 - 3.25990541428892e-8*x_86 + 1.87188336101543e-7*x_87 + 1.46079390745772e-7*x_88 - 1.12049291913477e-7*x_89 + 2.39091323587673e-6*x_9 + 1.82281691219707e-7*x_90 + 1.43670090237147e-5*x_91 - 3.05147430259084e-6*x_92 - 1.0118778804042e-5*x_93 - 1.37916673023165e-6*x_94 - 1.45219382933494e-6*x_95 - 7.33814550385626e-7*x_96 + 2.75783878319644e-6*x_97 + 5.07661793192259e-7*x_98 - 6.50773627808605e-7*x_99 - 1.91906519998819e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) - 3.74213841259559e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) + 7.22520153400587e-5*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 6.60393897899813e-5*std::sin(0.331999838352203*x_34 - 1.19063985347748) - 2.40878343251394e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 6.8681420450688e-5*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0744456583210964);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.02004497006069e-7*x_1 - 7.22043102674718e-7*x_10 + 1.21482039578301e-6*x_100 + 7.86898116638871e-6*x_101 + 3.96191258824754e-6*x_102 + 2.23235509645866e-6*x_103 - 3.16333398883718e-6*x_104 - 1.27793070083487e-6*x_105 + 7.90442139680128e-7*x_106 + 4.0445630476111e-6*x_107 - 7.7153913426854e-7*x_108 + 1.88696150252311e-6*x_109 + 1.35889219716639e-6*x_11 - 6.48649944918875e-7*x_110 - 2.36011856264054e-6*x_111 + 2.54525874559932e-6*x_112 + 3.47716851681748e-7*x_113 - 4.45632594461315e-7*x_114 - 3.88751530576517e-7*x_115 + 3.17011229164159e-6*x_116 - 1.83475362157293e-6*x_117 + 7.57085533183348e-7*x_118 + 5.27939837008549e-6*x_119 + 2.66858380568693e-6*x_12 - 2.82189265072559e-7*x_120 + 1.4955078405601e-6*x_13 + 5.1639172054857e-7*x_14 + 7.53427902340931e-7*x_15 + 1.61812846535464e-6*x_16 + 1.73864669344217e-6*x_17 - 2.06088057917112e-6*x_18 - 1.38906354361118e-6*x_19 - 5.63566145513232e-7*x_2 + 6.1513020174314e-6*x_20 + 1.00841628816837e-6*x_21 - 1.31687743151571e-8*x_22 + 5.13790106185737e-7*x_23 + 1.34064858029185e-6*x_24 + 2.16707393576662e-6*x_25 - 1.58176359801605e-6*x_26 + 5.69621783119554e-7*x_27 + 4.51568488258394e-7*x_28 + 3.28809724223397e-7*x_29 - 5.12633216316869e-7*x_3 + 2.39593693703383e-6*x_30 - 1.44885361150675e-5*x_31 + 5.15379919921157e-7*x_32 + 2.5214913117004e-5*x_33 + 5.43599861208104e-6*x_34 - 3.95706226904348e-6*x_35 + 3.43536018210267e-6*x_36 + 1.09337356763435e-5*x_37 + 2.03342526839597e-6*x_38 + 2.51524450270547e-6*x_39 - 2.60767164501219e-7*x_4 + 1.62268218673761e-6*x_40 + 1.5709166153814e-6*x_41 - 6.12673418040758e-6*x_42 + 2.16968123236214e-6*x_43 - 1.85731599198162e-6*x_44 - 2.08768812166964e-6*x_45 - 7.85302487668275e-7*x_46 + 4.10715067077794e-7*x_47 + 1.53564551082756e-6*x_48 + 1.18693265818232e-7*x_49 - 7.13636942515525e-7*x_5 + 3.75221794550038e-6*x_50 - 7.61327779363775e-7*x_51 - 3.06479398078496e-6*x_52 - 6.00068438775842e-7*x_53 + 5.29553175255922e-7*x_54 + 7.11426376571311e-6*x_55 + 5.73400542821115e-7*x_56 + 4.95127102270475e-7*x_57 + 3.05555678345646e-6*x_58 + 5.06495946010641e-7*x_59 + 8.07834661162246e-7*x_6 - 3.95619199798089e-7*x_60 + 3.85068844285892e-6*x_61 + 2.22704399122148e-6*x_62 + 8.98949963839338e-6*x_63 + 2.20710034678348e-6*x_64 + 2.08090738266735e-6*x_65 + 1.43001300975952e-6*x_66 + 6.61781754833088e-7*x_67 - 1.56946732809982e-6*x_68 + 2.8063014344957e-7*x_69 + 5.91305618045061e-7*x_7 - 7.48450152327788e-7*x_70 + 1.61534783379668e-6*x_71 + 1.77649616497836e-6*x_72 - 1.30973291998907e-6*x_73 + 1.29100298718218e-6*x_74 + 1.42795869450183e-6*x_75 + 5.9377814441127e-6*x_76 - 1.48779860757117e-6*x_77 - 9.96652706207934e-7*x_78 + 5.80554706023001e-7*x_79 - 7.67693178136947e-7*x_8 + 7.93734982390937e-7*x_80 - 6.15590653950604e-7*x_81 + 1.99379782168466e-6*x_82 + 2.82957627597957e-6*x_83 + 3.34475824346903e-7*x_84 - 1.10006831692674e-7*x_85 - 7.81947360597171e-7*x_86 + 3.95870209638122e-7*x_87 + 1.80029977195616e-6*x_88 - 7.40687642419304e-8*x_89 + 3.55265763787112e-6*x_9 + 2.09018729804786e-6*x_90 + 3.83416340815661e-6*x_91 - 6.49531532603922e-6*x_92 - 2.27838735899562e-5*x_93 + 1.34309059319321e-6*x_94 + 1.85636146069915e-6*x_95 + 2.8711390150323e-6*x_96 - 1.35375402163654e-5*x_97 + 5.12195673622839e-7*x_98 + 5.29667785383179e-7*x_99 + 1.0524850043547e-9*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) + 0.000212702419958077*std::pow(-0.00567634143285575*x_1 + 0.0108389540849391*x_10 - 0.0074666594716985*x_100 - 0.00140880209463711*x_101 + 0.00203936661547405*x_102 - 0.00291396442175469*x_103 + 0.00726289038177202*x_104 + 0.00232211560453027*x_105 + 0.00093068893264811*x_106 + 0.00136994943818462*x_107 + 0.00159108243489529*x_108 - 0.00314988302056077*x_109 - 0.000612608558444288*x_11 + 0.0019904671353288*x_110 + 0.00415224823480664*x_111 - 0.00901071368456248*x_112 - 0.00643539298527569*x_113 - 0.00402197676122908*x_114 - 0.000532579686019462*x_115 + 0.0165239454814692*x_116 + 0.00239273535210405*x_117 + 0.00204827153576972*x_118 + 0.0153087260196527*x_119 - 0.000521149790277762*x_12 - 0.00747105545390203*x_120 - 0.0025043655823891*x_13 - 0.00243673007149298*x_14 + 0.000157225907766424*x_15 - 0.000699637406376694*x_16 + 0.00451210082426243*x_17 + 0.0043676338466539*x_18 - 0.000654915362973841*x_19 - 0.00389690748133525*x_2 - 0.0131910397773916*x_20 - 0.00179035111568478*x_21 + 0.0104872656193543*x_22 + 0.00393354812774464*x_23 + 0.00214541201925347*x_24 - 0.000176956634409301*x_25 - 0.00101419100246858*x_26 + 0.000842892052582284*x_27 - 0.00158636426287632*x_28 - 1.52088841737493e-5*x_29 - 0.011832507791068*x_3 + 0.00130784310329373*x_30 - 0.00498686526014508*x_31 + 0.00284846502610313*x_32 + 0.0359356223539789*x_33 + 0.0378988911106021*x_34 + 0.0113850627892258*x_35 - 0.000352728219844087*x_36 + 0.00101778806831694*x_37 - 0.00531731314353315*x_38 + 0.00598688478930853*x_39 + 0.00613493724089739*x_4 + 0.000577872836745076*x_40 + 0.003210212615204*x_41 + 0.00140800572142984*x_42 - 0.0203348527348407*x_43 + 0.00194051186554134*x_44 + 0.00180621853237625*x_45 - 0.00135522097040798*x_46 - 0.00689616689877881*x_47 + 0.000475839762031777*x_48 + 0.00536081746801274*x_49 + 0.00302170236102607*x_5 + 0.0115166154888127*x_50 - 0.000308693924158674*x_51 + 0.0197988200873572*x_52 + 0.000647849760909772*x_53 + 0.00372106912753033*x_54 + 0.000652506020446982*x_55 + 0.00790752810932105*x_56 - 0.00140843323491888*x_57 - 0.00221208357956054*x_58 + 0.00147967801806762*x_59 - 0.00585447374821003*x_6 - 0.0024231142509612*x_60 + 0.00451604034260814*x_61 + 0.00434964296710527*x_62 + 0.00406793418395071*x_63 - 0.000160382458780999*x_64 - 0.00255134582403116*x_65 + 0.000132626672320446*x_66 - 2.65885234897848e-5*x_67 + 0.00492102167754416*x_68 + 0.000600262251582015*x_69 + 0.000496234866366255*x_7 + 0.00101063772427652*x_70 + 0.000916752265761479*x_71 - 0.00259984159517904*x_72 + 0.0013707517887377*x_73 - 0.00049249977410514*x_74 - 0.000670717465964463*x_75 + 0.00771880161000736*x_76 + 0.000776947961076378*x_77 + 0.00301093822069484*x_78 + 0.000780887291493768*x_79 - 0.00385776037150006*x_8 + 0.00756359449625696*x_80 + 0.00260982790223421*x_81 - 0.00395812078263485*x_82 + 0.0012156392780021*x_83 + 0.000359450395999131*x_84 + 0.00144627507127076*x_85 - 0.00691040500832851*x_86 + 0.000855981920028122*x_87 + 0.0101256807536784*x_88 - 0.00113235009848722*x_89 - 0.00644387336557473*x_9 + 0.0019274364893314*x_90 - 0.00310024709251781*x_91 - 0.00172291186659101*x_92 + 0.0123286918509974*x_93 - 0.00094335423352257*x_94 + 0.0100774538192946*x_95 + 0.00157790391593748*x_96 - 0.000983275406536608*x_97 - 0.00355727252876269*x_98 - 0.00163434323080927*x_99 + 0.22760538122125, 2) - 0.000119079249694213*std::exp(0.00293024113347167*x_1 - 0.000621562030187104*x_10 + 0.00872452960352608*x_100 - 0.00127275333576336*x_101 - 0.00258866154834106*x_102 - 0.000974221843247387*x_103 - 0.00345259138674555*x_104 + 0.00662615277691363*x_105 - 0.00285687494963204*x_106 - 0.00191973173709416*x_107 - 0.0017733757775913*x_108 + 0.000673486566012147*x_109 + 0.00884423789241642*x_11 - 0.00074819667781397*x_110 + 0.00621738647949188*x_111 + 0.00218222738471345*x_112 - 0.00172761968649661*x_113 + 0.00105835141719568*x_114 - 0.000485990014112321*x_115 - 0.00616161701222881*x_116 + 0.000145526786921999*x_117 + 0.00326509460248456*x_118 + 0.00212685158832908*x_119 + 0.00114533281373345*x_12 - 0.000354042661212652*x_120 - 0.00245708974844927*x_13 - 0.000837666510939429*x_14 - 0.00142924451205817*x_15 - 0.0031547839931236*x_16 + 0.00170307985088926*x_17 - 0.0031270032246472*x_18 + 0.0012261155982986*x_19 - 0.00177189751241112*x_2 + 0.000995962224484587*x_20 + 0.00145241505964428*x_21 - 4.22715411350328e-5*x_22 + 0.000464547373893975*x_23 + 0.0013273469515282*x_24 - 0.00526683155066994*x_25 - 0.000894606830806764*x_26 + 0.00237170628505072*x_27 + 0.000635192778725339*x_28 + 0.0013434419634355*x_29 + 0.0056291438100316*x_3 + 0.000206066259915896*x_30 + 0.00403002775759605*x_31 - 0.00882422509874158*x_32 - 0.00201625845178907*x_33 - 0.00178651549730526*x_34 + 0.00621870187565062*x_35 - 0.00262235870443735*x_36 - 0.000255808276951646*x_37 - 0.000548494419531347*x_38 + 0.00966668738466911*x_39 + 0.00125883352220763*x_4 - 0.00103009412052668*x_40 - 0.00335899524835382*x_41 - 0.00183040456667721*x_42 + 0.00161537086585504*x_43 + 0.00128333985047439*x_44 - 0.0102566028590167*x_45 - 0.000129931528333315*x_46 - 0.00101969470424268*x_47 - 0.00647739209498492*x_48 + 0.00226763513751165*x_49 + 0.00141974716653366*x_5 + 0.0174442759343242*x_50 - 0.000981874881874834*x_51 + 0.000717833262713697*x_52 + 0.000548354161222998*x_53 - 0.000485251761469157*x_54 + 0.00215815133070409*x_55 + 0.000584438053103544*x_56 - 0.000881661301310768*x_57 + 0.00105013374221907*x_58 - 0.00124534141521052*x_59 + 0.00169286461250524*x_6 + 0.00889123055944431*x_60 + 0.00426965000672752*x_61 - 0.00250359358039764*x_62 + 0.00112224262861831*x_63 - 0.00133900332826428*x_64 - 0.00043367599102875*x_65 - 0.000121755090144887*x_66 + 0.00139090333154809*x_67 - 0.00529251059586849*x_68 - 0.00354217966028427*x_69 + 0.00649938766257858*x_7 + 0.00126364108828776*x_70 + 0.00082852899212843*x_71 + 0.000522059673642588*x_72 - 0.00238463962494068*x_73 - 0.0003197209213606*x_74 + 0.000951721404967685*x_75 - 0.00132777878321077*x_76 - 0.00102950365406429*x_77 - 0.00553207613523432*x_78 + 0.000445769094647337*x_79 - 0.000575987375745394*x_8 + 0.00175531931013445*x_80 - 0.00269302438113847*x_81 + 0.0021490291320286*x_82 - 0.00324414566673046*x_83 - 0.000587101490690004*x_84 - 0.000672628076570495*x_85 + 0.00641281978501626*x_86 - 0.000134076768226897*x_87 + 0.00761205723858757*x_88 - 0.00101050381621343*x_89 + 0.0123714208878067*x_9 + 0.000121918409370987*x_90 + 0.0182993277383132*x_91 + 0.00403316287021809*x_92 + 0.00256060035138324*x_93 - 0.00186973840317208*x_94 - 0.000367791848818119*x_95 - 0.000583493592056376*x_96 + 0.00221365220578024*x_97 - 7.46867297179288e-5*x_98 + 0.00952203427366073*x_99) + 0.000205232451899017*std::sin(0.267999976873398*x_1 - 4.6069598197937) + 0.000231631202173444*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 0.000108626260860242*std::sin(0.331999838352203*x_34 - 1.19063985347748) - 7.72226767132591e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 0.000112972059824518*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0707852053776078);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.108654016499e-8*x_1 + 4.73625062728276e-7*x_10 + 9.02819599760096e-7*x_100 + 5.35588897147216e-6*x_101 + 2.68859199072261e-6*x_102 + 3.7005228909851e-6*x_103 + 1.28214387271142e-6*x_104 - 1.95351860483676e-7*x_105 + 3.71142929819327e-6*x_106 + 2.13739279062552e-7*x_107 - 6.22424392043956e-7*x_108 - 9.61321244925038e-7*x_109 + 1.32760679118767e-6*x_11 + 1.99348117536811e-6*x_110 - 1.79711376851485e-6*x_111 + 1.33298962862993e-6*x_112 + 1.82496510058906e-6*x_113 + 1.90018244651118e-8*x_114 + 1.29100241104552e-7*x_115 - 6.4664379803325e-9*x_116 + 1.34657842809586e-6*x_117 - 1.35868159309432e-6*x_118 + 4.35914321485011e-6*x_119 + 1.88304959907689e-6*x_12 + 6.1615002906912e-7*x_120 - 2.70718331104628e-7*x_13 + 8.58177299991875e-7*x_14 + 1.56154007210106e-7*x_15 + 9.05604991609491e-7*x_16 - 2.97772308804829e-7*x_17 + 5.65842736997221e-7*x_18 - 8.03061868937418e-7*x_19 - 1.06315026278132e-6*x_2 + 1.23141984104847e-6*x_20 + 9.64658494574169e-8*x_21 - 1.71791696925041e-8*x_22 - 1.35865972345153e-6*x_23 - 8.79343703745751e-7*x_24 + 5.66501310486234e-7*x_25 + 6.1947347983842e-7*x_26 - 1.01799682432711e-7*x_27 + 1.45662251781e-6*x_28 + 1.76871834102602e-6*x_29 - 6.87909174273643e-7*x_3 + 1.75851216761688e-6*x_30 - 4.85901071170306e-6*x_31 + 3.34575421824452e-6*x_32 - 9.7719553398723e-6*x_33 + 1.78163923338994e-6*x_34 - 3.37604164715379e-6*x_35 - 2.37993511739163e-7*x_36 - 2.41267775670439e-6*x_37 - 5.6393119728929e-7*x_38 + 2.32501049961344e-9*x_39 + 1.76925098771999e-6*x_4 + 3.7476857427868e-7*x_40 + 1.57003081803879e-6*x_41 - 4.25001732471374e-6*x_42 - 6.08535986604875e-7*x_43 - 6.77369267211479e-6*x_44 - 5.0950684293723e-6*x_45 - 1.02531668565132e-7*x_46 + 4.25988630911475e-6*x_47 + 7.19577892312092e-7*x_48 - 2.69645845848403e-6*x_49 + 1.28448283322162e-6*x_5 + 3.86226751173215e-6*x_50 + 4.46877498626256e-7*x_51 + 2.19068915144143e-7*x_52 - 7.99845684214914e-7*x_53 - 1.69783695163497e-6*x_54 + 4.94936048177166e-6*x_55 + 2.7228175691163e-6*x_56 - 8.44429788092751e-7*x_57 + 4.80073182753329e-7*x_58 + 3.45391201166623e-7*x_59 + 6.93515076233259e-7*x_6 + 2.71643741388318e-8*x_60 + 4.09783036003132e-6*x_61 + 2.28857723572667e-6*x_62 + 1.68519148897776e-5*x_63 - 4.28437019468546e-6*x_64 - 2.19496294122935e-6*x_65 + 1.17050823196231e-6*x_66 + 6.30930810984991e-7*x_67 + 1.6191562945393e-6*x_68 + 4.74043153590176e-7*x_69 - 2.8860800288976e-6*x_7 + 2.33012189791048e-6*x_70 - 5.37062376020979e-7*x_71 + 2.7485137748323e-6*x_72 + 5.42373177794287e-7*x_73 - 1.08383469779305e-7*x_74 + 2.04731151247377e-6*x_75 + 5.77027310680881e-6*x_76 + 1.39695448545431e-7*x_77 - 1.33389686878561e-6*x_78 + 5.56016522007458e-6*x_79 - 6.67372941271292e-6*x_8 - 2.27454560293101e-6*x_80 + 1.44510572313049e-6*x_81 + 1.05513206428795e-6*x_82 - 2.02679566206952e-7*x_83 + 5.67838663337545e-7*x_84 - 1.08689854845299e-7*x_85 - 3.49313564669423e-8*x_86 + 7.56494576911991e-7*x_87 - 1.21151247545137e-6*x_88 - 6.71086839183931e-7*x_89 + 2.20680077293998e-6*x_9 + 3.74341400770182e-7*x_90 + 6.90563436676255e-7*x_91 - 6.55891004087001e-6*x_92 - 1.04390127174294e-5*x_93 + 7.67709752786908e-7*x_94 + 1.89078349785759e-6*x_95 - 1.36179488111448e-6*x_96 + 4.33413814602866e-6*x_97 + 5.01502418616076e-7*x_98 - 1.14373377302466e-6*x_99 - 4.49542665594398e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) - 8.76599125986839e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) + 0.000155585929138662*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 0.000117656843304564*std::sin(0.331999838352203*x_34 - 1.19063985347748) - 5.18702221215012e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 0.000122363927795217*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0465466740245914);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.8774366095026e-7*x_1 - 1.00081053574828e-6*x_10 - 6.52836952680958e-7*x_100 - 4.3183716804814e-6*x_101 + 1.06237027087666e-6*x_102 + 3.64813896741802e-6*x_103 - 9.11312868965033e-7*x_104 + 1.27449530807945e-7*x_105 + 2.67440996798205e-6*x_106 - 1.19590852131494e-6*x_107 - 1.066726673916e-6*x_108 - 9.09058961765839e-8*x_109 + 1.74078892608922e-6*x_11 + 2.50844691270064e-6*x_110 - 1.63046896867367e-6*x_111 + 5.97819368990264e-6*x_112 + 8.65537612998432e-7*x_113 + 1.46281687898354e-6*x_114 + 1.64699651848409e-7*x_115 + 5.39084098733267e-7*x_116 + 2.13321454574783e-6*x_117 - 1.94751728175347e-6*x_118 - 1.35211589766876e-7*x_119 + 4.07839603074997e-6*x_12 + 3.40231611260963e-6*x_120 - 1.29400839265613e-6*x_13 - 4.10536292891359e-7*x_14 + 5.11768783739736e-7*x_15 - 3.4116939892962e-7*x_16 + 2.69837889919882e-6*x_17 + 1.19183553525911e-6*x_18 - 2.32867711229457e-7*x_19 + 7.84213047941001e-7*x_2 - 4.48212319864025e-7*x_20 + 1.38069249325347e-6*x_21 - 7.03453103263197e-7*x_22 - 1.07016260615794e-6*x_23 - 9.65298698421083e-7*x_24 + 1.65152670552976e-6*x_25 + 6.62158878523978e-7*x_26 - 3.42899120192005e-7*x_27 + 1.7378181839138e-6*x_28 - 1.86240996547199e-6*x_29 - 1.28277583045629e-6*x_3 + 1.19047184997074e-6*x_30 + 1.02129867364623e-5*x_31 - 1.30220587834183e-6*x_32 - 4.30116776024137e-5*x_33 - 4.29704064052259e-6*x_34 + 5.66950340617372e-8*x_35 - 3.00213678424846e-6*x_36 - 1.08122115147158e-5*x_37 - 1.08238571435418e-6*x_38 + 1.84605717120963e-6*x_39 + 1.00991519704144e-6*x_4 - 1.75434385898202e-6*x_40 + 3.59604682319813e-7*x_41 + 6.57778752944709e-7*x_42 + 9.05193379398665e-7*x_43 - 2.28389818786809e-6*x_44 - 8.95149835455724e-7*x_45 - 1.30098453547191e-7*x_46 + 2.80247424593596e-7*x_47 + 8.87131780257082e-7*x_48 - 8.38866995723587e-7*x_49 + 1.94486005727903e-6*x_5 - 8.29286668889093e-7*x_50 - 2.95628806326602e-6*x_51 - 2.80644821313045e-6*x_52 - 4.20958149516187e-7*x_53 - 4.86705309600356e-7*x_54 + 1.15283728864259e-6*x_55 - 9.05280093239629e-8*x_56 - 1.35595023730836e-7*x_57 - 2.61369882424064e-6*x_58 - 5.76873063484838e-7*x_59 + 1.43044222908716e-6*x_6 + 2.33187917300404e-6*x_60 + 6.29533262918752e-6*x_61 - 2.92142224434421e-6*x_62 + 4.61066498290361e-6*x_63 - 1.7803952997353e-6*x_64 + 6.61385628393038e-7*x_65 + 1.74474373143039e-7*x_66 - 6.55850641741825e-7*x_67 + 2.34624303158223e-6*x_68 - 7.27846845368334e-8*x_69 + 3.05007332196797e-8*x_7 + 2.44235834423425e-6*x_70 + 3.38449457390327e-7*x_71 + 1.14481171147509e-6*x_72 + 1.79794124826044e-6*x_73 - 1.44928183585997e-7*x_74 + 2.7124947641147e-6*x_75 - 3.98842973064989e-7*x_76 + 3.49456036433978e-7*x_77 - 2.19968478809339e-6*x_78 + 9.12914642636294e-7*x_79 - 7.23305798085849e-6*x_8 - 2.21122967141074e-6*x_80 + 6.00561161231817e-7*x_81 + 4.82874649099758e-7*x_82 - 1.2758157358215e-6*x_83 + 1.41023928469474e-6*x_84 + 4.58456464052982e-7*x_85 - 2.98791455856405e-6*x_86 + 2.49910804520254e-7*x_87 - 1.87583078007063e-6*x_88 + 1.56880864913344e-7*x_89 + 4.27579468148819e-7*x_9 - 8.78984082240194e-8*x_90 + 4.92173395640309e-5*x_91 + 8.54252848227494e-7*x_92 + 2.09206614640206e-6*x_93 - 2.64572512454692e-6*x_94 - 2.50947825808975e-6*x_95 - 1.22208508725064e-6*x_96 + 9.43394447667096e-6*x_97 + 8.44465685834129e-7*x_98 + 1.39494733555306e-6*x_99 - 9.54054005225781e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) + 7.24022056243382e-5*std::exp(0.00350893441710354*x_1 - 0.000744314307506927*x_10 + 0.0104475368423284*x_100 - 0.00152410937561721*x_101 - 0.00309989628411389*x_102 - 0.00116662090249709*x_103 - 0.00413444361515507*x_104 + 0.00793475160330973*x_105 - 0.00342107914656428*x_106 - 0.00229885953307699*x_107 - 0.00212359973702076*x_108 + 0.000806493419241924*x_109 + 0.0105908863196467*x_11 - 0.000895958030059287*x_110 + 0.00744525805508565*x_111 + 0.00261319544275686*x_112 - 0.00206880727608631*x_113 + 0.00126736522491866*x_114 - 0.000581968175727217*x_115 - 0.00737847467645256*x_116 + 0.000174266870193068*x_117 + 0.0039099180933902*x_118 + 0.00254688348105922*x_119 + 0.0013715245763361*x_12 - 0.000423962541806293*x_120 - 0.00294234037115952*x_13 - 0.001003097259374*x_14 - 0.00171150599229883*x_15 - 0.0037778222432102*x_16 + 0.00203942106866157*x_17 - 0.00374455505112593*x_18 + 0.00146826115198244*x_19 - 0.00212182952926923*x_2 + 0.00119265479134424*x_20 + 0.00173925249102869*x_21 - 5.06197472482375e-5*x_22 + 0.000556290828768887*x_23 + 0.00158948468385487*x_24 - 0.00630697804563846*x_25 - 0.00107128272227707*x_26 + 0.00284009452867634*x_27 + 0.000760636992398062*x_28 + 0.00160875829945603*x_29 + 0.00674084334842548*x_3 + 0.000246762282927213*x_30 + 0.00482591788743249*x_31 - 0.0105669211996073*x_32 - 0.00241444930741123*x_33 - 0.00213933441981146*x_34 + 0.00744683322881481*x_35 - 0.00314024829113274*x_36 - 0.000306327850265386*x_37 - 0.00065681657536577*x_38 + 0.01157576135151*x_39 + 0.00150744053826202*x_4 - 0.00123352739509519*x_40 - 0.0040223631766003*x_41 - 0.00219189114092725*x_42 + 0.00193439043730492*x_43 + 0.0015367866209819*x_44 - 0.0122821792252731*x_45 - 0.000155591704186976*x_46 - 0.00122107419822347*x_47 - 0.00775661217622681*x_48 + 0.00271547037155291*x_49 + 0.00170013301612926*x_5 + 0.0208893457634596*x_50 - 0.0011757853396243*x_51 + 0.000859598144502729*x_52 + 0.000656648617445915*x_53 - 0.000581084125579083*x_54 + 0.00258436460915192*x_55 + 0.000699858716668254*x_56 - 0.00105578058032798*x_57 + 0.00125752464141698*x_58 - 0.00149128387522818*x_59 + 0.00202718842298093*x_6 + 0.0106471595678795*x_60 + 0.00511286313145239*x_61 - 0.0029980282442792*x_62 + 0.00134387431086057*x_63 - 0.00160344307828212*x_64 - 0.000519322656900032*x_65 - 0.00014580050132624*x_66 + 0.00166559281254464*x_67 - 0.00633772844514185*x_68 - 0.00424172467567874*x_69 + 0.00778295164818067*x_7 + 0.00151319755050527*x_70 + 0.000992155172090947*x_71 + 0.000625161231852605*x_72 - 0.00285558207369425*x_73 - 0.000382862601993814*x_74 + 0.00113967685295192*x_75 - 0.00159000179797086*x_76 - 0.00123282031741875*x_77 - 0.00662460577978523*x_78 + 0.000533804027396181*x_79 - 0.000689739115147707*x_8 + 0.0021019772980389*x_80 - 0.00322486973141356*x_81 + 0.00257344086757774*x_82 - 0.00388483195258438*x_83 - 0.000703048156509289*x_84 - 0.00080546538673152*x_85 + 0.0076792874815958*x_86 - 0.000160555587453643*x_87 + 0.00911536232439565*x_88 - 0.00121006820183595*x_89 + 0.0148146526392751*x_9 + 0.000145996074464195*x_90 + 0.0219132617371831*x_91 + 0.0048296721534058*x_92 + 0.00306629328173103*x_93 - 0.00223899301628385*x_94 - 0.000440427056294518*x_95 - 0.00069872773402107*x_96 + 0.00265082635133057*x_97 - 8.94366110060218e-5*x_98 + 0.0114025406994754*x_99) - 0.000186038605705946*std::sin(0.267999976873398*x_1 - 4.6069598197937) + 2.74093485690195e-5*std::sin(0.272319942712784*x_33 - 7.58688020706177) - 0.000139119541063676*std::sin(0.331999838352203*x_34 - 1.19063985347748) - 9.13790216346374e-6*std::sin(0.411919862031937*x_86 - 7.59344005584717) + 0.000144685281361438*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0620504783248517);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.52646904514092e-7*x_1 - 4.20004883753071e-7*x_10 - 1.15874035136086e-7*x_100 + 6.31258404333748e-6*x_101 + 4.98534366680204e-7*x_102 + 2.65775303356252e-6*x_103 - 9.16931006825413e-7*x_104 + 7.41707533589551e-8*x_105 + 4.19728537422891e-7*x_106 + 2.95356459441296e-7*x_107 + 5.25401807498815e-7*x_108 - 5.01860570247854e-7*x_109 - 5.88069490577609e-7*x_11 - 6.84599688856518e-7*x_110 - 3.76671042398041e-7*x_111 + 9.25967780777531e-7*x_112 + 7.30906005923645e-7*x_113 - 1.76792028066719e-7*x_114 - 1.03059747856366e-7*x_115 - 1.6693173859211e-6*x_116 + 4.19493723972135e-7*x_117 + 3.46908085231047e-7*x_118 - 6.9826306619222e-8*x_119 + 6.10254146932817e-7*x_12 - 1.20264890801456e-7*x_120 + 9.66529365428885e-7*x_13 + 6.49373795170935e-7*x_14 + 1.10689627910815e-6*x_15 + 6.62436099806815e-7*x_16 + 4.32798424856893e-7*x_17 + 3.33917597377908e-7*x_18 + 3.45816084826844e-7*x_19 - 1.47644493726022e-7*x_2 + 7.37126607891246e-7*x_20 - 1.34384700988858e-7*x_21 - 1.53756778388781e-6*x_22 + 1.94052274323198e-7*x_23 - 1.50613694049278e-7*x_24 + 6.55524933075272e-7*x_25 - 1.48991372707334e-7*x_26 + 1.5682876477028e-7*x_27 + 2.19435238644551e-7*x_28 + 6.1467289801711e-7*x_29 - 2.58226720912641e-7*x_3 + 8.06810644679652e-8*x_30 - 9.28698534619831e-6*x_31 + 2.94474592200136e-6*x_32 - 2.8501362527891e-6*x_33 - 1.10430617042696e-6*x_34 - 3.60028102563259e-6*x_35 + 2.75381036465793e-6*x_36 + 2.40436559610596e-7*x_37 + 1.06745745468344e-9*x_38 - 3.78405670022289e-6*x_39 + 3.86721418919409e-7*x_4 + 2.86994378593221e-7*x_40 + 3.85549959715617e-7*x_41 - 1.74358224690905e-6*x_42 + 7.71449564660028e-7*x_43 - 1.48807218568692e-6*x_44 + 1.75302485923446e-7*x_45 + 1.49640147468683e-7*x_46 + 6.82651631494798e-7*x_47 + 3.00146338451921e-7*x_48 - 2.65125878325011e-6*x_49 - 4.173858107567e-7*x_5 - 2.55697825799636e-6*x_50 + 1.02038530361247e-6*x_51 - 1.00799604346112e-6*x_52 - 6.43077299917449e-7*x_53 - 7.40823874459323e-7*x_54 + 2.573562730877e-6*x_55 - 4.57955472546035e-9*x_56 + 3.16412638173976e-7*x_57 + 1.37663350590894e-6*x_58 - 9.89333333040897e-7*x_59 - 9.89307346305706e-8*x_6 - 7.86392011894299e-7*x_60 - 1.07134889047985e-6*x_61 + 2.16508671069876e-6*x_62 + 3.85860721835705e-6*x_63 - 1.99581166482697e-7*x_64 - 8.67279002593209e-7*x_65 + 5.30793312579381e-7*x_66 + 4.0674560605803e-7*x_67 + 5.98563535931488e-7*x_68 + 7.42012049578996e-8*x_69 - 1.82787904907009e-6*x_7 + 2.1831146393724e-7*x_70 - 6.34862817513945e-8*x_71 - 1.54600105955791e-7*x_72 - 1.38508571780494e-7*x_73 + 2.22788462109309e-7*x_74 + 1.77893947893946e-7*x_75 - 4.93536898555478e-8*x_76 + 1.11357952705727e-7*x_77 - 4.21128018528244e-7*x_78 + 1.1507424575419e-6*x_79 - 3.70528772968236e-6*x_8 - 3.39097146635395e-8*x_80 + 1.30205422482343e-6*x_81 + 2.27535918711002e-7*x_82 + 1.57895130592451e-7*x_83 - 3.4718834143118e-7*x_84 - 6.0906920684234e-7*x_85 + 7.75052901127755e-7*x_86 + 8.61325399792513e-8*x_87 - 1.99564029973242e-6*x_88 - 3.39054138917764e-7*x_89 + 6.45557842077956e-7*x_9 - 1.25492236380061e-7*x_90 - 1.54353146148326e-5*x_91 - 4.19107995494494e-6*x_92 - 7.30403534836097e-6*x_93 + 5.59286915699027e-7*x_94 + 1.637591578363e-6*x_95 + 7.38671857031306e-8*x_96 + 3.42371543061223e-7*x_97 + 3.63031355407924e-7*x_98 - 1.03632877796313e-6*x_99 - 1.08285061499265e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) - 2.11153684694593e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) + 8.54822583243276e-5*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 0.000168956514197773*std::sin(0.331999838352203*x_34 - 1.19063985347748) - 2.84986164962177e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 0.000175715939023718*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0411067966241895);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.51994527953071e-6*x_1 - 3.78689632172157e-6*x_10 + 3.54860907249946e-7*x_100 + 1.77979448915866e-5*x_101 + 3.36534211285973e-7*x_102 + 3.07470709959479e-7*x_103 - 1.21221565245915e-6*x_104 - 8.4147127057758e-7*x_105 - 3.97566154410032e-7*x_106 - 7.78740154788974e-7*x_107 - 4.00641691530903e-7*x_108 + 1.4876736057725e-6*x_109 + 6.19204367244506e-7*x_11 - 7.10661293095219e-7*x_110 - 1.05293835754856e-6*x_111 + 4.21688697039507e-6*x_112 + 9.01345756939744e-7*x_113 + 1.11341080717053e-6*x_114 + 1.36384523696006e-7*x_115 - 5.31195999907329e-6*x_116 - 6.64462249469542e-7*x_117 + 3.29215808106435e-6*x_118 - 3.53120599776161e-6*x_119 - 1.08605069289359e-6*x_12 + 2.04952219667216e-6*x_120 + 5.09477911190841e-6*x_13 + 8.80478116201997e-8*x_14 + 2.32150111103969e-6*x_15 + 4.29545720032928e-6*x_16 + 1.78627325514602e-7*x_17 - 7.25993673941937e-7*x_18 - 1.88424857734023e-7*x_19 + 2.07990607188848e-6*x_2 + 7.1535543592951e-7*x_20 + 8.73714727771396e-7*x_21 - 3.1888258499398e-6*x_22 - 1.10693958395593e-6*x_23 - 3.67660355435681e-7*x_24 - 4.01345976971095e-7*x_25 + 6.0241335416003e-7*x_26 + 1.05173609496852e-7*x_27 + 1.37283134227709e-7*x_28 - 7.20649987244082e-7*x_29 + 5.44523427183298e-6*x_3 - 4.63257539536786e-7*x_30 - 3.95799904973249e-5*x_31 - 4.21883244760858e-6*x_32 - 1.67509813909425e-5*x_33 - 1.28329318208784e-5*x_34 - 1.09997546022867e-5*x_35 + 1.08331327112763e-5*x_36 - 2.67948738183546e-6*x_37 + 1.60186713799494e-6*x_38 - 2.70655019348441e-6*x_39 - 1.87880186089535e-6*x_4 + 2.18687041735408e-6*x_40 - 2.24488110303664e-6*x_41 + 5.19950784380112e-7*x_42 + 8.4855940442064e-6*x_43 + 5.54339401335996e-7*x_44 + 9.19101283385672e-8*x_45 + 7.62040076411629e-7*x_46 + 1.47095494770487e-6*x_47 - 6.38138380359443e-7*x_48 - 4.75737313931768e-6*x_49 - 9.08994990658904e-7*x_5 - 4.00540133651208e-6*x_50 - 1.01791135170954e-6*x_51 + 7.79270194325065e-8*x_52 - 5.94138901683584e-7*x_53 + 8.06081273456502e-7*x_54 - 4.75175551513383e-6*x_55 - 3.45609892024575e-6*x_56 + 5.69086069342664e-6*x_57 + 3.43071755397056e-6*x_58 - 3.38531053127828e-7*x_59 + 1.96642962421525e-6*x_6 + 1.61292947273642e-6*x_60 - 1.0412873424414e-6*x_61 + 9.24819302842252e-6*x_62 - 9.22262668072672e-6*x_63 - 6.57355144796157e-7*x_64 + 3.21253259593094e-6*x_65 - 8.79912741262572e-7*x_66 + 1.18563446800798e-6*x_67 - 1.74212280954517e-6*x_68 + 3.34375842318286e-7*x_69 + 2.4466719909627e-7*x_7 - 6.97254076955417e-7*x_70 - 3.11474989815319e-8*x_71 + 6.35463488685499e-7*x_72 + 4.5992814307618e-7*x_73 + 9.80790194302567e-8*x_74 - 4.80879096608367e-7*x_75 - 1.51443594220918e-6*x_76 + 2.35084414492815e-7*x_77 - 5.10507473390784e-6*x_78 - 1.13977592275158e-6*x_79 + 2.10111334102701e-6*x_8 - 1.36883870560079e-6*x_80 - 5.74787965710233e-7*x_81 + 1.33167036042254e-6*x_82 - 1.66354930194899e-6*x_83 + 3.7733431963149e-7*x_84 - 1.36529686644732e-6*x_85 + 2.44188741286985e-6*x_86 + 6.61569377373693e-7*x_87 + 1.19834110657435e-6*x_88 - 2.09283972995616e-7*x_89 + 1.63457997040552e-6*x_9 - 1.02562767579129e-6*x_90 - 3.82924608224138e-5*x_91 + 6.04388999419905e-6*x_92 + 4.28347289299521e-6*x_93 - 7.69986368385342e-7*x_94 - 8.04369262962329e-7*x_95 + 1.01481916070448e-6*x_96 + 2.74279743063569e-7*x_97 + 7.48425034635083e-7*x_98 + 2.13548509413372e-6*x_99 - 1.64871826934628e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) + 0.000103345354386582*std::exp(-0.00350893441710354*x_1 + 0.000744314307506927*x_10 - 0.0104475368423284*x_100 + 0.00152410937561721*x_101 + 0.00309989628411389*x_102 + 0.00116662090249709*x_103 + 0.00413444361515507*x_104 - 0.00793475160330973*x_105 + 0.00342107914656428*x_106 + 0.00229885953307699*x_107 + 0.00212359973702076*x_108 - 0.000806493419241924*x_109 - 0.0105908863196467*x_11 + 0.000895958030059287*x_110 - 0.00744525805508565*x_111 - 0.00261319544275686*x_112 + 0.00206880727608631*x_113 - 0.00126736522491866*x_114 + 0.000581968175727217*x_115 + 0.00737847467645256*x_116 - 0.000174266870193068*x_117 - 0.0039099180933902*x_118 - 0.00254688348105922*x_119 - 0.0013715245763361*x_12 + 0.000423962541806293*x_120 + 0.00294234037115952*x_13 + 0.001003097259374*x_14 + 0.00171150599229883*x_15 + 0.0037778222432102*x_16 - 0.00203942106866157*x_17 + 0.00374455505112593*x_18 - 0.00146826115198244*x_19 + 0.00212182952926923*x_2 - 0.00119265479134424*x_20 - 0.00173925249102869*x_21 + 5.06197472482375e-5*x_22 - 0.000556290828768887*x_23 - 0.00158948468385487*x_24 + 0.00630697804563846*x_25 + 0.00107128272227707*x_26 - 0.00284009452867634*x_27 - 0.000760636992398062*x_28 - 0.00160875829945603*x_29 - 0.00674084334842548*x_3 - 0.000246762282927213*x_30 - 0.00482591788743249*x_31 + 0.0105669211996073*x_32 + 0.00241444930741123*x_33 + 0.00213933441981146*x_34 - 0.00744683322881481*x_35 + 0.00314024829113274*x_36 + 0.000306327850265386*x_37 + 0.00065681657536577*x_38 - 0.01157576135151*x_39 - 0.00150744053826202*x_4 + 0.00123352739509519*x_40 + 0.0040223631766003*x_41 + 0.00219189114092725*x_42 - 0.00193439043730492*x_43 - 0.0015367866209819*x_44 + 0.0122821792252731*x_45 + 0.000155591704186976*x_46 + 0.00122107419822347*x_47 + 0.00775661217622681*x_48 - 0.00271547037155291*x_49 - 0.00170013301612926*x_5 - 0.0208893457634596*x_50 + 0.0011757853396243*x_51 - 0.000859598144502729*x_52 - 0.000656648617445915*x_53 + 0.000581084125579083*x_54 - 0.00258436460915192*x_55 - 0.000699858716668254*x_56 + 0.00105578058032798*x_57 - 0.00125752464141698*x_58 + 0.00149128387522818*x_59 - 0.00202718842298093*x_6 - 0.0106471595678795*x_60 - 0.00511286313145239*x_61 + 0.0029980282442792*x_62 - 0.00134387431086057*x_63 + 0.00160344307828212*x_64 + 0.000519322656900032*x_65 + 0.00014580050132624*x_66 - 0.00166559281254464*x_67 + 0.00633772844514185*x_68 + 0.00424172467567874*x_69 - 0.00778295164818067*x_7 - 0.00151319755050527*x_70 - 0.000992155172090947*x_71 - 0.000625161231852605*x_72 + 0.00285558207369425*x_73 + 0.000382862601993814*x_74 - 0.00113967685295192*x_75 + 0.00159000179797086*x_76 + 0.00123282031741875*x_77 + 0.00662460577978523*x_78 - 0.000533804027396181*x_79 + 0.000689739115147707*x_8 - 0.0021019772980389*x_80 + 0.00322486973141356*x_81 - 0.00257344086757774*x_82 + 0.00388483195258438*x_83 + 0.000703048156509289*x_84 + 0.00080546538673152*x_85 - 0.0076792874815958*x_86 + 0.000160555587453643*x_87 - 0.00911536232439565*x_88 + 0.00121006820183595*x_89 - 0.0148146526392751*x_9 - 0.000145996074464195*x_90 - 0.0219132617371831*x_91 - 0.0048296721534058*x_92 - 0.00306629328173103*x_93 + 0.00223899301628385*x_94 + 0.000440427056294518*x_95 + 0.00069872773402107*x_96 - 0.00265082635133057*x_97 + 8.94366110060218e-5*x_98 - 0.0114025406994754*x_99) - 3.21496735353587e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) - 0.000146113291851703*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 0.000571939285507275*std::sin(0.331999838352203*x_34 - 1.19063985347748) + 4.87121743284193e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 0.00059482079808906*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0716479632137609);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.97762356048974e-7*x_1 - 2.07724059434907e-6*x_10 + 7.66286486246892e-7*x_100 - 6.34510417506635e-6*x_101 - 1.62826761247585e-6*x_102 + 4.05486654044908e-6*x_103 - 3.10572585202923e-7*x_104 + 8.56561001451707e-8*x_105 + 3.62045954788338e-7*x_106 - 6.33534355284328e-8*x_107 - 2.88587403965688e-7*x_108 - 1.11049797467839e-7*x_109 + 8.9604419748141e-8*x_11 + 1.86137316935365e-6*x_110 + 2.49829428013598e-6*x_111 + 2.85692768508889e-6*x_112 - 7.00248779788534e-7*x_113 + 2.18186685537473e-6*x_114 + 8.43285329292284e-7*x_115 + 2.68675127944648e-7*x_116 - 1.33019374456868e-6*x_117 - 6.57962573474065e-7*x_118 - 3.42632988541535e-6*x_119 - 1.09558843663147e-6*x_12 - 2.96923485750592e-6*x_120 + 5.71215671031233e-7*x_13 + 1.45173547447839e-6*x_14 + 6.74043460586921e-7*x_15 - 7.62055905302617e-7*x_16 + 1.07759380210975e-6*x_17 - 5.94037014360244e-7*x_18 - 1.96473345779412e-6*x_19 + 4.05219369771237e-7*x_2 - 5.49846256256387e-7*x_20 + 1.09226477186491e-6*x_21 - 1.66584196089478e-6*x_22 - 2.31755984562795e-6*x_23 - 5.43533974895373e-8*x_24 + 1.01785180387364e-6*x_25 + 2.72672040805523e-6*x_26 - 1.70559572374499e-6*x_27 - 1.22199751119795e-8*x_28 - 3.09457075845061e-6*x_29 + 2.62855525473465e-6*x_3 - 1.23402814230788e-6*x_30 + 1.22590384106714e-5*x_31 - 1.35791284557802e-6*x_32 - 2.65465167614838e-6*x_33 - 7.43747376632323e-6*x_34 + 2.33021378508832e-6*x_35 - 2.99547202033216e-6*x_36 + 5.49836963897991e-6*x_37 + 1.19969322954059e-6*x_38 - 9.65477460814097e-7*x_39 - 2.74162994581265e-6*x_4 + 8.01909612670244e-7*x_40 - 4.34772634122247e-6*x_41 + 7.37703059952999e-6*x_42 + 7.50593952832304e-7*x_43 - 2.30673389334198e-6*x_44 + 8.23230259882747e-7*x_45 - 2.46317583594251e-7*x_46 - 1.17945660243213e-6*x_47 + 2.3058662190359e-6*x_48 + 1.52863693511132e-6*x_49 - 1.08219146341556e-6*x_5 - 1.94140273574594e-6*x_50 - 3.68065540701042e-6*x_51 + 2.1873192590428e-6*x_52 + 9.40656740249698e-7*x_53 - 1.98692852045588e-6*x_54 - 1.15497339215716e-5*x_55 - 1.33506616834611e-6*x_56 + 4.45610097850327e-7*x_57 - 3.68538925561328e-6*x_58 - 1.8900172347718e-6*x_59 + 4.83834974200143e-7*x_6 + 7.61910307105992e-7*x_60 + 4.93518918405764e-6*x_61 - 2.65025588927665e-6*x_62 - 1.45705780633535e-5*x_63 - 9.74020723312281e-7*x_64 + 9.15710148386228e-7*x_65 - 2.31605244075571e-6*x_66 - 1.52699214907953e-6*x_67 + 2.12294444587264e-7*x_68 - 3.70409896174927e-7*x_69 - 1.24555740018504e-7*x_7 - 1.04586248398253e-6*x_70 + 9.14844118151065e-7*x_71 - 2.3934102571848e-7*x_72 + 8.95753530546617e-7*x_73 - 1.65809801347463e-6*x_74 + 4.96754655188594e-7*x_75 + 3.65108460767504e-6*x_76 + 1.16893102429291e-6*x_77 + 3.26986773569893e-7*x_78 + 1.62128533592297e-6*x_79 - 3.95325793320416e-6*x_8 - 1.94662705786901e-6*x_80 - 7.39291966456112e-7*x_81 - 7.48342632760826e-7*x_82 - 3.83109104475617e-6*x_83 + 5.04915691205277e-7*x_84 + 9.27702948221207e-7*x_85 - 1.53012211234225e-6*x_86 - 8.22603008810758e-7*x_87 + 9.5874096079531e-7*x_88 + 7.32524303661509e-7*x_89 - 3.64386273569833e-6*x_9 - 1.96441152190032e-6*x_90 + 4.21938991790737e-5*x_91 + 8.8185675136491e-6*x_92 + 2.20277381912081e-5*x_93 - 6.71975740890203e-7*x_94 - 8.414391231434e-7*x_95 - 2.73677204194863e-7*x_96 - 5.31936309311119e-6*x_97 - 4.64943344948951e-7*x_98 + 2.49161080013757e-6*x_99 + 5.29678959119752e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) + 0.00026718939775374*std::exp(-3.21841789842881e-5*x_1 + 0.000555120107132219*x_10 + 0.000340492802846713*x_100 + 0.0021463747336812*x_101 + 0.00134580972668796*x_102 - 0.000153017997887034*x_103 - 0.000344804393521633*x_104 + 0.000652368952435869*x_105 + 0.00358453263093613*x_106 + 9.41857548103845e-5*x_107 - 0.000465613562797923*x_108 + 0.000107970208884067*x_109 + 0.000904962311196241*x_11 + 0.0011082233988763*x_110 - 0.00141193319095002*x_111 + 0.000470558280730152*x_112 - 0.00062942994753804*x_113 + 0.000753241945108734*x_114 - 0.000270719190832822*x_115 - 0.000345268939456363*x_116 + 0.00125906405794088*x_117 - 0.00231413706717256*x_118 + 0.000871034350101286*x_119 - 1.17763283830648e-5*x_12 - 1.00271680121555e-5*x_120 - 0.000198265176688603*x_13 + 0.000240690334033789*x_14 - 0.000400836617445782*x_15 + 0.000383363530392579*x_16 - 0.00174265463749543*x_17 + 0.000169839433336462*x_18 - 0.000570599280099844*x_19 + 5.26861230864871e-5*x_2 + 0.000424627534383066*x_20 - 0.000356124049783963*x_21 + 0.000989224650140798*x_22 + 0.000443539478604549*x_23 - 0.000641595322703652*x_24 + 0.000194716719373229*x_25 + 0.000627137625775506*x_26 - 0.000747144763973218*x_27 - 0.000564064538748699*x_28 + 0.000431042588322709*x_29 + 0.000132645455747311*x_3 + 0.000741309425247457*x_30 + 0.00951143520179028*x_31 + 0.00121982364197667*x_32 - 7.97896275520438e-6*x_33 + 0.000662272068326155*x_34 - 0.0012810551004803*x_35 - 0.00106531521034319*x_36 + 0.000705421217736144*x_37 + 0.000188404584815156*x_38 + 0.00323043687452188*x_39 + 0.000836841240850099*x_4 - 4.74925639444383e-5*x_40 + 0.00147306237650086*x_41 - 0.000440709854666435*x_42 + 0.000284677457557838*x_43 - 0.00315502569921776*x_44 - 0.00328034171818552*x_45 - 0.000256497043591723*x_46 + 0.00394000272032875*x_47 - 0.000525593447739581*x_48 - 0.000968489950099282*x_49 + 0.000274502907498415*x_5 - 0.000444735221950441*x_50 + 0.000467228422862234*x_51 + 0.000424492049299491*x_52 - 0.00031878209194625*x_53 + 0.000382646959286617*x_54 + 0.000177808499249157*x_55 + 0.00183958443512349*x_56 - 0.000357884642453479*x_57 - 0.000131978359861022*x_58 + 0.00177841214233566*x_59 + 0.000946419360741889*x_6 + 0.000557771429507983*x_60 + 0.00467735851469364*x_61 + 0.000620775827121782*x_62 + 0.000872822511862791*x_63 + 0.000131393402147409*x_64 - 0.00140882671361086*x_65 - 0.000306483997910116*x_66 + 0.00033963408300899*x_67 + 0.000763188061239203*x_68 + 0.000750318832169402*x_69 - 0.00079554975115794*x_7 + 0.000803339179287021*x_70 + 5.46258307293897e-5*x_71 + 0.00118752671384859*x_72 + 0.00017878480052982*x_73 + 7.34873675904036e-5*x_74 + 0.00157223744267353*x_75 + 0.00521265650569454*x_76 + 0.000543398450455305*x_77 - 0.00105306410895532*x_78 + 0.0031298477195572*x_79 - 0.00214627778942427*x_8 - 5.87674316852166e-5*x_80 - 0.000163668518057425*x_81 - 0.000388237055860695*x_82 - 0.000128380447848083*x_83 - 8.80374538052065e-5*x_84 - 0.000153484785410481*x_85 - 3.27633592653111e-5*x_86 + 6.59180350234919e-5*x_87 - 8.24594223995457e-5*x_88 + 0.000479269579797821*x_89 + 0.000426956625517173*x_9 - 6.31293368785225e-5*x_90 + 0.00377802256152014*x_91 + 0.00016311754169697*x_92 + 0.00370663235541879*x_93 + 0.000334649128148896*x_94 + 0.000569390821164731*x_95 - 0.000782990795612414*x_96 + 0.000183586113405966*x_97 + 7.0323267648092e-5*x_98 + 5.55492048754263e-5*x_99) - 0.00488899886642964*std::exp(6.73715413940045e-5*x_1 - 1.42908348283539e-5*x_10 + 0.000200592709116326*x_100 - 2.92629002662137e-5*x_101 - 5.95180091723377e-5*x_102 - 2.2399121522645e-5*x_103 - 7.93813181009872e-5*x_104 + 0.000152347232107801*x_105 - 6.56847201849884e-5*x_106 - 4.41381034187418e-5*x_107 - 4.07731153052125e-5*x_108 + 1.54846737840431e-5*x_109 + 0.000203345019104762*x_11 - 1.72023943266674e-5*x_110 + 0.000142948955900206*x_111 + 5.01733529370558e-5*x_112 - 3.97211000461266e-5*x_113 + 2.43334125299527e-5*x_114 - 1.1173789071089e-5*x_115 - 0.000141666715019305*x_116 + 3.34592393679082e-6*x_117 + 7.50704280456298e-5*x_118 + 4.89001632613941e-5*x_119 + 2.63332720945509e-5*x_12 - 8.14008087343721e-6*x_120 - 5.64929356173188e-5*x_13 - 1.92594675473908e-5*x_14 - 3.28609153377759e-5*x_15 - 7.2534187700128e-5*x_16 + 3.91568848586672e-5*x_17 - 7.1895457606558e-5*x_18 + 2.81906143631054e-5*x_19 - 4.07391273160878e-5*x_2 + 2.28989721928552e-5*x_20 + 3.33936481180199e-5*x_21 - 9.71899155614241e-7*x_22 + 1.06807840052037e-5*x_23 + 3.05181061952875e-5*x_24 - 0.000121093979528849*x_25 - 2.05686284465094e-5*x_26 + 5.45298154245776e-5*x_27 + 1.46042303809878e-5*x_28 + 3.08881596180463e-5*x_29 + 0.000129424193414769*x_3 + 4.73783587338538e-6*x_30 + 9.26576242441157e-5*x_31 - 0.000202884888796006*x_32 - 4.63574271052504e-5*x_33 - 4.10752212174199e-5*x_34 + 0.000142979199236069*x_35 - 6.02927677138341e-5*x_36 - 5.88149477621939e-6*x_37 - 1.26108783566409e-5*x_38 + 0.000222254619880905*x_39 + 2.8942858586212e-5*x_4 - 2.36837261916947e-5*x_40 - 7.72293736620301e-5*x_41 - 4.20843102716144e-5*x_42 + 3.71402967190906e-5*x_43 + 2.95063033793313e-5*x_44 - 0.000235817843175053*x_45 - 2.9873607463571e-6*x_46 - 2.34446248096793e-5*x_47 - 0.000148926955078079*x_48 + 5.2137031587009e-5*x_49 + 3.2642554193422e-5*x_5 + 0.00040107544214471*x_50 - 2.25750787170169e-5*x_51 + 1.65042845179133e-5*x_52 + 1.26076535645516e-5*x_53 - 1.11568153080973e-5*x_54 + 4.96198009270293e-5*x_55 + 1.3437287476832e-5*x_56 - 2.02709873184997e-5*x_57 + 2.41444733250781e-5*x_58 - 2.86326506532659e-5*x_59 + 3.89220180595575e-5*x_6 + 0.000204425465480223*x_60 + 9.81669729771869e-5*x_61 - 5.75621427905106e-5*x_62 + 2.58023869928062e-5*x_63 - 3.07861073706202e-5*x_64 - 9.97099509915193e-6*x_65 - 2.79936964979689e-6*x_66 + 3.19793822788329e-5*x_67 - 0.000121684387204446*x_68 - 8.14411144809459e-5*x_69 + 0.000149432672943989*x_7 + 2.90533932222433e-5*x_70 + 1.90493794697299e-5*x_71 + 1.2003095755905e-5*x_72 - 5.48271762915064e-5*x_73 - 7.35096202217831e-6*x_74 + 2.18817957668809e-5*x_75 - 3.05280347864008e-5*x_76 - 2.36701503001892e-5*x_77 - 0.000127192432077477*x_78 + 1.02490374150948e-5*x_79 - 1.32429911259486e-5*x_8 + 4.03579644731521e-5*x_80 - 6.19174993813486e-5*x_81 + 4.94100650869819e-5*x_82 - 7.45887741379714e-5*x_83 - 1.34985247223122e-5*x_84 - 1.54649355596717e-5*x_85 + 0.000147442320928259*x_86 - 3.08266730590555e-6*x_87 + 0.000175014958149687*x_88 - 2.32333096772021e-5*x_89 + 0.000284441333146543*x_9 + 2.80312465407826e-6*x_90 + 0.000420734629011086*x_91 + 9.27297061514298e-5*x_92 + 5.88728315209786e-5*x_93 - 4.29886662863222e-5*x_94 - 8.45619955435894e-6*x_95 - 1.34155726098173e-5*x_96 + 5.08958663879513e-5*x_97 - 1.71718294624196e-6*x_98 + 0.000218928783332932*x_99) + 0.000103286328118392*std::sin(0.267999976873398*x_1 - 4.6069598197937) - 0.00032743487779186*std::sin(0.272319942712784*x_33 - 7.58688020706177) - 0.00017657030355423*std::sin(0.331999838352203*x_34 - 1.19063985347748) + 0.000109162312655239*std::sin(0.411919862031937*x_86 - 7.59344005584717) + 0.000183634332420095*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0610231320771664);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.10668297171813e-6*x_1 - 1.01214166829046e-7*x_10 - 7.6255303937017e-7*x_100 + 1.2041629001092e-5*x_101 + 5.87512035731728e-7*x_102 + 2.71026950056074e-6*x_103 - 5.71561938037395e-6*x_104 + 3.36178156868307e-6*x_105 + 2.73631505765374e-7*x_106 + 2.07782640928562e-7*x_107 + 8.33281686034489e-7*x_108 + 5.11717827174409e-7*x_109 + 1.30299281958767e-6*x_11 - 2.53966318526347e-6*x_110 + 6.1614083127197e-7*x_111 + 4.39150760045033e-6*x_112 - 2.3108488589334e-6*x_113 + 3.36408300184586e-7*x_114 - 1.10258215412048e-6*x_115 - 2.9795474638634e-6*x_116 + 2.28098736955678e-6*x_117 + 1.41259473673322e-6*x_118 - 2.74918367664265e-7*x_119 + 2.58096241662638e-6*x_12 + 5.68264743313608e-7*x_120 + 1.29444473328789e-6*x_13 - 6.9339726268227e-7*x_14 + 2.48393820769443e-6*x_15 + 4.09182629755122e-7*x_16 + 3.35911432965003e-6*x_17 + 6.47585057151616e-7*x_18 + 1.66869226612163e-6*x_19 + 5.05142994794725e-7*x_2 - 6.70928811748818e-7*x_20 + 3.33734233499161e-7*x_21 - 1.53163215740114e-6*x_22 + 3.82169419012744e-6*x_23 + 5.61339649124463e-7*x_24 + 7.25507438673993e-7*x_25 - 1.68876888634783e-6*x_26 + 1.05328184787119e-6*x_27 - 6.66163175783822e-7*x_28 - 7.73797235435806e-7*x_29 - 1.36704579060413e-6*x_3 + 3.67417131271201e-7*x_30 - 1.2235527821874e-5*x_31 + 5.92187456142562e-7*x_32 - 1.46955944417151e-5*x_33 + 1.03450643829105e-6*x_34 - 4.23162268935315e-6*x_35 + 6.11323207214274e-6*x_36 - 2.67527449773517e-6*x_37 - 7.10935219117681e-7*x_38 - 1.10173826121076e-6*x_39 + 1.89053605482096e-6*x_4 - 1.03779303984772e-6*x_40 + 1.13782148386924e-6*x_41 - 1.52103072888287e-6*x_42 + 1.56387833324631e-6*x_43 + 2.45573098561393e-6*x_44 + 8.97306834541637e-7*x_45 - 1.19523429312695e-7*x_46 - 1.72374476120422e-6*x_47 - 2.16319579997795e-6*x_48 - 3.76429061005677e-6*x_49 - 1.94757505864451e-7*x_5 - 5.12070352343266e-6*x_50 + 6.99736686863987e-7*x_51 - 1.52743870233176e-6*x_52 - 1.27683342874642e-6*x_53 + 2.04185901307014e-6*x_54 + 4.58030410706979e-6*x_55 - 5.47076082960979e-7*x_56 + 1.78332795691502e-6*x_57 + 2.80017249568138e-6*x_58 - 1.34179563333686e-6*x_59 + 2.9884485268329e-7*x_6 + 2.04746597927599e-6*x_60 + 1.58093274742849e-6*x_61 + 2.96319178349381e-6*x_62 - 6.1851105716156e-6*x_63 + 4.90856086767774e-6*x_64 + 3.3863198829768e-7*x_65 + 2.46813373270809e-7*x_66 + 1.11244634135616e-6*x_67 + 3.90232255379366e-7*x_68 - 5.70754484891734e-7*x_69 + 9.72658885587359e-7*x_7 + 1.72506968070509e-7*x_70 + 1.3909663159546e-6*x_71 - 2.34866677636249e-6*x_72 - 4.27993729653628e-7*x_73 + 1.20642316365389e-6*x_74 + 1.05761000327743e-6*x_75 - 2.60329458962026e-6*x_76 + 2.31209244142733e-8*x_77 - 3.57454470939023e-6*x_78 - 1.94541075047931e-6*x_79 - 6.88372865747194e-6*x_8 + 4.28603329304026e-6*x_80 + 1.32523354803781e-6*x_81 - 2.43879861286908e-7*x_82 + 1.93267739387826e-7*x_83 - 8.41777396931964e-7*x_84 - 1.62814216226319e-6*x_85 + 8.22787574321878e-7*x_86 - 1.31071770308317e-7*x_87 - 4.33471838610297e-7*x_88 - 9.34468075081276e-8*x_89 + 3.06764404971749e-6*x_9 + 1.75188547531726e-7*x_90 - 1.23963306180183e-5*x_91 - 2.00811107298519e-6*x_92 - 3.97052973530572e-6*x_93 - 1.61127048498721e-6*x_94 + 2.6088723732127e-6*x_95 + 1.54265423396629e-6*x_96 + 7.96298344363896e-7*x_97 + 4.59609419234927e-7*x_98 + 2.38313232058294e-6*x_99 - 2.83284445531699e-10*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) - 5.52398952011394e-5*std::sin(0.267999976873398*x_1 - 4.6069598197937) + 0.000116272034143177*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 0.000298908675702941*std::sin(0.331999838352203*x_34 - 1.19063985347748) - 3.87635068988169e-5*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 0.00031086708247305*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0485395287253334);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.6031023776193e-8*x_1 + 6.11331931927819e-7*x_10 - 1.87363178002827e-6*x_100 + 3.46118355086714e-6*x_101 + 3.40563818933254e-6*x_102 + 3.59540483750169e-7*x_103 - 2.78501009978662e-6*x_104 + 1.54752003799188e-6*x_105 - 9.04132587471491e-7*x_106 + 1.76188498217186e-6*x_107 + 9.37266277213135e-7*x_108 + 2.34521632805402e-6*x_109 - 7.18956579403865e-7*x_11 - 2.46426918416037e-6*x_110 + 2.552597817949e-7*x_111 + 2.62717496163238e-7*x_112 - 2.16037863532191e-6*x_113 - 1.84944262261847e-7*x_114 - 3.09780060978197e-7*x_115 + 5.31470502712917e-7*x_116 + 1.37584668150105e-7*x_117 + 1.33011456430095e-6*x_118 + 5.31468654778004e-6*x_119 - 1.53673378306917e-7*x_12 - 3.86503011464849e-7*x_120 + 2.4835708083022e-7*x_13 - 1.13435181078556e-6*x_14 + 2.54630945455593e-7*x_15 + 1.56636676393886e-8*x_16 + 1.09729392707396e-6*x_17 - 2.86208378990685e-7*x_18 - 8.29652996556456e-7*x_19 - 3.3603002646303e-7*x_2 + 2.83229680164326e-7*x_20 + 5.32774094406233e-7*x_21 + 9.52703484499489e-8*x_22 + 3.15393739107711e-6*x_23 + 5.26835299047126e-8*x_24 - 3.20947811034901e-7*x_25 - 1.6649559930701e-6*x_26 + 8.19914055118024e-7*x_27 + 1.14306790736821e-6*x_28 + 5.44734489034022e-8*x_29 - 1.8357587631479e-6*x_3 + 1.52649373716406e-6*x_30 - 1.6396853675426e-5*x_31 - 2.79757976019846e-6*x_32 + 2.80136830508487e-6*x_33 + 9.20600661194733e-6*x_34 - 1.05068589774397e-6*x_35 + 1.60186406916132e-6*x_36 - 2.52178458240665e-7*x_37 - 9.29156309057028e-8*x_38 + 5.80129507085971e-7*x_39 + 2.51043261639581e-7*x_4 - 6.87982145072231e-7*x_40 + 8.63175392315856e-7*x_41 - 1.58768909393508e-6*x_42 - 7.13802975924774e-8*x_43 + 1.565224763291e-6*x_44 + 3.12070263233345e-7*x_45 - 3.38804290187111e-7*x_46 - 1.7239636859912e-6*x_47 + 5.72169682935229e-7*x_48 - 6.69929876693165e-7*x_49 + 4.84000011989059e-7*x_5 + 1.07378329095513e-6*x_50 + 9.12740091444871e-7*x_51 + 9.49933809484595e-7*x_52 - 5.02266302053802e-7*x_53 + 2.7825019932013e-6*x_54 - 6.19808852202316e-7*x_55 + 2.75062959253953e-7*x_56 + 9.14298552461366e-7*x_57 + 2.43705526889241e-6*x_58 + 4.12434216698364e-7*x_59 + 3.52651015277351e-9*x_6 - 9.71702580485929e-7*x_60 - 8.86993717209523e-7*x_61 + 6.09992453514676e-7*x_62 - 9.96798266767762e-6*x_63 + 3.13949489339153e-6*x_64 + 3.21764134955946e-6*x_65 + 2.9109558548457e-7*x_66 + 1.03340316997955e-6*x_67 - 8.94273022994141e-7*x_68 + 6.93388426050378e-8*x_69 + 1.34755751690448e-6*x_7 - 1.28452652501164e-6*x_70 + 3.26174024053485e-7*x_71 - 4.6683892024707e-7*x_72 + 4.93645607995364e-7*x_73 + 7.24696871600482e-7*x_74 - 8.09718205600061e-7*x_75 + 1.26726094452574e-6*x_76 - 1.39031722827421e-6*x_77 - 6.60909528423896e-8*x_78 - 3.45649875136506e-6*x_79 + 1.18648316035356e-6*x_8 + 3.58149048984825e-6*x_80 + 3.71927265160983e-7*x_81 + 1.19651647276783e-6*x_82 + 4.7309829600652e-7*x_83 + 4.48191484947976e-7*x_84 - 7.73476774547905e-7*x_85 - 9.80697227329452e-7*x_86 + 2.67612114840206e-7*x_87 + 8.69359544248255e-7*x_88 - 2.01335155939324e-7*x_89 - 1.19114259349877e-6*x_9 + 5.36883425174096e-7*x_90 - 1.36789011710594e-5*x_91 + 2.50278180874375e-6*x_92 + 3.83456083246388e-6*x_93 + 2.8558900873901e-7*x_94 + 1.44492797604921e-6*x_95 + 1.95809267351307e-6*x_96 - 2.37323741104561e-6*x_97 - 1.85165833012103e-7*x_98 + 1.57867328251063e-6*x_99 + 1.73161686753615e-11*std::pow(-9.92716026306152*x_50 - 9.8080005645752, 2) + 3.37661794708451e-6*std::sin(0.267999976873398*x_1 - 4.6069598197937) - 3.73410176258943e-6*std::sin(0.272319942712784*x_33 - 7.58688020706177) + 7.75770817467802e-5*std::sin(0.331999838352203*x_34 - 1.19063985347748) + 1.24489848742802e-6*std::sin(0.411919862031937*x_86 - 7.59344005584717) - 8.06806995905392e-5*std::sin(0.347519844770432*x_92 + 8.20440006256104) + 0.0545966351925602);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
