
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000152416859213787*x_1 + 0.00365525507434547*x_10 - 0.000513422746092239*x_100 + 0.000732301293795274*x_101 + 0.000717488216937217*x_102 + 0.00142060088382339*x_103 + 0.00162461606886739*x_104 + 0.000628107104052234*x_105 - 0.00261256923213052*x_106 + 0.00461371297908056*x_107 - 0.000426021981585344*x_108 + 0.00144452518187374*x_109 + 0.000113848864165284*x_11 + 0.000433677543189721*x_110 - 0.00317405035722219*x_111 + 0.000273146804873688*x_112 - 0.000357183605314344*x_113 + 0.003824365677113*x_114 - 0.00424224202213619*x_115 - 0.00204406818954039*x_116 + 0.00115888960080612*x_117 - 0.00165828362122449*x_118 + 0.0024188029949741*x_119 + 0.006086571977966*x_12 - 0.00226318465878146*x_120 - 0.00103156805765343*x_13 + 0.00352880879750851*x_14 + 0.000533764011046797*x_15 + 0.000405321936156875*x_16 + 0.000215734591088476*x_17 - 0.000113503558385689*x_18 - 0.00110102070095618*x_19 - 0.00100458695700938*x_2 - 0.000479595494541368*x_20 - 5.3930713187004e-5*x_21 + 4.20355858415971e-6*x_23 + 0.000486552775510574*x_24 + 3.76509802059248e-5*x_25 - 0.00106195376982023*x_27 - 0.00032083219936126*x_28 - 7.35325195580338e-5*x_29 - 8.69371837636681e-5*x_3 - 0.000495798223073562*x_30 - 0.00015314522905727*x_31 + 0.00211275684649615*x_33 + 0.00436459972170965*x_34 + 0.00200785925100544*x_35 + 0.00414861897116103*x_36 - 0.000345825148237145*x_37 + 0.000838716414851462*x_38 - 0.000415916143304014*x_39 + 0.000163150139462342*x_40 - 0.00367844942807681*x_43 + 4.33936929385534e-5*x_44 + 0.000307853949440371*x_45 + 0.0027495642153012*x_46 + 0.000610028523916889*x_47 + 0.00097115984932542*x_48 - 0.00115062129208645*x_49 + 0.00101216751386269*x_5 - 0.00274359529144524*x_50 + 0.000823878763524228*x_51 - 0.00111548164208898*x_52 - 6.27082254812927e-5*x_53 - 0.00442030803870258*x_54 + 0.00336032300900197*x_55 + 0.00343970514437931*x_56 + 0.00406374741299441*x_57 + 0.00462584517402247*x_58 - 0.000551519969468556*x_59 - 0.00142420893672894*x_6 - 0.00540558236267124*x_60 - 0.00169765281797141*x_61 + 0.000491011370101446*x_62 - 5.33993068551542e-5*x_63 - 0.00208207015138691*x_64 + 0.000944385147649007*x_65 - 0.00115474742383819*x_66 + 0.000117895774502991*x_67 + 0.00102351184717496*x_68 - 0.00190697820880407*x_69 - 0.00199613057269186*x_7 + 0.00053651492864007*x_70 - 0.00156150130112185*x_71 + 0.000184904435165993*x_72 - 0.000128675150750597*x_73 - 0.000817571020680837*x_74 - 5.95128700223885e-5*x_75 + 9.06582668030479e-5*x_76 + 0.00104051046080679*x_77 - 0.00105783696571272*x_78 + 0.000105674043285146*x_79 - 0.000504774658159303*x_8 - 0.000537354964011876*x_80 + 0.000836955062898764*x_81 + 0.0012946973679213*x_82 - 0.00128435907640242*x_83 + 0.00175948649109936*x_84 + 0.000936238477596183*x_85 - 0.000562761429009528*x_86 - 0.00109658932585849*x_87 + 0.00225303023300956*x_88 + 0.00126041318466602*x_89 - 0.00064957301203317*x_9 - 0.00130403009076673*x_90 - 0.000676029887551426*x_91 + 0.000664528846574818*x_92 + 0.00051702483199321*x_93 + 5.13966128842226e-5*x_94 - 0.000179483148709743*x_95 - 0.00332373451090728*x_96 - 0.000150736570929429*x_97 + 3.27221527249014e-5*x_98 + 0.000659926207246779*x_99 - 1.75745772437009e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) - 0.00595290615184399*std::exp(0.029189258893403*x_10 + 0.00669057680316297*x_100 - 0.0583063677852155*x_103 + 0.0593104756250952*x_104 + 0.0942492155003098*x_105 - 0.0904132720293993*x_106 - 0.0584124306935858*x_107 - 0.0519807338279682*x_108 + 0.0281122303432858*x_11 - 0.0522748622130161*x_110 + 0.0778577433245358*x_111 - 0.0168238726320642*x_112 + 0.112412825258671*x_113 + 0.115948283556894*x_114 - 0.0202607941807376*x_115 + 0.0374602540545111*x_116 + 0.0146016403375496*x_117 + 0.0789000008802995*x_118 + 0.118328137691005*x_119 - 0.0256213731899713*x_12 + 0.121607749541299*x_120 + 0.00158754249157988*x_14 - 0.0568721192555759*x_16 + 0.0154530312269575*x_19 - 0.00757673814804583*x_23 - 0.0311956395632173*x_24 + 0.0829810574609817*x_27 - 0.0010864931629995*x_28 - 0.0639105907636783*x_29 - 0.0196979419223449*x_30 - 0.043165328433615*x_33 + 0.00493547350762955*x_34 - 0.0912133744595915*x_35 + 0.0966208654409604*x_36 - 0.0387670724744735*x_37 - 0.0392503868713667*x_38 + 0.0369299022447218*x_39 - 0.106288911464723*x_40 - 0.127013890573475*x_42 + 0.0729472076188764*x_43 + 0.0305823012811199*x_44 - 0.0799561122576772*x_45 + 0.101713387091912*x_46 - 0.125911055140375*x_49 + 0.0511991273733976*x_50 + 0.0555350186597973*x_51 + 0.00454314375976659*x_52 - 0.0149628630776873*x_53 - 0.0135375077392041*x_54 - 0.018729700161186*x_56 - 0.0613645016687377*x_58 - 0.0334660599581512*x_59 - 0.00477802266186767*x_6 + 0.00568155432686159*x_61 - 0.0477563893975102*x_62 + 0.0356360247105132*x_63 - 0.0303777884554*x_64 - 0.0173149331711402*x_65 - 0.0207086169149796*x_66 - 0.00916745083781955*x_67 + 0.0360527580802433*x_68 - 0.0281434260072881*x_69 + 0.0104498938427377*x_70 + 0.0215322403553564*x_71 + 0.0168560778716914*x_72 - 0.000720125824003612*x_73 + 0.0371468168491578*x_74 - 0.00447944703019963*x_75 + 0.0225310085297071*x_76 + 0.0401635986364162*x_77 + 0.00338162319355557*x_78 - 0.0361772849618053*x_79 - 0.0695004341821014*x_8 - 0.022222451719003*x_80 + 0.0473671839538413*x_81 - 0.0100514866983128*x_82 - 0.0228747012708898*x_83 + 0.00355790582499861*x_84 - 0.00504568370978536*x_85 + 0.0321926948690153*x_86 - 0.0402814593410561*x_87 + 0.000585793410245466*x_88 + 0.000974784003438613*x_89 + 0.0176000600152161*x_9 + 0.0108447196515595*x_90 + 0.0512052776543901*x_91 + 0.0520236237561565*x_93 + 0.00107727143933293*x_95 - 0.048515032517048*x_96 - 0.105434997440538*x_99 - 7.5847833745514e-5*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) - 0.489979856722407*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.338818678296139*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.709226618163683*std::sin(0.233519986271858*x_102 + 1.97087979316711) - 0.421557083874799*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.358786144229502*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 0.647574352917324*std::sin(0.321919918060303*x_15 + 5.13399982452393) + 0.315965985965683*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.341919863892972*std::sin(0.412079870700836*x_2 + 5.19591999053955) - 0.466015774797356*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.494649285754704*std::sin(0.347679853439331*x_21 - 1.15399980545044) + 1.90758121481852*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.163116795654041*std::sin(0.352959841489792*x_25 + 8.22855949401855) + 0.659951470491052*std::sin(0.202959999442101*x_26 - 1.17263984680176) + 0.223311316719354*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.396554852054738*std::sin(0.370719850063324*x_31 + 5.17447996139526) + 0.062648716816863*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.467225678968255*std::sin(0.210559993982315*x_4 - 1.200159907341) - 0.527935567302876*std::sin(0.261039972305298*x_41 + 1.96215975284576) + 0.690252026674678*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.39839132773043*std::sin(0.243039980530739*x_48 - 7.61728000640869) - 0.671027924109296*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 1.00372217078512*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.757127574966738*std::sin(0.224399983882904*x_57 - 4.2163200378418) - 0.236202234937799*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.167682879684214*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.236021864226664*std::sin(0.343999862670898*x_92 - 1.3698399066925) + 0.622499429716285*std::sin(0.281039953231812*x_94 + 1.98919987678528) - 0.345253327695691*std::sin(0.288799941539764*x_97 + 8.18423938751221) + 0.696299145371469*std::sin(0.280639946460724*x_98 + 8.17799949645996)) - 0.0177239956370524*std::sin(0.406479865312576*x_1 - 0.994959831237793) + 0.0257587294180224*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.00355951307034913*std::sin(0.239599987864494*x_100 - 1.19783997535706) + 0.00651174943296149*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.00301693549835657*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00440638598734233*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.011172005747486*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.00266039274227928*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.0306398560769736*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00259829498114562*std::sin(0.228319987654686*x_110 - 1.20983994007111) - 0.00665445103789925*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00227679166705915*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.0297064803482099*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.0358653173009824*std::sin(0.226719990372658*x_117 + 8.36223983764648) + 0.00614520182661665*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.00135263198626083*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.00737667447472032*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.00111557874035166*std::sin(0.272559970617294*x_14 + 5.15696001052856) - 0.0123869936324526*std::sin(0.351919859647751*x_15 + 5.03336000442505) - 0.0164589120130628*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.00278305658377967*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.00400860153564693*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.128038004713362*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.000595544177077968*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.00542752205700928*std::sin(0.269679963588715*x_20 - 4.3887996673584) - 0.00919852507463562*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.0191567451324349*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.00421469737029501*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.0193489271009944*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.00342527839738986*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.00138987296300966*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.0050186165182446*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00355429695058037*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.0057253747120107*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.0141784405576679*std::sin(0.373519837856293*x_25 + 8.2203197479248) - 0.00438353810882897*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.0194472944050075*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.00247906877765377*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00488201974530903*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.00771594489115805*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.0173737597910423*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.00455942689336325*std::sin(0.182880014181137*x_29 - 4.61615991592407) - 0.0239837390371804*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00349052301920971*std::sin(0.318319916725159*x_3 - 4.14279985427856) - 0.0172456655777137*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.00341209916377369*std::sin(0.400159865617752*x_31 + 5.20528030395508) + 0.00244947690239532*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.00641392408589639*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 0.00458924739868691*std::sin(0.327279835939407*x_32 + 8.2041597366333) - 0.00525996084861731*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00442977308627003*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.0242077360263569*std::sin(0.217040002346039*x_37 - 7.41472005844116) + 0.0299948668943041*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.0330316400127905*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.00182986612798776*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.00935337789902361*std::sin(0.231199979782104*x_40 + 1.97247982025146) - 0.00245159775413891*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.0305433240835869*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.00461461141032891*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.00312645523553366*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00580804066789502*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.0223640261810027*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.0325565573841476*std::sin(0.215999990701675*x_44 + 1.99159979820251) - 0.0019942387369346*std::sin(0.300399929285049*x_5 - 7.38207960128784) + 0.0255453790123344*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.0234788392928138*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.00484509809115202*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.020051267513422*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.0322941064195378*std::sin(0.0657600983977318*x_60 - 1.37215983867645) + 0.00233828899786811*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.00309188283760173*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.0171838964612717*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.00428217356726521*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 0.000924300603228133*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.0021691588505029*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00758617343583568*std::sin(0.27567994594574*x_92 - 7.38263988494873) - 0.00273539216336281*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.0136038223963425*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.00576156262540139*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.0050581294504242*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.0061533417388996*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.00382269237645479*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.0242358247427528*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.0031554327586016*std::sin(0.276959955692291*x_98 - 1.23423981666565) - 0.00473802414769036*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.189186081290245*std::sin(0.0396904089754351*x_100 + 0.0257424515730264*x_102 - 0.0691995292096926*x_103 - 0.0202989662896304*x_104 + 0.00203262930719234*x_105 + 0.00157631697195266*x_106 + 0.0335895915970994*x_107 + 0.0386549408234168*x_108 + 0.0199286084803748*x_11 + 0.0268786293768475*x_111 + 0.0641606626004475*x_112 + 0.0126479488600452*x_115 - 0.0616638830772129*x_117 - 0.0541758306127986*x_119 + 0.0091446076998069*x_12 + 0.016594533483447*x_120 + 0.00319884836789325*x_14 + 0.0161112456297078*x_16 - 0.0169952518079074*x_19 - 0.015260740172769*x_2 - 0.0119002692160634*x_22 + 0.00237116415783491*x_24 + 0.000268370649177566*x_26 - 0.0176254099502277*x_28 - 0.00566793910323547*x_31 + 0.0479001554881201*x_33 - 0.0388688984451342*x_35 - 0.0486149000194735*x_36 - 0.0153272813141076*x_37 - 0.0185432619095219*x_39 + 0.0179508079708114*x_4 + 0.0240544074307919*x_41 - 0.0495459808986016*x_43 - 0.028488116662057*x_44 + 0.0107176994335034*x_45 + 0.031813086990489*x_46 - 0.0350713400973999*x_47 + 0.0304071583922013*x_48 - 0.0363271837820431*x_49 + 0.012884619223775*x_5 + 0.0764373153326261*x_50 - 0.0706216033375399*x_51 + 0.0182719703653368*x_52 - 0.00813410594553088*x_53 + 0.00141478784572878*x_54 + 0.0484366647536593*x_55 - 0.00548944064220472*x_56 + 0.0555976238123868*x_57 + 0.0392448710470908*x_58 + 0.0338107340033799*x_59 + 0.0495414697597514*x_6 + 0.0311251663524853*x_61 + 0.0177941179082851*x_62 + 0.000772810699728153*x_63 - 0.0130216727584661*x_64 + 0.00263039027808321*x_65 + 0.0229234261810536*x_66 - 0.0273918575425476*x_67 - 0.00189747153600496*x_68 - 0.0208803753829387*x_69 + 0.00121987834971423*x_70 + 0.0091103199034722*x_71 + 0.00212026333051367*x_72 + 0.0243634541009169*x_73 - 0.0076152644840728*x_74 - 0.00870074042728851*x_75 - 0.0103138250580161*x_76 - 0.00351598520067346*x_77 - 0.000712262208808823*x_78 - 0.0141917425978143*x_79 - 0.000711021509430769*x_80 + 0.00479288157447296*x_81 - 0.0161926106290787*x_82 - 0.0108059524656129*x_83 - 0.00785399562102959*x_84 - 0.0171113742143962*x_85 + 0.000104731597909035*x_86 + 0.00114436557874069*x_87 + 0.00236010290089149*x_88 - 0.00511332210004856*x_89 + 0.00291192924679585*x_9 + 0.0166155414765537*x_90 - 0.0501639335828606*x_93 - 0.0216881377300108*x_94 - 0.00200875095433938*x_96 + 0.00491356681637168*x_98 - 0.0360380363915678*x_99 - 0.294345205429194*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.236138606964341*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.345244361558072*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.347339205577763*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.11145310188195*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.154618390455316*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.171200514363546*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.0919127895614298*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.425953534298472*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.504209081161576*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.357416727451954*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.241927787769317*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.187382289363882*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.334328873885397*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.154242313660205*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.185817358282693*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.277511184350489*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.326763896257512*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.341443083704442*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.236634014599653*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.361191055085117*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.258846437050781*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.300635093703631*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.153176934233585*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.416095758207264*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.332832629218608*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.279733393533428*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.38011213957593*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.128531718763869*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.413876311703829*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.161143642109116*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.0888443194938437*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.275278544642893*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 6.38708518883443) - 0.181790755046358);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000299773008968438*x_1 + 0.00591747171014718*x_10 - 5.57267902291667e-5*x_100 + 0.00275656325915962*x_101 + 0.0011248361239434*x_102 - 0.000824490507410649*x_103 + 0.00365394227083076*x_104 + 0.00602950626743597*x_105 - 0.00702994423186551*x_106 + 0.00456324805085707*x_107 - 0.00172252189364754*x_108 + 0.00119583823086086*x_109 + 0.00122974481371366*x_11 - 0.00230926563313229*x_110 + 0.000513677766263868*x_111 + 0.000167848324307549*x_112 + 0.00436073641550897*x_113 + 0.0114672999820884*x_114 - 0.00453373179695494*x_115 - 0.00109213323631176*x_116 + 0.000978024218107566*x_117 + 0.00323068670156323*x_118 + 0.00744872120697196*x_119 + 0.0077449082936372*x_12 + 0.00160230379527096*x_120 + 0.000246748832356156*x_13 + 0.00536280826737625*x_14 - 0.000757624150823644*x_15 - 0.001023554629486*x_16 - 0.000190513947401829*x_17 - 0.000164354277314403*x_18 + 0.000778960972237307*x_19 - 0.00236149457298339*x_2 + 0.000211594616641868*x_20 - 6.3824999150116e-5*x_21 - 8.41973655281772e-5*x_22 + 0.000456665047886904*x_23 - 0.000966620871118377*x_24 + 4.45585388665556e-5*x_25 + 1.89878911439556e-6*x_26 + 0.0038305268297677*x_27 - 0.000258841614806367*x_28 - 0.00267637733812971*x_29 - 0.000120956895737532*x_3 - 0.00260955640782113*x_30 + 2.74646647053499e-5*x_31 + 0.00210587191825018*x_33 + 0.00813488130733843*x_34 + 0.000221799061181293*x_35 + 0.0092528356428411*x_36 - 0.0021687363158363*x_37 - 0.000665519919207042*x_38 + 0.000609754425438886*x_39 + 0.000127006432611152*x_4 - 0.00387734726375766*x_40 + 0.000170190917385318*x_41 - 0.00514600105157234*x_42 - 0.00133890379862416*x_43 + 0.000975152599841798*x_44 - 0.00198633840114373*x_45 + 0.00838376170547519*x_46 - 0.000350977867108877*x_47 + 0.00110829738248439*x_48 - 0.00735225034066021*x_49 + 0.00193797902966219*x_5 - 0.000611529444423879*x_50 + 0.0028885646278296*x_51 + 0.00127228277731253*x_52 - 0.000471805466858287*x_53 - 0.00659800406911398*x_54 + 0.00746939577318907*x_55 + 0.00323284077532026*x_56 + 0.0070599946116332*x_57 + 0.00391723712367181*x_58 - 0.00146620288765059*x_59 + 0.000525105484857573*x_6 - 0.00784710534115261*x_60 - 0.00258437047725462*x_61 - 0.000536128510785617*x_62 + 0.00143763359076304*x_63 - 0.00360913906648969*x_64 + 1.59977845222251e-5*x_65 - 0.00244301584953386*x_66 + 4.29969933766733e-5*x_67 + 0.00327915106167568*x_68 - 0.00460503143043057*x_69 - 0.0024099317348912*x_7 + 0.000395886799459508*x_70 - 0.000844050222783348*x_71 + 0.000766289014789126*x_72 - 4.30673227434873e-5*x_73 - 0.000213694995180404*x_74 - 0.000371810168189597*x_75 + 0.000574799135438411*x_76 + 0.00243377487343486*x_77 - 0.00101547783345623*x_78 - 0.00200774909113291*x_79 - 0.00341321038797924*x_8 - 0.0016261969501633*x_80 + 0.00312097513638669*x_81 + 0.000945107633832091*x_82 - 0.00216348528030716*x_83 + 0.00304899601195271*x_84 + 0.00140974559366862*x_85 + 0.000447127046836846*x_86 - 0.00409396048956149*x_87 + 0.00327922558777616*x_88 + 0.00220308281283763*x_89 - 0.000270446001340896*x_9 - 0.00209303889376481*x_90 + 0.00109569726253873*x_91 + 0.000972821731240279*x_92 + 0.00255711955121414*x_93 - 0.000375887905576283*x_94 - 0.000168765716156922*x_95 - 0.00671634190187323*x_96 - 0.000198261358695051*x_97 + 7.34901620546885e-5*x_98 - 0.00225074919781621*x_99 - 3.07299485474866e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) - 2.07988604518058e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) - 0.0198516622596027*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.0256645213197004*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.00208256556242737*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.00167073939630319*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.0372988954553349*std::sin(0.237999975681305*x_100 - 1.19359982013702) - 0.00157043552769922*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.0137273275145891*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.00244268975590983*std::sin(0.237839981913567*x_101 + 1.98119974136353) + 0.0287345022374709*std::sin(0.233519986271858*x_102 + 1.97087979316711) - 0.00287294426369249*std::sin(0.235839992761612*x_102 + 1.95447981357574) - 0.00133105360136559*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00521479441449289*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.0170794956923437*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.00245751129855294*std::sin(0.248879969120026*x_109 + 1.95135986804962) - 0.0161771750321787*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.00314847615543619*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.0443668152273826*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00307498575789894*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.000788558425698202*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.00293590334428156*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00269449850794962*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.0430152779227768*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.00109396358201476*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.00121128623435024*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.000650305854339162*std::sin(0.231519982218742*x_116 - 1.19407987594604) + 0.0519333348618427*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.00301372723374499*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.00271122568808389*std::sin(0.25111997127533*x_12 - 4.21424007415771) + 0.000596773009438062*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.00356740469802843*std::sin(0.180880010128021*x_13 - 4.40488004684448) - 0.00873002069242359*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.0145363146279386*std::sin(0.313839942216873*x_13 - 4.26895999908447) + 0.000492186558433497*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.00252881227313208*std::sin(0.314319908618927*x_15 + 5.14832019805908) - 0.0262366445594081*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.0179364895296229*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.00171169929086485*std::sin(0.35607984662056*x_17 - 7.36687994003296) + 0.0128014446978923*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.0238326676957235*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.00329364426312215*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.00132577631855429*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.0017685706284967*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.185400299627047*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.0138529728614907*std::sin(0.412079870700836*x_2 + 5.19591999053955) - 0.000704804449072582*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.00642327108626721*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.00236545996481788*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.01888075120232*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.0133195554615384*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.0277391567869515*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.0200408454001392*std::sin(0.347679853439331*x_21 - 1.15399980545044) + 0.00185949885784871*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.00109130274512026*std::sin(0.380159854888916*x_21 - 1.18823993206024) + 0.077286152664831*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.0280174381818672*std::sin(0.231279984116554*x_22 - 1.16823983192444) + 0.00151121200602701*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.00164486311121576*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.00593934654453833*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00131470404179509*std::sin(0.328399837017059*x_23 - 1.17247986793518) - 0.00420637863740911*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.00196346067493798*std::sin(0.302319914102554*x_25 - 1.160719871521) - 0.00252600051732649*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.00660871970911896*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.0205305224298107*std::sin(0.373519837856293*x_25 + 8.2203197479248) + 0.0267381067204541*std::sin(0.202959999442101*x_26 - 1.17263984680176) - 0.0051877547975377*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.0281598750128563*std::sin(0.353839844465256*x_26 - 1.16007995605469) + 0.00109375007398287*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00577768932917217*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.00231193586591029*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.0111727646641247*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.0251573763439897*std::sin(0.313359916210175*x_28 - 1.17319989204407) + 0.00201159142775183*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.00241579476932548*std::sin(0.328719854354858*x_29 - 1.16823983192444) - 0.034728691794477*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00167424452858201*std::sin(0.280079960823059*x_3 - 1.11783981323242) - 0.0015399975365398*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.0090475164997881*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.00255551658020134*std::sin(0.256079971790314*x_30 - 1.17471981048584) + 0.0160665237200911*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.0249718946537307*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.00403809282982829*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00183140294394453*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.0028988650803024*std::sin(0.299599945545197*x_32 + 2.03711986541748) + 0.00282978431526576*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 0.00664527571078591*std::sin(0.327279835939407*x_32 + 8.2041597366333) + 0.00253822917449125*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.00212706808691307*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.00622496860978918*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00524247217881261*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.0350530416545192*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.00108376492060715*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.0434328644993091*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.0478301420680057*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.0189297707867737*std::sin(0.210559993982315*x_4 - 1.200159907341) - 0.000807325811573302*std::sin(0.269039958715439*x_4 - 4.17000007629395) - 0.00412665346813367*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.0029439810152539*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.00290137502969363*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.0442270359443678*std::sin(0.244559973478317*x_41 + 1.98751986026764) + 0.00203593850116019*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.0213894478173743*std::sin(0.261039972305298*x_41 + 1.96215975284576) - 0.00370004383325858*std::sin(0.246239975094795*x_42 + 5.17119979858398) - 0.002562472234521*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.00235487366152995*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.032383331528067*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.0471422177138643*std::sin(0.215999990701675*x_44 + 1.99159979820251) + 0.0279657416923469*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.01614092901321*std::sin(0.243039980530739*x_48 - 7.61728000640869) - 0.00236010759302644*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.0271868721405969*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 0.036989961953687*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.0339975919612926*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.0406660667036159*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.0306752220513974*std::sin(0.224399983882904*x_57 - 4.2163200378418) + 0.00573399392063899*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.0290344340589567*std::sin(0.351439833641052*x_6 + 2.03335976600647) + 0.0142479634304496*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.00197918335779993*std::sin(0.381999850273132*x_60 + 8.21647930145264) - 0.00956979542855991*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.00679371579982014*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.00268938796059936*std::sin(0.326159834861755*x_7 - 7.3583197593689) + 0.00276727831846327*std::sin(0.346639841794968*x_7 + 8.22824001312256) - 0.00136411991182181*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.0248824523610171*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.000909393889351542*std::sin(0.360239863395691*x_8 - 7.56568002700806) + 0.00188926894575167*std::sin(0.330639839172363*x_9 - 1.10911989212036) + 0.000407795807149798*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.00256711906089119*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00292827787903681*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.00114013136096859*std::sin(0.261199980974197*x_92 + 5.20943975448608) + 0.00334697360213819*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.00956248766194492*std::sin(0.343999862670898*x_92 - 1.3698399066925) + 0.00120683839352039*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.0196984696379903*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.0252207274768116*std::sin(0.281039953231812*x_94 + 1.98919987678528) - 0.00254196640472143*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.000628595665165956*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.00732422156812294*std::sin(0.294399946928024*x_95 - 4.4191198348999) - 0.0027148169678991*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.00452401467105344*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.00194766419351893*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 0.0139880290207558*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.0350937143942077*std::sin(0.247999966144562*x_98 - 7.41847991943359) + 0.00139215775063522*std::sin(0.276959955692291*x_98 - 1.23423981666565) + 0.0282107422905663*std::sin(0.280639946460724*x_98 + 8.17799949645996) - 0.00560727587916338*std::sin(0.250319957733154*x_99 + 1.95055973529816) - 0.469957009178019);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.68182075795455e-5*x_1 + 0.00394720669396463*x_10 + 0.000403303324212119*x_100 + 0.00153473198249056*x_101 + 0.000101748110594046*x_102 + 0.00118242152406723*x_103 + 0.000810800353792237*x_104 + 0.00151462761652156*x_105 - 0.00342145883384814*x_106 + 0.00398317123258817*x_107 - 5.17552893368784e-5*x_108 + 0.000494277460501178*x_109 + 3.01931030427147e-5*x_11 - 0.000234165615723074*x_110 - 0.00212176234424045*x_111 + 0.000254314577919616*x_112 + 0.000448864643264117*x_113 + 0.00342472249759844*x_114 - 0.00441101053779076*x_115 - 0.00100496689446093*x_116 - 0.000682729965619111*x_117 - 0.000767372993587912*x_118 + 0.00216954753276465*x_119 + 0.00577652933248593*x_12 - 0.00328287196226895*x_120 + 0.00013654566092187*x_13 + 0.00490985401531686*x_14 + 7.39074479968587e-6*x_15 + 0.000238059902063889*x_16 - 3.1276134067477e-5*x_17 - 0.000120996088401256*x_18 + 0.000400535840289627*x_19 - 0.00163831655240157*x_2 + 0.000132291387430723*x_20 + 4.08237100727073e-5*x_21 + 0.000525948299320482*x_23 + 0.000149139590992318*x_24 - 2.85005075781254e-5*x_25 + 0.000474749816419394*x_27 + 0.000154723536770208*x_28 - 8.43738194817814e-5*x_29 - 5.87105353731161e-5*x_3 - 1.32633089083862e-5*x_30 + 4.22435053310006e-5*x_31 + 0.00324518474948896*x_33 + 0.00472295518180876*x_34 + 0.00285320031128298*x_35 + 0.00440329907104804*x_36 + 0.000200633361287857*x_37 - 0.000700782770577908*x_38 - 0.00188859169880398*x_39 + 0.00126913884827496*x_40 - 0.000278301989557505*x_42 - 0.00387047900484284*x_43 + 6.78304649710649e-5*x_44 - 0.000985345947848464*x_45 + 0.00373130753853073*x_46 + 0.00119093927463368*x_47 + 0.00109027675441432*x_48 - 0.00139679928128448*x_49 + 0.00134973014728622*x_5 - 0.00328702254953177*x_50 - 0.000550289960916929*x_51 + 0.00077469940241508*x_52 - 6.41447371746357e-5*x_53 - 0.004773233904487*x_54 + 0.00409188697988901*x_55 + 0.00133095608220256*x_56 + 0.00488763441927637*x_57 + 0.00360819692023327*x_58 + 0.000374620274686077*x_59 + 0.000459434347316748*x_6 - 0.00589863610565175*x_60 - 0.00289796263825776*x_61 + 0.00116567348494439*x_62 + 0.000319270346566882*x_63 - 0.00171337515904805*x_64 + 0.00111276748754583*x_65 - 0.00184927647496219*x_66 + 0.000685261034874962*x_67 + 0.00101582551792152*x_68 - 0.00189712412715472*x_69 - 0.00178662224892907*x_7 - 0.000351118864380127*x_70 - 0.000607102404251539*x_71 - 0.000316905818862775*x_72 - 0.000357761805338544*x_73 - 0.00100188661442119*x_74 - 0.00064897152355957*x_75 + 0.000352770282638329*x_76 + 0.000471158966549715*x_77 - 0.000939395781336993*x_78 - 0.000231818296913791*x_79 + 0.00022981378040043*x_8 - 0.00086845689451895*x_80 + 0.00044324800398861*x_81 + 0.000502671919652204*x_82 - 0.000409856983629616*x_83 + 0.00213548115410462*x_84 + 0.000689884506512975*x_85 - 3.90853400453739e-5*x_86 - 0.00202593342710693*x_87 + 0.00222686147344241*x_88 + 0.00213045136673543*x_89 - 0.00109168027520013*x_9 - 0.00163590478970576*x_90 - 0.000608458942874352*x_91 + 0.00078128339176549*x_92 + 0.00104851486629087*x_93 + 4.49806776365469e-5*x_94 + 0.00013822304580169*x_95 - 0.00312386708865043*x_96 - 0.000146476688307038*x_97 - 2.47695533186112e-5*x_98 + 0.00141029625248942*x_99 - 1.6619129561103e-7*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) + 1.33033554286491e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) - 0.00107360201591545*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.0188939815933969*std::sin(0.406479865312576*x_1 - 0.994959831237793) + 0.0274590994863473*std::sin(0.237999975681305*x_100 - 1.19359982013702) - 0.000981854350205245*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.000742390551484702*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.00155399679508214*std::sin(0.233519986271858*x_102 + 1.97087979316711) - 0.00179619778937142*std::sin(0.235839992761612*x_102 + 1.95447981357574) - 0.000832190017231622*std::sin(0.25791996717453*x_103 + 1.94479978084564) + 0.00333548387153632*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.0009236798796156*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.0119094856079207*std::sin(0.258959978818893*x_11 - 7.41095972061157) + 0.00201382654840389*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.0326624362021647*std::sin(0.199520006775856*x_110 - 4.20688009262085) - 0.00196682066164888*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00183556053051614*std::sin(0.269279956817627*x_112 - 7.43856000900269) - 0.00172345362075383*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.0316674470247741*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.0382328374934534*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.00169508947631452*std::sin(0.25111997127533*x_12 - 4.21424007415771) + 0.000373109347736344*std::sin(0.27295994758606*x_120 - 7.44464015960693) + 0.0055838909270959*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.000786141557540704*std::sin(0.313839942216873*x_13 - 4.26895999908447) + 0.000307720695938709*std::sin(0.272559970617294*x_14 + 5.15696001052856) - 0.00141890961681117*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.0132046765572329*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.000692317683756645*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.0175453880146556*std::sin(0.451359868049622*x_17 + 1.96111989021301) - 0.00210667889182557*std::sin(0.338479846715927*x_18 + 4.99368000030518) + 0.00110573069356038*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.136489974035666*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.000749185604511492*std::sin(0.412079870700836*x_2 + 5.19591999053955) + 0.00045080662546066*std::sin(0.42103984951973*x_2 + 5.20783996582031) + 0.00410844904090688*std::sin(0.269679963588715*x_20 - 4.3887996673584) - 0.00102109396622459*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.00980573269174358*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.0204213089042384*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.0010838332700241*std::sin(0.347679853439331*x_21 - 1.15399980545044) + 0.00116258006812625*std::sin(0.364559859037399*x_21 - 4.36879968643188) + 0.00417972904325303*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.0206261770756656*std::sin(0.231279984116554*x_22 - 1.16823983192444) + 0.000944827123450179*std::sin(0.327679842710495*x_22 - 7.36279964447021) + 0.00105208641842092*std::sin(0.504719853401184*x_22 + 8.14903926849365) + 0.0037989214975983*std::sin(0.311679929494858*x_23 - 7.36215972900391) + 0.00269048153914949*std::sin(0.345839858055115*x_24 - 7.36495971679688) - 0.00157928456967049*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.000357407591845272*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.0151143794212872*std::sin(0.373519837856293*x_25 + 8.2203197479248) + 0.00144602929978602*std::sin(0.202959999442101*x_26 - 1.17263984680176) + 0.00331818880694166*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.0207310377441895*std::sin(0.353839844465256*x_26 - 1.16007995605469) + 0.000683825123181417*std::sin(0.387359857559204*x_26 + 8.2052001953125) + 0.00369552240039271*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.00822528529878661*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.0185206261850922*std::sin(0.313359916210175*x_28 - 1.17319989204407) + 0.00125767009172758*std::sin(0.182880014181137*x_29 - 4.61615991592407) - 0.0255669394863766*std::sin(0.345119833946228*x_29 - 1.17687976360321) - 0.00096282416812883*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.000489300685563606*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.000868897124536732*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.0183840762920313*std::sin(0.384479850530624*x_31 + 5.18416023254395) - 0.00258284266551829*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00185417045286315*std::sin(0.299599945545197*x_32 + 2.03711986541748) + 0.00176921369332292*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 0.00489219009381089*std::sin(0.327279835939407*x_32 + 8.2041597366333) + 0.000137270517851524*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.00398161092239162*std::sin(0.234959989786148*x_35 + 1.98535978794098) - 0.00335318710758951*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.0258057228328151*std::sin(0.217040002346039*x_37 - 7.41472005844116) + 0.0319748703736208*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.0352121051698232*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.00102374500491347*std::sin(0.210559993982315*x_4 - 1.200159907341) - 0.000504749380757799*std::sin(0.269039958715439*x_4 - 4.17000007629395) - 0.00258003120027009*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.00185577586528162*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.0325595319957109*std::sin(0.244559973478317*x_41 + 1.98751986026764) + 0.00127289216198715*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.001156767327378*std::sin(0.261039972305298*x_41 + 1.96215975284576) + 0.00236661995639027*std::sin(0.246239975094795*x_42 + 5.17119979858398) - 0.00160208710664528*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.0238403070995329*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.034705661666635*std::sin(0.215999990701675*x_44 + 1.99159979820251) + 0.00151242129071338*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.000872921053195332*std::sin(0.243039980530739*x_48 - 7.61728000640869) + 0.00150957069175192*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.00147029907898325*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 0.0272316655193931*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.0250287105975909*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.00219927029895117*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.00165895328070594*std::sin(0.224399983882904*x_57 - 4.2163200378418) - 0.00366757396775315*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.0213748799695528*std::sin(0.351439833641052*x_6 + 2.03335976600647) + 0.00890799057268368*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.000517546164630648*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.000367412405211326*std::sin(0.314079910516739*x_7 + 4.82047986984253) - 0.00177000500223631*std::sin(0.346639841794968*x_7 + 8.22824001312256) - 0.000852863454755186*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.0183182297090714*std::sin(0.319439917802811*x_8 + 1.98247981071472) + 0.00118119266940657*std::sin(0.330639839172363*x_9 - 1.10911989212036) + 0.000254958627834976*std::sin(0.252399981021881*x_91 - 1.34951984882355) - 0.00164197925044159*std::sin(0.360639840364456*x_91 - 7.3983998298645) + 0.00209256638258563*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.00051715095173275*std::sin(0.343999862670898*x_92 - 1.3698399066925) + 0.000754529240948029*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.0145018299044832*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.00136396758658642*std::sin(0.281039953231812*x_94 + 1.98919987678528) - 0.00158926662606002*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.00539202371126441*std::sin(0.294399946928024*x_95 - 4.4191198348999) - 0.00169733478575076*std::sin(0.282319933176041*x_96 + 1.95719981193542) - 0.00289364772040776*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.000756489605705581*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.0258356657250068*std::sin(0.247999966144562*x_98 - 7.41847991943359) + 0.000870393033985753*std::sin(0.276959955692291*x_98 - 1.23423981666565) + 0.00152567122075496*std::sin(0.280639946460724*x_98 + 8.17799949645996) + 0.00358652264530794*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.119112335145473*std::sin(0.0400663672778103*x_100 + 0.0259862910456396*x_102 - 0.0698550058902917*x_103 - 0.020491243595489*x_104 + 0.00205188292244642*x_105 + 0.00159124827319341*x_106 + 0.0339077613051047*x_107 + 0.039021090891041*x_108 + 0.0201173776567675*x_11 + 0.0271332310333068*x_111 + 0.0647684097719484*x_112 + 0.0127677536568387*x_115 - 0.0622479800769168*x_117 - 0.0546889987517201*x_119 + 0.00923122790039074*x_12 + 0.0167517213985679*x_120 + 0.00322914872591409*x_14 + 0.016263855711399*x_16 - 0.0171562354355161*x_19 - 0.0154052940364466*x_2 - 0.0120129917887899*x_22 + 0.0023936244668729*x_24 + 0.000270912728644033*x_26 - 0.0177923626064137*x_28 - 0.00572162735735595*x_31 + 0.048353878732745*x_33 - 0.0392370751772931*x_35 - 0.0490753935178594*x_36 - 0.015472465473496*x_37 - 0.0187189087080298*x_39 + 0.0181208428851693*x_4 + 0.0242822572921506*x_41 - 0.0500152938472206*x_43 - 0.0287579638179471*x_44 + 0.0108192203849978*x_45 + 0.0321144291657652*x_46 - 0.0354035453284723*x_47 + 0.030695183231055*x_48 - 0.0366712847045915*x_49 + 0.0130066658263464*x_5 + 0.0771613502834466*x_50 - 0.07129055028939*x_51 + 0.0184450474168697*x_52 - 0.00821115439984423*x_53 + 0.00142818909934223*x_54 + 0.0488954699593395*x_55 - 0.00554143811056314*x_56 + 0.0561242595615306*x_57 + 0.0396166090935526*x_58 + 0.034130998432145*x_59 + 0.0500107399776415*x_6 + 0.0314199923571826*x_61 + 0.0179626686119376*x_62 + 0.000780130971960849*x_63 - 0.0131450175692336*x_64 + 0.00265530604713322*x_65 + 0.0231405630817337*x_66 - 0.0276513206351797*x_67 - 0.00191544490024828*x_68 - 0.0210781599531805*x_69 + 0.00123143336779799*x_70 + 0.00919661532076369*x_71 + 0.00214034703896883*x_72 + 0.024594231336028*x_73 - 0.00768739833155577*x_74 - 0.00878315619686336*x_75 - 0.0104115204020527*x_76 - 0.00354928956465821*x_77 - 0.000719008949338394*x_78 - 0.0143261706269667*x_79 - 0.000717756497719837*x_80 + 0.00483828104670666*x_81 - 0.0163459914220784*x_82 - 0.0109083093737272*x_83 - 0.00792839079449259*x_84 - 0.0172734577848863*x_85 + 0.000105723643966794*x_86 + 0.00115520531940817*x_87 + 0.00238245843470822*x_88 - 0.00516175687171901*x_89 + 0.00293951182920108*x_9 + 0.0167729283850745*x_90 - 0.0506390999466526*x_93 - 0.0218935736439542*x_94 - 0.00202777838736874*x_96 + 0.00496010945189942*x_98 - 0.0363793984317296*x_99 - 0.297133322926646*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.238375375798205*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.348514609646378*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.350629296595928*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.112508815845591*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.156082977721916*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.17282217199841*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.0927834123950588*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.429988281527827*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.508985086123204*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.360802275486405*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.244219393291534*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.189157225153735*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.337495727518444*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.155703338625557*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.187577470621547*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.280139845441463*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.329859092373797*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.344677325059495*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.238875476068801*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.364612354573035*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.261298300600732*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.303482790726184*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.154627867636492*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.420037129911899*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.335985310016973*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.282383103991579*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.383712664700164*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.129749206011676*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.417796660210135*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.162670038326485*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.0896858769480202*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.277886057565935*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 6.54837942091784) - 0.250236674082537);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000167277559715492*x_1 + 0.00107279208922037*x_10 + 0.000833905130861764*x_100 + 0.00118731996836397*x_101 + 0.00235964588927933*x_102 - 0.000182113508021047*x_103 - 0.00216848207018296*x_104 - 0.00279119931628903*x_105 + 0.0024857417469482*x_106 + 0.00815937810979781*x_107 + 0.00398321894285716*x_108 + 0.00122128671882056*x_109 - 2.09128604627806e-5*x_11 + 0.00228051216919786*x_110 - 0.0035675516807456*x_111 + 0.00431303916590998*x_112 - 0.00501938354723408*x_113 - 0.000257404999623198*x_114 + 2.85633771700748e-5*x_115 - 0.00360975200700108*x_116 - 0.0021223836370742*x_117 - 0.00323949817315751*x_118 - 0.0057264119328682*x_119 + 0.00639658290745904*x_12 - 0.00486925976755554*x_120 - 0.000446780827482152*x_13 + 0.0018751003040603*x_14 - 0.000299381717064515*x_15 + 0.00393674651997*x_16 - 7.58296386563894e-6*x_17 - 8.24024451363221e-5*x_18 - 0.00218006051842032*x_19 - 0.00168533679948486*x_2 - 0.000190900125721605*x_20 - 0.000107359366400412*x_21 - 0.000637359863442069*x_22 + 0.00044007305446157*x_23 + 0.00166452875894803*x_24 + 7.4951454197283e-5*x_25 + 1.43735135068025e-5*x_26 - 0.00376876564126469*x_27 - 0.00125498657596765*x_28 + 0.00243069865069524*x_29 - 8.66792750352599e-5*x_3 - 0.000825709443312958*x_30 - 0.000364524525389134*x_31 + 0.00530728852291164*x_33 + 0.00412177573533912*x_34 + 0.00327699474028113*x_35 - 0.00354437187752565*x_36 - 2.49032771017123e-5*x_37 + 0.00318579312669369*x_38 - 0.00167461188821467*x_39 + 0.000961417284703739*x_4 + 0.00348296994911983*x_40 + 0.00128831655460153*x_41 + 0.00512160574971445*x_42 - 0.00715101562556182*x_43 - 0.00278402337835429*x_44 + 0.00547750015756081*x_45 - 0.000822345160187204*x_46 - 0.00260149631369904*x_47 + 0.00190833342736022*x_48 + 0.00196794757911199*x_49 + 0.00149107390765134*x_5 + 0.000972140420413103*x_50 - 0.0042216754700732*x_51 + 0.000331847279483106*x_52 + 0.000303805724247201*x_53 - 0.00230880345046776*x_54 + 0.0063048388350585*x_55 + 0.00409190859407374*x_56 + 0.00606375768313416*x_57 + 0.00846200350829111*x_58 + 0.0022632114877906*x_59 + 0.00202407521807172*x_6 - 0.0038298926857997*x_60 + 0.000659379343718172*x_61 + 0.00305391074377394*x_62 - 0.00162449264637785*x_63 - 0.000901804486895149*x_64 + 0.000912579819930465*x_65 + 0.00161377339463461*x_66 - 0.00115142283821831*x_67 - 0.000428791593095743*x_68 - 0.00193903328271587*x_69 - 0.00136576360992209*x_7 + 0.000187708578042152*x_70 - 0.00196703484436704*x_71 - 0.000138397885830139*x_72 + 0.00141608471557561*x_73 - 0.00268689302211545*x_74 + 0.000101255641015464*x_75 - 0.00185528724363908*x_76 - 0.000972127889566773*x_77 - 0.000801942752403657*x_78 + 0.000546230918714709*x_79 + 0.00179762929877107*x_8 + 0.000708375012103127*x_80 - 0.000635266248461387*x_81 + 0.00086072856598063*x_82 - 0.000878227089574417*x_83 + 0.000817793551651286*x_84 + 0.000486826578524307*x_85 - 0.00212602428456648*x_86 + 0.000850232038825319*x_87 + 0.00186213305203792*x_88 + 0.000251244300258929*x_89 - 0.000721595245043401*x_9 - 0.000843939307303353*x_90 - 0.00255555126335847*x_91 + 0.000431874780967971*x_92 - 0.00467507150836208*x_93 - 0.00133695190208376*x_94 - 0.000400734450907561*x_95 - 0.000928922197755934*x_96 - 0.000105960287709612*x_97 + 0.000328302660515513*x_98 + 0.00302963798324131*x_99 + 3.058426914257e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) - 3.49855465678043e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) + 0.0197575528164933*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.0128674430903372*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.0157646702382115*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.0126472155844202*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.0187005792403208*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.00141684294446334*std::sin(0.239599987864494*x_100 - 1.19783997535706) + 0.0136622512942261*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.0184907496747866*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.0285982825109698*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.00259196301793597*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.00120087317851266*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00877175137803895*std::sin(0.25639995932579*x_108 + 1.9586398601532) + 0.0169985280732508*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.0186029462540472*std::sin(0.248879969120026*x_109 + 1.95135986804962) - 0.00811076413606043*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.0052960189530033*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.0222442282451468*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00517240152063082*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00596925435096781*std::sin(0.23191998898983*x_110 + 1.94151985645294) - 0.00264876454053857*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00453238787986417*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.0215666068262687*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.00828111990048176*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.00916923260094595*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.00492270569176513*std::sin(0.231519982218742*x_116 - 1.19407987594604) + 0.0260378606911024*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.0228134071191163*std::sin(0.232879981398582*x_118 + 5.16504001617432) + 0.00244606092975831*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.00053840709341773*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.027004652187331*std::sin(0.180880010128021*x_13 - 4.40488004684448) - 0.0146846768927748*std::sin(0.208959996700287*x_13 + 8.18591976165771) + 0.0144674032966552*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 0.000444049462952393*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.0191426826120196*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.0261122662591804*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.00899283315624088*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.0129572750814205*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.0127407577480662*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.011949005066003*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.00554020471516926*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.0100359032381566*std::sin(0.380239844322205*x_18 - 1.16895985603333) - 0.00159559992917492*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.0929543074139184*std::sin(0.110080063343048*x_19 + 1.72039985656738) + 0.0137873010026632*std::sin(0.412079870700836*x_2 + 5.19591999053955) - 0.00118554422399058*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.0108045174026216*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.017906133175265*std::sin(0.33519983291626*x_20 - 1.15567982196808) + 0.018791244492106*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.00667803695829605*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.0139076048558932*std::sin(0.272719949483871*x_21 + 2.00431990623474) + 0.0199458391092108*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.00167763514675477*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.00826097781374207*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.0769197673872537*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.0140471270378023*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.00136341163362789*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.00276680710986291*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.00999051297054271*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00995208796960319*std::sin(0.328399837017059*x_23 - 1.17247986793518) - 0.00707550570099224*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.0148630663180732*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.00227895125113997*std::sin(0.328959852457047*x_25 - 1.15583980083466) + 0.00657739019507837*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.0102934056587176*std::sin(0.373519837856293*x_25 + 8.2203197479248) - 0.0266113511722106*std::sin(0.202959999442101*x_26 - 1.17263984680176) - 0.00872626831994769*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.0141185407140556*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.000986778538816715*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00971859105206456*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.017500964769382*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.00560169861290183*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.0126131753784162*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.0018148526770333*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.0182871591601767*std::sin(0.328719854354858*x_29 - 1.16823983192444) - 0.0174119540240274*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.0126737488448917*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.0013893818661464*std::sin(0.318319916725159*x_3 - 4.14279985427856) - 0.00900462554545977*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.0193448297148441*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.0159903582292506*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.0125201802641113*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.0067924338965796*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.0138634115561402*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.00487615076295665*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.00255302422208397*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 0.00333174758893716*std::sin(0.327279835939407*x_32 + 8.2041597366333) - 0.00252619636177403*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.0161015468465364*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.0104709548720488*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00881830785716644*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.0175745735918527*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.00820391775286981*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.0217759725666963*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.0239806393969398*std::sin(0.185760006308556*x_4 - 1.18887984752655) - 0.0188400316927051*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.000728367296737479*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.00372305627798443*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.0222854400026368*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.00488037272268915*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.0221741469860033*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.00183681854482509*std::sin(0.25927996635437*x_41 - 7.43383979797363) + 0.0212880482974657*std::sin(0.261039972305298*x_41 + 1.96215975284576) - 0.00622380519987317*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00231185594176118*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.0178259966439659*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.0162360587334652*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.0236357341728327*std::sin(0.215999990701675*x_44 + 1.99159979820251) - 0.0278331663773738*std::sin(0.169440016150475*x_47 - 7.37831974029541) + 0.0160644107941895*std::sin(0.243039980530739*x_48 - 7.61728000640869) - 0.00396991240420031*std::sin(0.300399929285049*x_5 - 7.38207960128784) + 0.027057989160241*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 0.0185456889853406*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.0170454018729209*std::sin(0.292639940977097*x_53 + 8.14832019805908) - 0.0404732838101292*std::sin(0.18520000576973*x_55 + 8.21592044830322) + 0.0305298020847084*std::sin(0.224399983882904*x_57 - 4.2163200378418) + 0.00964509146041247*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.0145570191339199*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.0128544764196589*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.0149820843768803*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.00952442854156198*std::sin(0.484079837799072*x_60 - 7.69736051559448) - 0.00676150928722671*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.020358213497033*std::sin(0.326159834861755*x_7 - 7.3583197593689) + 0.00465481004120428*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.00123070551982371*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.0124753365050158*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.0068839584409346*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.0017044936444501*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 0.000367912341481736*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.00431812423848967*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.0221665699086362*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.00863060220440957*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.00301963108313149*std::sin(0.27567994594574*x_92 - 7.38263988494873) - 0.00951715541838578*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.00108880653347925*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.00987623863605866*std::sin(0.27991995215416*x_94 + 1.96287977695465) - 0.0251011652665232*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.00229335563419717*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.00475836321952821*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.00367215125639221*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.00244930097328638*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.00760979796534134*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.0147434896166295*std::sin(0.276399940252304*x_97 + 1.96775984764099) + 0.0139217169102571*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.0175949657182731*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.00125600118679005*std::sin(0.276959955692291*x_98 - 1.23423981666565) - 0.0280770055176982*std::sin(0.280639946460724*x_98 + 8.17799949645996) - 0.00943194036248099*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.0350818672000551);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.13735445846061e-6*x_1 + 0.00255084931342308*x_10 + 0.000884438844867133*x_100 + 0.000209590184916989*x_101 + 0.000816637808451244*x_102 - 0.00449770123399504*x_103 + 0.00364776149548048*x_104 + 0.00584862890915124*x_105 - 0.00586027124060035*x_106 - 0.00155984247459041*x_107 - 0.00246944943772269*x_108 + 0.000463451941738583*x_109 + 0.00211685979178814*x_11 - 0.00299923437337507*x_110 + 0.00442089582387675*x_111 + 0.000337958114750447*x_112 + 0.00656126629177882*x_113 + 0.00819374979008056*x_114 - 0.00172291460027688*x_115 + 0.00156431498584916*x_116 + 0.000240656127037118*x_117 + 0.00444177825851626*x_118 + 0.0066699027333361*x_119 + 0.000219575992116781*x_12 + 0.00730860156517814*x_120 - 0.00030746203071179*x_13 + 0.00076499609135724*x_14 + 6.77800521549158e-5*x_15 - 0.00290593517455904*x_16 + 4.84975434032477e-5*x_17 - 2.68645775179498e-5*x_18 + 0.000211354165311878*x_19 - 0.000513447636206534*x_2 - 0.000146468561554253*x_20 - 3.24512898936702e-5*x_21 - 0.000237630496524842*x_22 - 0.00048046604562985*x_23 - 0.00169093526095769*x_24 + 2.26554184293215e-5*x_25 + 5.35895864697549e-6*x_26 + 0.0046469037496654*x_27 - 0.000557278585070674*x_28 - 0.0038729982977603*x_29 - 2.73780433224724e-5*x_3 - 0.00154785654191282*x_30 - 0.000159950812114842*x_31 - 0.00131191328576804*x_33 + 0.00150638363220442*x_34 - 0.00581206603601191*x_35 + 0.00581132983304282*x_36 - 0.00285126636038646*x_37 - 0.00185911484168778*x_38 + 0.00205734788684187*x_39 + 0.000358450664743623*x_4 - 0.00659487880716103*x_40 + 0.000480330375524126*x_41 - 0.00760914120207861*x_42 + 0.00269700108552433*x_43 + 0.00126863261963243*x_44 - 0.00416935800341175*x_45 + 0.00726062517850425*x_46 - 0.00078984219653056*x_47 + 0.000764532656099703*x_48 - 0.00860246015951289*x_49 + 0.000482986416501971*x_5 + 0.00413539674977603*x_50 + 0.00244229064606698*x_51 + 0.000252107603034898*x_52 - 0.00104800405147455*x_53 - 0.00178187448569808*x_54 + 0.00191857249595542*x_55 - 3.08783283829209e-5*x_56 + 0.00204357501451265*x_57 - 0.00160690443447321*x_58 - 0.00163243801378732*x_59 + 0.000220618780055077*x_6 - 0.00125214196224189*x_60 + 0.000731296054568626*x_61 - 0.00248549247242024*x_62 + 0.00208062594287759*x_63 - 0.00261118494711826*x_64 - 0.000871456506394299*x_65 - 0.000942745004133881*x_66 - 0.00114264119755136*x_67 + 0.00243902188370838*x_68 - 0.00266281369972224*x_69 - 0.000489930457101381*x_7 + 0.000887045606057496*x_70 + 0.000939350833917775*x_71 + 0.00119214377978024*x_72 + 0.000460518223791023*x_73 + 0.00186907866931126*x_74 - 0.000336064749915413*x_75 + 0.00107357230484819*x_76 + 0.00266030843431642*x_77 - 5.59682195696099e-5*x_78 - 0.00243821373629723*x_79 - 0.00446736215970587*x_8 - 0.00141224672427037*x_80 + 0.00324643416128994*x_81 - 0.000481249551314427*x_82 - 0.00202700162070031*x_83 + 0.000466671567403115*x_84 - 0.000312996183006284*x_85 + 0.00168584152856015*x_86 - 0.00258689652965612*x_87 + 0.000650988039408947*x_88 + 0.000128262035484118*x_89 + 0.0010464505541767*x_9 + 0.000641523207783839*x_90 + 0.00290759690879423*x_91 + 0.00014268867348853*x_92 + 0.00216053497914514*x_93 - 0.000453817836577176*x_94 - 4.34618184843429e-5*x_95 - 0.00383846745372506*x_96 - 3.64047650022904e-5*x_97 + 0.000117806181980943*x_98 - 0.00692785046841735*x_99 - 4.54388787112647e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) - 1.05750075827195e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) - 0.0293536864286373*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.0041950020025049*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.00587763150949822*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.00471533319144383*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.00609670210393691*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.00108707601547877*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.0202979308280111*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.00689401118326848*std::sin(0.237839981913567*x_101 + 1.98119974136353) + 0.0424883094086337*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.00198868960093062*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.000921372714664099*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00265141884111241*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.0252546186992379*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.00693584207091507*std::sin(0.248879969120026*x_109 + 1.95135986804962) - 0.00264424497965483*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.00160081651083237*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.00725199104262147*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00156345092952977*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00222555099036681*std::sin(0.23191998898983*x_110 + 1.94151985645294) - 0.00203227070009566*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00136999535235209*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.00703107510857173*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.00308749694890709*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.00341861704931879*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.00183536031193175*std::sin(0.231519982218742*x_116 - 1.19407987594604) + 0.00848877877083005*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.00850565210030943*std::sin(0.232879981398582*x_118 + 5.16504001617432) + 0.00187674588741883*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.000413094083649293*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.0100682977950641*std::sin(0.180880010128021*x_13 - 4.40488004684448) - 0.00443870640093949*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.0214941406838674*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 0.000340697974146043*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.00713707504163404*std::sin(0.314319908618927*x_15 + 5.14832019805908) - 0.038794848877904*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.00293181425662977*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.00483093443408643*std::sin(0.35607984662056*x_17 - 7.36687994003296) + 0.0189288729871326*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.00389557582092325*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.00167462602761361*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.00374174278354945*std::sin(0.380239844322205*x_18 - 1.16895985603333) - 0.00122422772409872*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.0303046613849546*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.0204837164849468*std::sin(0.412079870700836*x_2 + 5.19591999053955) - 0.000358351959259859*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.00326585875223954*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.00667604529456681*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.0279180475207778*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.00217715191869712*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.00453411216283762*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.0296334223274387*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.00128716943390793*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.00307998726035038*std::sin(0.380159854888916*x_21 - 1.18823993206024) + 0.11427927097147*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.00457959873141178*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.00104608071906163*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.000836316966208218*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.00301981134449308*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00371049346110992*std::sin(0.328399837017059*x_23 - 1.17247986793518) - 0.00213869822769683*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.00554148140105845*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.0017485306012502*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.00977199206290119*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.00335582267959219*std::sin(0.373519837856293*x_25 + 8.2203197479248) + 0.039536336559826*std::sin(0.202959999442101*x_26 - 1.17263984680176) - 0.00263767077279888*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.00460288078619029*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.000757108108791229*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00293761807807545*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.00652498405744059*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.00182624758730806*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.00411210646893289*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.00139244990035053*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.00681810537581267*std::sin(0.328719854354858*x_29 - 1.16823983192444) - 0.00567658869641085*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00472522573758913*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.0010660064398323*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.0133781221350487*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.00721244269367886*std::sin(0.256079971790314*x_30 - 1.17471981048584) + 0.02375678636431*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.00408178850381788*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.00205313470870717*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00516877444058454*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.0014739038360545*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.00195881372004505*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 0.00108620552733806*std::sin(0.327279835939407*x_32 + 8.2041597366333) + 0.00375315589685668*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.0060032311280113*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.00316503350764085*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00266549137014505*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.00572960539972045*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.00305871323389445*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.00709933184724026*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.00781809016641813*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.0279905303936021*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.000558841487573859*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.00285652351228492*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.00830880712271662*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.00147517999894361*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.00722914337814134*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.00140930326305311*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.0316275350599013*std::sin(0.261039972305298*x_41 + 1.96215975284576) - 0.00188125650844043*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00177377680098663*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.006646167536624*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.00529322713312181*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.00770564528551634*std::sin(0.215999990701675*x_44 + 1.99159979820251) + 0.041351580620627*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.0238668058485367*std::sin(0.243039980530739*x_48 - 7.61728000640869) - 0.00119997707326901*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.0401999041367183*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 0.00604620528609605*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.00555708655467852*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.060130932850551*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.0453579573060679*std::sin(0.224399983882904*x_57 - 4.2163200378418) + 0.00291540151108424*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.00474583209644456*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.00986262666723549*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.0055858555796536*std::sin(0.381999850273132*x_60 + 8.21647930145264) - 0.0141503905578623*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.0100455367749738*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.00759026832272188*std::sin(0.326159834861755*x_7 - 7.3583197593689) + 0.00140699964159352*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.000944261647309421*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.00406716868713132*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.00256658530950051*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.00130777667818329*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 0.000282281592173873*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.00130523033209308*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00826448811068035*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.00321779642048114*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.0023168189098826*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.0141395849191755*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.000835389322907766*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.00321981924183483*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.0372926617517045*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.00175958239735819*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.00177408757494628*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.00119718282536134*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.00187923181828522*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.00230019762676809*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.00549689894055738*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 0.0206834174519228*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.00573625357454184*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.000963669806105072*std::sin(0.276959955692291*x_98 - 1.23423981666565) + 0.0417138510764162*std::sin(0.280639946460724*x_98 + 8.17799949645996) - 0.00285097277699196*std::sin(0.250319957733154*x_99 + 1.95055973529816) - 0.125439680300005);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000116908970287697*x_1 - 0.00278712345039017*x_10 + 0.00102479735669975*x_100 - 0.00193069406645729*x_101 + 3.00890415923854e-5*x_102 - 0.00496390160877087*x_103 + 0.000983749422936989*x_104 + 0.00203815879511152*x_105 - 0.000398896969075404*x_106 - 0.00643352101969549*x_107 - 0.00136160582175186*x_108 - 0.000727342347449765*x_109 + 0.00146932029929072*x_11 - 0.00183592699395104*x_110 + 0.00574045112314549*x_111 + 0.000214624785122664*x_112 + 0.00424460703247338*x_113 + 9.8454563410691e-6*x_114 + 0.00319187258253859*x_115 + 0.00303840358159835*x_116 - 0.000527078734150859*x_117 + 0.00342463783387314*x_118 + 0.00130995708960864*x_119 - 0.00733002093944513*x_12 + 0.00813042913964479*x_120 - 0.000195324393074394*x_13 - 0.00452750883702039*x_14 + 0.00032908928157049*x_15 - 0.00253941284831432*x_16 + 0.000101202028265247*x_17 + 0.000128558251234692*x_18 - 4.51543890096425e-5*x_19 + 0.00148705905964328*x_2 - 0.000166715900295507*x_20 + 5.3407932835936e-6*x_21 - 0.000215779915514059*x_22 - 0.000886278415224642*x_23 - 0.00136142529335495*x_24 - 3.72860083469053e-6*x_25 + 4.86619209654692e-6*x_26 + 0.00278450121817652*x_27 - 0.000408719218856244*x_28 - 0.00242160929518539*x_29 + 7.92101939326127e-5*x_3 - 4.95693190269511e-6*x_30 - 0.000156009086355364*x_31 - 0.00390836757999528*x_33 - 0.00547163653677451*x_34 - 0.00745227253769376*x_35 - 0.00165365201296529*x_36 - 0.00169490319022483*x_37 - 0.0015560919832142*x_38 + 0.00237459128114565*x_39 + 0.000325490436982913*x_4 - 0.00497727081220442*x_40 + 0.00043616307403792*x_41 - 0.0048271018314895*x_42 + 0.00550836697580364*x_43 + 0.000672667633032709*x_44 - 0.00292834155583048*x_45 + 0.00101244941488048*x_46 - 0.00118138580453854*x_47 - 0.000358569979206141*x_48 - 0.0040548740211178*x_49 - 0.00121146308613773*x_5 + 0.00636231890678298*x_50 + 0.00070359400964588*x_51 - 0.000312960016261537*x_52 - 0.000783115411967593*x_53 + 0.00438884476673892*x_54 - 0.00414530289756905*x_55 - 0.00314412935816859*x_56 - 0.00420757520450693*x_57 - 0.00601619248040886*x_58 - 0.000748291627006656*x_59 + 0.00029316574843709*x_6 + 0.00619979596287268*x_60 + 0.0035041782126093*x_61 - 0.00266445375391959*x_62 + 0.00125027816922716*x_63 + 0.000368840467059988*x_64 - 0.0014688969878762*x_65 + 0.00126604063033291*x_66 - 0.00145732361095951*x_67 + 0.000105914514870613*x_68 + 0.000847917722464069*x_69 + 0.00188441389005931*x_7 + 0.000634827516825803*x_70 + 0.00203767664727053*x_71 + 0.00083271291241326*x_72 + 0.000670802170519604*x_73 + 0.00251089568110184*x_74 + 4.84358916901987e-5*x_75 + 0.000630375639116134*x_76 + 0.00093774718454412*x_77 + 0.00105917271254393*x_78 - 0.0013654301182557*x_79 - 0.00259134241929278*x_8 - 0.000148341091452584*x_80 + 0.00123710877650652*x_81 - 0.00153655048869735*x_82 - 0.000417691850252117*x_83 - 0.00230264185087401*x_84 - 0.00157345169724592*x_85 + 0.00163326066356334*x_86 + 0.00049493989800777*x_87 - 0.0023877440844395*x_88 - 0.00203890711418282*x_89 + 0.00170563447679396*x_9 + 0.0026500591785146*x_90 + 0.00271172794858735*x_91 - 0.000793996129876997*x_92 + 0.000264574909912579*x_93 - 0.000320472074642059*x_94 + 5.87155148904894e-5*x_95 + 0.00158637463481892*x_96 + 0.000155053806149907*x_97 + 8.58540458774485e-5*x_98 - 0.00644247556238073*x_99 - 2.88256044700627e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) + 1.74042171071777e-6*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) - 0.0186214488281459*std::sin(0.274479955434799*x_1 - 4.2960000038147) + 0.0200748409688454*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.00533717199218877*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.00428174923905031*std::sin(0.327039837837219*x_10 - 1.12639987468719) - 0.0291752721686134*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.00123734987690902*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.012876640934009*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.00626009360092019*std::sin(0.237839981913567*x_101 + 1.98119974136353) + 0.0269538165630678*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.00226359959918534*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.00104874028940363*std::sin(0.25791996717453*x_103 + 1.94479978084564) + 0.000436367244106645*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.0160210742499244*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.00629807805802591*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.0126538193348995*std::sin(0.258959978818893*x_11 - 7.41095972061157) + 0.000263460407809149*std::sin(0.344479858875275*x_11 + 5.061119556427) - 0.034703813443042*std::sin(0.199520006775856*x_110 - 4.20688009262085) - 0.000257310826503987*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00202090729808065*std::sin(0.23191998898983*x_110 + 1.94151985645294) - 0.00231320520810283*std::sin(0.269279956817627*x_112 - 7.43856000900269) - 0.000225472146111014*std::sin(0.271599948406219*x_112 + 1.96775984764099) - 0.0336466382042973*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.00280359566860325*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.0031042686391888*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.00166659540268683*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.0406223605477112*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.00772354103718703*std::sin(0.232879981398582*x_118 + 5.16504001617432) + 0.00213618114991199*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.000470198869515283*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.00914249845605231*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.000730516827271188*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.0136354948746445*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 0.000387794956718912*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.00648080727020783*std::sin(0.314319908618927*x_15 + 5.14832019805908) - 0.0246107518703599*std::sin(0.321919918060303*x_15 + 5.13399982452393) + 0.014029958726335*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.00438672072518333*std::sin(0.35607984662056*x_17 - 7.36687994003296) + 0.0120081353516294*std::sin(0.387039840221405*x_17 + 2.00999975204468) + 0.0186419613245518*std::sin(0.451359868049622*x_17 + 1.96111989021301) - 0.000275607887086003*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.00339768234093318*std::sin(0.380239844322205*x_18 - 1.16895985603333) - 0.00139346099274852*std::sin(0.41567987203598*x_18 + 8.1988000869751) - 0.14502049285183*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.0129945000012863*std::sin(0.412079870700836*x_2 + 5.19591999053955) + 5.89771236659216e-5*std::sin(0.42103984951973*x_2 + 5.20783996582031) + 0.000537491007176528*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.00606217009473387*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.0177107054186803*std::sin(0.35335984826088*x_20 + 8.23607921600342) + 0.0104185834730863*std::sin(0.363519847393036*x_20 - 1.17807984352112) - 0.0216976250665727*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.018798908233035*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.00146510356031135*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.00279677651034704*std::sin(0.380159854888916*x_21 - 1.18823993206024) + 0.0724967067317629*std::sin(0.153920039534569*x_22 - 4.4475998878479) + 0.0219152973417705*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.00119068752372182*std::sin(0.327679842710495*x_22 - 7.36279964447021) + 0.000137640015257189*std::sin(0.504719853401184*x_22 + 8.14903926849365) + 0.000496996828145629*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.0033693064537702*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.000351984317650952*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.00503193153248375*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.00199024179856982*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.00619917537753742*std::sin(0.352959841489792*x_25 + 8.22855949401855) + 0.016059016556424*std::sin(0.373519837856293*x_25 + 8.2203197479248) + 0.0250811382717129*std::sin(0.202959999442101*x_26 - 1.17263984680176) + 0.000434104603972713*std::sin(0.258959978818893*x_26 + 5.20328044891357) + 0.0220267117217464*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.000861768277361041*std::sin(0.387359857559204*x_26 + 8.2052001953125) + 0.000483469561689403*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.00592499922878343*std::sin(0.256799966096878*x_27 - 1.18519985675812) - 0.00873935932880501*std::sin(0.361759841442108*x_27 + 2.03087973594666) - 0.0196781511335386*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.00158493765685915*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.00619116747839227*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.0271648536181742*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00429073214655868*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.00121336771148409*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.00848683920365979*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.00654924472174943*std::sin(0.256079971790314*x_30 - 1.17471981048584) + 0.0150708764529352*std::sin(0.370719850063324*x_31 + 5.17447996139526) + 0.0195330669767683*std::sin(0.384479850530624*x_31 + 5.18416023254395) - 0.00033790237918139*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00469349569357132*std::sin(0.29615992307663*x_32 + 2.0271999835968) - 0.000242573276256674*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.00222959377345656*std::sin(0.32535982131958*x_32 - 1.1885598897934) + 0.00519794822690719*std::sin(0.327279835939407*x_32 + 8.2041597366333) + 0.00238093435546096*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.00545122248430865*std::sin(0.230879992246628*x_34 + 1.98255980014801) + 0.000520897312721431*std::sin(0.234959989786148*x_35 + 1.98535978794098) - 0.00043868328358572*std::sin(0.265119940042496*x_36 - 1.23519992828369) + 0.02741856074084*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.00277745867152401*std::sin(0.243279978632927*x_38 + 1.95791983604431) - 0.0339732752769386*std::sin(0.249519973993301*x_38 + 1.97479975223541) + 0.0374128347679507*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.0177566872448641*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.000636093921690125*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.00325140005481289*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.00754479633372721*std::sin(0.231599986553192*x_40 + 1.95583975315094) + 0.000242783305571665*std::sin(0.241679981350899*x_41 - 1.19143986701965) - 0.0345944778025168*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.00160412077374206*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.0200639373562214*std::sin(0.261039972305298*x_41 + 1.96215975284576) + 0.000309614876879061*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00201897795104811*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.00603503965407523*std::sin(0.256479978561401*x_42 + 1.96983981132507) + 0.0253303080298765*std::sin(0.273919969797134*x_42 + 1.94215977191925) - 0.0368747389337851*std::sin(0.215999990701675*x_44 + 1.99159979820251) + 0.0262326963382263*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.0151406708278464*std::sin(0.243039980530739*x_48 - 7.61728000640869) + 0.000197490747344114*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.0255020935649145*std::sin(0.33231982588768*x_5 - 7.34832000732422) - 0.0289336237529553*std::sin(0.18792000412941*x_51 - 1.1827198266983) + 0.0265929858361611*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.0381459784203737*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.0287742693912596*std::sin(0.224399983882904*x_57 - 4.2163200378418) - 0.000479813186483366*std::sin(0.229039996862411*x_57 - 4.20983982086182) - 0.0227107935929657*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.0112260041790442*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.00507222542004571*std::sin(0.381999850273132*x_60 + 8.21647930145264) - 0.00897675235143354*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.00637270720531838*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.00689232855781517*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.000231562266414162*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.00107479331383614*std::sin(0.311839938163757*x_8 - 7.41599988937378) + 0.0194631050328167*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.00233058285591618*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.00148855948317643*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 0.000321303283631175*std::sin(0.252399981021881*x_91 - 1.34951984882355) - 0.000214813198921411*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00750455254005297*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.00292191385325947*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.00263708843921201*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.00896989744929539*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.000950870832538588*std::sin(0.205679997801781*x_93 + 8.3834400177002) + 0.0154081831640763*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.0236577914723932*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.00200282135911493*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.00161095681166677*std::sin(0.288719952106476*x_95 + 4.98839950561523) + 0.00572902106254333*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.00213901072779591*std::sin(0.282319933176041*x_96 + 1.95719981193542) - 0.000378563689647886*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.00499144851493754*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 0.0131211866900781*std::sin(0.288799941539764*x_97 + 8.18423938751221) + 0.0274503750408553*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.00109688439353516*std::sin(0.276959955692291*x_98 - 1.23423981666565) + 0.0264625141762968*std::sin(0.280639946460724*x_98 + 8.17799949645996) + 0.000469209584856497*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.402612169292379);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00059773854487326*x_1 - 0.000449257457968366*x_10 + 0.00129348613409193*x_100 - 0.00223467800106882*x_101 - 0.00100526462617326*x_102 - 0.00216654786788416*x_103 + 0.000684871444258045*x_104 + 0.0003148510946147*x_105 - 0.00166954162348557*x_106 - 0.00464017165280895*x_107 - 0.0014247282865209*x_108 - 0.000553363296410786*x_109 + 0.000694325379089333*x_11 - 0.000688029677116864*x_110 + 0.00175465901705134*x_111 - 0.000497019787501527*x_112 + 0.00270509020113577*x_113 - 0.00265559858658187*x_114 - 0.00175505347118523*x_115 + 0.00258885643806008*x_116 - 0.00122384679448232*x_117 - 0.000417918751480324*x_118 + 0.00115233801355531*x_119 - 0.00438755282364635*x_12 + 0.00267645168311584*x_120 - 0.000802260358253627*x_13 - 0.000765151178799972*x_14 + 0.00152115968893338*x_15 - 0.00241987317314059*x_16 + 0.000388264457049129*x_17 + 6.03219065209896e-5*x_18 - 0.000289286154459026*x_19 + 0.00115376215145305*x_2 - 0.00044815580941398*x_20 + 0.000121171634730597*x_21 - 0.000748504983892701*x_23 - 0.000581986067933725*x_24 - 8.45942979641635e-5*x_25 + 0.000743129911624748*x_27 + 0.000131105237341289*x_28 - 0.00117141454875151*x_29 + 7.81632644278037e-5*x_3 + 0.00226839058853923*x_30 - 0.000143105856637964*x_31 - 0.0014832509995455*x_33 - 0.00474700244004305*x_34 - 0.00397175294882412*x_35 + 6.8159014881801e-5*x_36 + 0.000123583640977126*x_37 - 0.00257241670833604*x_38 - 0.00055286087531871*x_39 - 0.00105993743433707*x_40 - 0.0026563714213*x_42 + 0.00112612528387835*x_43 + 0.000764722037199655*x_44 - 0.00435082914805676*x_45 + 0.00125346085522195*x_46 + 0.00189882756745593*x_47 + 0.000374690810572664*x_48 - 0.00136985784228124*x_49 - 0.000833697875732937*x_5 + 0.000770158775065302*x_50 - 0.00100916357136124*x_51 - 0.00116212615316067*x_52 - 0.000693253838525008*x_53 + 0.00147982315143279*x_54 - 0.00482772227907145*x_55 - 0.00338520607453018*x_56 - 0.00276669355597174*x_57 - 0.00421604741438048*x_58 + 8.68587694690203e-5*x_59 - 0.000921309268113838*x_6 + 0.00274463678295573*x_60 + 0.000656538216331387*x_61 - 0.00128711762615577*x_62 + 0.00101807483091639*x_63 - 2.93375858983098e-5*x_64 + 0.000381670976581373*x_65 - 0.000340855914670704*x_66 - 0.000277980749700623*x_67 - 0.000534442510754772*x_68 + 0.001551626299437*x_69 + 0.000688026141287896*x_7 + 0.000131409759504035*x_70 + 0.00169371797397601*x_71 - 7.18469822739237e-5*x_72 - 0.000204025567078279*x_73 + 0.00173716606991996*x_74 - 0.000669731535479338*x_75 + 0.00130412479232369*x_76 + 0.000521496945713843*x_77 + 0.000226522254143533*x_78 - 0.000166794748221026*x_79 - 0.00031940495890524*x_8 - 0.000561475069959381*x_80 - 3.26673856175086e-5*x_81 - 0.00124645655694717*x_82 + 0.000263477387153865*x_83 - 0.00122909294948148*x_84 - 0.0015632595346072*x_85 + 0.00161755033804815*x_86 + 0.00025791578152142*x_87 - 0.00135404708338505*x_88 - 0.000331049102452146*x_89 + 0.000301361743975543*x_9 + 0.00182977607448555*x_90 + 0.00143018705844533*x_91 - 0.000284581709975175*x_92 + 0.00117398484776653*x_93 + 0.000439184224882781*x_94 + 0.000425793178682902*x_95 + 0.00124631087371111*x_96 + 6.45856455702909e-5*x_97 - 7.35201984782214e-5*x_98 - 0.00358031598455147*x_99 - 1.58628333499118e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) + 3.94865954569197e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) - 0.0102474499642001*std::sin(0.274479955434799*x_1 - 4.2960000038147) + 0.00941948625402306*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.0136895766983225*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.00332617065697717*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.00708606161077989*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.0148327817627585*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.00608487438069159*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.00281916153426069*std::sin(0.25791996717453*x_103 + 1.94479978084564) + 0.00990027688840076*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.00881645452316721*std::sin(0.188240006566048*x_109 - 4.2007999420166) + 0.00593740580415827*std::sin(0.258959978818893*x_11 - 7.41095972061157) + 0.00597737575784699*std::sin(0.344479858875275*x_11 + 5.061119556427) - 0.0162836704009873*std::sin(0.199520006775856*x_110 - 4.20688009262085) - 0.00583785438338296*std::sin(0.228319987654686*x_110 - 1.20983994007111) - 0.00621822124068808*std::sin(0.269279956817627*x_112 - 7.43856000900269) - 0.00511550009142174*std::sin(0.271599948406219*x_112 + 1.96775984764099) - 0.0157876242482479*std::sin(0.262879967689514*x_113 + 8.36128044128418) - 0.0190607620443402*std::sin(0.226719990372658*x_117 + 8.36223983764648) + 0.00574235565172121*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.00126396075347133*std::sin(0.27295994758606*x_120 - 7.44464015960693) + 0.0165739270288887*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.00750366165138712*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 0.0010424474354694*std::sin(0.272559970617294*x_14 + 5.15696001052856) - 0.0135433848730215*std::sin(0.321919918060303*x_15 + 5.13399982452393) + 0.00658311583002414*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.0066081198791134*std::sin(0.387039840221405*x_17 + 2.00999975204468) + 0.00874715265327177*std::sin(0.451359868049622*x_17 + 1.96111989021301) - 0.00625297712335088*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.0037458193128856*std::sin(0.41567987203598*x_18 + 8.1988000869751) - 0.0680462944184423*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.00715091987749686*std::sin(0.412079870700836*x_2 + 5.19591999053955) + 0.0013380698534544*std::sin(0.42103984951973*x_2 + 5.20783996582031) + 0.0121945674611006*std::sin(0.269679963588715*x_20 - 4.3887996673584) - 0.00974626460505563*std::sin(0.35335984826088*x_20 + 8.23607921600342) + 0.00488859184306515*std::sin(0.363519847393036*x_20 - 1.17807984352112) - 0.0101809265327038*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.0103451065101037*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.00393840461997211*std::sin(0.364559859037399*x_21 - 4.36879968643188) + 0.0398951972888456*std::sin(0.153920039534569*x_22 - 4.4475998878479) + 0.0102830623856*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.00320073568272035*std::sin(0.327679842710495*x_22 - 7.36279964447021) + 0.00312276936542204*std::sin(0.504719853401184*x_22 + 8.14903926849365) + 0.011275837675149*std::sin(0.311679929494858*x_23 - 7.36215972900391) + 0.00798580152883242*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.00535005013071108*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.00341142840639757*std::sin(0.352959841489792*x_25 + 8.22855949401855) + 0.00753518724960859*std::sin(0.373519837856293*x_25 + 8.2203197479248) + 0.013802240193904*std::sin(0.202959999442101*x_26 - 1.17263984680176) + 0.00984894222905758*std::sin(0.258959978818893*x_26 + 5.20328044891357) + 0.0103353400710029*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.00231655444491779*std::sin(0.387359857559204*x_26 + 8.2052001953125) + 0.0109689317713065*std::sin(0.204159989953041*x_27 + 1.77231991291046) - 0.00410066885184304*std::sin(0.361759841442108*x_27 + 2.03087973594666) - 0.0092333520546746*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.00426053554112949*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.0127462511730999*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00326170322022724*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.00467033800088982*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.00829355727330219*std::sin(0.370719850063324*x_31 + 5.17447996139526) + 0.00916527588796948*std::sin(0.384479850530624*x_31 + 5.18416023254395) - 0.00766631125577239*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00550348962508443*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.00599346193396482*std::sin(0.32535982131958*x_32 - 1.1885598897934) + 0.00243897333724641*std::sin(0.327279835939407*x_32 + 8.2041597366333) + 0.00131023670074228*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.0118180906014699*std::sin(0.234959989786148*x_35 + 1.98535978794098) - 0.00995282306925413*std::sin(0.265119940042496*x_36 - 1.23519992828369) + 0.0128652952421517*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.0159408883971682*std::sin(0.249519973993301*x_38 + 1.97479975223541) + 0.0175547932542858*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.00977156856864243*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.00170991000758212*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.00874022106296119*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.00550825475904253*std::sin(0.241679981350899*x_41 - 1.19143986701965) - 0.0162323680985381*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.00431210245981274*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.0110412565660281*std::sin(0.261039972305298*x_41 + 1.96215975284576) + 0.00702452590396928*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00542729695390266*std::sin(0.252799987792969*x_42 + 1.96831977367401) + 0.0118854484908686*std::sin(0.273919969797134*x_42 + 1.94215977191925) - 0.0173023087478762*std::sin(0.215999990701675*x_44 + 1.99159979820251) + 0.0144359467210583*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.00833196536771449*std::sin(0.243039980530739*x_48 - 7.61728000640869) + 0.00448065960039404*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.0140338933989826*std::sin(0.33231982588768*x_5 - 7.34832000732422) - 0.0135761907973766*std::sin(0.18792000412941*x_51 - 1.1827198266983) + 0.0124779202448425*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.0209918685063538*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.0158345834722413*std::sin(0.224399983882904*x_57 - 4.2163200378418) - 0.0108859761245742*std::sin(0.229039996862411*x_57 - 4.20983982086182) - 0.0106563239230084*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.0301770795732545*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.00493993896024305*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.00350692359255589*std::sin(0.314079910516739*x_7 + 4.82047986984253) - 0.00525367241782601*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.00288919573154805*std::sin(0.311839938163757*x_8 - 7.41599988937378) + 0.00913244845135965*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.00400145744263942*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 0.000863708457848751*std::sin(0.252399981021881*x_91 - 1.34951984882355) - 0.00487367046295833*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00708886496054962*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.00493616668305246*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.00255607465664125*std::sin(0.205679997801781*x_93 + 8.3834400177002) + 0.00722980419813677*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.0130189673539471*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.00538386576034311*std::sin(0.270399957895279*x_95 + 1.9871199131012) + 0.00268816252300001*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.0057499619554068*std::sin(0.282319933176041*x_96 + 1.95719981193542) - 0.00858883291086975*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.00722063601594045*std::sin(0.288799941539764*x_97 + 8.18423938751221) + 0.0128802230994702*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.00294857966364926*std::sin(0.276959955692291*x_98 - 1.23423981666565) + 0.0145624163002109*std::sin(0.280639946460724*x_98 + 8.17799949645996) + 0.0106454021733025*std::sin(0.250319957733154*x_99 + 1.95055973529816) - 0.162823110818863*std::sin(0.0406840134175678*x_100 + 0.0263868846966603*x_102 - 0.0709318610599084*x_103 - 0.0208071279235547*x_104 + 0.00208351388008967*x_105 + 0.00161577828227855*x_106 + 0.0344304689849075*x_107 + 0.0396226234929578*x_108 + 0.0204274986259482*x_11 + 0.0275515054251594*x_111 + 0.0657668521312592*x_112 + 0.0129645759368533*x_115 - 0.0632075685600858*x_117 - 0.0555320611819122*x_119 + 0.00937353259795326*x_12 + 0.0170099588370753*x_120 + 0.00327892791431503*x_14 + 0.0165145724192069*x_16 - 0.0174207086910035*x_19 - 0.0156427755212906*x_2 - 0.0121981789796784*x_22 + 0.00243052356735142*x_24 + 0.000275089004469039*x_26 - 0.0180666421288075*x_28 - 0.00580982954014676*x_31 + 0.0490992816372433*x_33 - 0.039841937301443*x_35 - 0.0498319189885419*x_36 - 0.0157109824447495*x_37 - 0.0190074714725005*x_39 + 0.0184001861203464*x_4 + 0.0246565822809149*x_41 - 0.050786308423096*x_43 - 0.0292012844019242*x_44 + 0.0109860049017882*x_45 + 0.0326094915972358*x_46 - 0.0359493113809382*x_47 + 0.0311683671686042*x_48 - 0.0372365936900727*x_49 + 0.0132071710751266*x_5 + 0.0783508369621512*x_50 - 0.0723895352031485*x_51 + 0.0187293884517252*x_52 - 0.00833773407658035*x_53 + 0.00145020545729991*x_54 + 0.0496492218046868*x_55 - 0.00562686257228093*x_56 + 0.0569894473641723*x_57 + 0.0402273219517274*x_58 + 0.0346571474409012*x_59 + 0.0507816843529932*x_6 + 0.031904349645081*x_61 + 0.0182395734995451*x_62 + 0.000792157140442654*x_63 - 0.0133476555898554*x_64 + 0.00269623911996497*x_65 + 0.0234972881963453*x_66 - 0.0280775816767934*x_67 - 0.00194497258715718*x_68 - 0.0214030919351094*x_69 + 0.00125041662277379*x_70 + 0.00933838644546581*x_71 + 0.00217334172194555*x_72 + 0.0249733655844532*x_73 - 0.00780590400668576*x_74 - 0.0089185536109155*x_75 - 0.0105720199886697*x_76 - 0.00360400390856896*x_77 - 0.000730092886620022*x_78 - 0.0145470168026107*x_79 - 0.000728821127738041*x_80 + 0.00491286593709214*x_81 - 0.016597974299197*x_82 - 0.0110764672486163*x_83 - 0.00805061150731021*x_84 - 0.0175397380904384*x_85 + 0.000107353434861596*x_86 + 0.00117301347509177*x_87 + 0.00241918540436651*x_88 - 0.0052413283283494*x_89 + 0.00298482609793646*x_9 + 0.0170314927414993*x_90 - 0.0514197308530179*x_93 - 0.0222310756978071*x_94 - 0.00205903775971357*x_96 + 0.00503657239735434*x_98 - 0.0369402078221157*x_99 - 0.301713804322087*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.242050069579504*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.353887163184975*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.356034449252437*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.114243204074848*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.158489086766027*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.175486325368222*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.0942137221633983*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.436616798667529*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.516831384527507*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.366364250474671*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.247984175970096*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.192073192780981*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.342698418639429*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.15810359531423*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.190469085422349*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.28445836258901*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.33494406036343*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.349990724644957*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.242557879183952*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.370233064125973*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.265326364477154*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.308161152826624*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.157011545320131*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.426512244315109*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.341164717181798*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.28673620226235*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.38962781654023*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.131749364790085*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.424237236481826*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.165177690705596*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.0910684364224945*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.28216983127464*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 0.345226570549646) + 0.0619399639885496);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000151839836460024*x_1 + 0.00446590435394383*x_10 - 4.30128566212504e-5*x_100 + 0.00171642076428066*x_101 + 0.000381150623467495*x_102 + 0.00425346369924756*x_103 - 0.000898694382110553*x_104 - 0.00224886131645837*x_105 - 0.000926019517202256*x_106 + 0.00845501179255735*x_107 + 0.00187945065838546*x_108 + 0.0011747310937549*x_109 - 0.00107909472996469*x_11 + 0.00220298627214639*x_110 - 0.00695554138031219*x_111 + 0.00108231010169762*x_112 - 0.00440291875293138*x_113 + 7.85043236553599e-5*x_114 - 0.00579019527205208*x_115 - 0.00344970545908727*x_116 - 0.000830812598243466*x_117 - 0.00506464797858149*x_118 - 0.00167451396752141*x_119 + 0.00957704424491701*x_12 - 0.00948175265030307*x_120 - 0.000448257512990282*x_13 + 0.00653603519146034*x_14 + 0.000399233009082559*x_15 + 0.00271880983097922*x_16 + 0.00010888825095232*x_17 - 0.000172776448372758*x_18 - 0.000850840652138596*x_19 - 0.00204419137955461*x_2 - 0.000145951243904614*x_20 + 2.33247128297787e-5*x_21 + 0.000794933252847962*x_23 + 0.00170318021012486*x_24 - 1.6283825100138e-5*x_25 - 0.00361069253531633*x_27 + 5.04740343974592e-5*x_28 + 0.00256379181756753*x_29 - 9.59169571893832e-5*x_3 + 0.000777595449611454*x_30 - 4.66053933645485e-5*x_31 + 0.0060533566144611*x_33 + 0.00630260689394024*x_34 + 0.00749839598186469*x_35 + 0.00227762741738159*x_36 + 0.00172187498760021*x_37 + 0.00122304991742589*x_38 - 0.0037415306440705*x_39 + 0.0058833487876617*x_40 + 0.00503199588401064*x_42 - 0.00878862789831841*x_43 - 0.00117880586221959*x_44 + 0.00229880122116828*x_45 + 0.000778445670551122*x_46 + 0.00164710512104376*x_47 + 0.00160523173687067*x_48 + 0.0033948483213*x_49 + 0.00178646947987627*x_5 - 0.00681976135240744*x_50 - 0.00263049880177031*x_51 - 8.15886829219099e-5*x_52 + 0.000499195576015606*x_53 - 0.00627113618964882*x_54 + 0.00537657208237806*x_55 + 0.00359786556540084*x_56 + 0.00669018766785764*x_57 + 0.00825035421500484*x_58 + 0.00155809476172527*x_59 - 0.000126125248902682*x_6 - 0.0083745080548405*x_60 - 0.00393516207441836*x_61 + 0.00338115917200037*x_62 - 0.00117637175707148*x_63 - 0.00143593434360424*x_64 + 0.00236780844272219*x_65 - 0.00155024088156488*x_66 + 0.00111813806477132*x_67 - 8.42453658449124e-5*x_68 - 0.00149999036908322*x_69 - 0.00272878485146646*x_7 - 0.000523511838401763*x_70 - 0.0021901823619875*x_71 - 0.000961525078699648*x_72 - 0.000406332755147411*x_73 - 0.00288452397524617*x_74 - 0.000535782233815818*x_75 - 0.000477337668005728*x_76 - 0.000711513288889085*x_77 - 0.0015969780028146*x_78 + 0.00138226403618897*x_79 + 0.00297175811585274*x_8 - 0.000214488112567095*x_80 - 0.00119996705351704*x_81 + 0.00148872321869652*x_82 - 3.85810959285445e-5*x_83 + 0.00275858783425417*x_84 + 0.00125137497632667*x_85 - 0.00159144102189826*x_86 - 0.000797152456711312*x_87 + 0.00321721837306925*x_88 + 0.00268739732033883*x_89 - 0.00215548788705468*x_9 - 0.00260947405776197*x_90 - 0.00305769501682698*x_91 + 0.00108970856327472*x_92 - 0.000862960920721486*x_93 + 0.000106237792544739*x_94 + 3.49463978190021e-5*x_95 - 0.00257382272676283*x_96 - 0.00021655550623472*x_97 - 1.41521365169784e-5*x_98 + 0.00603282823453521*x_99 + 3.00491533245148e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) + 7.60090017524317e-6*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) + 0.019411865986807*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.0269796741238579*std::sin(0.406479865312576*x_1 - 0.994959831237793) + 0.0392102401610866*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.00108323653208834*std::sin(0.239599987864494*x_100 - 1.19783997535706) + 0.0134232105395262*std::sin(0.227359995245934*x_101 - 7.41120004653931) - 0.0280979143880798*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.00198166567566434*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.00091811848479979*std::sin(0.25791996717453*x_103 + 1.94479978084564) + 0.00190573574311062*std::sin(0.25639995932579*x_108 + 1.9586398601532) + 0.0167011143533659*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.0170061582359521*std::sin(0.258959978818893*x_11 - 7.41095972061157) + 0.0011506040447291*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.0466403484342162*std::sin(0.199520006775856*x_110 - 4.20688009262085) - 0.00112374713221633*std::sin(0.228319987654686*x_110 - 1.20983994007111) - 0.00202509284915722*std::sin(0.269279956817627*x_112 - 7.43856000900269) - 0.00098469886024398*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.0452195529480947*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.0545946068225386*std::sin(0.226719990372658*x_117 + 8.36223983764648) + 0.00187011734023336*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.000411635061602748*std::sin(0.27295994758606*x_120 - 7.44464015960693) + 0.00319036785523304*std::sin(0.208959996700287*x_13 + 8.18591976165771) + 0.0142142752485682*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 0.000339494650556653*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.0256553945695081*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.0188556270505522*std::sin(0.351919859647751*x_15 + 5.03336000442505) - 0.0125178398495472*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.0250539489875169*std::sin(0.451359868049622*x_17 + 1.96111989021301) - 0.00120365542692895*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.00121990382959102*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.194900953113187*std::sin(0.110080063343048*x_19 + 1.72039985656738) + 0.0135460723232914*std::sin(0.412079870700836*x_2 + 5.19591999053955) + 0.000257569316015236*std::sin(0.42103984951973*x_2 + 5.20783996582031) + 0.0023473710224833*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.0184624646176615*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.0140021027998333*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.0291606222169465*std::sin(0.272719949483871*x_21 + 2.00431990623474) + 0.0195968579397746*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.00128262323328186*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.0755739453223818*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.0294531638644619*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.00104238602845242*std::sin(0.327679842710495*x_22 - 7.36279964447021) + 0.000601111793564895*std::sin(0.504719853401184*x_22 + 8.14903926849365) + 0.00217052180795279*std::sin(0.311679929494858*x_23 - 7.36215972900391) + 0.00153721230046746*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.00174235490230591*std::sin(0.328959852457047*x_25 - 1.15583980083466) + 0.00646230928474172*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.0215825885801214*std::sin(0.373519837856293*x_25 + 8.2203197479248) - 0.0261457472734974*std::sin(0.202959999442101*x_26 - 1.17263984680176) + 0.00189585417148656*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.0296028997288269*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.000754434051073949*std::sin(0.387359857559204*x_26 + 8.2052001953125) + 0.00211144451573993*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.0117453018486361*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.0264465410095564*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.00138753185580878*std::sin(0.182880014181137*x_29 - 4.61615991592407) - 0.0365083289764558*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00106224137284384*std::sin(0.318319916725159*x_3 - 4.14279985427856) - 0.008847076658397*std::sin(0.420319855213165*x_3 + 1.99263978004456) - 0.0157105838921574*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.0262515544950296*std::sin(0.384479850530624*x_31 + 5.18416023254395) - 0.00147571260305395*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00105938419789551*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.00195189531449111*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 0.0069858062383797*std::sin(0.327279835939407*x_32 + 8.2041597366333) - 0.00248199691968838*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.00227490179602228*std::sin(0.234959989786148*x_35 + 1.98535978794098) - 0.00191585052435816*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.0368492998216569*std::sin(0.217040002346039*x_37 - 7.41472005844116) + 0.0456585383323531*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.0502811500053992*std::sin(0.185760006308556*x_4 - 1.18887984752655) - 0.0185103982159517*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.000556867694960584*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.00284643445280462*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.00106030145366593*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.0464934063012215*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.00140432569350552*std::sin(0.25927996635437*x_41 - 7.43383979797363) + 0.0209155832460239*std::sin(0.261039972305298*x_41 + 1.96215975284576) + 0.00135217330227247*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00176751193406956*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.0340427830618233*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.0495579736536799*std::sin(0.215999990701675*x_44 + 1.99159979820251) - 0.0273461850627094*std::sin(0.169440016150475*x_47 - 7.37831974029541) + 0.015783340800866*std::sin(0.243039980530739*x_48 - 7.61728000640869) + 0.000862496397771154*std::sin(0.300399929285049*x_5 - 7.38207960128784) + 0.0265845706869429*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 0.0388854756701937*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.0357397646613217*std::sin(0.292639940977097*x_53 + 8.14832019805908) - 0.0397651454441451*std::sin(0.18520000576973*x_55 + 8.21592044830322) + 0.0299956392462417*std::sin(0.224399983882904*x_57 - 4.2163200378418) - 0.00209547611982003*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.0305222746811954*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.00982779249673073*std::sin(0.0657600983977318*x_60 - 1.37215983867645) + 0.00935778495276905*std::sin(0.484079837799072*x_60 - 7.69736051559448) - 0.00664320694831332*std::sin(0.314079910516739*x_7 + 4.82047986984253) - 0.00101129609021094*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.000940926575189865*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.0261575288212115*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.00130315769408027*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 0.000281284591532573*std::sin(0.252399981021881*x_91 - 1.34951984882355) - 0.000938148306971493*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00230863605275352*std::sin(0.27567994594574*x_92 - 7.38263988494873) - 0.00935063908335327*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.000832438780917902*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.0207078980726492*std::sin(0.27991995215416*x_94 + 1.96287977695465) - 0.0246619842443081*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.00175336766417252*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.00769954399917852*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.00187259449094994*std::sin(0.282319933176041*x_96 + 1.95719981193542) - 0.00165329172651992*std::sin(0.273999959230423*x_97 + 1.96847975254059) + 0.0136781364310755*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.0368920567953347*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.000960266185602263*std::sin(0.276959955692291*x_98 - 1.23423981666565) - 0.0275857578862407*std::sin(0.280639946460724*x_98 + 8.17799949645996) + 0.00204916727583839*std::sin(0.250319957733154*x_99 + 1.95055973529816) - 0.157712653279305*std::sin(0.0407310069548714*x_100 + 0.0264173638196905*x_102 - 0.0710137934647703*x_103 - 0.0208311619472441*x_104 + 0.00208592051795604*x_105 + 0.00161764464526992*x_106 + 0.0344702391401284*x_107 + 0.0396683910335412*x_108 + 0.0204510941451229*x_11 + 0.0275833297853738*x_111 + 0.0658428185062393*x_112 + 0.0129795511379639*x_115 - 0.0632805787422552*x_117 - 0.0555962054924038*x_119 + 0.00938435983491456*x_12 + 0.017029606803635*x_120 + 0.00328271535828413*x_14 + 0.0165336481718145*x_16 - 0.0174408311089991*x_19 - 0.0156608442734426*x_2 - 0.0122122689263372*x_22 + 0.00243333103127483*x_24 + 0.000275406755947013*x_26 - 0.0180875106555214*x_28 - 0.0058165403933367*x_31 + 0.0491559955336704*x_33 - 0.0398879581683523*x_35 - 0.0498894791441702*x_36 - 0.0157291299817689*x_37 - 0.0190294267380866*x_39 + 0.0184214399190797*x_4 + 0.0246850627557222*x_41 - 0.0508449709806686*x_43 - 0.0292350143988586*x_44 + 0.0109986946830512*x_45 + 0.0326471583668364*x_46 - 0.0359908359298582*x_47 + 0.0312043693154474*x_48 - 0.0372796051608604*x_49 + 0.0132224264945029*x_5 + 0.0784413389227558*x_50 - 0.0724731513471127*x_51 + 0.0187510225074868*x_52 - 0.0083473648770949*x_53 + 0.00145188056942703*x_54 + 0.0497065709293424*x_55 - 0.00563336208287441*x_56 + 0.0570552750811464*x_57 + 0.0402737879710791*x_58 + 0.0346971794292496*x_59 + 0.0508403415693669*x_6 + 0.031941201915033*x_61 + 0.018260641776877*x_62 + 0.000793072150123425*x_63 - 0.0133630732809381*x_64 + 0.00269935350822267*x_65 + 0.0235244295867007*x_66 - 0.0281100137003595*x_67 - 0.00194721919790551*x_68 - 0.0214278143485287*x_69 + 0.00125186096160055*x_70 + 0.00934917308559585*x_71 + 0.00217585211870104*x_72 + 0.0250022119712426*x_73 - 0.00781492049769321*x_74 - 0.00892885530798524*x_75 - 0.010584231581725*x_76 - 0.00360816684329178*x_77 - 0.000730936206745555*x_78 - 0.0145638198591271*x_79 - 0.000729662978872601*x_80 + 0.00491854072011595*x_81 - 0.0166171463881546*x_82 - 0.0110892615216763*x_83 - 0.00805991065654366*x_84 - 0.0175599979976356*x_85 + 0.000107477437319123*x_86 + 0.00117436840662062*x_87 + 0.00242197977173577*x_88 - 0.00524738251370695*x_89 + 0.00298827382899334*x_9 + 0.0170511655815722*x_90 - 0.0514791250680178*x_93 - 0.0222567545037396*x_94 - 0.00206141612555417*x_96 + 0.00504239007198757*x_98 - 0.036982876941715*x_99 - 0.302062309735575*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.242329658243911*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.354295933318681*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.356445699686375*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.114375164808841*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.158672155302916*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.175689027178706*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.0943225471217808*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.437121128651029*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.517428369262007*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.366787432718141*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.248270619038152*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.192295053851012*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.343094264810134*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.158286218575313*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.19068909361031*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.284786936482064*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.335330949582882*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.350394994056771*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.242838054412161*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.370660715182211*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.265632839265635*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.308517105482579*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.157192907169474*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.4270049026686*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.341558791795308*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.287067407256288*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.390077870204877*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.131901546646517*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.424727267005451*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.165368485155746*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.0911736283051212*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.282495761717044*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 0.315608658176858) - 0.455645048650581);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000337519449347088*x_1 - 0.0041313138086753*x_10 - 0.000408020759785735*x_100 - 0.000517956719411735*x_101 - 7.81098958248664e-5*x_102 - 0.0012692903554679*x_103 - 0.00113741753369959*x_104 - 0.000540966700170563*x_105 + 0.00344794058875131*x_106 - 0.00389652477246038*x_107 + 0.000334163500388819*x_108 - 0.000917317216193214*x_109 - 8.62040539927251e-5*x_11 - 0.000328371851776092*x_110 + 0.00321052444344921*x_111 - 0.000283525511236296*x_112 - 6.509927459049e-5*x_113 - 0.00219920729062*x_114 + 0.00570812106555506*x_115 + 0.00114469249232031*x_116 + 0.000396777697383437*x_117 + 0.00234885007950221*x_118 - 0.00207065270326038*x_119 - 0.00565865729625021*x_12 + 0.00349199151555679*x_120 + 0.00081205560113441*x_13 - 0.00481362463718486*x_14 - 0.000902899295485965*x_15 + 2.08632819248295e-5*x_16 - 0.000254412959979751*x_17 + 0.000117816331160538*x_18 + 0.000630554303456785*x_19 + 0.00116150442125295*x_2 + 0.000363139994493845*x_20 - 4.28591267874888e-5*x_21 - 0.000116968104939206*x_23 - 0.00044201093024765*x_24 + 2.99215055570194e-5*x_25 + 0.000804089885152104*x_27 + 2.1637111966049e-5*x_28 - 5.84368237040246e-5*x_29 + 5.6093797448338e-5*x_3 - 0.000787234413291667*x_30 + 0.000115958465560228*x_31 - 0.00309807611548457*x_33 - 0.00357757127888156*x_34 - 0.00227514889901849*x_35 - 0.00425793489625327*x_36 - 0.00035159287339622*x_37 + 0.000601703956872652*x_38 + 0.00200915050544705*x_39 - 0.00150454574490184*x_40 + 0.00480941052299033*x_43 - 7.41140263618638e-5*x_44 + 0.00139012223768668*x_45 - 0.0034518002934988*x_46 - 0.00184786997455369*x_47 - 0.00139184638944905*x_48 + 0.000871807908031859*x_49 - 0.00110728768484144*x_5 + 0.0038386021567362*x_50 + 0.000810617470679862*x_51 + 0.000637583960372321*x_52 + 0.000204425293047645*x_53 + 0.00483782132596027*x_54 - 0.00262182778865833*x_55 - 0.00165246750362419*x_56 - 0.00433443749915724*x_57 - 0.00385889264647876*x_58 - 0.000280597180448458*x_59 + 0.000829853737464901*x_6 + 0.00574792769458288*x_60 + 0.00260595715448095*x_61 - 0.000974683072192393*x_62 - 0.000230138176945262*x_63 + 0.00199235511430695*x_64 - 0.00155965627658004*x_65 + 0.00176769831913997*x_66 - 0.000482363240183047*x_67 - 0.000672688522035677*x_68 + 0.00141258905914797*x_69 + 0.00200055637669193*x_7 - 3.18845581867304e-5*x_70 + 0.000815424870663811*x_71 + 0.000286669838770594*x_72 + 0.000373817779986734*x_73 + 0.000777669093874963*x_74 + 0.00066638067697014*x_75 - 0.000570739506723645*x_76 - 0.000709392917860567*x_77 + 0.00114192949380799*x_78 - 0.000193663068669072*x_79 - 0.00040114806192428*x_8 + 0.000864726725320415*x_80 - 0.000290204058198309*x_81 - 0.000662690790672683*x_82 + 0.000666995100320202*x_83 - 0.00184265649448098*x_84 - 0.000406675306443443*x_85 + 1.92662322223359e-5*x_86 + 0.00142525676962824*x_87 - 0.00216029075561256*x_88 - 0.00193278345336745*x_89 + 0.00111438238575266*x_9 + 0.00116904269402133*x_90 + 0.00070171686455446*x_91 - 0.000763055782644757*x_92 - 0.000922086421771656*x_93 - 0.000229731964265071*x_94 - 0.00014263655294331*x_95 + 0.00292164772171024*x_96 + 0.000153490223459608*x_97 + 2.60045308047971e-5*x_98 - 0.00088126600093787*x_99 - 1.39666433060597e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) + 0.0183974508743347*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.0267374788821691*std::sin(0.237999975681305*x_100 - 1.19359982013702) - 0.00269519120066683*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.00493056477832898*std::sin(0.235839992761612*x_102 + 1.95447981357574) - 0.00228436245279821*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00350178672867296*std::sin(0.25639995932579*x_108 + 1.9586398601532) + 0.0115965062910239*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.0021142333024689*std::sin(0.344479858875275*x_11 + 5.061119556427) - 0.0318040727675642*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00206488376376693*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00503861554323643*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00180938276096636*std::sin(0.271599948406219*x_112 + 1.96775984764099) - 0.0308352317415978*std::sin(0.262879967689514*x_113 + 8.36128044128418) - 0.0372280848319472*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.00465302235504769*std::sin(0.25111997127533*x_12 - 4.21424007415771) + 0.0010241855430954*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.00586229641513913*std::sin(0.208959996700287*x_13 + 8.18591976165771) + 0.000844693626690877*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.0128576598358745*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.0170842981123458*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.0022117151421189*std::sin(0.338479846715927*x_18 + 4.99368000030518) + 0.00303523189052245*std::sin(0.41567987203598*x_18 + 8.1988000869751) - 0.132903040036725*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.000473283253355642*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.00431329092898605*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.00954803965439749*std::sin(0.363519847393036*x_20 - 1.17807984352112) - 0.0198846402754324*std::sin(0.272719949483871*x_21 + 2.00431990623474) + 0.00319128348214734*std::sin(0.364559859037399*x_21 - 4.36879968643188) + 0.0200841245451146*std::sin(0.231279984116554*x_22 - 1.16823983192444) + 0.00259355142515992*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.00110454206925801*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.00398833074777626*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00282462542479444*std::sin(0.345839858055115*x_24 - 7.36495971679688) - 0.00433513776726156*std::sin(0.328959852457047*x_25 - 1.15583980083466) + 0.0147171760237326*std::sin(0.373519837856293*x_25 + 8.2203197479248) - 0.00348362935481007*std::sin(0.258959978818893*x_26 + 5.20328044891357) + 0.02018622949257*std::sin(0.353839844465256*x_26 - 1.16007995605469) + 0.0018771006661102*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00387977630701247*std::sin(0.204159989953041*x_27 + 1.77231991291046) - 0.00800912615817826*std::sin(0.361759841442108*x_27 + 2.03087973594666) - 0.0180339071845624*std::sin(0.313359916210175*x_28 - 1.17319989204407) + 0.00345230569468622*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.0248950445348208*std::sin(0.345119833946228*x_29 - 1.17687976360321) - 0.00264295333130391*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.0179009458001625*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.00271161981790556*std::sin(0.400159865617752*x_31 + 5.20528030395508) + 0.00194661696311638*std::sin(0.299599945545197*x_32 + 2.03711986541748) + 0.00485649340693599*std::sin(0.32535982131958*x_32 - 1.1885598897934) + 0.00476362414528059*std::sin(0.327279835939407*x_32 + 8.2041597366333) - 0.00418012882800967*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00352037262488869*std::sin(0.265119940042496*x_36 - 1.23519992828369) + 0.0251275526943104*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.0311345760555569*std::sin(0.249519973993301*x_38 + 1.97479975223541) + 0.0342867368554083*std::sin(0.185760006308556*x_4 - 1.18887984752655) - 0.0013855375690662*std::sin(0.269039958715439*x_4 - 4.17000007629395) - 0.00708218829703228*std::sin(0.231199979782104*x_40 + 1.97247982025146) - 0.00194830241929533*std::sin(0.241679981350899*x_41 - 1.19143986701965) - 0.0317038728666785*std::sin(0.244559973478317*x_41 + 1.98751986026764) + 0.00349409029319714*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.00248461652770123*std::sin(0.246239975094795*x_42 + 5.17119979858398) - 0.00439773075469853*std::sin(0.252799987792969*x_42 + 1.96831977367401) + 0.023213787762236*std::sin(0.273919969797134*x_42 + 1.94215977191925) - 0.0337936026039286*std::sin(0.215999990701675*x_44 + 1.99159979820251) - 0.00158483590926066*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.0265160218423435*std::sin(0.18792000412941*x_51 - 1.1827198266983) + 0.024370960212433*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.00385043440212737*std::sin(0.229039996862411*x_57 - 4.20983982086182) - 0.0208131516504747*std::sin(0.351439833641052*x_6 + 2.03335976600647) + 0.024452443279496*std::sin(0.0657600983977318*x_60 - 1.37215983867645) + 0.00185825513335821*std::sin(0.346639841794968*x_7 + 8.22824001312256) - 0.00234111106005284*std::sin(0.311839938163757*x_8 - 7.41599988937378) + 0.0178368296545392*std::sin(0.319439917802811*x_8 + 1.98247981071472) + 0.00324237509179571*std::sin(0.330639839172363*x_9 - 1.10911989212036) + 0.000699861695506337*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.00172384618526258*std::sin(0.360639840364456*x_91 - 7.3983998298645) + 0.00574409687137105*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.0020711835420639*std::sin(0.205679997801781*x_93 + 8.3834400177002) + 0.0141207242071691*std::sin(0.27991995215416*x_94 + 1.96287977695465) - 0.00436253852231244*std::sin(0.270399957895279*x_95 + 1.9871199131012) + 0.00525032221773218*std::sin(0.294399946928024*x_95 - 4.4191198348999) - 0.00465918573175839*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.0030379212057504*std::sin(0.273999959230423*x_97 + 1.96847975254059) + 0.0251567086922354*std::sin(0.247999966144562*x_98 - 7.41847991943359) + 0.00238922977306128*std::sin(0.276959955692291*x_98 - 1.23423981666565) - 0.00376534196690317*std::sin(0.250319957733154*x_99 + 1.95055973529816) - 0.696302175521851*std::sin(-0.00623284988073635*x_10 - 0.00142865432047939*x_100 + 0.0124502934049615*x_103 - 0.0126647028715703*x_104 - 0.0201252527080558*x_105 + 0.0193061548374147*x_106 + 0.0124729412627985*x_107 + 0.011099566173414*x_108 - 0.00600286948641859*x_11 + 0.0111623720869304*x_110 - 0.0166251437889164*x_111 + 0.00359244038744622*x_112 - 0.0240037702589665*x_113 - 0.0247587048365419*x_114 + 0.00432633418526342*x_115 - 0.00799897458406462*x_116 - 0.0031179219920866*x_117 - 0.0168476994524865*x_118 - 0.0252668805874279*x_119 + 0.00547099100441724*x_12 - 0.0259671836819539*x_120 - 0.000338991615561156*x_14 + 0.0121440350032132*x_16 - 0.00329972145547433*x_19 + 0.00161787839954686*x_23 + 0.00666127698004135*x_24 - 0.0177191368916855*x_27 + 0.000232001394970422*x_28 + 0.0136469760836994*x_29 + 0.00420614704230078*x_30 + 0.00921719229535519*x_33 - 0.00105388305937287*x_34 + 0.0194770025576262*x_35 - 0.02063167659856*x_36 + 0.00827802254012106*x_37 + 0.0083812257797797*x_38 - 0.00788572733697055*x_39 + 0.022696116799876*x_40 + 0.027121569465118*x_42 - 0.0155765857560064*x_43 - 0.0065303094398108*x_44 + 0.017073213354589*x_45 - 0.0217190945107686*x_46 + 0.0268860784674611*x_49 - 0.010932667941604*x_50 - 0.0118585208242008*x_51 - 0.000970107982002551*x_52 + 0.00319505471823798*x_53 + 0.00289069530014122*x_54 + 0.00399939614233438*x_56 + 0.013103303797613*x_58 + 0.00714608509180138*x_59 + 0.00102026221655487*x_6 - 0.00121319542020232*x_61 + 0.0101975321486474*x_62 - 0.00760944267814347*x_63 + 0.00648663934369592*x_64 + 0.00369729767873929*x_65 + 0.00442195880820793*x_66 + 0.00195754695485173*x_67 - 0.00769842871726514*x_68 + 0.00600953076861716*x_69 - 0.00223138997222486*x_70 - 0.00459782902405931*x_71 - 0.00359931724666017*x_72 + 0.000153770130740472*x_73 - 0.00793204561354367*x_74 + 0.000956506672194223*x_75 - 0.00481109829955269*x_76 - 0.00857622599755371*x_77 - 0.00072208581230583*x_78 + 0.00772501922995088*x_79 + 0.0148405882617642*x_8 + 0.00474521145097525*x_80 - 0.010114424211169*x_81 + 0.00214631717432748*x_82 + 0.00488448780453168*x_83 - 0.00075972784982306*x_84 + 0.00107741649843247*x_85 - 0.00687418050275583*x_86 + 0.00860139306608195*x_87 - 0.000125085820113432*x_88 - 0.00020814788007342*x_89 - 0.00375818147241774*x_9 - 0.00231569803925779*x_90 - 0.0109339812253119*x_91 - 0.0111087245588587*x_93 - 0.000230032259013073*x_95 + 0.0103595269664809*x_96 + 0.0225137785656907*x_99 + 1.61959631534763e-5*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) + 0.104626530693648*std::sin(0.274479955434799*x_1 - 4.2960000038147) + 0.0723487350714005*std::sin(0.227359995245934*x_101 - 7.41120004653931) - 0.151442798139545*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.0900160579461109*std::sin(0.188240006566048*x_109 - 4.2007999420166) + 0.0766124341983931*std::sin(0.313839942216873*x_13 - 4.26895999908447) + 0.138278047520449*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.0674689468867617*std::sin(0.387039840221405*x_17 + 2.00999975204468) + 0.0730109383958477*std::sin(0.412079870700836*x_2 + 5.19591999053955) + 0.0995094249214876*std::sin(0.35335984826088*x_20 + 8.23607921600342) + 0.105623604661622*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.40733022344612*std::sin(0.153920039534569*x_22 - 4.4475998878479) + 0.0348307061872051*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.140920962027973*std::sin(0.202959999442101*x_26 - 1.17263984680176) - 0.0476841813238318*std::sin(0.420319855213165*x_3 + 1.99263978004456) - 0.0846772736286705*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.0133775252248189*std::sin(0.344479858875275*x_32 - 7.59592008590698) - 0.0997677785540629*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.112731301254239*std::sin(0.261039972305298*x_41 + 1.96215975284576) - 0.147391109786265*std::sin(0.169440016150475*x_47 - 7.37831974029541) + 0.0850694205220881*std::sin(0.243039980530739*x_48 - 7.61728000640869) + 0.143286142756459*std::sin(0.33231982588768*x_5 - 7.34832000732422) - 0.214327113796109*std::sin(0.18520000576973*x_55 + 8.21592044830322) + 0.161671200100259*std::sin(0.224399983882904*x_57 - 4.2163200378418) + 0.0504368088699385*std::sin(0.484079837799072*x_60 - 7.69736051559448) - 0.0358057126581413*std::sin(0.314079910516739*x_7 + 4.82047986984253) - 0.0503982938953209*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.132923741244506*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.0737227406221765*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.148682365010858*std::sin(0.280639946460724*x_98 + 8.17799949645996) + 7.74025054043741) - 0.25618502497673*std::sin(0.0372433286880169*x_100 + 0.0241553213967373*x_102 - 0.0649330878149348*x_103 - 0.0190474498264702*x_104 + 0.00190730917979487*x_105 + 0.00147913041509013*x_106 + 0.0315186523051772*x_107 + 0.0362717014932591*x_108 + 0.0186999261304856*x_11 + 0.0252214490706025*x_111 + 0.0602048884794396*x_112 + 0.0118681497314738*x_115 - 0.0578620458923831*x_117 - 0.0508356632885179*x_119 + 0.00858080425670758*x_12 + 0.0155714108496798*x_120 + 0.00300162594097505*x_14 + 0.0151179197204029*x_16 - 0.0159474232076886*x_19 - 0.014319851494315*x_2 - 0.0111665676754312*x_22 + 0.00222497193612055*x_24 + 0.000251824472348536*x_26 - 0.0165387294558654*x_28 - 0.00531848687011793*x_31 + 0.0449469098732464*x_33 - 0.0364724677296528*x_35 - 0.0456175874045773*x_36 - 0.014382290095028*x_37 - 0.0173999919897962*x_39 + 0.0168440653228384*x_4 + 0.0225713522603136*x_41 - 0.0464912632399147*x_43 - 0.0267317047099268*x_44 + 0.0100569082830158*x_45 + 0.0298516766632603*x_46 - 0.0329090447917807*x_47 + 0.0285324294635069*x_48 - 0.0340874604426975*x_49 + 0.0120902283740132*x_5 + 0.0717246340475981*x_50 - 0.0662674851045904*x_51 + 0.0171454267078759*x_52 - 0.00763260417649143*x_53 + 0.00132756023740898*x_54 + 0.0454503410909245*x_55 - 0.00515099358833825*x_56 + 0.0521697969703205*x_57 + 0.036825260042804*x_58 + 0.0317261603540124*x_59 + 0.0464870302317071*x_6 + 0.0292061692196788*x_61 + 0.0166970358602692*x_62 + 0.000725163676731209*x_63 - 0.0122188319830996*x_64 + 0.00246821567812638*x_65 + 0.0215101007511629*x_66 - 0.0257030345659534*x_67 - 0.00178048445243601*x_68 - 0.0195930126090982*x_69 + 0.00114466772982665*x_70 + 0.00854863044691713*x_71 + 0.00198954019779295*x_72 + 0.0228613449062077*x_73 - 0.00714575146862405*x_74 - 0.00816430326437749*x_75 - 0.00967793445777133*x_76 - 0.00329920995704351*x_77 - 0.00066834825438906*x_78 - 0.0133167621062623*x_79 - 0.000667184049334673*x_80 + 0.00449738031047536*x_81 - 0.0151942682260871*x_82 - 0.0101397201453124*x_83 - 0.00736976382907235*x_84 - 0.0160563861804709*x_85 + 9.82744553567463e-5*x_86 + 0.00107381063809824*x_87 + 0.00221459265208996*x_88 - 0.00479806433281333*x_89 + 0.0027323965878454*x_9 + 0.0155911236118444*x_90 - 0.0470711165477439*x_93 - 0.0203509730174283*x_94 - 0.0018849030276088*x_96 + 0.00461062480071503*x_98 - 0.0338161402023487*x_99 - 0.276197588196334*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.221579670810308*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.323958597734526*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.325924285828689*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.104581550400691*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.145085517775931*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.160645284152787*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.08624598034219*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.39969171125243*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.473122475225836*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.335380486185644*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.227011924322422*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.175829384812118*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.313716095687369*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.144732627693571*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.174360938299842*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.260401455166734*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.306617530679203*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.320391684613908*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.222044534485759*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.338922110679993*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.242887467870911*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.282099678461032*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.143732933379823*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.390441708428702*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.312312100783778*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.262486655827301*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.356676630903285*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.120607198875708*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.388359100116853*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.151208460279872*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.0833666943321321*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.258306467067131*std::sin(0.276399940252304*x_97 + 1.96775984764099) + 6.37791230786616) + 0.88409746386393);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000237136846907472*x_1 - 0.00188883724586215*x_10 - 0.00190614833754358*x_100 + 0.000451801932109479*x_101 + 0.000277423893886434*x_102 + 0.00439760848641392*x_103 - 0.00237414438111201*x_104 - 0.00477938734113977*x_105 + 0.00552828502790853*x_106 + 0.00358028774539453*x_107 + 0.00214123968161737*x_108 + 0.000509728598248333*x_109 - 0.00179356063665355*x_11 + 0.00282052180335901*x_110 - 0.00450088690882264*x_111 - 8.43387171154034e-5*x_112 - 0.00639438657940521*x_113 - 0.00418133118216429*x_114 + 0.0023853991764113*x_115 - 0.00297567026302905*x_116 + 0.00170174131722977*x_117 - 0.00332260105241773*x_118 - 0.00503478142678538*x_119 + 0.00199028452418407*x_12 - 0.00564330053757224*x_120 - 7.99190486108753e-5*x_13 - 0.00120546994732551*x_14 - 0.000516297291099213*x_15 + 0.0032993994590638*x_16 - 8.42736668363294e-5*x_17 - 2.13217895514405e-6*x_18 - 0.000883590657456987*x_19 + 0.00024330042480297*x_2 - 4.05256492524247e-5*x_20 - 9.87658450067556e-5*x_21 + 0.000182771521787148*x_22 + 0.000377224164302652*x_23 + 0.00164878269235438*x_24 + 6.89520062988317e-5*x_25 - 4.12179851250578e-6*x_26 - 0.00450885667219005*x_27 + 5.23614317809017e-5*x_28 + 0.00326886857214582*x_29 - 3.54045601160489e-5*x_3 - 0.000394840052988384*x_30 + 7.41109143398968e-5*x_31 + 0.00074504087660377*x_33 + 0.000962534614162664*x_34 + 0.00544752485519273*x_35 - 0.00430960789534747*x_36 + 0.00158019754024012*x_37 + 0.00355326937486567*x_38 - 0.000121042457105427*x_39 - 0.000275699350205068*x_4 + 0.00434291487883778*x_40 - 0.00036944211697996*x_41 + 0.00676407230295593*x_42 - 0.00203764447893276*x_43 - 0.00123388363231421*x_44 + 0.00590228315806009*x_45 - 0.00644828473621984*x_46 - 0.000784414120635969*x_47 - 0.000893533363594649*x_48 + 0.00687973995815366*x_49 - 0.000192135420218449*x_5 - 0.00287026271538161*x_50 - 0.000188580092224975*x_51 - 0.000771486486627064*x_52 + 0.00109313121193871*x_53 + 0.000906234126445089*x_54 + 0.000449495831481019*x_55 + 0.00296599964155914*x_56 - 0.000804774917662248*x_57 + 0.00363439945449576*x_58 + 0.000446257363509863*x_59 - 0.000906531866928288*x_6 + 3.39007560077875e-5*x_60 - 3.01278726594137e-5*x_61 + 0.00187601135336388*x_62 - 0.00219027641786975*x_63 + 0.00169243474910055*x_64 + 0.000240153646366229*x_65 + 0.00129051316994651*x_66 + 0.00059930941017576*x_67 - 0.00143960244789455*x_68 + 0.00114989972630552*x_69 - 5.4210878634768e-5*x_7 - 0.000130464400756271*x_70 - 0.00207076579667758*x_71 - 0.000468357773270532*x_72 - 9.66593989214449e-5*x_73 - 0.00200315994073359*x_74 + 0.000974150679383894*x_75 - 0.00156451516937699*x_76 - 0.00177007554770228*x_77 - 0.000100801587556543*x_78 + 0.00199392084749933*x_79 + 0.00277679941709555*x_8 + 0.00149950437569488*x_80 - 0.00200367797204295*x_81 + 0.00144652462611672*x_82 + 0.000770371848895005*x_83 - 4.87565691309478e-6*x_84 + 0.00116091166855537*x_85 - 0.0022995445905052*x_86 + 0.00229442194527738*x_87 + 0.000151510718904142*x_88 - 0.000534684428586781*x_89 - 0.00055891893702922*x_9 - 0.00113014140143206*x_90 - 0.00273961522910027*x_91 - 5.99883553549499e-5*x_92 - 0.00237151663741343*x_93 + 0.000122655273193412*x_94 - 0.000386065555712957*x_95 + 0.00202949188086258*x_96 - 3.52752335764402e-6*x_97 - 1.5539913397938e-5*x_98 + 0.00613485972070974*x_99 + 4.03924507123457e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) - 3.21851477485912e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) + 0.0260936749744321*std::sin(0.274479955434799*x_1 - 4.2960000038147) - 0.000332947539582626*std::sin(0.406479865312576*x_1 - 0.994959831237793) + 0.0045207314347499*std::sin(0.41023987531662*x_1 + 8.40791988372803) - 0.00362675934165521*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.000483881047937985*std::sin(0.237999975681305*x_100 - 1.19359982013702) + 0.000300777592450772*std::sin(0.239599987864494*x_100 - 1.19783997535706) + 0.0180436488264352*std::sin(0.227359995245934*x_101 - 7.41120004653931) - 0.00530247141511936*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.0377695707357688*std::sin(0.233519986271858*x_102 + 1.97087979316711) + 0.000550240518402348*std::sin(0.235839992761612*x_102 + 1.95447981357574) + 0.000254929979983457*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00806962136689608*std::sin(0.25639995932579*x_108 + 1.9586398601532) + 0.022449848455771*std::sin(0.188240006566048*x_109 - 4.2007999420166) + 0.00533464529475469*std::sin(0.248879969120026*x_109 + 1.95135986804962) - 0.000209867566095103*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.00487210203080294*std::sin(0.344479858875275*x_11 + 5.061119556427) + 0.000575573640554715*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00475837948776651*std::sin(0.228319987654686*x_110 - 1.20983994007111) - 0.00171176405079687*std::sin(0.23191998898983*x_110 + 1.94151985645294) - 0.000562298753426002*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00416959538661589*std::sin(0.271599948406219*x_112 + 1.96775984764099) + 0.000558040057340084*std::sin(0.262879967689514*x_113 + 8.36128044128418) - 0.00237472262237996*std::sin(0.287759929895401*x_113 - 7.41791963577271) + 0.00262940089613525*std::sin(0.224719986319542*x_114 - 7.41479969024658) - 0.00141165213280793*std::sin(0.231519982218742*x_116 - 1.19407987594604) + 0.000673734602300894*std::sin(0.226719990372658*x_117 + 8.36223983764648) + 0.00654205163436624*std::sin(0.232879981398582*x_118 + 5.16504001617432) + 0.000519267375622405*std::sin(0.25111997127533*x_12 - 4.21424007415771) - 0.000114296923275389*std::sin(0.27295994758606*x_120 - 7.44464015960693) + 0.00774394758552241*std::sin(0.180880010128021*x_13 - 4.40488004684448) - 0.0135092500132389*std::sin(0.208959996700287*x_13 + 8.18591976165771) + 0.0191070079808573*std::sin(0.313839942216873*x_13 - 4.26895999908447) - 9.42660080411859e-5*std::sin(0.272559970617294*x_14 + 5.15696001052856) - 0.00548942196201721*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.0344863048041095*std::sin(0.321919918060303*x_15 + 5.13399982452393) - 0.000232691269914837*std::sin(0.351919859647751*x_15 + 5.03336000442505) - 0.00371567307683341*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.0168266381314435*std::sin(0.387039840221405*x_17 + 2.00999975204468) - 0.000309182780856718*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.0050967420780345*std::sin(0.338479846715927*x_18 + 4.99368000030518) + 0.0028779303695724*std::sin(0.380239844322205*x_18 - 1.16895985603333) - 0.000338725408548112*std::sin(0.41567987203598*x_18 + 8.1988000869751) + 0.00240521040037179*std::sin(0.110080063343048*x_19 + 1.72039985656738) + 0.0182088011850249*std::sin(0.412079870700836*x_2 + 5.19591999053955) - 0.00109064798909673*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.00993967575386155*std::sin(0.269679963588715*x_20 - 4.3887996673584) - 0.00513482476303433*std::sin(0.33519983291626*x_20 - 1.15567982196808) + 0.0248174776854337*std::sin(0.35335984826088*x_20 + 8.23607921600342) - 0.000172795477617165*std::sin(0.363519847393036*x_20 - 1.17807984352112) + 0.000359861923285621*std::sin(0.272719949483871*x_21 + 2.00431990623474) + 0.0263423434897053*std::sin(0.347679853439331*x_21 - 1.15399980545044) - 0.000356140433506427*std::sin(0.364559859037399*x_21 - 4.36879968643188) + 0.00236894660782909*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.101587450022475*std::sin(0.153920039534569*x_22 - 4.4475998878479) - 0.000363472086303846*std::sin(0.231279984116554*x_22 - 1.16823983192444) - 0.000289434810177424*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.00254533955758573*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.00919082785852596*std::sin(0.311679929494858*x_23 - 7.36215972900391) + 0.00285389521288748*std::sin(0.328399837017059*x_23 - 1.17247986793518) - 0.0065091507414665*std::sin(0.345839858055115*x_24 - 7.36495971679688) - 0.00426218437211718*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.000483792133284176*std::sin(0.328959852457047*x_25 - 1.15583980083466) + 0.00868671760741131*std::sin(0.352959841489792*x_25 + 8.22855949401855) - 0.000266343831010958*std::sin(0.373519837856293*x_25 + 8.2203197479248) - 0.0351454430904251*std::sin(0.202959999442101*x_26 - 1.17263984680176) - 0.00802777897515617*std::sin(0.258959978818893*x_26 + 5.20328044891357) - 0.00036531992877217*std::sin(0.353839844465256*x_26 - 1.16007995605469) - 0.000209480432779938*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00894067178034842*std::sin(0.204159989953041*x_27 + 1.77231991291046) - 0.00501863726775751*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.000144945018023794*std::sin(0.361759841442108*x_27 + 2.03087973594666) + 0.000326368314130837*std::sin(0.313359916210175*x_28 - 1.17319989204407) - 0.000385269955984904*std::sin(0.182880014181137*x_29 - 4.61615991592407) - 0.0052440890940618*std::sin(0.328719854354858*x_29 - 1.16823983192444) - 0.000450537625146302*std::sin(0.345119833946228*x_29 - 1.17687976360321) - 0.00363436811131974*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.0002949479575893*std::sin(0.318319916725159*x_3 - 4.14279985427856) - 0.0118923519745599*std::sin(0.420319855213165*x_3 + 1.99263978004456) - 0.00554739036531227*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.0211183649227292*std::sin(0.370719850063324*x_31 + 5.17447996139526) - 0.000323962047844392*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.00624873726383727*std::sin(0.400159865617752*x_31 + 5.20528030395508) + 0.00397551991051531*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.00448584195893597*std::sin(0.299599945545197*x_32 + 2.03711986541748) - 0.000541974311258455*std::sin(0.32535982131958*x_32 - 1.1885598897934) - 8.62096031401917e-5*std::sin(0.327279835939407*x_32 + 8.2041597366333) - 0.00333633154864692*std::sin(0.344479858875275*x_32 - 7.59592008590698) - 0.00461733533764634*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.00963281305245798*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00811245125827618*std::sin(0.265119940042496*x_36 - 1.23519992828369) - 0.000454745437422238*std::sin(0.217040002346039*x_37 - 7.41472005844116) + 0.00235258386715921*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.000563457435731335*std::sin(0.249519973993301*x_38 + 1.97479975223541) - 0.000620503609674022*std::sin(0.185760006308556*x_4 - 1.18887984752655) - 0.0248819106325284*std::sin(0.210559993982315*x_4 - 1.200159907341) + 0.00015462303905219*std::sin(0.269039958715439*x_4 - 4.17000007629395) + 0.000790357116310474*std::sin(0.231199979782104*x_40 + 1.97247982025146) - 0.00639064995555422*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.00448972597422543*std::sin(0.241679981350899*x_41 - 1.19143986701965) + 0.000573760274632761*std::sin(0.244559973478317*x_41 + 1.98751986026764) - 0.000389933028103323*std::sin(0.25927996635437*x_41 - 7.43383979797363) + 0.0281149906708271*std::sin(0.261039972305298*x_41 + 1.96215975284576) - 0.00572562413818934*std::sin(0.246239975094795*x_42 + 5.17119979858398) + 0.00049077737724792*std::sin(0.252799987792969*x_42 + 1.96831977367401) + 0.0051118445337849*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.000420111110643706*std::sin(0.273919969797134*x_42 + 1.94215977191925) + 0.000611579121339438*std::sin(0.215999990701675*x_44 + 1.99159979820251) - 0.0367590866999582*std::sin(0.169440016150475*x_47 - 7.37831974029541) + 0.0212161656766224*std::sin(0.243039980530739*x_48 - 7.61728000640869) - 0.00365214295081887*std::sin(0.300399929285049*x_5 - 7.38207960128784) + 0.0357353150547896*std::sin(0.33231982588768*x_5 - 7.34832000732422) + 0.000479873233103372*std::sin(0.18792000412941*x_51 - 1.1827198266983) - 0.000441053018454607*std::sin(0.292639940977097*x_53 + 8.14832019805908) - 0.0534528098038459*std::sin(0.18520000576973*x_55 + 8.21592044830322) + 0.0403205164137078*std::sin(0.224399983882904*x_57 - 4.2163200378418) + 0.00887305542305644*std::sin(0.229039996862411*x_57 - 4.20983982086182) + 0.00037666564136083*std::sin(0.351439833641052*x_6 + 2.03335976600647) - 0.00272884054286248*std::sin(0.0657600983977318*x_60 - 1.37215983867645) + 0.00429631440285186*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.0125788525020799*std::sin(0.484079837799072*x_60 - 7.69736051559448) - 0.00892988252726391*std::sin(0.314079910516739*x_7 + 4.82047986984253) - 0.00583799180830997*std::sin(0.326159834861755*x_7 - 7.3583197593689) + 0.00428221833343185*std::sin(0.346639841794968*x_7 + 8.22824001312256) + 0.00026126300357776*std::sin(0.311839938163757*x_8 - 7.41599988937378) - 0.000322801707040733*std::sin(0.319439917802811*x_8 + 1.98247981071472) + 0.00197406776349897*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.000361842148227323*std::sin(0.330639839172363*x_9 - 1.10911989212036) - 7.81030732702117e-5*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.00397248236048596*std::sin(0.360639840364456*x_91 - 7.3983998298645) + 0.00635656235571988*std::sin(0.373839855194092*x_91 - 7.38359975814819) + 0.00247494137820434*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.000641028965717734*std::sin(0.27567994594574*x_92 - 7.38263988494873) - 0.0125692469343271*std::sin(0.343999862670898*x_92 - 1.3698399066925) - 0.000231139667995173*std::sin(0.205679997801781*x_93 + 8.3834400177002) - 0.000255549554882113*std::sin(0.27991995215416*x_94 + 1.96287977695465) - 0.0331509501215854*std::sin(0.281039953231812*x_94 + 1.98919987678528) + 0.000486849999135585*std::sin(0.270399957895279*x_95 + 1.9871199131012) + 0.00136452471630763*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 9.50176128394281e-5*std::sin(0.294399946928024*x_95 - 4.4191198348999) + 0.000519955195324381*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.0070006758755866*std::sin(0.273999959230423*x_97 + 1.96847975254059) + 0.00422789414308531*std::sin(0.276399940252304*x_97 + 1.96775984764099) + 0.0183863234235696*std::sin(0.288799941539764*x_97 + 8.18423938751221) - 0.000455273087575485*std::sin(0.247999966144562*x_98 - 7.41847991943359) - 0.00026663294937119*std::sin(0.276959955692291*x_98 - 1.23423981666565) - 0.0370811235095149*std::sin(0.280639946460724*x_98 + 8.17799949645996) - 0.00867696588744198*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.169374530459017);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00029243835584926*x_1 - 0.00465076813160684*x_10 - 0.000273665776328244*x_100 - 0.00184608704511828*x_101 - 8.64560662774804e-5*x_102 - 0.00655573397018284*x_103 + 0.00300940774137692*x_104 + 0.00541191581437827*x_105 - 0.00104173869903235*x_106 - 0.0111412183256426*x_107 - 0.00372491267505661*x_108 - 0.00109243696311655*x_109 + 0.00207894324730998*x_11 - 0.00403236857005976*x_110 + 0.0104133481656208*x_111 - 0.00175270447371516*x_112 + 0.0081404093334608*x_113 + 0.00418628844791847*x_114 + 0.00704812419765379*x_115 + 0.00460337845793961*x_116 + 0.00224804163456285*x_117 + 0.00861983735124063*x_118 + 0.00554474831964877*x_119 - 0.0116721144319491*x_12 + 0.0152507787822784*x_120 + 0.000436016685243794*x_13 - 0.00830072845443046*x_14 - 0.000706085184205848*x_15 - 0.00455616733182168*x_16 - 0.000159445721495611*x_17 + 0.000204017456714062*x_18 + 0.00121162494485983*x_19 + 0.00245663842656095*x_2 + 0.000123774984353188*x_20 - 8.1453115306911e-5*x_21 - 0.00119305918082202*x_23 - 0.0028686160061866*x_24 + 5.6865363925327e-5*x_25 + 0.00649737988416435*x_27 - 0.000250848074647349*x_28 - 0.00490414416873384*x_29 + 9.4635392949043e-5*x_3 - 0.00222005868964892*x_30 + 3.95240333699466e-5*x_31 - 0.00885033750191561*x_33 - 0.00673403516208077*x_34 - 0.0114967431111278*x_35 + 5.41665563053581e-5*x_36 - 0.00351718708542906*x_37 - 0.00175078867132118*x_38 + 0.00632255256614753*x_39 - 0.0106744258193739*x_40 - 0.00952562756836167*x_42 + 0.013019478375569*x_43 + 0.00223536019525924*x_44 - 0.00401047254844725*x_45 + 0.00162380578500351*x_46 - 0.00264006767755034*x_47 - 0.00212077905729069*x_48 - 0.00774777128403661*x_49 - 0.00212992713976573*x_5 + 0.0100628644440613*x_50 + 0.00558689644061341*x_51 + 1.09083430513817e-5*x_52 - 0.000927140881364205*x_53 + 0.00716980645319627*x_54 - 0.00580931443655417*x_55 - 0.0037496743335602*x_56 - 0.00794182306140614*x_57 - 0.0109716466523121*x_58 - 0.00324023721226646*x_59 - 0.000273977232314797*x_6 + 0.00996346423573258*x_60 + 0.00525449108470906*x_61 - 0.00557975020105239*x_62 + 0.00223949527163762*x_63 + 0.000766139425872082*x_64 - 0.00362163965411119*x_65 + 0.00155630864907517*x_66 - 0.00176450876313823*x_67 + 0.0013406916157785*x_68 + 0.000650051997908594*x_69 + 0.00319644171647774*x_7 + 0.00117868821947931*x_70 + 0.00276466264604329*x_71 + 0.00186837802472361*x_72 + 0.000591505433530475*x_73 + 0.00440171212590469*x_74 + 0.000837303155451135*x_75 + 0.000926335232684137*x_76 + 0.00215811629307013*x_77 + 0.00201606540677142*x_78 - 0.00271579894001801*x_79 - 0.00597468166470123*x_8 - 0.000203468488095325*x_80 + 0.00307010750285855*x_81 - 0.00167865220916359*x_82 - 0.000946278163877456*x_83 - 0.00315438001441727*x_84 - 0.00129881600513644*x_85 + 0.00247592878085151*x_86 - 6.23320622389806e-5*x_87 - 0.00368508158322432*x_88 - 0.00347844964874317*x_89 + 0.00328189589005105*x_9 + 0.00326451394764587*x_90 + 0.00505536164480883*x_91 - 0.00132671523665506*x_92 + 0.0022766492694101*x_93 - 0.000230703190934829*x_94 - 0.000190286743806044*x_95 + 0.00138214052769966*x_96 + 0.000254640125179391*x_97 + 4.94212132843447e-5*x_98 - 0.0101693445047507*x_99 - 5.68834017180844e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) - 2.65433921064174e-5*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) + 0.00637756567448378*std::pow(0.077870282097411*x_100 + 0.0505051980469933*x_102 - 0.135765465755262*x_103 - 0.0398253954056676*x_104 + 0.00398790089687649*x_105 + 0.00309264254134698*x_106 + 0.0659008319824017*x_107 + 0.0758387535951359*x_108 + 0.0390987748485055*x_11 + 0.0527343130493387*x_111 + 0.125879501502387*x_112 + 0.0248145426340887*x_115 - 0.120980964782102*x_117 - 0.106289839827329*x_119 + 0.0179411903186698*x_12 + 0.032557512935448*x_120 + 0.0062759551041376*x_14 + 0.0316093301760259*x_16 - 0.0333436990638561*x_19 - 0.0299406877617286*x_2 - 0.0233476385054013*x_22 + 0.00465208665358305*x_24 + 0.000526527659895278*x_26 - 0.0345800328174044*x_28 - 0.0111201680273201*x_31 + 0.093977328948117*x_33 - 0.0762585260487364*x_35 - 0.0953796162946274*x_36 - 0.0300712376245514*x_37 - 0.0363808051661634*x_39 + 0.0352184448748985*x_4 + 0.0471933532728556*x_41 - 0.0972063430174002*x_43 - 0.0558920338228643*x_44 + 0.0210275051294812*x_45 + 0.0624154329040066*x_46 - 0.0688079366632133*x_47 + 0.0596570824766971*x_48 - 0.0712718291883306*x_49 + 0.0252788761711691*x_5 + 0.149965582652581*x_50 - 0.138555492775832*x_51 + 0.0358485468795479*x_52 - 0.0159586444418031*x_53 + 0.00277573175733901*x_54 + 0.0950299290329706*x_55 - 0.0107699643919023*x_56 + 0.109079315682935*x_57 + 0.0769961625037646*x_58 + 0.0663347005669108*x_59 + 0.0971974924244254*x_6 + 0.0610657724816329*x_61 + 0.0349110280534106*x_62 + 0.00151620980355668*x_63 - 0.0255477672631065*x_64 + 0.00516067327770289*x_65 + 0.0449744336084471*x_66 - 0.053741236965596*x_67 - 0.0037227291830619*x_68 - 0.0409660863503725*x_69 + 0.00239333062240712*x_70 + 0.0178739196494576*x_71 + 0.00415983377168227*x_72 + 0.0477996849284149*x_73 - 0.0149407075645948*x_74 - 0.0170703484549286*x_75 - 0.0202351270118717*x_76 - 0.00689815918994983*x_77 - 0.00139741717354426*x_78 - 0.0278433764748964*x_79 - 0.00139498299327096*x_80 + 0.00940335587105402*x_81 - 0.0317689635891709*x_82 - 0.0212006524636539*x_83 - 0.0154090842193117*x_84 - 0.033571524495353*x_85 + 0.000205477325233325*x_86 + 0.00224517894220382*x_87 + 0.00463038510853046*x_88 - 0.0100320416106607*x_89 + 0.00571303641733787*x_9 + 0.0325987294003761*x_90 - 0.0984187303696163*x_93 - 0.0425508692603472*x_94 - 0.00394105295248186*x_96 + 0.00964013332117968*x_98 - 0.0707045387661538*x_99 - 0.57748823386974*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.463290261125392*std::sin(0.327039837837219*x_10 - 1.12639987468719) + 0.677349428263806*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.681459390820866*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.218664526474152*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.303352320951264*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.33588548701935*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.180327566187041*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.835696147569053*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.989228995106316*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.701230904681349*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.474648298344796*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.367633191732921*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.655933874072161*std::sin(0.33519983291626*x_20 - 1.15567982196808) - 0.302614480075306*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.364562887649369*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.544460860152231*std::sin(0.302319914102554*x_25 - 1.160719871521) + 0.641091826404963*std::sin(0.256799966096878*x_27 - 1.18519985675812) + 0.669891541423286*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.464262222193842*std::sin(0.280079960823059*x_3 - 1.11783981323242) + 0.708635916751252*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.507841707691377*std::sin(0.29615992307663*x_32 + 2.0271999835968) + 0.589828630125037*std::sin(0.230879992246628*x_34 + 1.98255980014801) - 0.300524267385811*std::sin(0.243279978632927*x_38 + 1.95791983604431) + 0.816355762199112*std::sin(0.231599986553192*x_40 + 1.95583975315094) - 0.652998328752844*std::sin(0.256479978561401*x_42 + 1.96983981132507) - 0.54882070577796*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.74575798792468*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.25217178298168*std::sin(0.360239863395691*x_8 - 7.56568002700806) - 0.812001336790455*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.31615448651606*std::sin(0.261199980974197*x_92 + 5.20943975448608) - 0.174307405751852*std::sin(0.288719952106476*x_95 + 4.98839950561523) - 0.54008055044164*std::sin(0.276399940252304*x_97 + 1.96775984764099) - 1.32614783672685, 2) - 0.0367468913050646*std::sin(0.274479955434799*x_1 - 4.2960000038147) + 0.0318580718006677*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.0463001384167461*std::sin(0.237999975681305*x_100 - 1.19359982013702) - 0.000918646400147592*std::sin(0.239599987864494*x_100 - 1.19783997535706) - 0.0254102958981997*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.0531896833936267*std::sin(0.233519986271858*x_102 + 1.97087979316711) - 0.00168056558777194*std::sin(0.235839992761612*x_102 + 1.95447981357574) - 0.000778616872664246*std::sin(0.25791996717453*x_103 + 1.94479978084564) - 0.00665509214886928*std::sin(0.25639995932579*x_108 + 1.9586398601532) - 0.0316154064855842*std::sin(0.188240006566048*x_109 - 4.2007999420166) + 0.0200811695370103*std::sin(0.258959978818893*x_11 - 7.41095972061157) - 0.00401806807277235*std::sin(0.344479858875275*x_11 + 5.061119556427) - 0.0550737404167339*std::sin(0.199520006775856*x_110 - 4.20688009262085) + 0.00392428002883563*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00171739430930787*std::sin(0.269279956817627*x_112 - 7.43856000900269) + 0.00343870427864975*std::sin(0.271599948406219*x_112 + 1.96775984764099) - 0.0533960402190544*std::sin(0.262879967689514*x_113 + 8.36128044128418) - 0.0644662680541286*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.00158596623319832*std::sin(0.25111997127533*x_12 - 4.21424007415771) + 0.000349090024490659*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.0111412047248011*std::sin(0.208959996700287*x_13 + 8.18591976165771) - 0.0269077907242096*std::sin(0.313839942216873*x_13 - 4.26895999908447) + 0.000287910838828503*std::sin(0.272559970617294*x_14 + 5.15696001052856) - 0.0485659645638903*std::sin(0.321919918060303*x_15 + 5.13399982452393) + 0.022265054709905*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.023696418501866*std::sin(0.387039840221405*x_17 + 2.00999975204468) + 0.0295841418273012*std::sin(0.451359868049622*x_17 + 1.96111989021301) + 0.00420333081890135*std::sin(0.338479846715927*x_18 + 4.99368000030518) + 0.00103454806811174*std::sin(0.41567987203598*x_18 + 8.1988000869751) - 0.230142459460168*std::sin(0.110080063343048*x_19 + 1.72039985656738) - 0.0256428747042061*std::sin(0.412079870700836*x_2 + 5.19591999053955) - 0.000899467588305147*std::sin(0.42103984951973*x_2 + 5.20783996582031) - 0.00819734347675773*std::sin(0.269679963588715*x_20 - 4.3887996673584) - 0.0349496633136608*std::sin(0.35335984826088*x_20 + 8.23607921600342) + 0.0165339282568634*std::sin(0.363519847393036*x_20 - 1.17807984352112) - 0.0344333735120292*std::sin(0.272719949483871*x_21 + 2.00431990623474) - 0.0370970832542894*std::sin(0.347679853439331*x_21 - 1.15399980545044) + 0.00108773770187428*std::sin(0.364559859037399*x_21 - 4.36879968643188) + 0.143062370003166*std::sin(0.153920039534569*x_22 - 4.4475998878479) + 0.0347788118137835*std::sin(0.231279984116554*x_22 - 1.16823983192444) + 0.000884002841702412*std::sin(0.327679842710495*x_22 - 7.36279964447021) - 0.00209916531838604*std::sin(0.504719853401184*x_22 + 8.14903926849365) - 0.00757976161977128*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00536815744206381*std::sin(0.345839858055115*x_24 - 7.36495971679688) - 0.00147761639435947*std::sin(0.328959852457047*x_25 - 1.15583980083466) - 0.0122332277086348*std::sin(0.352959841489792*x_25 + 8.22855949401855) + 0.0254850986514236*std::sin(0.373519837856293*x_25 + 8.2203197479248) + 0.0494942080169868*std::sin(0.202959999442101*x_26 - 1.17263984680176) - 0.00662058433739989*std::sin(0.258959978818893*x_26 + 5.20328044891357) + 0.0349556225453059*std::sin(0.353839844465256*x_26 - 1.16007995605469) + 0.000639803131299236*std::sin(0.387359857559204*x_26 + 8.2052001953125) - 0.00737345556448338*std::sin(0.204159989953041*x_27 + 1.77231991291046) - 0.0138690581619545*std::sin(0.361759841442108*x_27 + 2.03087973594666) - 0.0312285388805607*std::sin(0.313359916210175*x_28 - 1.17319989204407) + 0.001176706200973*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.0431096743613304*std::sin(0.345119833946228*x_29 - 1.17687976360321) - 0.000900841306902349*std::sin(0.318319916725159*x_3 - 4.14279985427856) + 0.0167476204788679*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.029740320637726*std::sin(0.370719850063324*x_31 + 5.17447996139526) + 0.0309982953886845*std::sin(0.384479850530624*x_31 + 5.18416023254395) + 0.00515339201359655*std::sin(0.400159865617752*x_31 + 5.20528030395508) + 0.00369951578204792*std::sin(0.299599945545197*x_32 + 2.03711986541748) + 0.00165531862248528*std::sin(0.32535982131958*x_32 - 1.1885598897934) + 0.00824896237464374*std::sin(0.327279835939407*x_32 + 8.2041597366333) + 0.00469844944784188*std::sin(0.344479858875275*x_32 - 7.59592008590698) - 0.00794427093939316*std::sin(0.234959989786148*x_35 + 1.98535978794098) + 0.00669041436051975*std::sin(0.265119940042496*x_36 - 1.23519992828369) + 0.0435122987080324*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.0539144018503678*std::sin(0.249519973993301*x_38 + 1.97479975223541) + 0.059372862686864*std::sin(0.185760006308556*x_4 - 1.18887984752655) + 0.0350404021806726*std::sin(0.210559993982315*x_4 - 1.200159907341) - 0.00047225558608866*std::sin(0.269039958715439*x_4 - 4.17000007629395) - 0.00241393886364219*std::sin(0.231199979782104*x_40 + 1.97247982025146) - 0.0037027189657518*std::sin(0.241679981350899*x_41 - 1.19143986701965) - 0.0549002285721505*std::sin(0.244559973478317*x_41 + 1.98751986026764) + 0.00119094833377389*std::sin(0.25927996635437*x_41 - 7.43383979797363) - 0.0395934458153598*std::sin(0.261039972305298*x_41 + 1.96215975284576) - 0.00472197573057842*std::sin(0.246239975094795*x_42 + 5.17119979858398) - 0.00149895099302143*std::sin(0.252799987792969*x_42 + 1.96831977367401) + 0.0401983145570715*std::sin(0.273919969797134*x_42 + 1.94215977191925) - 0.0585189233830811*std::sin(0.215999990701675*x_44 + 1.99159979820251) + 0.0517666509129272*std::sin(0.169440016150475*x_47 - 7.37831974029541) - 0.0298780503241879*std::sin(0.243039980530739*x_48 - 7.61728000640869) - 0.00301195641944869*std::sin(0.300399929285049*x_5 - 7.38207960128784) - 0.0503249059152186*std::sin(0.33231982588768*x_5 - 7.34832000732422) - 0.0459166508170932*std::sin(0.18792000412941*x_51 - 1.1827198266983) + 0.0422021401552993*std::sin(0.292639940977097*x_53 + 8.14832019805908) + 0.0752758894152265*std::sin(0.18520000576973*x_55 + 8.21592044830322) - 0.0567820989366348*std::sin(0.224399983882904*x_57 - 4.2163200378418) + 0.00731769172277515*std::sin(0.229039996862411*x_57 - 4.20983982086182) - 0.0360412365934901*std::sin(0.351439833641052*x_6 + 2.03335976600647) + 0.00833452891504115*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.0177143973046836*std::sin(0.484079837799072*x_60 - 7.69736051559448) + 0.0125756691197348*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.00353158547530814*std::sin(0.346639841794968*x_7 + 8.22824001312256) - 0.000797959434985966*std::sin(0.311839938163757*x_8 - 7.41599988937378) + 0.0308872682260193*std::sin(0.319439917802811*x_8 + 1.98247981071472) + 0.00110515209654491*std::sin(0.330639839172363*x_9 - 1.10911989212036) + 0.000238545386694279*std::sin(0.252399981021881*x_91 - 1.34951984882355) + 0.00327614332405297*std::sin(0.360639840364456*x_91 - 7.3983998298645) + 0.00195785512793248*std::sin(0.27567994594574*x_92 - 7.38263988494873) + 0.0177008700895833*std::sin(0.343999862670898*x_92 - 1.3698399066925) + 0.000705955593982048*std::sin(0.205679997801781*x_93 + 8.3834400177002) + 0.0244522487784975*std::sin(0.27991995215416*x_94 + 1.96287977695465) + 0.0466854270995237*std::sin(0.281039953231812*x_94 + 1.98919987678528) - 0.00148695584492706*std::sin(0.270399957895279*x_95 + 1.9871199131012) + 0.0090917564249347*std::sin(0.294399946928024*x_95 - 4.4191198348999) - 0.00158806699837841*std::sin(0.282319933176041*x_96 + 1.95719981193542) + 0.00577352281329099*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.0258928736181354*std::sin(0.288799941539764*x_97 + 8.18423938751221) + 0.0435627868915128*std::sin(0.247999966144562*x_98 - 7.41847991943359) + 0.000814360528338454*std::sin(0.276959955692291*x_98 - 1.23423981666565) + 0.0522201650939922*std::sin(0.280639946460724*x_98 + 8.17799949645996) - 0.00715597485037061*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.338588020242287);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00021152632077968*x_1 - 0.00369935265056758*x_10 + 0.000340774512920196*x_100 - 9.41540402926602e-5*x_101 + 1.10259799400073e-5*x_102 + 0.00110431927776039*x_103 - 0.00411523804721348*x_104 - 0.0046092412941486*x_105 + 0.00608148225784786*x_106 + 0.000676777146740586*x_107 + 0.00333496641448586*x_108 - 0.000897080567903231*x_109 - 0.00118858675502293*x_11 + 0.00212670697823957*x_110 - 0.00122896158828575*x_111 + 0.00146253507220392*x_112 - 0.0051902402881974*x_113 - 0.00725905121186952*x_114 + 0.00426009816483551*x_115 - 0.000708073437553278*x_116 - 0.00202312040568364*x_117 - 0.00226746381258883*x_118 - 0.00777118370683252*x_119 - 0.00212872246606583*x_12 - 0.00409787636776131*x_120 + 0.000858515521626198*x_13 - 0.00228659756034536*x_14 - 0.000639983137042406*x_15 + 0.00286740325095297*x_16 - 0.000218757493719286*x_17 + 6.66427498219423e-5*x_18 - 8.05865119824399e-5*x_19 + 0.00027917120227593*x_2 + 0.000413213345616336*x_20 + 1.62435674611863e-5*x_21 - 0.000151758171318166*x_22 + 0.00046998436366769*x_23 + 0.00117508154115715*x_24 - 1.13402215697401e-5*x_25 + 3.42239643618157e-6*x_26 - 0.00305409969339393*x_27 + 2.37158426923294e-5*x_28 + 0.00307905382880164*x_29 + 4.57167355447853e-5*x_3 + 0.00080953408152886*x_30 + 5.96675833564915e-5*x_31 + 0.00134989134774368*x_33 - 0.00234833766475863*x_34 + 0.00287491377685308*x_35 - 0.0077244843110245*x_36 + 0.00173524667659922*x_37 + 0.00160135838313582*x_38 - 0.00149968832091943*x_39 + 0.000228917660758188*x_4 + 0.00477978557362024*x_40 + 0.000306753806788807*x_41 + 0.00607519913940514*x_42 - 0.00154389170520304*x_43 - 0.00187836181510072*x_44 + 0.00421547388450118*x_45 - 0.00617216284518219*x_46 - 0.00119489892118288*x_47 - 0.000340191071781871*x_48 + 0.00611999490874082*x_49 - 0.000374600053704964*x_5 + 0.000444387590376107*x_50 - 0.00374875589837772*x_51 + 0.00101970844047635*x_52 + 0.000722660070796398*x_53 + 0.00336476766837139*x_54 - 0.000809398804665628*x_55 - 0.00101041615553638*x_56 - 0.00156334765148917*x_57 + 0.000791520855091359*x_58 + 0.0022787162012061*x_59 + 0.00199765044375237*x_6 + 0.00319521431974269*x_60 + 0.00117529800678187*x_61 + 0.00223547616869767*x_62 - 0.00170364179612177*x_63 + 0.00260431090121965*x_64 + 8.73494719575726e-5*x_65 + 0.00204757699005673*x_66 + 3.01584924595282e-5*x_67 - 0.002218867592042*x_68 + 0.0020013158019264*x_69 + 0.00124181298328895*x_7 - 0.000844283378983077*x_70 - 5.99190785967398e-5*x_71 - 0.000835527199183721*x_72 + 0.000464155321625768*x_73 - 0.00148949118400342*x_74 + 0.000240269642062676*x_75 - 0.00141688318437198*x_76 - 0.00262603692908192*x_77 + 0.000524373321305534*x_78 + 0.00136981220926342*x_79 + 0.00347630875657155*x_8 + 0.0014347395953374*x_80 - 0.00259882916982644*x_81 - 0.000432891421436531*x_82 + 0.00171034939271059*x_83 - 0.0012353141012334*x_84 - 0.000359015079095696*x_85 - 0.0013176316392242*x_86 + 0.00248518979572602*x_87 - 0.00129257831197832*x_88 - 0.000900324984292675*x_89 - 0.000354630661101311*x_9 + 0.000294313389225258*x_90 - 0.0020522729245396*x_91 - 0.000401606147979928*x_92 - 0.00349175861545538*x_93 - 0.000389765023448708*x_94 + 2.53216410714975e-6*x_95 + 0.00416396984895162*x_96 + 9.14102033793344e-5*x_97 + 5.28045639892204e-5*x_98 + 0.00438782493121034*x_99 + 3.62787638592908e-6*std::pow(-5.51599979400635*x_18 - 8.79796028137207, 2) + 5.2933442595133e-6*std::pow(-1.04831981658936*x_4 - 4.39728021621704, 2) + 0.0234362178061449*std::sin(0.274479955434799*x_1 - 4.2960000038147) + 0.0104065090459244*std::sin(0.406479865312576*x_1 - 0.994959831237793) - 0.00375363693889449*std::sin(0.41023987531662*x_1 + 8.40791988372803) + 0.00301135734997954*std::sin(0.327039837837219*x_10 - 1.12639987468719) - 0.015124041789978*std::sin(0.237999975681305*x_100 - 1.19359982013702) - 0.00306683094671393*std::sin(0.239599987864494*x_100 - 1.19783997535706) + 0.0162060301712304*std::sin(0.227359995245934*x_101 - 7.41120004653931) + 0.00440272837670245*std::sin(0.237839981913567*x_101 + 1.98119974136353) - 0.0339230057504516*std::sin(0.233519986271858*x_102 + 1.97087979316711) - 0.00561044004715354*std::sin(0.235839992761612*x_102 + 1.95447981357574) - 0.00259935304850341*std::sin(0.25791996717453*x_103 + 1.94479978084564) + 0.00132717377196987*std::sin(0.25639995932579*x_108 + 1.9586398601532) + 0.0201634893758711*std::sin(0.188240006566048*x_109 - 4.2007999420166) - 0.00442944287297586*std::sin(0.248879969120026*x_109 + 1.95135986804962) + 0.00655955808459379*std::sin(0.258959978818893*x_11 - 7.41095972061157) + 0.000801292369945473*std::sin(0.344479858875275*x_11 + 5.061119556427) - 0.0179899581313525*std::sin(0.199520006775856*x_110 - 4.20688009262085) - 0.000782588942667112*std::sin(0.228319987654686*x_110 - 1.20983994007111) + 0.00142130557067659*std::sin(0.23191998898983*x_110 + 1.94151985645294) + 0.00573338992527435*std::sin(0.269279956817627*x_112 - 7.43856000900269) - 0.000685754310548488*std::sin(0.271599948406219*x_112 + 1.96775984764099) - 0.0174419336811365*std::sin(0.262879967689514*x_113 + 8.36128044128418) + 0.00197177087019038*std::sin(0.287759929895401*x_113 - 7.41791963577271) - 0.00218323438880451*std::sin(0.224719986319542*x_114 - 7.41479969024658) + 0.00117211775728282*std::sin(0.231519982218742*x_116 - 1.19407987594604) - 0.0210580478900238*std::sin(0.226719990372658*x_117 + 8.36223983764648) - 0.0054319720216405*std::sin(0.232879981398582*x_118 + 5.16504001617432) - 0.00529462731648923*std::sin(0.25111997127533*x_12 - 4.21424007415771) + 0.00116541042355913*std::sin(0.27295994758606*x_120 - 7.44464015960693) - 0.00642992580502359*std::sin(0.180880010128021*x_13 - 4.40488004684448) + 0.00222180465245925*std::sin(0.208959996700287*x_13 + 8.18591976165771) + 0.0171610936789047*std::sin(0.313839942216873*x_13 - 4.26895999908447) + 0.00096116837803072*std::sin(0.272559970617294*x_14 + 5.15696001052856) + 0.00455795646063333*std::sin(0.314319908618927*x_15 + 5.14832019805908) + 0.0309741173487504*std::sin(0.321919918060303*x_15 + 5.13399982452393) + 0.00727292896746411*std::sin(0.351919859647751*x_15 + 5.03336000442505) + 0.00308518387242555*std::sin(0.35607984662056*x_17 - 7.36687994003296) - 0.0151129634511084*std::sin(0.387039840221405*x_17 + 2.00999975204468) + 0.00966372483143403*std::sin(0.451359868049622*x_17 + 1.96111989021301) - 0.000838237892574682*std::sin(0.338479846715927*x_18 + 4.99368000030518) - 0.0023895924583697*std::sin(0.380239844322205*x_18 - 1.16895985603333) + 0.00345375982602059*std::sin(0.41567987203598*x_18 + 8.1988000869751) - 0.0751765392836275*std::sin(0.110080063343048*x_19 + 1.72039985656738) + 0.0163543629243171*std::sin(0.412079870700836*x_2 + 5.19591999053955) + 0.000179373893739158*std::sin(0.42103984951973*x_2 + 5.20783996582031) + 0.00163473307639017*std::sin(0.269679963588715*x_20 - 4.3887996673584) + 0.00426352863103492*std::sin(0.33519983291626*x_20 - 1.15567982196808) + 0.0222899922301046*std::sin(0.35335984826088*x_20 + 8.23607921600342) + 0.00540084393827336*std::sin(0.363519847393036*x_20 - 1.17807984352112) - 0.0112477369997991*std::sin(0.272719949483871*x_21 + 2.00431990623474) + 0.0236595611830814*std::sin(0.347679853439331*x_21 - 1.15399980545044) + 0.00363132936185195*std::sin(0.364559859037399*x_21 - 4.36879968643188) - 0.00196697495123552*std::sin(0.380159854888916*x_21 - 1.18823993206024) - 0.0912414831345309*std::sin(0.153920039534569*x_22 - 4.4475998878479) + 0.0113605751789113*std::sin(0.231279984116554*x_22 - 1.16823983192444) + 0.00295117606892102*std::sin(0.327679842710495*x_22 - 7.36279964447021) + 0.000418620372381181*std::sin(0.504719853401184*x_22 + 8.14903926849365) + 0.0015115734830589*std::sin(0.311679929494858*x_23 - 7.36215972900391) - 0.00236963567631644*std::sin(0.328399837017059*x_23 - 1.17247986793518) + 0.00107053029492949*std::sin(0.345839858055115*x_24 - 7.36495971679688) + 0.00353896110186492*std::sin(0.302319914102554*x_25 - 1.160719871521) - 0.00493290964278032*std::sin(0.328959852457047*x_25 - 1.15583980083466) + 0.00780203654974805*std::sin(0.352959841489792*x_25 + 8.22855949401855) + 0.00832476338529555*std::sin(0.373519837856293*x_25 + 8.2203197479248) - 0.0315661270391294*std::sin(0.202959999442101*x_26 - 1.17263984680176) + 0.00132029214489607*std::sin(0.258959978818893*x_26 + 5.20328044891357) + 0.0114183307922616*std::sin(0.353839844465256*x_26 - 1.16007995605469) + 0.00213593395952755*std::sin(0.387359857559204*x_26 + 8.2052001953125) + 0.00147043145535262*std::sin(0.204159989953041*x_27 + 1.77231991291046) + 0.0041670562613745*std::sin(0.256799966096878*x_27 - 1.18519985675812) - 0.00453035827541221*std::sin(0.361759841442108*x_27 + 2.03087973594666) - 0.0102008707364626*std::sin(0.313359916210175*x_28 - 1.17319989204407) + 0.0039283439109481*std::sin(0.182880014181137*x_29 - 4.61615991592407) + 0.00435425258466235*std::sin(0.328719854354858*x_29 - 1.16823983192444) + 0.0140818697068364*std::sin(0.345119833946228*x_29 - 1.17687976360321) + 0.00301767503535514*std::sin(0.280079960823059*x_3 - 1.11783981323242) - 0.00300739000081259*std::sin(0.318319916725159*x_3 - 4.14279985427856) - 0.0106811996154707*std::sin(0.420319855213165*x_3 + 1.99263978004456) + 0.00460608857001378*std::sin(0.256079971790314*x_30 - 1.17471981048584) - 0.0189676080706797*std::sin(0.370719850063324*x_31 + 5.17447996139526) + 0.0101256611947187*std::sin(0.384479850530624*x_31 + 5.18416023254395) - 0.00102770127958129*std::sin(0.400159865617752*x_31 + 5.20528030395508) - 0.00330093893052648*std::sin(0.29615992307663*x_32 + 2.0271999835968) - 0.000737765939988796*std::sin(0.299599945545197*x_32 + 2.03711986541748) + 0.00552615497899312*std::sin(0.32535982131958*x_32 - 1.1885598897934) + 0.00269454165676847*std::sin(0.327279835939407*x_32 + 8.2041597366333) - 0.00299654965903489*std::sin(0.344479858875275*x_32 - 7.59592008590698) + 0.00383384873284582*std::sin(0.230879992246628*x_34 + 1.98255980014801) + 0.00158426476934303*std::sin(0.234959989786148*x_35 + 1.98535978794098) - 0.00133421780859954*std::sin(0.265119940042496*x_36 - 1.23519992828369) + 0.0142133878329891*std::sin(0.217040002346039*x_37 - 7.41472005844116) - 0.00195338870115929*std::sin(0.243279978632927*x_38 + 1.95791983604431) - 0.0176112576452193*std::sin(0.249519973993301*x_38 + 1.97479975223541) + 0.0193942758525746*std::sin(0.185760006308556*x_4 - 1.18887984752655) - 0.0223478631349688*std::sin(0.210559993982315*x_4 - 1.200159907341) - 0.00157658925778464*std::sin(0.269039958715439*x_4 - 4.17000007629395) - 0.00805875079824393*std::sin(0.231199979782104*x_40 + 1.97247982025146) + 0.00530626074186153*std::sin(0.231599986553192*x_40 + 1.95583975315094) + 0.000738404726245019*std::sin(0.241679981350899*x_41 - 1.19143986701965) - 0.0179332801066581*std::sin(0.244559973478317*x_41 + 1.98751986026764) + 0.00397589018513362*std::sin(0.25927996635437*x_41 - 7.43383979797363) + 0.0252516767233772*std::sin(0.261039972305298*x_41 + 1.96215975284576) + 0.000941667252881945*std::sin(0.246239975094795*x_42 + 5.17119979858398) - 0.00500413357333913*std::sin(0.252799987792969*x_42 + 1.96831977367401) - 0.00424444777241283*std::sin(0.256479978561401*x_42 + 1.96983981132507) + 0.0131308676396514*std::sin(0.273919969797134*x_42 + 1.94215977191925) - 0.0191153347055683*std::sin(0.215999990701675*x_44 + 1.99159979820251) - 0.0330154324026539*std::sin(0.169440016150475*x_47 - 7.37831974029541) + 0.0190554485060378*std::sin(0.243039980530739*x_48 - 7.61728000640869) + 0.000600651271656357*std::sin(0.300399929285049*x_5 - 7.38207960128784) + 0.032095924695003*std::sin(0.33231982588768*x_5 - 7.34832000732422) - 0.0149987747242323*std::sin(0.18792000412941*x_51 - 1.1827198266983) + 0.0137854216674308*std::sin(0.292639940977097*x_53 + 8.14832019805908) - 0.048009017286406*std::sin(0.18520000576973*x_55 + 8.21592044830322) + 0.0362141555627491*std::sin(0.224399983882904*x_57 - 4.2163200378418) - 0.00145931090187508*std::sin(0.229039996862411*x_57 - 4.20983982086182) - 0.0117729490027892*std::sin(0.351439833641052*x_6 + 2.03335976600647) + 0.0278241891535455*std::sin(0.0657600983977318*x_60 - 1.37215983867645) - 0.00356729982225572*std::sin(0.381999850273132*x_60 + 8.21647930145264) + 0.0112977848953425*std::sin(0.484079837799072*x_60 - 7.69736051559448) - 0.00802043683372735*std::sin(0.314079910516739*x_7 + 4.82047986984253) + 0.00484737968112633*std::sin(0.326159834861755*x_7 - 7.3583197593689) - 0.000704276892258365*std::sin(0.346639841794968*x_7 + 8.22824001312256) - 0.00266392671766215*std::sin(0.311839938163757*x_8 - 7.41599988937378) + 0.0100893939284557*std::sin(0.319439917802811*x_8 + 1.98247981071472) - 0.00163910061544289*std::sin(0.360239863395691*x_8 - 7.56568002700806) + 0.00368946599035841*std::sin(0.330639839172363*x_9 - 1.10911989212036) + 0.00079636558091592*std::sin(0.252399981021881*x_91 - 1.34951984882355) - 0.000653336031362996*std::sin(0.360639840364456*x_91 - 7.3983998298645) - 0.00527795725253835*std::sin(0.373839855194092*x_91 - 7.38359975814819) - 0.00205498413540246*std::sin(0.261199980974197*x_92 + 5.20943975448608) + 0.00653615002961011*std::sin(0.27567994594574*x_92 - 7.38263988494873) - 0.0112891575870684*std::sin(0.343999862670898*x_92 - 1.3698399066925) + 0.00235677891110455*std::sin(0.205679997801781*x_93 + 8.3834400177002) + 0.00798738070837342*std::sin(0.27991995215416*x_94 + 1.96287977695465) - 0.0297747591434093*std::sin(0.281039953231812*x_94 + 1.98919987678528) - 0.00496408868623096*std::sin(0.270399957895279*x_95 + 1.9871199131012) - 0.00113298709580394*std::sin(0.288719952106476*x_95 + 4.98839950561523) + 0.00296984218227047*std::sin(0.294399946928024*x_95 - 4.4191198348999) - 0.00530164056082898*std::sin(0.282319933176041*x_96 + 1.95719981193542) - 0.00115136918892571*std::sin(0.273999959230423*x_97 + 1.96847975254059) - 0.00351048936621882*std::sin(0.276399940252304*x_97 + 1.96775984764099) + 0.0165138057721353*std::sin(0.288799941539764*x_97 + 8.18423938751221) + 0.0142298799088871*std::sin(0.247999966144562*x_98 - 7.41847991943359) + 0.00271868051699699*std::sin(0.276959955692291*x_98 - 1.23423981666565) - 0.0333046720294125*std::sin(0.280639946460724*x_98 + 8.17799949645996) + 0.00142706095150035*std::sin(0.250319957733154*x_99 + 1.95055973529816) + 0.487594249622709);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
