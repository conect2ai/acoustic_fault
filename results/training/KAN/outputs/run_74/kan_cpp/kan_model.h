
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.1708900264106e-5*x_1 - 1.15038833653322e-5*x_10 - 1.70156833372106e-6*x_100 - 2.25899580137265e-5*x_101 - 6.70023629570478e-6*x_102 - 4.11631347864299e-5*x_103 - 2.23032718521909e-5*x_104 + 4.7780263897104e-6*x_105 + 1.12655446109094e-5*x_106 - 8.41104364840758e-6*x_107 - 4.5437292591269e-5*x_108 + 2.24495995392808e-5*x_109 - 1.31331633886742e-5*x_11 - 2.16872439440147e-5*x_110 - 2.84789636617122e-6*x_111 - 1.4144235271619e-5*x_112 - 3.00417613017967e-5*x_113 - 1.00189512006648e-5*x_114 - 1.23907527341567e-5*x_115 + 2.20113330096755e-6*x_116 + 2.42866760732842e-5*x_117 + 3.79306848405858e-5*x_118 + 2.19831431837898e-5*x_119 + 1.63811717655389e-6*x_12 - 2.28893636830552e-5*x_120 - 2.56817243023455e-5*x_13 - 7.3053919420996e-6*x_14 + 3.51706731758413e-6*x_15 - 1.86469257923419e-5*x_16 + 9.89457608083734e-6*x_17 + 6.57341305606705e-6*x_18 - 6.73983106457772e-6*x_19 - 3.37427847169283e-5*x_2 - 1.27998646291848e-5*x_20 + 1.12711053157191e-5*x_21 - 4.57729197851604e-5*x_22 - 1.96065740422422e-5*x_23 + 7.36141072276851e-7*x_24 + 2.6101982364985e-5*x_25 - 1.23960004423093e-5*x_26 + 2.02883900930961e-5*x_27 + 1.89504913646449e-5*x_28 + 3.45256708963082e-5*x_29 - 3.73682479471738e-5*x_3 + 7.17131977365816e-6*x_30 - 4.59338520964115e-5*x_31 + 8.27915216160725e-6*x_32 + 2.15650199601982e-5*x_33 - 9.21122884098993e-6*x_34 - 7.28471711806578e-6*x_35 - 1.14806071565435e-6*x_36 - 5.13629128798344e-5*x_37 - 2.85904850377683e-7*x_38 + 5.91701434124285e-5*x_39 + 6.08076380882072e-6*x_4 - 5.55230650934835e-5*x_40 + 2.55449954319567e-5*x_41 - 1.78108515879528e-6*x_42 - 1.75777108620736e-5*x_43 + 8.28374880116385e-5*x_44 - 6.44335728669273e-6*x_45 - 3.63039340293445e-5*x_46 - 4.35591338803995e-6*x_47 + 1.46398270199022e-5*x_48 - 1.89988309187725e-5*x_49 - 1.20306050736948e-5*x_5 - 1.44485976789108e-5*x_50 + 2.61973709182992e-5*x_51 + 1.27364843305825e-6*x_52 - 8.61804887312361e-6*x_53 - 1.83939287371465e-5*x_54 + 1.5322844927794e-5*x_55 + 3.29606475243682e-5*x_56 + 3.18122038357719e-5*x_57 - 2.48373930097949e-6*x_58 + 8.56063170014778e-6*x_59 - 3.16041195020077e-6*x_6 + 2.14961394261072e-5*x_60 - 2.54502732423315e-5*x_61 + 3.52627967708109e-5*x_62 + 2.92540936953365e-6*x_63 - 1.68652575054002e-5*x_64 - 2.60014271689237e-5*x_65 - 2.15927607545307e-5*x_66 + 1.63168341800846e-5*x_67 - 1.87640387944295e-5*x_68 - 5.31703317758931e-6*x_69 - 3.96382838464024e-5*x_7 - 2.3486158598881e-5*x_70 + 2.66645460890482e-6*x_71 - 7.57946582907667e-6*x_72 - 1.40377804213628e-5*x_73 + 1.27787473048922e-5*x_74 - 2.1971498206568e-5*x_75 - 1.88262108793358e-5*x_76 - 4.0239783361534e-5*x_77 + 1.78160023390179e-5*x_78 - 2.92327006970298e-6*x_79 + 1.36199837507518e-5*x_8 - 2.79592440661833e-5*x_80 - 2.83995668537602e-5*x_81 + 1.41578945062664e-5*x_82 - 6.37723413631e-6*x_83 + 1.68584632346299e-6*x_84 - 4.45307980725954e-6*x_85 - 3.5681245682207e-5*x_86 + 2.38672502288876e-6*x_87 + 3.21260168658592e-5*x_88 + 1.45287202721088e-5*x_89 + 5.84583588661925e-5*x_9 - 1.10130324900447e-5*x_90 + 4.86611145033285e-5*x_91 + 4.59352303746742e-5*x_92 - 4.87281170358711e-5*x_93 + 1.99431537563516e-5*x_94 - 2.53924711688963e-5*x_95 - 6.56759033943107e-6*x_96 - 2.84576703198422e-5*x_97 - 1.03623435384408e-6*x_98 - 1.88581735241336e-6*x_99 + 5.88757230789578e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 3.10491895598729e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 4.63053281434655e-7*std::sin(1.2875999212265*x_102 + 0.772799849510193) - 1.28347368559259e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 2.26996793202657e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 6.36732711048642e-6*std::sin(1.12983989715576*x_105 - 5.19687986373901) - 5.86698478233386e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) + 1.94121555873512e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 2.2966635425798e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 5.14865018094478e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 2.15083159774376e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 6.16669382075376e-7*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 4.38874109042185e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 2.74931546617834e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 1.23062211678318e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 7.63645848822823e-6*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 4.06794606652063e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 5.92377687594713e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 3.040563302357e-7*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 6.23228014905501e-7*std::sin(1.7804799079895*x_12 + 4.00704002380371) - 1.43687322681176e-5*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 2.81083711380077e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 1.99180059320412e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 2.40088746648732e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 1.86670737668361e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 3.63043215285263e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) - 9.62562253363812e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 2.02958483896051e-5*std::sin(1.66791975498199*x_18 + 7.19591999053955) - 0.000323360030652421*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 4.33540992884294e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 2.22673137832656e-5*std::sin(1.56167984008789*x_2 - 1.78783988952637) + 9.40544257517053e-6*std::sin(1.26583993434906*x_24 - 1.99143981933594) - 0.000110042008947203*std::sin(1.7105598449707*x_24 - 8.56167984008789) - 9.74716818690231e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) - 1.01297033199727e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 3.40189863210809e-7*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 9.12314135686724e-6*std::sin(1.4948798418045*x_28 - 8.41952037811279) - 1.52481953500138e-5*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 4.184443177449e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 2.6055733062402e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) - 1.24278730089889e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) + 6.36245158654799e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 4.53308250587401e-6*std::sin(0.592319846153259*x_31 - 1.80071985721588) - 1.43032434939689e-5*std::sin(0.631359875202179*x_31 - 5.02360010147095) - 8.68060636968439e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 7.17186854612771e-7*std::sin(1.08399987220764*x_37 - 5.21920013427734) + 1.03636052500688e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 5.66392148698744e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) - 2.36193915640341e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 2.65911948296968e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 9.00899337909002e-7*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 3.92821065394103e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) - 1.27157227736919e-5*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 4.18680129363115e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 5.91478412654769e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) + 3.59055169600196e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) - 6.52953688877605e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 9.99424160399232e-7*std::sin(1.78607988357544*x_55 - 8.18703937530518) + 1.7732782571812e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 7.44262261477548e-7*std::sin(0.981519818305969*x_56 + 1.21311986446381) - 7.70299269871201e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 7.33298525444101e-7*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 7.09347397404743e-6*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 1.59195159846271e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) + 1.58689116055931e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 2.97729517080583e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) + 6.79106611507356e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 9.22477356531226e-7*std::sin(1.98919987678528*x_64 - 5.60559988021851) - 7.60904095443625e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) + 1.04645100508266e-5*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 4.6586649040767e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) + 1.07324423515736e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 3.40750274824791e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) - 1.00692479489599e-5*std::sin(1.964479804039*x_70 + 4.21384000778198) - 9.41808762447084e-7*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 5.37639772728528e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 3.44134390897157e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) - 0.000115057921213495*std::sin(1.04719984531403*x_73 - 2.01999998092651) - 0.000121231330668473*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 1.50104111672018e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) + 2.35715717148154e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 2.7007045707298e-5*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 1.28064446144878e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 1.25272471863753e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) - 3.57162629501246e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 6.56178742155055e-6*std::sin(1.85911989212036*x_80 + 1.59799981117249) - 5.24333372379921e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 5.69211462294654e-6*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 2.02205213242186e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) + 2.53565169628782e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 1.79822353492092e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) - 2.30049022190732e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) + 0.000145253535108347*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 5.91161512672151e-7*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 4.36653088916754e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) + 1.14714359532638e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 3.75298382564472e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) - 2.20184113531587e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) + 5.50689220226153e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) + 1.05158989092914e-5*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 5.94334683994192e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0355917006209241);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000144402513288345*x_1 + 1.75220450558728e-5*x_10 - 2.60057081496589e-5*x_100 + 3.00118216324689e-5*x_101 + 2.305642172518e-5*x_102 + 1.67767778828311e-5*x_103 - 1.00606663901935e-5*x_104 + 9.40965273068871e-6*x_105 - 1.80249822952601e-5*x_106 - 3.50624092604767e-5*x_107 - 8.81243196436629e-6*x_108 + 2.75915942648321e-5*x_109 + 1.82729095581869e-5*x_11 + 6.56430710151776e-5*x_110 + 1.88309531175902e-5*x_111 + 4.87058152850501e-7*x_112 + 2.25524892807033e-5*x_113 + 1.81757817652466e-5*x_114 + 2.03468247984181e-5*x_115 - 3.82151960365975e-5*x_116 - 5.08202913008457e-5*x_117 - 3.01510052768402e-5*x_118 - 1.39458087788759e-6*x_119 - 3.56979490562235e-5*x_12 + 3.87775980633504e-6*x_120 + 3.50461992705537e-5*x_13 + 2.40231989003979e-5*x_14 + 1.07193283439488e-5*x_15 + 1.80716923114571e-5*x_16 - 2.22994751870917e-5*x_17 + 7.07345196119842e-6*x_18 + 1.12318367481764e-5*x_19 + 6.24580414151463e-5*x_2 - 6.25340640323012e-6*x_20 - 5.80197817143431e-6*x_21 + 4.30510747290774e-5*x_22 - 5.72110585961305e-7*x_23 + 1.51396876673988e-6*x_24 + 9.4036549904605e-7*x_25 - 1.85611615377189e-5*x_26 - 4.50914281203991e-5*x_27 + 1.12569436177963e-5*x_28 - 2.07246267056544e-5*x_29 + 3.60588370652016e-5*x_3 - 9.61892947950513e-6*x_30 - 0.000118482080098349*x_31 - 4.09495570154101e-5*x_32 - 3.4262950405607e-5*x_33 - 4.45388408054006e-5*x_34 + 8.95496732856918e-6*x_35 + 1.43175431982698e-5*x_36 + 1.9972554422885e-5*x_37 - 5.57648914291986e-6*x_38 - 9.55826512829595e-5*x_39 + 2.53274722240743e-6*x_4 + 3.03443083847866e-5*x_40 + 2.58220189974158e-5*x_41 + 1.58862485693922e-5*x_42 - 1.01130776467854e-5*x_43 + 1.57152463946956e-5*x_44 - 5.77622846935259e-6*x_45 - 1.84120035106341e-5*x_46 - 8.63031120583267e-6*x_47 - 8.89911822289749e-6*x_48 + 2.14031808861868e-5*x_49 - 3.64153281023875e-7*x_5 - 3.56766544160689e-5*x_50 - 1.94824115105506e-6*x_51 - 2.78845200519498e-5*x_52 + 2.67783278422914e-5*x_53 - 5.6745941721192e-5*x_54 - 6.55621678874507e-6*x_55 - 2.65674243490191e-5*x_56 - 8.10440977860162e-5*x_57 + 2.83380857724693e-5*x_58 + 2.09618712774906e-5*x_59 + 7.35532958252968e-6*x_6 - 1.07746528812746e-5*x_60 - 1.09774494527022e-5*x_61 - 8.9025673620694e-5*x_62 - 2.14403686357598e-5*x_63 - 1.47721170910492e-5*x_64 - 1.78427554746464e-5*x_65 + 9.89352006233546e-6*x_66 - 3.2755804341006e-5*x_67 + 1.36489701976975e-5*x_68 - 2.76408395392897e-5*x_69 + 3.96493809053987e-5*x_7 + 4.59049769404391e-5*x_70 + 2.9740850024555e-7*x_71 + 6.10882349091345e-6*x_72 - 2.01608108455023e-5*x_73 - 3.52879580411071e-5*x_74 + 9.80464759059392e-6*x_75 - 3.59897237162053e-5*x_76 + 1.06566316902934e-5*x_77 - 1.44421639562711e-5*x_78 - 2.39419480896248e-5*x_79 - 0.000126776028280172*x_8 - 7.17717963357197e-6*x_80 + 1.79587596227943e-5*x_81 - 4.5931070072559e-5*x_82 + 1.37189492140283e-5*x_83 - 1.18919439696752e-5*x_84 + 2.90713010436248e-6*x_85 + 7.59625219298678e-5*x_86 - 3.22083798161083e-6*x_87 - 2.87773089801349e-5*x_88 + 9.26723215443464e-6*x_89 - 6.47243613043884e-6*x_9 + 2.68401131205405e-5*x_90 - 0.000258283254873981*x_91 - 6.18417341192047e-5*x_92 + 1.00392742276013e-6*x_93 - 3.60547819127233e-5*x_94 + 1.44099177502281e-5*x_95 + 5.03457988113092e-5*x_96 - 3.0519919168882e-6*x_97 + 1.92130345131454e-5*x_98 - 8.72927245502408e-6*x_99 - 7.8826292459432e-6*std::sin(0.811439871788025*x_1 + 7.40240001678467) - 2.77054836328862e-6*std::sin(1.36503994464874*x_100 - 1.99583983421326) + 2.51860417015159e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 0.000104138039948812*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 6.76685764954644e-6*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 1.7373274283392e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 4.76033363597685e-5*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 6.43976672151506e-6*std::sin(1.70703983306885*x_105 + 7.00392007827759) - 3.07490868257402e-6*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 1.53483150004945e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 8.177158591527e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) - 3.35414117461345e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 1.30829981342892e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 8.19581022746689e-6*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 4.67865184133098e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 2.08361036848932e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) + 5.44640625336721e-6*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 1.76589961037123e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) - 1.65380005281463e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) + 3.3898143911929e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 4.76666712638941e-6*std::sin(1.95199978351593*x_120 + 9.98999977111816) - 3.76331460237257e-6*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 5.43463488259747e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) - 3.21444982241167e-6*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 5.56472314571375e-6*std::sin(1.08207988739014*x_17 + 7.79120016098022) + 4.86063680697564e-6*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 3.19319322303281e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) - 1.81101762507983e-6*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 0.000422818547428454*std::sin(0.48431983590126*x_19 + 1.35343980789185) - 3.86852702205931e-6*std::sin(1.30535984039307*x_19 + 4.39175987243652) - 1.98693333486521e-6*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 7.63135517014628e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 0.000143888538992557*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 0.000127451852537608*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 8.21900332547828e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) - 1.85033481562089e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 2.48925230899444e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 5.05841922275558e-6*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 1.2473978563712e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 7.10931587608312e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) - 3.65382958775716e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 0.000516234376232189*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 1.72341407843797e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 4.74494195390674e-6*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 0.000113505722046809*std::sin(1.08175981044769*x_36 + 0.95279985666275) - 3.90086816188674e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 8.40878585716456e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) - 7.58319232872574e-6*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 3.08842030108027e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) + 3.5601860849851e-6*std::sin(1.14527988433838*x_46 + 4.59015989303589) - 4.90010312056198e-6*std::sin(1.40071988105774*x_46 - 1.97103977203369) + 3.50517928235862e-6*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 4.21829961075467e-6*std::sin(1.65063989162445*x_47 - 1.60215985774994) + 5.60553664536225e-6*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 1.76321883879708e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 2.91328930350364e-5*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 8.53788050775015e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 3.79966979672476e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 0.000143879632328757*std::sin(0.899279832839966*x_56 + 4.3840799331665) + 4.0481346544746e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 0.000100722658182276*std::sin(1.00431978702545*x_6 - 4.80304002761841) - 3.98850153577878e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 1.93545685394847e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) + 2.1313987450038e-6*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 0.000128756621135121*std::sin(0.76887983083725*x_63 + 7.62136030197144) - 3.98617847219058e-6*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 8.87985043937742e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 3.50712889347606e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 9.94941655957647e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) + 3.07659536088252e-5*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 1.38876509214298e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 8.70805161728322e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) - 4.56216576447799e-6*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 3.34036102073317e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) + 5.12261454931352e-6*std::sin(1.69351983070374*x_72 + 9.77544021606445) + 7.19823855175177e-6*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 1.02587723934735e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 0.000150447236844556*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 0.000158519452860766*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 5.70674676562288e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) + 6.93010832177304e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) - 2.40986406866852e-6*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 4.86882974548663e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 4.76268281839026e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 2.89793367770145e-5*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 1.79038599220326e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 6.85606920653232e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 1.55309546503576e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 7.68755721484371e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) + 7.45488724051332e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 5.36057030198242e-6*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 1.86656372717315e-5*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 0.000189930365232354*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 2.24751275153206e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) - 5.84616923415215e-6*std::sin(1.13975989818573*x_94 - 5.19264030456543) + 3.37263440572497e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) + 3.34882273675396e-6*std::sin(1.7766398191452*x_95 + 1.3847998380661) - 6.47347481096648e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 7.20069254418184e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 3.48853250934159e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 1.77173348840498e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0946510200180704);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000115833819460561*x_1 + 2.35536076616625e-5*x_10 - 5.58663464797956e-6*x_100 + 5.41504531456924e-5*x_101 + 3.86330730016319e-5*x_102 + 1.21796320515379e-5*x_103 + 1.60270507026794e-5*x_104 + 1.91960844311629e-5*x_105 - 3.12222913276752e-5*x_106 - 1.53174916444599e-5*x_107 - 6.67021338108808e-6*x_108 + 2.56963955042066e-5*x_109 - 5.51937352537346e-6*x_11 + 1.76218067759281e-5*x_110 + 5.41109785676168e-7*x_111 + 2.1800765790942e-6*x_112 + 1.19617017450874e-5*x_113 + 8.64504434958109e-6*x_114 + 7.15608413455365e-6*x_115 + 1.2975418423542e-5*x_116 - 2.23986073605486e-5*x_117 - 3.9024296038393e-5*x_118 - 2.10203095243032e-5*x_119 - 5.67158372997117e-7*x_12 + 1.88425487968592e-5*x_120 - 1.74091514702441e-5*x_13 + 3.84541804047178e-5*x_14 - 5.94960021830218e-6*x_15 + 3.6551634167028e-5*x_16 - 1.27079282708375e-5*x_17 - 1.85265363202602e-8*x_18 + 8.79279623783962e-6*x_19 - 4.17712059152242e-6*x_2 - 1.70037801246905e-5*x_20 + 5.19571222520148e-6*x_21 + 1.97836928951591e-5*x_22 - 1.03652551233836e-5*x_23 - 1.00568499632248e-5*x_24 + 2.22298672093622e-5*x_25 - 5.97981006459289e-6*x_26 - 2.67265226697883e-5*x_27 + 1.25506096869461e-5*x_28 - 2.58433587189026e-5*x_29 + 3.8544258689793e-5*x_3 + 1.50522929628188e-5*x_30 - 0.000146611029471362*x_31 - 5.28478527977065e-5*x_32 - 4.34692191025862e-5*x_33 + 1.36226595385709e-5*x_34 + 1.92397850751375e-5*x_35 + 1.60276970500949e-5*x_36 - 2.47082102435479e-5*x_37 + 1.62306607170509e-5*x_38 - 6.00945036092576e-5*x_39 + 1.29201892892651e-5*x_4 + 3.30466641914233e-5*x_40 + 3.45756031321583e-5*x_41 + 3.26338662528648e-5*x_42 - 2.41760526627367e-5*x_43 + 2.86856343283283e-5*x_44 + 3.22587564688069e-6*x_45 - 2.06698268665006e-5*x_46 - 2.01660176205368e-5*x_47 - 8.51018680109271e-6*x_48 + 3.00931595318401e-5*x_49 + 2.12825741815169e-5*x_5 - 4.34494576273317e-5*x_50 - 2.14520750572441e-5*x_51 - 5.6262609940284e-5*x_52 + 2.56428684946947e-5*x_53 - 7.27548900635685e-5*x_54 - 5.99485500670748e-6*x_55 - 1.03783905150592e-5*x_56 - 7.04093963251517e-5*x_57 + 9.20787548480555e-6*x_58 + 3.45695227668506e-5*x_59 + 3.95218992736004e-6*x_6 + 9.15646467368543e-6*x_60 - 2.02400529944288e-5*x_61 - 3.66073626488222e-5*x_62 - 4.31397543868117e-6*x_63 + 1.26746845261418e-5*x_64 - 4.25040815503459e-5*x_65 + 1.57035943274142e-6*x_66 - 0.000101038928091232*x_67 - 2.63830791872198e-5*x_68 - 1.49871785219717e-5*x_69 + 2.94507912972304e-5*x_7 + 4.83578972552721e-5*x_70 + 1.54030680128021e-5*x_71 + 1.73554176713166e-5*x_72 - 5.13639160668785e-6*x_73 - 1.67289427071539e-5*x_74 - 2.3059777568712e-5*x_75 - 3.66135641029902e-5*x_76 + 1.65279116767597e-5*x_77 - 2.31504519395621e-5*x_78 + 8.43977875027297e-6*x_79 - 0.00018089018396*x_8 - 3.52153612054723e-5*x_80 + 2.26797554448947e-6*x_81 - 1.58525634287253e-5*x_82 + 5.1925825556133e-5*x_83 - 1.6167604703647e-5*x_84 - 1.85894659212856e-5*x_85 + 5.37027275395781e-5*x_86 + 1.21757188568524e-6*x_87 - 1.46358741284113e-5*x_88 - 1.34391979636464e-5*x_89 - 5.44115253690377e-5*x_9 + 3.06234514195034e-5*x_90 - 0.000123107575142465*x_91 - 4.46773275079956e-5*x_92 - 2.48438446953669e-5*x_93 - 3.24882013956973e-6*x_94 + 4.56477345871222e-6*x_95 + 1.02977293707764e-5*x_96 - 2.43036323625019e-5*x_97 + 3.0619366123554e-5*x_98 + 6.66300014530659e-7*x_99 - 2.56962872926891e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 3.1944041350627e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 1.32490906409503e-5*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 1.8959691507112e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 3.43467182378441e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) + 2.99101267085233e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 8.66680967429512e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) + 2.81610942067714e-6*std::sin(1.70703983306885*x_105 + 7.00392007827759) - 1.0023779432081e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 7.79038481447876e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 1.17948677343705e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 1.76444242297599e-5*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 6.64057194486409e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 4.15996906086112e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 6.74856418962552e-7*std::sin(1.49207997322083*x_118 - 8.21432018280029) + 3.5871793143958e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) + 1.77545353755219e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 8.96322332978362e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 8.69979771391814e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 1.78320828088716e-5*std::sin(1.7804799079895*x_12 + 4.00704002380371) - 2.08446311494637e-6*std::sin(1.95199978351593*x_120 + 9.98999977111816) - 1.226788805843e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) - 9.35636053984603e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) - 1.04786643577247e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 2.8245012361129e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) + 1.58450075375224e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) - 1.39638311546004e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 2.08807839880461e-5*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 0.000419695043076016*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 4.46035841843224e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 2.29090679126548e-5*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 1.38938796887571e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 0.000142825585438266*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 0.000126510322374022*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 1.49637699752743e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 9.73366675827895e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) + 4.28553943010511e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) - 2.21204628101574e-6*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 6.33145027162558e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) - 1.22395200349675e-5*std::sin(1.74031984806061*x_29 + 1.58823990821838) + 1.81465134312675e-6*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 9.39872166169027e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 2.48588074686367e-6*std::sin(0.592319846153259*x_31 - 1.80071985721588) - 2.07496269893132e-6*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 0.000112667216690324*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 2.05204757729453e-5*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 1.53092938833467e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) - 2.47201641222612e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 3.06560509036813e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) + 1.16057170267513e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 2.57769407212653e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 4.04142347488632e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) - 1.84466204861069e-6*std::sin(1.65063989162445*x_47 - 1.60215985774994) + 1.82732785692104e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 8.94961646664479e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 5.30402401394804e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 8.4748082818775e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 5.48070606495133e-7*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 2.61951679179942e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 2.12951696020887e-5*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 9.99785856643247e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 2.09814702109073e-5*std::sin(1.30439984798431*x_6 - 4.79152011871338) + 3.33211568505647e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) + 6.94806679066905e-6*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 2.34418260360952e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) - 1.29943936249516e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 8.81425196536278e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 5.05874026569595e-7*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 9.87591683701921e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) - 1.52797161711912e-6*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 7.04899168694435e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 1.5854146320869e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) - 1.48720329858505e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) - 1.46073958044497e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) - 2.69474597425211e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) + 2.34652677496303e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 5.20707222041867e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 0.000149335831959519*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 0.000157348415771764*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 8.2315051788055e-7*std::sin(1.66879975795746*x_75 - 8.61567974090576) - 3.44179444390528e-6*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 2.77854010704082e-5*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 7.02287991927762e-7*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 6.86977184983051e-7*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 5.27606708982586e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) - 3.08235920359333e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 6.80542109249507e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) - 2.67383576589586e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 1.10886586745965e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) - 3.70242257306804e-6*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 2.72087883758994e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 3.39832327005226e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 0.00018852728505512*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 3.24184927305921e-7*std::sin(1.80111992359161*x_92 - 8.18575954437256) - 1.90577077159587e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) - 1.67499753538891e-6*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 3.86114652955598e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) + 3.21501030036496e-6*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 7.14749858039026e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) + 1.52553495937568e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 8.9928344987244e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0430581033803997);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.40406734887126e-5*x_1 + 7.91865833318736e-6*x_10 - 7.66658923588698e-6*x_100 + 1.25769393483734e-5*x_101 - 3.04064805815472e-7*x_102 - 3.13002427670846e-5*x_103 + 9.10668166595329e-6*x_104 + 1.28221361730021e-5*x_105 - 7.17582073452224e-6*x_106 - 3.25952751863133e-5*x_107 - 3.61751968887239e-5*x_108 + 8.76556018723672e-6*x_109 - 2.42902808665856e-5*x_11 - 1.07024347557231e-6*x_110 + 1.90693206989471e-5*x_111 + 1.1748502641752e-5*x_112 - 3.27363290686162e-5*x_113 - 2.54587078735741e-5*x_114 - 6.34768842775421e-6*x_115 + 2.71279897468753e-6*x_116 - 5.96762451007493e-5*x_117 - 6.2399239851605e-6*x_118 + 2.82855638223956e-5*x_119 - 2.03478977310154e-5*x_12 - 1.12305380685006e-5*x_120 - 8.60880013322502e-5*x_13 - 2.67528072118143e-5*x_14 - 8.64850832606484e-6*x_15 - 2.99798912695997e-6*x_16 - 1.50469167404657e-5*x_17 - 6.38669022486657e-6*x_18 - 3.31425456033331e-5*x_19 + 7.13045963542549e-6*x_2 - 8.15628037160301e-6*x_20 + 1.8166538983923e-5*x_21 + 4.33441688551033e-5*x_22 - 2.5007258117062e-5*x_23 + 9.26219101444103e-6*x_24 + 5.24359053770206e-5*x_25 + 8.67592732161928e-6*x_26 + 8.50939546267546e-6*x_27 + 1.36206958001989e-5*x_28 - 5.96289825358345e-6*x_29 - 4.77730814241462e-5*x_3 + 8.70903122088458e-7*x_30 - 5.14357821489572e-5*x_31 - 2.86177287300185e-5*x_32 - 9.26254035249554e-6*x_33 - 7.0624484128981e-5*x_34 - 1.90841546797262e-5*x_35 - 1.58923122849542e-5*x_36 - 1.351407035336e-5*x_37 + 6.45299321511406e-6*x_38 - 1.3581937741635e-5*x_39 - 1.2098746098172e-5*x_4 - 7.25626271447135e-6*x_40 - 1.78364242355856e-5*x_41 - 3.08844251548445e-6*x_42 - 1.61825341636782e-5*x_43 + 8.90451579124166e-5*x_44 - 2.66496072524489e-5*x_45 - 2.77935449338073e-5*x_46 - 1.69869406281771e-5*x_47 - 2.09787689593459e-6*x_48 - 2.1505113082734e-5*x_49 - 5.05295016822272e-6*x_5 + 4.08936315369452e-5*x_50 + 5.96663359423577e-5*x_51 - 5.22696943173142e-6*x_52 + 3.50307237766573e-6*x_53 - 4.97383116039135e-5*x_54 - 7.99803992484095e-6*x_55 - 1.20168710403317e-5*x_56 - 3.90809845230819e-5*x_57 - 2.85160993689892e-5*x_58 + 2.58506963972725e-5*x_59 - 1.11108337004119e-5*x_6 + 6.97824501960835e-6*x_60 - 2.37690652887158e-5*x_61 - 1.94560810706805e-5*x_62 - 3.85892129263649e-6*x_63 - 3.00540309398981e-5*x_64 + 6.8324180368756e-6*x_65 - 1.55762088315046e-5*x_66 - 1.57698600232751e-5*x_67 - 9.16412497671097e-6*x_68 + 4.21395461882394e-6*x_69 + 9.9841490665247e-7*x_7 - 4.03007448551425e-6*x_70 - 1.56796716403738e-5*x_71 + 1.31684415444472e-5*x_72 - 4.82038658864663e-5*x_73 + 3.89382775613403e-5*x_74 - 4.63661287331661e-5*x_75 - 3.1541485637883e-5*x_76 - 2.254261959038e-5*x_77 + 1.35305577059141e-5*x_78 - 2.09284993938932e-5*x_79 - 8.30164887330537e-5*x_8 - 3.19700803653679e-5*x_80 - 7.48052780884096e-6*x_81 + 2.14212313206474e-5*x_82 - 4.47140766720377e-5*x_83 - 8.52827790485493e-6*x_84 - 2.63791274348645e-5*x_85 + 2.9897811474761e-5*x_86 - 1.16494559853328e-6*x_87 - 4.24386355026666e-6*x_88 + 1.71408110243358e-5*x_89 + 4.18827379894711e-5*x_9 + 1.06695516240632e-5*x_90 - 2.49087740313853e-5*x_91 + 1.06625376719633e-6*x_92 - 5.28943334810565e-5*x_93 - 7.48860604448628e-6*x_94 - 5.03410014294258e-5*x_95 - 2.28769099255677e-5*x_96 - 2.5546121616629e-5*x_97 - 3.70082042513098e-7*x_98 + 8.49470793282018e-8*x_99 + 8.37864108384768e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 1.22697618482118e-6*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 5.35955620774162e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) - 2.9784201244816e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 3.50048536345779e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 4.18372594290819e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) - 1.36148841553089e-5*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 2.58578739607615e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 3.26839629431434e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 7.93966044439721e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 6.64353262518134e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 7.13756785090977e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 6.76781541019922e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 4.23968039949066e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 3.80117076143716e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 5.01762339750458e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 5.78911956531162e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 9.13497233070159e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 3.51926453726653e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 7.21347998177749e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 1.91398047626925e-5*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 4.00011992890702e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 1.30873562332993e-5*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 3.4167180142192e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 2.87862297865412e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 5.16649077026522e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 1.28217669155125e-5*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 8.02034545113217e-7*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 0.000120515976574743*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 1.71323142714239e-6*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 8.79941283469655e-7*std::sin(1.56167984008789*x_2 - 1.78783988952637) + 2.18262047442055e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 4.10125523113086e-5*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 3.63276033377628e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) - 2.35069192005326e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 3.9374879010323e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 5.99446557609449e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 2.03112895791253e-5*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 6.45277049522194e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 1.71202208529749e-5*std::sin(1.74031984806061*x_29 + 1.58823990821838) + 4.03580954242913e-6*std::sin(1.77439987659454*x_29 + 3.80479979515076) + 0.000147646609814716*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 1.40018779489776e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 1.9052570737591e-5*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 3.23525375660282e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 8.30099561510825e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) + 2.40497103956879e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 8.0603621976613e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 8.80292482251934e-6*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 3.78420961675329e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 1.04273543296807e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 1.55231778660512e-6*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 1.69379209497144e-5*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 5.9582631845862e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 9.12110473935553e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) + 8.33220933892866e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 2.43355220230513e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 3.08704178559208e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) + 4.1150572129226e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 8.614376754509e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 2.87089806912858e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 8.48747827030855e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 4.66084914055862e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 2.26551630601439e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) + 3.68252861046355e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 4.23700743401496e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 2.53102389677055e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 2.84936692418648e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 2.83588234319161e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) - 3.39822988933224e-6*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 7.18406109614772e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) + 2.49056312128493e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 4.84923853614592e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 1.34126961414587e-5*std::sin(1.964479804039*x_70 + 4.21384000778198) - 1.09008556934091e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 7.6511853316053e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 5.30684764926388e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 4.28819780531537e-5*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 4.51828018988258e-5*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 4.63644649870779e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) - 7.6545981752387e-6*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 1.06724208827843e-6*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 3.9556808026336e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 3.86944173005915e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) - 8.28829118477891e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 4.31149834004561e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 1.95418550324848e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 3.74006976629307e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 6.24575597906132e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) - 8.23423871868772e-6*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 2.7730150172634e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) - 5.33850163818385e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 5.41358546979255e-5*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 1.82599177002461e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 6.21403749942985e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) - 3.7252175534833e-6*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 1.48307309831889e-6*std::sin(1.7766398191452*x_95 + 1.3847998380661) + 7.15022712124074e-6*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 2.05241349807009e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 1.40076555309369e-5*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 9.16515089470712e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0883339037473306);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.02303859176383e-5*x_1 - 3.51888272804388e-5*x_10 + 7.72972546081308e-6*x_100 - 6.92075629715061e-6*x_101 + 2.03623049525484e-5*x_102 - 2.88843302285514e-5*x_103 - 3.13635197135839e-5*x_104 + 1.13227654842392e-5*x_105 + 7.83742391511468e-6*x_106 + 8.31152756704498e-7*x_107 - 4.86628959522663e-5*x_108 + 5.47097799132237e-6*x_109 - 2.16587563581349e-5*x_11 - 1.56432703592542e-5*x_110 - 2.83321346565944e-5*x_111 - 7.82687486961247e-6*x_112 - 4.64021252082387e-5*x_113 - 3.13367533127649e-6*x_114 - 2.09181752206317e-6*x_115 - 1.13801466303182e-5*x_116 - 4.0501447809189e-5*x_117 + 5.49638901237253e-5*x_118 - 1.1264199812497e-6*x_119 + 1.19275412509367e-5*x_12 - 1.74215697292386e-5*x_120 - 3.72096070707213e-5*x_13 - 2.26567481895124e-5*x_14 + 1.13180186717722e-5*x_15 - 2.96933959728804e-5*x_16 + 1.68881229415099e-5*x_17 + 8.78473719027066e-6*x_18 - 2.12224199168888e-5*x_19 - 6.63429403231309e-5*x_2 - 5.23909342932331e-5*x_20 + 1.10410451088666e-5*x_21 - 4.21975713377653e-5*x_22 - 1.34489003581064e-5*x_23 - 3.55993239187582e-6*x_24 + 5.02976052235383e-5*x_25 - 3.08662519592591e-5*x_26 + 2.66544192544042e-5*x_27 - 3.40063789250035e-7*x_28 + 2.93616475396717e-5*x_29 - 4.03190550086461e-6*x_3 + 9.20494193314255e-6*x_30 - 9.94224939911761e-6*x_31 + 4.243276747002e-6*x_32 + 1.39954625704607e-5*x_33 + 1.02196544607594e-5*x_34 + 1.90176751363096e-5*x_35 + 8.02676990790711e-6*x_36 - 2.15736539166393e-5*x_37 - 6.60069608656712e-6*x_38 + 3.8206653984451e-5*x_39 - 4.47080216465465e-6*x_4 - 1.45367690174726e-5*x_40 + 9.42258603389021e-6*x_41 - 3.39751851466606e-5*x_42 - 3.2857919682934e-5*x_43 + 5.17045712203854e-5*x_44 - 1.32852087584915e-5*x_45 - 4.84402595857201e-5*x_46 - 1.54668720458394e-5*x_47 - 1.42894836986253e-5*x_48 - 1.91924282012882e-5*x_49 + 3.71762503747368e-6*x_5 + 3.83718819768719e-6*x_50 + 1.04539695200285e-5*x_51 - 3.1587623045128e-5*x_52 - 1.20330592676956e-5*x_53 + 4.65255244963479e-5*x_54 + 8.31529895843328e-6*x_55 - 1.35260172800141e-5*x_56 - 5.95221120734801e-5*x_57 - 6.06952876784898e-7*x_58 + 2.82340561251134e-5*x_59 + 1.87191105759327e-6*x_6 + 2.40312501462733e-5*x_60 - 3.39294360361106e-5*x_61 - 5.45651811845545e-6*x_62 - 1.45898247518494e-5*x_63 - 1.25207115345065e-5*x_64 - 1.56765007522832e-5*x_65 - 1.10941892032823e-6*x_66 + 1.25890815931429e-5*x_67 - 2.77104891600041e-5*x_68 - 1.42952607488718e-5*x_69 - 5.25551757959766e-5*x_7 - 3.27639791107988e-5*x_70 - 8.59945715972632e-6*x_71 - 1.128999094955e-5*x_72 - 4.57586017766261e-5*x_73 - 7.04097839507664e-6*x_74 - 4.09313813636995e-5*x_75 - 3.96651495857239e-5*x_76 - 2.45212185603902e-5*x_77 + 2.02670273666724e-5*x_78 + 1.07314787001724e-5*x_79 + 4.92077093009916e-5*x_8 - 4.86530192862419e-5*x_80 - 1.17018385388321e-5*x_81 - 5.60678370230427e-6*x_82 - 4.38767583191736e-5*x_83 + 1.4798909141914e-8*x_84 - 4.20248811755802e-5*x_85 - 8.9126966892553e-6*x_86 - 3.97813398987523e-6*x_87 + 5.27852099728373e-6*x_88 + 4.94992703808769e-6*x_89 + 2.2382936677679e-6*x_9 - 9.8147428033181e-6*x_90 + 3.73977458972347e-5*x_91 + 3.71506864133212e-5*x_92 - 4.93529504306207e-5*x_93 + 1.49975071579825e-5*x_94 - 3.47208371493702e-5*x_95 + 2.1326885311871e-6*x_96 - 4.05061822542502e-5*x_97 - 1.1921075680048e-5*x_98 - 3.10457570146139e-6*x_99 - 5.48871073417299e-6*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 5.62016487699096e-6*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 8.37139205262186e-7*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 9.85405660169136e-6*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 5.27225448052573e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 2.42155754172289e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 4.50446322159591e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 2.84070224070837e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) - 2.14107295498283e-6*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 0.000119583160634835*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 2.61276530091761e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 1.11485683638969e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 0.000101933421839957*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 6.38559275680894e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 1.49492260047034e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 2.9042207700886e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) + 3.79235754122374e-6*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 0.000137586345318826*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 5.49693706650409e-7*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 1.12671397874274e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 2.1026665362592e-5*std::sin(1.95199978351593*x_120 + 9.98999977111816) - 2.62041314003735e-6*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 7.57501486006283e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) - 2.23823608776367e-6*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 4.33563672494885e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) + 3.38448360121639e-6*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 1.40857759852984e-5*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 3.67371953615845e-6*std::sin(1.66791975498199*x_18 + 7.19591999053955) - 0.000331305085713092*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 7.84745719770106e-6*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 4.03057138056127e-6*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 7.22116585170941e-6*std::sin(1.26583993434906*x_24 - 1.99143981933594) - 0.000112745774834126*std::sin(1.7105598449707*x_24 - 8.56167984008789) - 9.98665909669195e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 7.7772276123655e-6*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 6.15018364288898e-7*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 3.46962098437537e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 2.23136387417826e-5*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 9.71883742477142e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 9.90925325612146e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) - 8.80603045811528e-6*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 4.88486509409172e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 5.50665179457498e-6*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 2.09308315400016e-5*std::sin(0.631359875202179*x_31 - 5.02360010147095) - 8.89389152873141e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 1.29657915744572e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 7.95680923404458e-6*std::sin(0.809759855270386*x_40 + 7.80695962905884) - 5.28021144155625e-6*std::sin(0.879359900951385*x_43 + 8.00504016876221) - 2.41997272539373e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) + 2.47897382594364e-6*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 1.62870707539689e-6*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 7.11039220657565e-6*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 1.86077130965248e-5*std::sin(1.65063989162445*x_47 - 1.60215985774994) + 3.90316075972166e-6*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 0.000137377478653159*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 2.75669848481282e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) - 6.68996961138972e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 1.21407030189117e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 1.36146027090102e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 1.34552791883816e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) - 7.89225759023162e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 1.3257069314103e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 2.69771838336689e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) + 1.48410267760924e-6*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 1.21835885631385e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) - 2.7755942701354e-6*std::sin(0.847599864006042*x_63 + 7.17751979827881) + 6.95792469093419e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 1.12059764723344e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) - 7.79599742280347e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) + 7.41484839523072e-6*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 0.000108202704396173*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 8.23998930355683e-6*std::sin(1.30271983146667*x_67 - 1.79703998565674) - 3.17665685157702e-6*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 1.47349608250082e-5*std::sin(1.964479804039*x_70 + 4.21384000778198) - 1.70266591451674e-6*std::sin(1.69351983070374*x_72 + 9.77544021606445) + 5.01216636904128e-6*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 7.99290623762563e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) - 0.000117884929602142*std::sin(1.04719984531403*x_73 - 2.01999998092651) - 0.000124210021619534*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 1.82341943884923e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) + 1.67021322406642e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 4.88850278757701e-6*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 1.55568823481843e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 1.52177217402394e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 2.74216823190202e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 2.49551272333239e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) - 5.37216404043731e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 2.16476754757058e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 2.45632789372276e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) + 1.79668926875356e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 4.1765753406523e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 1.76623495384292e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) + 0.000148822458985131*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 7.18125161062365e-7*std::sin(1.80111992359161*x_92 - 8.18575954437256) - 4.07071432996761e-6*std::sin(1.13975989818573*x_94 - 5.19264030456543) + 8.12832689308101e-6*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 6.79321688578397e-6*std::sin(1.7766398191452*x_95 + 1.3847998380661) - 1.56016078435133e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) + 5.64219823149424e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 1.53885731341199e-5*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 0.000138040879626997*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0512939870819696);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000116131189784374*x_1 - 6.12187890311761e-6*x_10 - 3.96037055854323e-6*x_100 + 3.33698854704298e-5*x_101 + 4.44261137203048e-5*x_102 + 1.17538259999158e-5*x_103 - 2.02814587492427e-5*x_104 + 1.76196226074177e-5*x_105 - 1.30665232891113e-5*x_106 - 1.68088351893953e-5*x_107 - 1.74823414472217e-5*x_108 + 8.46102481488618e-6*x_109 + 1.01114916473734e-5*x_11 + 3.70898826360474e-5*x_110 - 2.08994060786416e-5*x_111 - 4.81933644413019e-6*x_112 + 4.19579799073114e-6*x_113 + 2.13782892737847e-5*x_114 + 1.2272943630021e-5*x_115 - 3.77866149798674e-5*x_116 - 5.43912460601453e-5*x_117 - 4.17887133216375e-6*x_118 - 1.9919383198298e-5*x_119 - 1.49947207484242e-5*x_12 + 7.89861909067555e-6*x_120 + 1.52936376119509e-5*x_13 + 1.13567997685238e-5*x_14 + 5.91288298206599e-6*x_15 + 4.81281492239617e-6*x_16 - 3.2883994844714e-6*x_17 + 6.96392834512683e-6*x_18 + 3.78896059324016e-7*x_19 + 7.45590750896746e-6*x_2 - 4.1449801038572e-5*x_20 + 2.46446711793453e-6*x_21 - 4.85481944399417e-6*x_22 - 2.47686821145398e-6*x_23 - 4.74503708581702e-6*x_24 + 2.16707325342668e-5*x_25 - 2.87730888638331e-5*x_26 - 2.56684433118888e-5*x_27 + 3.29318198886579e-6*x_28 - 1.0120347405692e-5*x_29 + 5.86978789623679e-5*x_3 + 6.48924268232331e-6*x_30 - 0.000108043756937622*x_31 - 3.16446106590378e-5*x_32 - 2.32040704528288e-5*x_33 + 8.12066142693659e-6*x_34 + 2.96895738326355e-5*x_35 + 2.09134196403525e-5*x_36 + 1.51310623099679e-6*x_37 - 1.1064044533876e-6*x_38 - 5.44398664747532e-5*x_39 + 5.80742060687213e-6*x_4 + 2.95975613276397e-5*x_40 + 2.93508079498629e-5*x_41 + 3.36569398715258e-6*x_42 - 2.16296064741065e-5*x_43 + 7.5678166961147e-6*x_44 - 1.10533691133457e-5*x_45 - 3.53818290104348e-5*x_46 - 1.18046936994947e-5*x_47 - 1.64423552058176e-5*x_48 + 2.51528697360976e-5*x_49 + 1.25387825291299e-5*x_5 - 2.70538627748595e-5*x_50 - 2.79590753813931e-5*x_51 - 4.28813140785687e-5*x_52 + 2.20981622808562e-5*x_53 - 6.16901106101951e-6*x_54 - 5.86714446723964e-6*x_55 - 3.5764092676166e-5*x_56 - 9.42375276623643e-5*x_57 + 2.48829275403666e-5*x_58 + 2.85956918519147e-5*x_59 + 1.17054759196562e-5*x_6 + 6.2217556541065e-6*x_60 - 1.50231429619042e-5*x_61 - 6.96957389059669e-5*x_62 - 1.88521757510076e-5*x_63 - 5.10796326848509e-6*x_64 - 2.72865784159868e-5*x_65 + 1.46975706806369e-5*x_66 - 3.59375151914409e-5*x_67 - 1.36543030219191e-5*x_68 - 2.7436464087809e-5*x_69 + 3.1257757510133e-6*x_7 + 2.19128098179383e-5*x_70 + 2.65663548625362e-7*x_71 + 2.86975411961988e-6*x_72 - 2.28534027779206e-5*x_73 - 4.00516846319464e-5*x_74 - 6.52020146129541e-6*x_75 - 2.43419562998175e-5*x_76 + 7.31937993975218e-6*x_77 - 1.14906037997159e-5*x_78 - 2.25306866863651e-6*x_79 - 7.45439699689097e-5*x_8 - 3.11866020613978e-5*x_80 + 1.22946009868174e-5*x_81 - 3.52746118546886e-5*x_82 + 2.27837483595486e-5*x_83 - 1.24757887750037e-5*x_84 - 2.33905022688282e-5*x_85 + 4.77191787442693e-5*x_86 - 6.18433355665689e-6*x_87 - 2.36890601632665e-5*x_88 - 1.01186787805139e-5*x_89 - 2.25119646654075e-5*x_9 + 1.75048029815029e-5*x_90 - 0.000161139069234669*x_91 - 3.53553976505115e-5*x_92 - 1.59318844761797e-5*x_93 - 7.95830348695869e-6*x_94 + 2.72622805602101e-6*x_95 + 3.37921125017274e-5*x_96 - 2.11907021579835e-5*x_97 + 1.38638597006872e-5*x_98 - 7.15277564546147e-6*x_99 - 5.81225118299565e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 7.5807252357732e-6*std::sin(1.36503994464874*x_100 - 1.99583983421326) + 6.28349270619725e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 5.92943143681252e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 3.17183354190704e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 1.52239140837567e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 2.71044777919301e-5*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 6.13838753253459e-6*std::sin(1.70703983306885*x_105 + 7.00392007827759) - 2.26728177493471e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 7.19422556991226e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 5.07642427996596e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) - 8.36801664033256e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 6.13240213702842e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 3.84162740357434e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 2.90453236769189e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 1.82583344489239e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) + 4.01590385663516e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 8.27731261081202e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) - 4.12595226059041e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) + 8.45701530032053e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 4.54358850649289e-6*std::sin(1.95199978351593*x_120 + 9.98999977111816) - 2.77487740031435e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 4.76228102887566e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) - 2.37017233718149e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 2.60835626210999e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) + 3.58398716341959e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 3.04375271913997e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 4.95527426800689e-6*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 0.000199076051858485*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 1.05849949453997e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 5.4366117094353e-6*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 4.34515545650647e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 6.77471752943168e-5*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 6.0008274848752e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 4.67975167588252e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) - 4.61627335321887e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 2.18129079566488e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 4.8216866905376e-6*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 5.84693600168509e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 6.22977639829477e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) - 2.65295688346671e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 0.000293934506612476*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 1.06990478101806e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 4.52288006569421e-6*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 5.34420051955003e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) - 9.73200828202279e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 4.78781041312125e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) - 5.59146158069062e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 1.45412381684294e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) + 2.6251007295299e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) - 1.22249310084373e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 9.59080931189554e-6*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 4.02088442934468e-6*std::sin(1.65063989162445*x_47 - 1.60215985774994) + 4.13323854031317e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 8.26474701295634e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 1.65877417984965e-5*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 4.01989825909901e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 2.35885556040621e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 8.19224574868605e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) + 1.0099413348293e-5*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 4.7423343288913e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) - 9.95063877275089e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 1.69600896046964e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) + 1.57158537977153e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 7.33116887384871e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) - 2.93920591946465e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 4.18090828161746e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 2.17724458545537e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 4.68449309762379e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) + 2.23384113688378e-5*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 6.5095675559009e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 4.95820691826782e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) - 3.36390974816634e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 3.18403310718202e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) + 1.27800595022973e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) + 5.30761618142018e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 4.80860098757807e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 7.08352131338337e-5*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 7.46358621451636e-5*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 3.54277925716681e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) + 5.03178326570595e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 6.59382727340443e-6*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 3.02259583917319e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 2.95669925273372e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 1.65003096455501e-5*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 1.56888575391456e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 3.2280494722998e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 1.36095197358274e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 4.77247709730092e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) + 5.41281248760374e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 2.51266356825435e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 1.06278758925697e-5*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 8.94250913742022e-5*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 1.39526807187432e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) - 4.31066881201866e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) + 2.44878789423153e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 9.16298930819178e-6*std::sin(1.7766398191452*x_95 + 1.3847998380661) - 4.70023276872192e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 3.39030880045562e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 3.32527021369277e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 8.30465778487233e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0704424007378548);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.59019663464172e-6*x_1 - 8.47876674208566e-6*x_10 - 9.53293672443207e-6*x_100 - 2.19032376726371e-5*x_101 - 1.88253950630359e-5*x_102 - 6.20409832641786e-5*x_103 - 2.03477274433381e-5*x_104 + 9.23847239452947e-6*x_105 + 7.26184403597632e-6*x_106 - 2.38454231440345e-5*x_107 - 5.79852221639445e-5*x_108 + 3.2761780876723e-5*x_109 - 2.08648294983655e-5*x_11 - 1.00715198638263e-5*x_110 + 1.6923410195018e-5*x_111 - 3.91660563087657e-6*x_112 - 4.06333397711713e-5*x_113 - 2.02136152921702e-5*x_114 - 1.13983296344424e-5*x_115 - 2.61339726191276e-6*x_116 - 5.24190412894308e-7*x_117 + 4.26522907652587e-5*x_118 + 4.4334235980096e-5*x_119 - 7.6119622041983e-6*x_12 - 3.94597032265392e-5*x_120 - 4.43617894352843e-5*x_13 - 1.88969279557876e-5*x_14 + 6.66236979334895e-6*x_15 - 2.3827165064777e-5*x_16 + 9.50585969445967e-7*x_17 + 6.55618057631229e-6*x_18 - 1.65044962020554e-5*x_19 - 2.06464560494146e-5*x_2 - 6.05738999091116e-6*x_20 + 1.37866425899114e-5*x_21 - 1.60341419649077e-5*x_22 - 3.10441780123229e-5*x_23 + 3.21336125112656e-6*x_24 + 3.38732316714502e-5*x_25 - 1.08627694219226e-5*x_26 + 2.12933966350496e-5*x_27 + 2.54006125934975e-5*x_28 + 3.6235970474877e-5*x_29 - 6.50665525238984e-5*x_3 - 1.74259218936585e-6*x_30 - 1.55865044052025e-5*x_31 + 3.24247532091098e-6*x_32 + 2.40175147500534e-5*x_33 - 5.34743170129699e-5*x_34 - 1.75915462990013e-5*x_35 - 4.34876744649031e-6*x_36 - 4.64409500653803e-5*x_37 - 7.08274277438839e-6*x_38 + 4.40433708186506e-5*x_39 - 4.51449392246314e-6*x_4 - 6.24053268610531e-5*x_40 + 1.08828389949269e-5*x_41 - 1.5977650466057e-5*x_42 - 2.14714181923031e-5*x_43 + 0.000127601814648764*x_44 - 1.64777326508721e-5*x_45 - 4.39607736998929e-5*x_46 - 7.0042737107372e-6*x_47 + 1.7268406732523e-5*x_48 - 3.39208562709954e-5*x_49 - 2.040249084757e-5*x_5 + 4.82860420176221e-6*x_50 + 6.43889569413886e-5*x_51 + 8.75686213658043e-7*x_52 - 1.43969201080449e-5*x_53 - 3.17339931978962e-5*x_54 + 1.34400911731383e-5*x_55 + 2.96159927210195e-5*x_56 + 1.27545179901571e-5*x_57 - 7.62068437310692e-6*x_58 + 1.79252769304753e-5*x_59 - 7.59431693160329e-6*x_6 + 2.21569016386402e-5*x_60 - 3.52618186704508e-5*x_61 + 3.35418121602519e-5*x_62 - 4.45111687216334e-6*x_63 - 3.05281241562759e-5*x_64 - 2.13217840841058e-5*x_65 - 2.65697390923318e-5*x_66 + 3.08621226829506e-5*x_67 - 1.15886128052781e-5*x_68 - 8.40791200317808e-6*x_69 - 3.28967028695923e-5*x_7 - 2.63311650569251e-5*x_70 - 8.59506424580068e-6*x_71 - 7.96930728007786e-6*x_72 - 3.76873704595666e-5*x_73 + 2.84070737561962e-5*x_74 - 3.13400657564538e-5*x_75 - 4.67080721279425e-5*x_76 - 5.84256355695598e-5*x_77 + 2.98345016278079e-5*x_78 - 1.69195706332971e-5*x_79 + 2.18899236688444e-5*x_8 - 3.52302610123164e-5*x_80 - 3.0786999230652e-5*x_81 + 1.91777950679177e-5*x_82 - 2.42693546061775e-5*x_83 + 2.97468768860735e-6*x_84 - 9.43492652439356e-6*x_85 - 1.50770578022971e-5*x_86 + 5.34968088481377e-6*x_87 + 2.7130838989817e-5*x_88 + 3.21402444369113e-5*x_89 + 7.901530981051e-5*x_9 - 5.73776413796832e-6*x_90 + 3.35305536943279e-5*x_91 + 5.30961770283645e-5*x_92 - 5.51400873591514e-5*x_93 + 1.72152369796702e-5*x_94 - 4.04686725293998e-5*x_95 - 8.16531839209392e-6*x_96 - 3.09046624659623e-5*x_97 - 8.48387548130407e-6*x_98 - 4.47119022679935e-6*x_99 + 0.000114059802706124*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 1.75084391795823e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) + 5.85298426504234e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 3.88691364299808e-6*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 3.16731512539903e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 2.13916309184016e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 1.77677684004769e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) + 1.07808212933654e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 4.44932099088942e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 7.18397707889029e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 1.15159558506845e-5*std::sin(1.19663989543915*x_114 - 5.18671989440918) - 7.7946887209996e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 6.12366626022921e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 3.83615483622533e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 6.58898166672707e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 2.56553964747375e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 7.88082254453579e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 8.26552121462162e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) - 3.84326596507924e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) + 7.87758970949054e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) - 7.97988322820393e-6*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 5.44542826606491e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 6.69164037178246e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 4.65123375860537e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 2.60464054379194e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 7.0332278473593e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) - 5.34572865468691e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 1.14446989491367e-5*std::sin(1.66791975498199*x_18 + 7.19591999053955) - 0.000298399962261381*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 2.44470989850901e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 1.25563956609944e-5*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 2.84837495885131e-6*std::sin(1.26583993434906*x_24 - 1.99143981933594) - 0.000101547897712528*std::sin(1.7105598449707*x_24 - 8.56167984008789) - 8.99478705905177e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 3.06771244910611e-6*std::sin(1.09903979301453*x_25 - 7.99959993362427) - 4.29999310301994e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 3.06500466107828e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) - 8.46830576723472e-6*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 5.83860678396221e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 8.75366720301445e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) - 1.78770263387432e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 1.92682562582107e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 2.42709741013272e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) - 7.94351309055271e-6*std::sin(0.631359875202179*x_31 - 5.02360010147095) - 8.01055284381768e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) - 9.06522757411043e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 3.13854807381891e-6*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 0.000109727020504255*std::sin(0.879359900951385*x_43 + 8.00504016876221) - 2.17962174766134e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 5.15150604932325e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) - 1.13873497080758e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 2.21509283475788e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) - 7.06186050396555e-6*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 8.11108050224506e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 8.25297351701324e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 1.08737440663898e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) - 6.02552380163958e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 5.35110443762231e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 5.37025381045276e-6*std::sin(0.899279832839966*x_56 + 4.3840799331665) + 9.40746017822497e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) - 7.10840089283046e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) - 9.26887877288209e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 2.38311892178755e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 3.08408416478967e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 4.80579303741874e-6*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 5.7679070764802e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) + 6.26686566167085e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 4.93911681519535e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) - 7.02170125685593e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) + 1.50528028139136e-5*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 6.50029439035928e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 3.25024790670027e-6*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 6.60134722531567e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) - 5.59210244363876e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) + 1.19044440203577e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 0.000104156829330387*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 4.80175092379143e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) - 0.000106176633143893*std::sin(1.04719984531403*x_73 - 2.01999998092651) - 0.000111873518886613*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 8.03685572052445e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) + 3.39068164026575e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 1.52291001436484e-5*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 6.85681068380171e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 6.70732314330149e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 1.0816429763704e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 2.20449385199085e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) - 4.83860229153462e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 1.91231914186999e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 1.08264464354994e-5*std::sin(0.758319854736328*x_87 + 1.22591996192932) + 3.64743927843726e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 2.50908416839119e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 6.96687974945645e-7*std::sin(1.14151990413666*x_87 + 8.98439979553223) + 0.000134041456228253*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 3.16518963534744e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 8.45927023368733e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) + 1.65012277266894e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 2.11628354828871e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) - 3.16726538332826e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) + 5.08181676633581e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) + 5.84015651275936e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 8.29282743427772e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0508662621026818);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.36095189488601e-5*x_1 + 2.04496272713212e-5*x_10 - 1.84396909057829e-5*x_100 - 8.23184437314209e-7*x_101 - 3.16954515132232e-5*x_102 - 2.52578101107804e-5*x_103 + 2.67189126099428e-5*x_104 - 3.0880573195533e-6*x_105 - 7.90840617711696e-6*x_106 - 2.41949110408511e-5*x_107 - 6.6253754597651e-6*x_108 + 2.19121894033005e-5*x_109 - 1.371355867263e-5*x_11 + 1.47611889328414e-5*x_110 + 5.3223737826921e-5*x_111 + 1.7696410795315e-5*x_112 - 5.19013010374432e-6*x_113 - 2.05201701176401e-5*x_114 + 2.11230120868106e-6*x_115 + 1.46902396592348e-5*x_116 - 1.85547829031766e-5*x_117 - 1.5409034137373e-5*x_118 + 4.20240989669494e-5*x_119 - 1.83184928359098e-5*x_12 - 1.90019697456207e-5*x_120 - 2.9844420724513e-5*x_13 - 6.25646157807651e-6*x_14 + 1.69481316201535e-6*x_15 + 8.32454036219098e-6*x_16 - 2.21492025242341e-5*x_17 - 4.71814816003279e-6*x_18 - 6.03450542232869e-6*x_19 + 3.8975049602152e-5*x_2 + 3.57881543180567e-5*x_20 + 1.73864228943978e-6*x_21 + 7.64185403009329e-5*x_22 - 1.60669071839627e-5*x_23 + 9.89297617574006e-6*x_24 + 3.22664164164741e-6*x_25 + 1.98913467084781e-5*x_26 - 2.85937414601462e-6*x_27 + 9.89139789244304e-6*x_28 - 7.84133775276745e-6*x_29 - 6.38338269285603e-5*x_3 - 1.65669020774002e-5*x_30 + 4.12776857274062e-5*x_31 - 7.98608206391257e-6*x_32 - 6.16475152270083e-6*x_33 - 8.44157235631805e-5*x_34 - 2.98031647647945e-5*x_35 - 1.51791034548826e-5*x_36 + 1.08654581591046e-5*x_37 - 5.32848962518849e-6*x_38 - 3.29681819436943e-5*x_39 - 1.63064346882512e-5*x_4 - 9.96718727249904e-6*x_40 - 2.74883709203947e-5*x_41 - 8.90853569793502e-6*x_42 + 1.48948074452051e-6*x_43 + 6.12630361841743e-5*x_44 - 4.5720914490032e-6*x_45 + 7.86456371788741e-6*x_46 - 5.93919185902489e-6*x_47 + 6.81066716661154e-6*x_48 - 2.81058679277311e-5*x_49 - 1.48562746046136e-5*x_5 + 3.19051958281554e-5*x_50 + 6.73477964013843e-5*x_51 + 9.93689825756797e-6*x_52 - 9.56565447877763e-6*x_53 - 5.6785789604576e-5*x_54 - 3.97985085466863e-6*x_55 + 5.48574430026794e-6*x_56 + 3.10001090874769e-6*x_57 - 1.79947227916725e-5*x_58 + 6.30202537798977e-6*x_59 - 1.10656286459523e-5*x_6 - 5.65315191286056e-6*x_60 - 7.37398484950779e-6*x_61 + 4.92383847404174e-6*x_62 - 1.10720871612311e-6*x_63 - 1.77501346683227e-5*x_64 + 1.39390473555276e-5*x_65 - 1.59599144175114e-5*x_66 + 1.34785154559365e-5*x_67 + 1.97464676651093e-5*x_68 + 6.01989332822206e-6*x_69 + 3.20877746336889e-5*x_7 + 8.75480727952466e-6*x_70 - 1.24158499178594e-5*x_71 + 6.67771510296444e-6*x_72 - 2.30903391144849e-5*x_73 + 3.55415970927066e-5*x_74 - 1.03425647432557e-5*x_75 - 4.05296162003633e-5*x_76 - 1.71510351680664e-5*x_77 + 1.43375682520093e-5*x_78 - 2.50451725885869e-5*x_79 - 5.58764594750622e-5*x_8 + 5.72681250027376e-6*x_80 - 1.77422116329466e-6*x_81 + 1.47194453666467e-5*x_82 - 3.3683740107654e-5*x_83 + 1.64200761001103e-6*x_84 + 9.04139098852661e-6*x_85 + 3.3814545040419e-5*x_86 + 5.60660441392662e-6*x_87 - 5.00201478950132e-6*x_88 + 3.57907037794996e-5*x_89 + 2.11589284342056e-5*x_9 + 1.14540714022387e-5*x_90 - 2.550880803661e-5*x_91 - 4.30973382934193e-7*x_92 - 3.55216256276299e-6*x_93 - 2.00949209729864e-5*x_94 - 1.85646315019717e-5*x_95 - 8.0119687727042e-6*x_96 + 6.90498008473729e-6*x_97 - 6.73755828047476e-6*x_98 - 8.17421642090745e-7*x_99 + 0.000109801110262852*std::sin(0.811439871788025*x_1 + 7.40240001678467) - 2.06357321100059e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 5.83487875140736e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 1.84521409980677e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) + 2.69455989902962e-6*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 1.20021905707626e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 8.43479937706381e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 3.61156776315568e-6*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 4.28319507069636e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) + 6.11169264374569e-6*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 1.45257182557976e-5*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 7.77057677459281e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) - 5.20964441066643e-6*std::sin(1.72047984600067*x_114 - 9.00583934783936) - 3.26356822068945e-6*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 8.31105055667649e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 1.43944591617551e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 7.58657339960558e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) - 7.03180489711836e-6*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 3.83137727698739e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 7.85322131869411e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 2.67325542613937e-6*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 5.24211032532795e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 3.75447497572769e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 4.47756894778063e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) + 2.21587044004794e-6*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 6.77062565469608e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 1.79081544480532e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) - 1.348890892967e-5*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 0.000168318425160941*std::sin(0.48431983590126*x_19 + 1.35343980789185) - 2.881374977796e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) - 1.47991728143126e-5*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 1.3521940846504e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 5.72801085222828e-5*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 5.07368828388604e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 1.45631901944628e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 4.28669158361863e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 1.71968047611051e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 2.83687664281308e-6*std::sin(1.84455990791321*x_28 - 5.2151198387146) - 4.96713307119537e-6*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 4.91141523357323e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) + 4.92614898110885e-6*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 9.14711809725635e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 3.06143351156287e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 2.66107145489003e-6*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 4.51851142715238e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 9.0371853662358e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 1.48994644353998e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 0.000105630102729917*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 1.22945893569362e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 4.95916238956566e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 1.13521242903966e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) + 2.61074455969569e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 2.36571844110985e-6*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 7.80823413198888e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) - 7.02113007587006e-6*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 5.16203541211594e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 3.39881637174389e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 6.74964687482976e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 2.54939238705215e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 9.37835931432129e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 4.0096347017826e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 9.24020659414317e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 1.33709522014423e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 2.9689325897791e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 2.28142888879783e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 5.5525486268133e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 3.53495004112517e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 6.22998387804133e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 3.96073005019126e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) - 4.14791296043961e-6*std::sin(1.51143980026245*x_65 - 4.78983974456787) + 5.53005681553162e-6*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 1.54297311856015e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 6.35487031691436e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 1.87335049567502e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) - 1.18676190326647e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 0.000100267887814966*std::sin(1.76191997528076*x_72 - 5.78991985321045) - 4.08503889638917e-6*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 5.98910386725069e-5*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 6.31044802201185e-5*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 1.01373349613784e-5*std::sin(1.66879975795746*x_75 - 8.61567974090576) - 9.34327812185452e-6*std::sin(1.77895987033844*x_76 + 0.788479864597321) - 1.79492659292705e-5*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 8.64887825358645e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 8.46032127019637e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 5.13482689421462e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 1.23687415067115e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 2.72930972081638e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 1.07294384707698e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 1.3656001522809e-5*std::sin(0.758319854736328*x_87 + 1.22591996192932) - 1.00507930931389e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) - 2.13457686266226e-6*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 3.30735023365211e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 7.56087455495589e-5*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 3.99243045608715e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 8.14342337646785e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) - 4.54703733230563e-6*std::sin(1.19999992847443*x_94 - 5.40343999862671) + 2.49428632234827e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) + 8.72763783268038e-6*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 2.86649967575016e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 1.95644843925255e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) - 7.0550353751625e-6*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0572224537567818);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.63901613283259e-5*x_1 + 3.83174162049362e-5*x_10 - 5.70936532332912e-6*x_100 + 4.55645925823888e-5*x_101 - 4.06916528988113e-6*x_102 - 1.58367612902268e-5*x_103 + 3.87244661589931e-5*x_104 + 2.15220773828384e-5*x_105 - 3.78117330991843e-5*x_106 - 1.57382843578561e-5*x_107 + 5.02009089452247e-6*x_108 + 3.25667374895874e-5*x_109 - 2.30045009715417e-5*x_11 + 1.06347414590119e-5*x_110 + 3.26714096966122e-5*x_111 + 3.00207426641935e-5*x_112 + 6.06363401478357e-7*x_113 - 1.89873615759913e-5*x_114 + 2.75914693878432e-6*x_115 + 3.607173054013e-5*x_116 - 2.04024234257451e-5*x_117 - 3.74137941972836e-5*x_118 + 9.74672092783094e-6*x_119 + 5.56681930407252e-6*x_12 - 1.82782047276777e-6*x_120 - 4.52641202632895e-5*x_13 + 2.09793070667867e-5*x_14 - 4.27160094152791e-6*x_15 + 3.06036198732999e-5*x_16 - 2.07325780801573e-5*x_17 - 6.32348330387001e-6*x_18 - 2.02398076101979e-6*x_19 - 2.28700898237789e-6*x_2 + 1.54756698747441e-5*x_20 - 1.27556147329965e-7*x_21 + 6.15348729232395e-5*x_22 - 2.14386946279827e-5*x_23 - 1.24463497681487e-5*x_24 + 1.2805843408718e-5*x_25 + 2.25470648728743e-5*x_26 - 5.86864835182346e-6*x_27 + 1.93429619285755e-5*x_28 - 2.1323766996232e-5*x_29 - 2.30048705288487e-5*x_3 + 2.65093099463777e-6*x_30 - 5.686397498916e-6*x_31 - 5.65460268631487e-5*x_32 - 2.27164296525752e-5*x_33 - 2.85781490059779e-5*x_34 - 8.78389524015978e-6*x_35 + 4.82250354901114e-6*x_36 - 1.21085284745034e-5*x_37 + 8.1179842790454e-6*x_38 - 5.28921222873773e-5*x_39 - 2.22754969038016e-6*x_4 + 2.06974309227929e-5*x_40 - 1.56581643899414e-5*x_41 + 2.29506483767591e-5*x_42 - 1.20984050768807e-5*x_43 + 7.19167638077332e-5*x_44 - 4.17029243183032e-6*x_45 + 4.69950766433313e-6*x_46 - 1.07002944048377e-5*x_47 + 5.44385492185953e-6*x_48 + 1.28424212379314e-6*x_49 + 7.68927373055522e-6*x_5 - 1.04858733726449e-5*x_50 + 3.8438299101287e-5*x_51 - 3.67014592952084e-5*x_52 + 8.2479062188037e-6*x_53 - 7.84301162216116e-5*x_54 - 8.26486895573491e-6*x_55 + 7.94043935931621e-6*x_56 - 5.20487617672669e-5*x_57 - 6.00771489038793e-6*x_58 + 3.04279671881705e-5*x_59 - 1.1296321756769e-5*x_6 + 5.06045734736714e-6*x_60 - 2.23847321609117e-5*x_61 + 1.30802478240822e-5*x_62 + 1.91318275806681e-6*x_63 + 8.85125843090889e-6*x_64 - 2.02489952214478e-5*x_65 - 9.1198355089844e-6*x_66 - 8.52902641086048e-5*x_67 - 5.88867413169236e-6*x_68 + 3.79394851693372e-6*x_69 + 4.44916499459943e-5*x_7 + 4.40124093697739e-5*x_70 + 2.2269096478087e-7*x_71 + 1.81855073396501e-5*x_72 - 1.59203416557895e-5*x_73 + 3.49855048998253e-5*x_74 - 2.85530981682233e-5*x_75 - 5.57160618400805e-5*x_76 - 2.6602482049826e-6*x_77 - 7.91243026545364e-6*x_78 + 5.41305031215927e-6*x_79 - 0.000111387629377281*x_8 - 2.36518695303751e-5*x_80 - 8.73713726092587e-6*x_81 + 2.59703227427199e-5*x_82 + 2.90763835222478e-5*x_83 + 6.504458327024e-7*x_84 - 1.19489274507146e-5*x_85 + 5.90403844205931e-5*x_86 + 1.28851804715345e-5*x_87 - 1.18232062157118e-5*x_88 - 9.55062841518151e-8*x_89 - 3.30541012672207e-5*x_9 + 3.4279615922865e-5*x_90 - 2.44346032086358e-5*x_91 - 1.57329518299981e-5*x_92 - 7.3348504767636e-6*x_93 + 7.8132319404993e-6*x_94 - 8.00125502055202e-6*x_95 - 1.07403032372332e-5*x_96 - 9.69270212947691e-6*x_97 + 1.95560788685023e-5*x_98 + 3.86062911825602e-6*x_99 + 6.73906886029364e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 1.02395566854501e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) + 1.65288783533151e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 7.10127866133996e-6*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 2.41449910334371e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) + 3.36817724234465e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 3.24611983158482e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 2.11741067522654e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 2.62882100685449e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 5.47646998441214e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 2.50402009906367e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) - 2.20122685859344e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 4.66817670775237e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 2.92436718344746e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 1.43270282899409e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) + 4.03952007582583e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 4.65627719348403e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 6.30094978593518e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) - 1.08534164350383e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) + 2.22463816967999e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 1.56729153323955e-5*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 3.21735749038171e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) - 1.05361909525113e-5*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 2.74811842918268e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 1.98556253752174e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 4.15548735391108e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 1.04992955659735e-5*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 6.69326616928012e-6*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 0.000391761724197916*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 1.42975312239461e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 7.34342586548932e-6*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 5.20389856132337e-6*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 0.000133319653243408*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 0.000118090272543686*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 5.60462180403911e-6*std::sin(1.09903979301453*x_25 - 7.99959993362427) - 1.21432178357986e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) + 4.82594290566393e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 1.66322031918478e-5*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 4.45087093848207e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) - 1.37829148103379e-5*std::sin(1.74031984806061*x_29 + 1.58823990821838) + 2.83061169076594e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 3.52025461780318e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 5.2774609213151e-6*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 1.56014824465081e-5*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 0.000105168511754825*std::sin(1.08175981044769*x_36 + 0.95279985666275) - 2.56002813321257e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 5.73403643900068e-6*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 6.48307229601516e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 2.86156997974122e-5*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 3.04369753207935e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) - 3.21579743884859e-6*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 1.29546491337092e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 1.38698698467986e-5*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 4.792321987164e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 6.29138445901791e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 1.98660155073489e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 7.91075701161846e-5*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 1.16353980839538e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 9.81129818997798e-6*std::sin(0.899279832839966*x_56 + 4.3840799331665) + 2.65667491758431e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 9.33243881453961e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) - 2.6175394084625e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) + 3.7522931041508e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 1.82218933089062e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 8.78004470434145e-6*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 3.40788972503527e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 8.22760860399287e-5*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 1.07395755395653e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 9.21861306664303e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) - 2.38342992936788e-5*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 4.95528684567353e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 5.93810879886504e-6*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 3.90031654155422e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 1.09831867989575e-5*std::sin(1.964479804039*x_70 + 4.21384000778198) + 3.36182532134174e-6*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 6.1539650996577e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 3.66045778236657e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 0.000139396602314397*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 0.000146875898773462*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 1.7475273888161e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) - 5.36873577782983e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 8.90651831324488e-6*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 1.49093935321865e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 1.45843490366834e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 1.97613039361554e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) - 3.47104250792631e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 6.35247793623772e-5*std::sin(2.1165599822998*x_80 + 7.81583976745605) - 3.01100455515331e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 2.3540937311179e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) - 5.7752805568833e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 1.91271825976936e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 1.27282875424976e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 0.000175979620131393*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 6.88236266882434e-7*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 4.99804517105222e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) - 2.61277055982914e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 1.2376777354579e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) + 5.0149830581038e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 6.67178803693586e-5*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 1.14703781916138e-5*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 6.32176578947921e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0681364979686568);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.80792881039319e-5*x_1 + 1.54557639616237e-5*x_10 - 6.29936395175118e-6*x_100 + 2.64864548700096e-6*x_101 + 5.38107033082822e-6*x_102 - 2.64939707040059e-5*x_103 + 6.29056565822311e-6*x_104 + 1.36012964040105e-5*x_105 - 9.18329274585047e-6*x_106 - 1.36685510130365e-5*x_107 - 3.22903584821931e-5*x_108 + 5.14433145424327e-5*x_109 - 6.88683625588636e-6*x_11 + 5.46866948060004e-6*x_110 + 1.18690154203867e-5*x_111 - 4.25029022904602e-6*x_112 - 4.99538552248554e-6*x_113 - 2.82675762966446e-6*x_114 + 3.48140048393611e-7*x_115 + 1.19416096572779e-5*x_116 + 2.07085041213605e-5*x_117 + 6.29642338380213e-7*x_118 + 1.93222789390656e-5*x_119 - 1.95486958646707e-5*x_12 - 5.66356325440556e-6*x_120 + 2.38746580133239e-6*x_13 + 2.57481245436746e-5*x_14 + 1.52973363042343e-5*x_15 + 9.20779444371206e-6*x_16 + 3.06836550786489e-7*x_17 + 2.80233221175523e-6*x_18 + 1.15433394073525e-5*x_19 - 5.58815104473975e-6*x_2 - 1.42372667005139e-5*x_20 - 1.76559123396405e-7*x_21 - 1.22553846920257e-5*x_22 - 2.47874884854764e-5*x_23 + 3.37738121404994e-6*x_24 + 3.41272593126302e-5*x_25 + 3.98557303933889e-6*x_26 + 4.61076640833424e-6*x_27 + 3.2741354749642e-5*x_28 + 2.06592326488494e-5*x_29 - 3.05725143622227e-5*x_3 + 1.36911737667727e-5*x_30 - 0.000127460900783963*x_31 - 4.43679020310256e-5*x_32 + 1.29480433843901e-6*x_33 - 1.75754489663578e-5*x_34 - 5.26192188315012e-6*x_35 + 5.21743289795866e-6*x_36 - 5.17917442028057e-5*x_37 + 2.4963095670568e-6*x_38 + 3.57992891636058e-6*x_39 + 1.99331346451281e-5*x_4 - 3.6006093427883e-5*x_40 + 3.32375481477051e-5*x_41 + 4.75690890183987e-5*x_42 - 2.37748678497915e-5*x_43 + 0.000102783989099617*x_44 - 2.94477886615439e-6*x_45 - 2.71970558235209e-5*x_46 - 1.06899163481532e-5*x_47 + 1.25552803651895e-5*x_48 - 1.5150756399899e-5*x_49 - 9.00313220489274e-6*x_5 - 5.17572550341949e-5*x_50 + 1.94274745989231e-5*x_51 - 1.90859167171045e-5*x_52 + 1.43506531354113e-5*x_53 - 9.64977346108773e-5*x_54 + 9.44848128762675e-6*x_55 + 3.93563800677332e-5*x_56 + 7.05339973555509e-6*x_57 + 1.85061996235912e-5*x_58 + 2.10824574987517e-5*x_59 - 6.54453385570671e-6*x_6 + 2.36090961087759e-5*x_60 - 3.17369519457793e-5*x_61 + 1.03393420019737e-5*x_62 + 2.04257550649043e-5*x_63 - 1.58656406469949e-5*x_64 - 5.3386265413285e-5*x_65 - 2.98159736377022e-5*x_66 - 5.16561034892301e-5*x_67 - 1.06687480695812e-5*x_68 - 1.80065178268992e-6*x_69 - 5.7141825156938e-7*x_7 + 3.43540462464127e-5*x_70 + 8.30840448513351e-6*x_71 + 1.28190150449491e-5*x_72 - 9.86404638348727e-6*x_73 + 1.36602938372458e-5*x_74 - 1.82616013724209e-5*x_75 - 3.94456497840421e-5*x_76 - 1.64531530101643e-5*x_77 - 3.10795226426411e-6*x_78 + 7.46169531034886e-6*x_79 - 0.000200960894229786*x_8 - 2.77356192642658e-5*x_80 - 2.55005682491795e-5*x_81 + 2.68263614672164e-5*x_82 + 1.07587670168095e-5*x_83 + 7.86544718524574e-6*x_84 + 1.12993274675983e-5*x_85 + 6.05262659847286e-6*x_86 + 3.63341929563342e-6*x_87 + 2.56458589647633e-5*x_88 + 9.21231902026515e-6*x_89 + 2.70586872538167e-5*x_9 + 1.97796133031366e-5*x_90 - 8.61103227996711e-5*x_91 + 9.83303235605562e-6*x_92 - 4.68482908065917e-5*x_93 - 4.37811534530896e-6*x_94 - 1.28679241022888e-5*x_95 + 2.8586240130254e-5*x_96 - 3.36551222141237e-5*x_97 + 3.4665067908136e-5*x_98 - 4.39628660027865e-6*x_99 + 6.38731323571077e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 5.38192505820969e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 5.56108533617775e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 5.35796991220737e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 1.91982762553534e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) + 2.58516561558984e-6*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 2.44922262855818e-5*std::sin(1.30823981761932*x_105 + 7.41160011291504) + 1.74447766202421e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 2.49160582262764e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 4.35447598714344e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 7.07084227419497e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 7.40595347322489e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 3.71178212160548e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 2.32523627704666e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 4.04566070911259e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) + 3.10043909572892e-6*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 4.4132359475227e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 5.01004015673365e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 3.65159532874271e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 7.48472003923211e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) - 1.29124930822574e-5*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 3.04942277759021e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) - 8.08680678299463e-7*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 2.60467634029405e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 1.5787696116695e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 3.9385855711984e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) - 8.65008701246444e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 3.51798989197474e-5*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 3.18077594462006e-5*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 7.51480204939249e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 3.85971472131608e-5*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 3.92638188803151e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 1.08244353592718e-5*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 9.58793764167794e-6*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 4.22873068745012e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 4.08554465688396e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) + 3.70403953380951e-6*std::sin(1.4948798418045*x_28 - 8.41952037811279) - 1.37028245289837e-5*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 3.53899695947575e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) - 1.05787536957188e-6*std::sin(1.74031984806061*x_29 + 1.58823990821838) + 1.16813599320071e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 0.00026560594542194*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 1.49024737448395e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) - 1.28536414502984e-5*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 8.53879926647053e-6*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 8.61312825195765e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 4.32637503481228e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 6.14467878914108e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 2.32335432310113e-6*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 2.88482725658089e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 1.08194419482264e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 6.80898137827531e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) - 1.14270124383569e-5*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 4.54217968282737e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 5.00243453002722e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 1.49890630180869e-5*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 6.42286983441461e-6*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 3.28559921223763e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 7.40270069780325e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 8.93829309609883e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 7.57715597323892e-6*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 8.80662299650159e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) + 2.87998475570511e-6*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 1.7270774750121e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 6.62461193218693e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 3.23000990163678e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 6.68012669765272e-6*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 3.03263718851395e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 7.48473903242392e-6*std::sin(1.13487982749939*x_65 - 4.78239965438843) - 9.83593156507127e-6*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 3.94007045419959e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 4.48034921554948e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 3.6967337752126e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) - 9.04875197465918e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) - 1.13107478303602e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 5.83274982761239e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 2.91052001757269e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 1.13178325501602e-5*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 1.19250885629415e-5*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 4.9346610839006e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) - 2.21556828883528e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 4.68127825881058e-5*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 4.21010878105227e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 4.11832284208728e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 1.49100573242294e-5*std::sin(1.73783993721008*x_80 + 3.59624004364014) - 2.66411744279092e-6*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 5.15767819066132e-6*std::sin(2.1165599822998*x_80 + 7.81583976745605) - 2.31102607858847e-6*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 6.64748077606488e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) - 2.38334106770474e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 1.52084933470708e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 9.60359182324465e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 1.42880661351829e-5*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 1.94343890942655e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 4.7371648421398e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) - 1.07823737988085e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 6.50525117744028e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) + 2.06958172135495e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 5.41693115603313e-6*std::sin(1.28271985054016*x_96 - 8.61431980133057) + 9.45013584957917e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 5.02659147315441e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0747005777484689);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.03027953459733e-5*x_1 + 1.84370316523229e-5*x_10 - 1.99194072649423e-5*x_100 - 3.00912332500925e-5*x_101 - 4.00118372481842e-5*x_102 - 2.6892632381519e-5*x_103 + 1.09209394679319e-5*x_104 - 3.73245889847658e-6*x_105 + 5.16224317690986e-6*x_106 - 2.35434806496924e-5*x_107 - 1.37789101807235e-5*x_108 + 3.68117271571459e-5*x_109 - 2.05660382397896e-6*x_11 + 2.67760333863626e-5*x_110 + 4.77379876835069e-5*x_111 + 1.32311069585939e-5*x_112 - 5.91947024954234e-6*x_113 - 1.8450825342715e-5*x_114 + 6.34923545957648e-6*x_115 - 5.71605985049276e-6*x_116 - 6.4321969776175e-6*x_117 - 4.71341285544686e-7*x_118 + 5.12331858332575e-5*x_119 - 4.36220398357009e-5*x_12 - 2.05486745036248e-5*x_120 + 1.00102762018695e-5*x_13 - 9.65048227117447e-6*x_14 + 2.26014314039861e-5*x_15 - 9.38510426166477e-6*x_16 - 1.35054507513977e-5*x_17 - 1.38487297221666e-6*x_18 - 3.26379108105323e-7*x_19 + 5.35223225353106e-5*x_2 + 2.30566453565227e-5*x_20 - 1.09650880039704e-5*x_21 + 4.92339584722394e-5*x_22 - 1.48604942806028e-5*x_23 + 1.824949740111e-5*x_24 + 1.1998297963902e-5*x_25 + 2.43326756003939e-5*x_26 + 9.35110567852766e-6*x_27 + 2.30054730104112e-5*x_28 + 1.76791010884737e-5*x_29 - 8.06789270475078e-5*x_3 - 1.56159329452518e-5*x_30 + 1.06816284921436e-5*x_31 - 2.56198516567121e-5*x_32 + 1.95914870821063e-5*x_33 - 9.47701487039951e-5*x_34 - 3.98263395079027e-5*x_35 - 1.74377193317819e-5*x_36 + 1.13750604221748e-5*x_37 - 1.57203540083717e-5*x_38 - 1.36026636772895e-5*x_39 - 4.65169269725705e-6*x_4 - 3.45287352321156e-5*x_40 - 2.634121473134e-5*x_41 + 2.31083580073845e-5*x_42 + 5.70934750697721e-6*x_43 + 8.06849813554874e-5*x_44 - 1.33991555255055e-5*x_45 + 8.69838571283213e-6*x_46 + 4.61046207143244e-6*x_47 + 1.36373639172112e-5*x_48 - 4.59248353100084e-5*x_49 - 3.30811243465206e-5*x_5 + 3.8670386445315e-6*x_50 + 7.31189782581732e-5*x_51 + 3.43600679649832e-5*x_52 + 4.26243838174136e-7*x_53 - 7.01987200021484e-5*x_54 + 2.43790734112252e-6*x_55 + 2.67093565401055e-5*x_56 + 2.65691774354354e-5*x_57 + 5.47033296581944e-6*x_58 - 4.15433631615305e-6*x_59 - 1.62911281567345e-5*x_6 - 4.97761443638001e-6*x_60 - 1.1946642761861e-5*x_61 - 5.75905397531928e-6*x_62 + 1.51185529259763e-5*x_63 - 3.9926490943809e-5*x_64 + 9.76552128939831e-6*x_65 - 2.78057541792035e-5*x_66 + 2.54991814428779e-5*x_67 + 4.10920202394006e-5*x_68 + 1.42482839860221e-5*x_69 + 1.89059526512839e-5*x_7 + 1.97543227487063e-5*x_70 - 1.68688072297263e-5*x_71 + 7.37292044784746e-6*x_72 - 2.47468530577911e-5*x_73 + 4.11348831866931e-5*x_74 + 3.32128976471426e-6*x_75 - 2.71531941466871e-5*x_76 - 1.79297458951565e-5*x_77 + 1.36042598822003e-5*x_78 - 2.21170770304655e-5*x_79 - 0.000106288721908487*x_8 + 1.83505892125193e-5*x_80 - 1.09132418527561e-5*x_81 + 3.44211323925356e-5*x_82 - 6.78485801294423e-5*x_83 + 2.05074613731989e-5*x_84 + 3.32708982261559e-5*x_85 + 1.82838126204641e-5*x_86 + 3.06336820988802e-6*x_87 + 1.13963947660836e-5*x_88 + 3.44366465351238e-5*x_89 + 7.14004074569468e-5*x_9 + 1.10168469505297e-5*x_90 - 9.27865298203656e-5*x_91 + 7.5570283707197e-6*x_92 - 9.2052602221034e-6*x_93 - 3.63149057344463e-5*x_94 - 1.82879985317433e-5*x_95 + 3.15355222867638e-5*x_96 + 3.61298230278468e-6*x_97 + 1.09175307207943e-5*x_98 - 5.44471949447162e-6*x_99 + 0.000126560067605295*std::sin(0.811439871788025*x_1 + 7.40240001678467) - 2.65866700774364e-6*std::sin(1.36503994464874*x_100 - 1.99583983421326) + 5.14449806776402e-6*std::sin(1.2875999212265*x_102 + 0.772799849510193) + 7.84691548987714e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) + 2.16171000266307e-5*std::sin(1.39079988002777*x_104 - 8.00072002410889) - 4.49871888177973e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) + 3.58696358828059e-5*std::sin(1.30823981761932*x_105 + 7.41160011291504) - 1.85901289937828e-5*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 4.93693967589504e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) + 4.90310388941261e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 6.28973762838993e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) - 6.85116502080916e-6*std::sin(1.71207988262177*x_114 - 2.18215990066528) - 4.17943592083851e-5*std::sin(1.72047984600067*x_114 - 9.00583934783936) - 2.61819678589382e-5*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 3.59874303612596e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) - 5.39540051811395e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 8.74451305681797e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) - 5.64126371373304e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) - 3.37805014261564e-6*std::sin(1.8653599023819*x_119 + 4.58495998382568) + 6.92403109319118e-6*std::sin(1.7804799079895*x_12 + 4.00704002380371) + 1.37602743363281e-5*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 6.0422142870843e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) + 1.40727039492446e-5*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 5.16098086241491e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) + 1.77768150434588e-5*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 7.80402710443619e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) + 9.21801619302867e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) - 1.73788441091378e-6*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 3.18497044540419e-5*std::sin(0.48431983590126*x_19 + 1.35343980789185) - 3.71230666766109e-6*std::sin(1.30535984039307*x_19 + 4.39175987243652) - 1.90669622446937e-6*std::sin(1.56167984008789*x_2 - 1.78783988952637) - 5.75030979292574e-5*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 1.08387095814719e-5*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 9.60058128984944e-6*std::sin(0.995839834213257*x_25 - 4.99191999435425) + 6.19310912110006e-5*std::sin(1.09903979301453*x_25 - 7.99959993362427) - 3.77949182983575e-6*std::sin(2.25279974937439*x_27 + 0.399279862642288) - 6.44578919397606e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) + 1.46024956993369e-5*std::sin(1.84455990791321*x_28 - 5.2151198387146) - 3.98488125961811e-5*std::sin(1.7092798948288*x_29 - 5.3808798789978) + 1.84092031510983e-5*std::sin(1.74031984806061*x_29 + 1.58823990821838) + 1.09388882311604e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) - 0.000388988262622819*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 1.32562212865484e-5*std::sin(0.592319846153259*x_31 - 1.80071985721588) + 1.36975587479643e-5*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 8.55005941205835e-6*std::sin(1.08175981044769*x_36 + 0.95279985666275) - 7.967908954991e-6*std::sin(1.08399987220764*x_37 - 5.21920013427734) - 6.33611233955214e-5*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 0.000121752438665235*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 2.32641813888059e-6*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 5.71607997211126e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) - 1.00089451666628e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) + 3.36363177691355e-6*std::sin(1.28031992912292*x_47 + 1.18255984783173) + 1.21772631353801e-5*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 9.00000589481126e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) - 5.63269984106596e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) - 2.19519543227362e-5*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 6.43133969617974e-6*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 2.92264431812293e-6*std::sin(1.78607988357544*x_55 - 8.18703937530518) - 0.000108414880494515*std::sin(0.899279832839966*x_56 + 4.3840799331665) + 8.26871532843515e-6*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 7.58714799632528e-6*std::sin(1.00431978702545*x_6 - 4.80304002761841) - 8.14690878672403e-6*std::sin(1.30439984798431*x_6 - 4.79152011871338) - 5.01176470923015e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 3.42208114634275e-5*std::sin(1.33119988441467*x_60 + 7.4255199432373) - 9.7019525747368e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 6.40003482577653e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 6.68893580497722e-6*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 2.69762660489023e-6*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 7.49460918495496e-6*std::sin(1.13487982749939*x_65 - 4.78239965438843) - 9.2107559963843e-6*std::sin(1.51143980026245*x_65 - 4.78983974456787) + 4.43648669221823e-5*std::sin(1.44135987758636*x_66 + 4.78663969039917) - 6.56161237103144e-5*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 7.3248149768816e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) + 9.64285585901225e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) + 1.04634467627587e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 0.000115571788209828*std::sin(1.76191997528076*x_72 - 5.78991985321045) - 3.27722142928511e-5*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 1.13327574170269e-5*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 1.19408142205165e-5*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 4.38953696026189e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) - 2.07474592180538e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) - 2.31254800580733e-6*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 3.74502479237018e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 3.66337829939549e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) + 2.18362479986848e-5*std::sin(1.73783993721008*x_80 + 3.59624004364014) + 4.63611126919143e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 5.16447963961329e-6*std::sin(2.1165599822998*x_80 + 7.81583976745605) + 4.02165980907927e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 5.91314419836556e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) - 2.23185499874219e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) - 1.71246375229287e-5*std::sin(1.0447998046875*x_87 + 2.01191973686218) + 1.40647623392924e-5*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 1.43069078598599e-5*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 1.72875031899774e-6*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 9.38635511605568e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) - 1.00970420000999e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) + 3.21358928180603e-6*std::sin(1.7766398191452*x_95 + 1.3847998380661) + 1.93803831633708e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 5.4240744828116e-6*std::sin(1.28271985054016*x_96 - 8.61431980133057) - 1.00705929503619e-5*std::sin(1.05887985229492*x_98 + 7.37215995788574) - 5.6599003589131e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.068548639009966);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.64019919215021e-5*x_1 + 1.53982836769514e-5*x_10 - 2.22725720269382e-5*x_100 - 5.77420624889939e-7*x_101 - 1.10342825022619e-7*x_102 - 2.9080355669568e-6*x_103 - 2.21365938560239e-5*x_104 - 3.06794305471433e-6*x_105 - 3.92396232372067e-6*x_106 - 1.89041131402121e-5*x_107 - 2.69567236424441e-5*x_108 + 2.36690207208896e-5*x_109 + 2.25309477093431e-6*x_11 - 3.1870018084964e-6*x_110 + 1.59459993330765e-5*x_111 - 2.05875881107276e-5*x_112 + 4.15743388188044e-6*x_113 - 4.01789467110189e-6*x_114 - 5.0346988075885e-6*x_115 + 1.37699374558141e-5*x_116 + 2.91825625515948e-5*x_117 - 8.94587444455799e-6*x_118 - 1.28217451535933e-6*x_119 + 4.90556212272702e-6*x_12 - 5.14742874742432e-6*x_120 - 1.57228322233122e-5*x_13 + 2.29916133447663e-5*x_14 - 6.82802601337023e-6*x_15 + 1.11657843231024e-5*x_16 - 7.75262750225115e-6*x_17 + 7.03180107860504e-6*x_18 + 2.714298979862e-6*x_19 + 5.69841914919462e-6*x_2 + 1.70349221231552e-5*x_20 + 7.38507116863197e-6*x_21 - 2.60256324687126e-5*x_22 - 2.03547439033635e-6*x_23 - 4.38460070584524e-6*x_24 - 5.61154549609742e-6*x_25 - 2.06840047471781e-5*x_26 - 1.58598821746591e-5*x_27 + 1.69508256547357e-5*x_28 + 3.34559643720149e-6*x_29 - 3.17436958063361e-6*x_3 - 2.34452523618633e-6*x_30 - 0.000131999609501868*x_31 + 4.77054999895718e-7*x_32 - 1.9973002246235e-5*x_33 - 1.13337483825958e-5*x_34 - 6.68979090075688e-6*x_35 + 1.64719328861652e-6*x_36 - 4.13383509732914e-5*x_37 + 1.08341539202254e-5*x_38 + 6.85210757781515e-6*x_39 + 1.23560044921479e-5*x_4 - 2.2363719449898e-5*x_40 + 5.33211451723781e-5*x_41 + 1.56262467188004e-5*x_42 - 7.06432370269802e-6*x_43 + 3.43447766009577e-5*x_44 + 1.28572757876824e-5*x_45 - 2.2955291084111e-5*x_46 - 6.90631534198282e-6*x_47 + 1.54642529067411e-5*x_48 + 1.60019301378029e-5*x_49 - 4.31768697946096e-6*x_5 - 4.6086821871312e-5*x_50 + 3.94283403565169e-7*x_51 - 7.88621403901921e-6*x_52 + 7.78126231018627e-6*x_53 - 5.67219567981455e-5*x_54 + 1.46914226015004e-5*x_55 + 3.46949215248431e-5*x_56 + 2.46827720848164e-5*x_57 - 9.22911497767832e-7*x_58 + 1.64350472444816e-6*x_59 - 8.2419379979532e-7*x_6 - 3.53936747309544e-6*x_60 - 1.72289179498159e-5*x_61 - 1.00240830916163e-6*x_62 - 1.25347186453782e-5*x_63 - 2.22207967888416e-6*x_64 - 2.47330818063997e-5*x_65 - 5.75120083989096e-6*x_66 - 2.71900213415743e-5*x_67 - 1.56758554121815e-5*x_68 - 1.70805066728878e-5*x_69 - 2.25313292965734e-7*x_7 + 5.7879730796038e-6*x_70 + 2.16493413426957e-5*x_71 - 4.12606223688297e-6*x_72 + 6.89562582244676e-6*x_73 - 1.43931427796862e-5*x_74 - 9.97387374241267e-6*x_75 - 1.10790266746632e-5*x_76 - 1.27193508961371e-5*x_77 - 5.52971686198099e-6*x_78 - 1.42192491068741e-5*x_79 - 1.83828036639375e-5*x_8 - 1.04643136083965e-5*x_80 - 1.32932322269765e-5*x_81 - 3.8416474077004e-5*x_82 + 2.9304285971413e-5*x_83 - 1.56082096707746e-5*x_84 + 5.87433518973708e-6*x_85 - 7.4911458624551e-6*x_86 + 3.62563132807787e-6*x_87 + 2.21004505852567e-5*x_88 + 8.42934079132819e-6*x_89 + 3.00804112967565e-5*x_9 - 3.8931564096991e-6*x_90 - 5.93404126215163e-5*x_91 - 1.45802007784575e-5*x_92 - 2.76464482415268e-5*x_93 + 1.26040449292662e-6*x_94 + 5.20259140282302e-6*x_95 - 4.35537508682971e-6*x_96 - 1.35640759700901e-5*x_97 + 8.56847093122155e-6*x_98 + 2.91145670809584e-7*x_99 + 2.61986245385555e-5*std::sin(0.811439871788025*x_1 + 7.40240001678467) + 3.30910338190827e-5*std::sin(1.36503994464874*x_100 - 1.99583983421326) - 1.57961082562858e-5*std::sin(1.2875999212265*x_102 + 0.772799849510193) - 1.08479346053669e-5*std::sin(1.24527990818024*x_103 - 5.20168018341064) - 4.75817051516456e-6*std::sin(1.39079988002777*x_104 - 8.00072002410889) + 2.471971991351e-5*std::sin(1.12983989715576*x_105 - 5.19687986373901) - 4.95878240153052e-6*std::sin(1.30823981761932*x_105 + 7.41160011291504) + 8.69870812457009e-6*std::sin(1.70703983306885*x_105 + 7.00392007827759) + 1.02197345012212e-5*std::sin(1.4327198266983*x_110 + 7.59600019454956) - 1.07922914408737e-5*std::sin(1.62335991859436*x_110 - 7.79647970199585) + 1.81568216748955e-6*std::sin(1.19663989543915*x_114 - 5.18671989440918) + 2.1036404897984e-5*std::sin(1.71207988262177*x_114 - 2.18215990066528) + 9.19941562191726e-6*std::sin(1.72047984600067*x_114 - 9.00583934783936) + 5.76295004149097e-6*std::sin(0.983359813690186*x_115 + 1.4139997959137) + 1.03886265884571e-6*std::sin(1.49207997322083*x_118 - 8.21432018280029) + 2.96468379407206e-5*std::sin(1.81063985824585*x_118 - 1.9948798418045) - 1.81016191507222e-5*std::sin(1.86239993572235*x_118 - 4.99719953536987) + 1.2417065488842e-5*std::sin(0.487919867038727*x_119 + 4.82288026809692) + 1.0372254988738e-5*std::sin(1.8653599023819*x_119 + 4.58495998382568) - 2.12601391384085e-5*std::sin(1.7804799079895*x_12 + 4.00704002380371) - 6.4387186450272e-6*std::sin(1.95199978351593*x_120 + 9.98999977111816) + 1.25077132530067e-5*std::sin(2.03727984428406*x_15 - 8.59447956085205) - 7.73271922946761e-6*std::sin(2.08359980583191*x_15 + 3.81520009040833) + 1.06835119815803e-5*std::sin(1.68151986598969*x_16 - 8.41112041473389) - 3.91287994639043e-6*std::sin(1.08207988739014*x_17 + 7.79120016098022) - 1.6154761913961e-5*std::sin(1.08063983917236*x_18 - 8.00111961364746) - 4.31330155791462e-6*std::sin(1.18015992641449*x_18 + 7.59136009216309) + 2.16305357713867e-5*std::sin(1.66791975498199*x_18 + 7.19591999053955) + 4.71636204246028e-5*std::sin(0.48431983590126*x_19 + 1.35343980789185) + 4.62051340497261e-5*std::sin(1.30535984039307*x_19 + 4.39175987243652) + 2.37316478757451e-5*std::sin(1.56167984008789*x_2 - 1.78783988952637) + 7.94949106750683e-6*std::sin(1.26583993434906*x_24 - 1.99143981933594) + 1.60501578697749e-5*std::sin(1.7105598449707*x_24 - 8.56167984008789) + 1.42167150236316e-5*std::sin(0.995839834213257*x_25 - 4.99191999435425) - 8.56163709629127e-6*std::sin(1.09903979301453*x_25 - 7.99959993362427) + 1.160487598818e-5*std::sin(2.25279974937439*x_27 + 0.399279862642288) + 3.54185508549896e-5*std::sin(1.4948798418045*x_28 - 8.41952037811279) - 6.83281154322829e-6*std::sin(1.84455990791321*x_28 - 5.2151198387146) + 8.77117860054698e-6*std::sin(1.7092798948288*x_29 - 5.3808798789978) - 1.01155541763042e-5*std::sin(1.74031984806061*x_29 + 1.58823990821838) - 3.66423727546621e-5*std::sin(1.77439987659454*x_29 + 3.80479979515076) + 5.37755152407496e-5*std::sin(0.547119855880737*x_31 - 1.49287986755371) - 3.8267231513189e-6*std::sin(0.592319846153259*x_31 - 1.80071985721588) - 6.40937271643148e-6*std::sin(0.631359875202179*x_31 - 5.02360010147095) + 1.2661083160128e-5*std::sin(1.08175981044769*x_36 + 0.95279985666275) + 2.44653512881911e-5*std::sin(1.08399987220764*x_37 - 5.21920013427734) + 8.75933128123902e-6*std::sin(0.809759855270386*x_40 + 7.80695962905884) + 2.52034191163038e-5*std::sin(0.879359900951385*x_43 + 8.00504016876221) + 3.44500220431874e-6*std::sin(1.70887982845306*x_44 - 1.76423990726471) - 1.1832597426286e-5*std::sin(1.14527988433838*x_46 + 4.59015989303589) + 3.07323239898798e-5*std::sin(1.40071988105774*x_46 - 1.97103977203369) - 4.186536055873e-5*std::sin(1.28031992912292*x_47 + 1.18255984783173) - 5.69799476949216e-6*std::sin(1.65063989162445*x_47 - 1.60215985774994) - 1.86305032657143e-5*std::sin(1.77591979503632*x_47 - 3.00543975830078) + 1.23982154273769e-5*std::sin(1.65895986557007*x_49 + 1.60535979270935) + 3.03473849387375e-6*std::sin(1.46415984630585*x_51 + 1.1969598531723) + 9.52364455029685e-6*std::sin(2.19695973396301*x_51 + 4.58656024932861) - 8.4369070442273e-7*std::sin(1.78607988357544*x_55 - 8.18703937530518) + 1.49877685744208e-5*std::sin(0.899279832839966*x_56 + 4.3840799331665) - 2.53889729858798e-5*std::sin(0.981519818305969*x_56 + 1.21311986446381) + 1.12351864589613e-5*std::sin(1.00431978702545*x_6 - 4.80304002761841) + 2.50149677294197e-5*std::sin(1.30439984798431*x_6 - 4.79152011871338) + 2.75388223048006e-5*std::sin(1.37263989448547*x_6 - 1.80375993251801) - 7.08389469047285e-6*std::sin(1.33119988441467*x_60 + 7.4255199432373) + 1.341242265332e-5*std::sin(0.76887983083725*x_63 + 7.62136030197144) + 1.3248421291708e-5*std::sin(0.847599864006042*x_63 + 7.17751979827881) - 9.90509754354864e-6*std::sin(0.755279839038849*x_64 - 1.59903979301453) - 7.78733996619566e-7*std::sin(1.98919987678528*x_64 - 5.60559988021851) + 1.10981533075137e-5*std::sin(1.13487982749939*x_65 - 4.78239965438843) + 3.08535883573928e-5*std::sin(1.51143980026245*x_65 - 4.78983974456787) - 9.76521371683865e-6*std::sin(1.44135987758636*x_66 + 4.78663969039917) + 9.07107283091561e-6*std::sin(1.30271983146667*x_67 - 1.79703998565674) + 1.51627666628775e-5*std::sin(1.76319992542267*x_70 + 4.21487998962402) - 4.51209287643462e-6*std::sin(1.964479804039*x_70 + 4.21384000778198) - 3.21278646859824e-5*std::sin(1.69351983070374*x_72 + 9.77544021606445) - 2.39239907488171e-5*std::sin(1.76191997528076*x_72 - 5.78991985321045) + 7.21353852148517e-6*std::sin(2.09615993499756*x_72 + 6.19799995422363) + 1.67817528715852e-5*std::sin(1.04719984531403*x_73 - 2.01999998092651) + 1.76821744223648e-5*std::sin(1.54455983638763*x_75 - 4.99271965026855) + 1.26714410889091e-6*std::sin(1.66879975795746*x_75 - 8.61567974090576) + 6.94984826899022e-5*std::sin(1.77895987033844*x_76 + 0.788479864597321) + 2.8783072135599e-5*std::sin(1.45159983634949*x_77 + 7.18344020843506) - 1.08109036243749e-6*std::sin(1.73695993423462*x_77 - 8.79096031188965) - 1.0575211628793e-6*std::sin(1.77063989639282*x_78 + 0.999279797077179) - 3.01874272281751e-6*std::sin(1.73783993721008*x_80 + 3.59624004364014) - 2.54746684720476e-5*std::sin(1.85911989212036*x_80 + 1.59799981117249) + 7.64765518514567e-6*std::sin(2.1165599822998*x_80 + 7.81583976745605) - 2.20983588173286e-5*std::sin(0.692399859428406*x_86 - 4.80279970169067) - 1.70696952863437e-6*std::sin(0.758319854736328*x_87 + 1.22591996192932) + 7.47612198516738e-5*std::sin(0.949759840965271*x_87 - 2.1671998500824) + 3.76932822830538e-6*std::sin(1.0447998046875*x_87 + 2.01191973686218) - 1.94437702678839e-6*std::sin(1.14151990413666*x_87 + 8.98439979553223) - 2.11859288278754e-5*std::sin(1.16959989070892*x_87 + 1.21535992622375) + 4.99044842837038e-7*std::sin(1.80111992359161*x_92 - 8.18575954437256) + 1.94302672338968e-5*std::sin(1.13975989818573*x_94 - 5.19264030456543) + 3.38224112788005e-5*std::sin(1.19999992847443*x_94 - 5.40343999862671) - 3.99978603169016e-5*std::sin(1.7766398191452*x_95 + 1.3847998380661) - 6.49191406835569e-5*std::sin(1.21207988262177*x_96 - 1.99207985401154) - 8.03206794057505e-6*std::sin(1.28271985054016*x_96 - 8.61431980133057) + 4.71223996056447e-6*std::sin(1.05887985229492*x_98 + 7.37215995788574) + 1.24580868726022e-5*std::sin(1.3925598859787*x_99 - 4.6017599105835) + 0.0567395272901089);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
