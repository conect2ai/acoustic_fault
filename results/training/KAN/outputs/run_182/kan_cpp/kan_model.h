
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.41946255259459e-5*x_1 + 7.75472015724303e-5*x_10 - 9.92523973364092e-6*x_100 - 1.49387102766208e-5*x_101 - 0.000199368304107382*x_102 - 9.84272419084763e-5*x_103 - 7.48990910960854e-5*x_104 + 3.84394431723901e-5*x_105 - 7.98291237284064e-5*x_106 - 4.88817740183504e-5*x_107 - 4.02748237861169e-5*x_108 - 8.36363299020687e-5*x_109 + 1.6527711501348e-5*x_11 + 5.13349307056861e-5*x_110 + 1.05113708242787e-5*x_111 - 3.94038624329895e-5*x_112 - 0.000122674590393345*x_113 + 0.000136817357539364*x_114 - 7.67245071993328e-5*x_115 - 0.000213718784382685*x_116 - 0.000148065792800995*x_117 - 0.000288775885128122*x_118 - 0.000309630016277158*x_119 + 0.000115769566964209*x_12 - 0.000215925767934004*x_120 + 0.000607967474141692*x_13 - 5.64120283835118e-5*x_14 + 1.21153532825878e-5*x_15 - 2.27934932077447e-5*x_16 - 2.14306196694793e-5*x_17 - 0.000341022026904866*x_18 - 0.000102286212334859*x_19 + 5.48985898205218e-5*x_2 + 0.0003369992911139*x_20 + 6.73251533479943e-7*x_21 - 2.6683599026279e-5*x_22 + 0.000271817576140942*x_23 - 0.000173808718580699*x_24 - 0.000394155779727035*x_25 - 0.000132769050416642*x_26 + 0.000231721065342113*x_27 - 0.000241939447990803*x_28 - 0.000347573844597602*x_29 + 5.37790688868694e-5*x_3 - 3.1335116835134e-5*x_30 + 4.7688810085801e-5*x_31 + 7.14549186632707e-5*x_32 - 0.000167428569476194*x_33 - 0.000212019424139798*x_34 - 8.6510876009891e-5*x_35 - 0.000457110564256656*x_36 - 3.1210881581569e-5*x_37 + 2.39185990756941e-5*x_38 + 7.88172639838945e-5*x_39 + 0.000106009852762435*x_4 - 0.000279613818616396*x_40 + 7.49574762152634e-6*x_41 + 8.27584727036494e-5*x_42 + 0.000316429367748668*x_43 + 7.09052818128021e-5*x_44 - 2.47400126194456e-5*x_45 - 7.32294728811887e-5*x_46 - 0.000189925165155145*x_47 - 3.5009794041759e-5*x_48 - 0.000247161830580711*x_49 + 0.000151252629099276*x_5 - 0.000170116146033766*x_50 - 0.000205237731483685*x_51 - 4.18995803249453e-6*x_52 - 5.8110121907241e-5*x_53 - 0.000196209823847165*x_54 + 0.000922375916155585*x_55 - 0.000536796120302334*x_56 - 0.000892008502374053*x_57 - 0.000588017996281486*x_58 + 0.000121122283214374*x_59 - 0.000129061725792644*x_6 - 0.000309368623374843*x_60 - 0.00010331389721082*x_61 + 6.32408225148123e-5*x_62 - 9.8071086019307e-5*x_63 - 0.000100581753130748*x_64 - 7.81866894208187e-5*x_65 - 0.000101000179633292*x_66 - 0.000178713373929766*x_67 - 0.000108878588542364*x_68 + 4.78596050995649e-5*x_69 - 0.000109921959638361*x_7 - 6.32640599357319e-5*x_70 - 0.000102614371045607*x_71 - 0.000163357123205188*x_72 + 7.70364078314587e-5*x_73 - 1.52858086486151e-6*x_74 - 1.94661214711554e-5*x_75 - 0.000161491440766918*x_76 - 0.000106870046517578*x_77 + 4.81358953511857e-5*x_78 + 1.46390696553403e-5*x_79 + 2.63502840028463e-5*x_8 - 0.000117758732831843*x_80 - 4.66940283611205e-5*x_81 - 6.95354151344913e-5*x_82 + 0.000236946141557483*x_83 - 0.000110926919006423*x_84 + 2.3487873809885e-5*x_85 + 2.58058359526002e-5*x_86 + 4.61491040456697e-5*x_87 - 4.09367872233945e-5*x_88 - 4.896322117612e-5*x_89 - 4.76143779427106e-5*x_9 - 0.000299831486460475*x_90 + 7.10157189054831e-5*x_91 + 6.97405487342764e-5*x_92 - 1.69305940203713e-5*x_93 - 4.84864970031477e-6*x_94 - 2.5694845943532e-5*x_95 - 8.25470153241231e-5*x_96 - 4.64486077120646e-5*x_97 + 6.03674427805774e-5*x_98 - 0.000490473326118148*x_99 + 2.88049932827426e-7*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) - 1.09329336596434e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) - 2.12569180799531e-5*std::exp(0.690639853477478*x_23) - 5.62936049016664e-5*std::exp(0.522799849510193*x_26) - 0.000263650411551551*std::sin(0.440479874610901*x_100 - 5.88263988494873) - 0.000261030821400685*std::sin(0.352959841489792*x_112 + 1.41575980186462) - 0.000207202619962664*std::sin(0.614879846572876*x_13 - 1.78223991394043) - 4.14333879566001e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) + 0.000204086655829034*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 0.000282140547971663*std::sin(0.618319809436798*x_20 - 7.4270396232605) - 2.48913416877976e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 0.000424750364558175*std::sin(1.07687973976135*x_3 + 1.17927992343903) - 3.30519781707995e-5*std::sin(1.19159984588623*x_31 + 7.59752035140991) - 9.42945527064128e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) + 6.13522968106653e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) - 0.000370760672818076*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.00121692673338327*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.00111004489506745*std::sin(0.219599992036819*x_44 + 4.58184003829956) + 0.00147844872691808*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000107883479365821*std::sin(0.651199817657471*x_47 - 7.82536029815674) + 0.000138133145772877*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.000831132741623143*std::sin(0.56471985578537*x_52 - 1.59223985671997) + 0.000125537956324167*std::sin(0.609919846057892*x_52 - 7.80079984664917) + 3.63011702811488e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000105094300431979*std::sin(0.622399806976318*x_58 - 8.2105598449707) + 9.1859584788956e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) + 0.000131666293519199*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 2.59145817052175e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) + 3.01549889952825e-5*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 5.6603604867324e-5*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 0.000109924701708992*std::sin(1.06479978561401*x_64 + 4.80335998535156) + 5.17580948904366e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) + 7.89593378860672e-5*std::sin(1.32183992862701*x_73 + 7.61008024215698) + 5.86269114836745e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) - 7.26842256681703e-5*std::sin(0.598719835281372*x_8 + 4.18455982208252) + 0.000155184278035511*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 0.000260453293375743*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 0.000107980052098554*std::sin(1.23527991771698*x_91 - 8.61303997039795) + 3.20113194467727e-5*std::sin(1.50623989105225*x_91 + 6.02320003509521) + 5.68413658836e-5*std::sin(1.18935990333557*x_92 - 8.00663948059082) + 5.92504243415302e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0226491310084681 - 1.49467233859648e-5*std::exp(-1.43183982372284*x_98) + 3.07553990594374e-5*std::exp(-2.46079969406128*x_46) - 1.50164416062194e-6*std::exp(-3.49255990982056*x_39) - 4.11647739995856e-6*std::exp(-2.12303996086121*x_25) + 2.7303653197665e-6*std::exp(-3.79119992256165*x_118) + 3.66740179548514e-6*std::exp(-4.05719995498657*x_115) - 2.42126082844779e-6*std::exp(-2.90335988998413*x_110) - 6.69669068515577e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00011289803176127*x_1 + 7.87832247628987e-5*x_10 - 7.2313039871862e-5*x_100 - 9.73024906481802e-5*x_101 - 0.000130454029598448*x_102 - 3.08662963018155e-5*x_103 - 0.000249246589137423*x_104 - 6.74211970726864e-5*x_105 - 0.00016305838666886*x_106 - 0.000160427180362136*x_107 + 0.000153895608865079*x_108 - 0.000149504918032841*x_109 - 4.00509838840911e-5*x_11 - 0.00011500770253684*x_110 - 0.000147745540921353*x_111 - 2.98554427536067e-5*x_112 + 2.18993951934211e-5*x_113 - 6.7559032400906e-6*x_114 + 2.83500295489897e-5*x_115 + 1.12133624052005e-6*x_116 + 2.0296953888424e-5*x_117 + 4.77598346844231e-5*x_118 + 0.000240825180308006*x_119 - 6.45443587700556e-5*x_12 + 5.06735392015626e-5*x_120 - 6.89638813849759e-5*x_13 - 0.000127713167700865*x_14 + 6.47132525893596e-5*x_15 + 5.52138474699116e-5*x_16 - 0.000123285163803108*x_17 - 0.000113499798519489*x_18 + 0.000143493629890794*x_19 + 0.000225010740993823*x_2 + 0.000110326321390293*x_20 - 5.4685522005358e-5*x_21 + 0.000233237552510221*x_22 + 5.03950464431318e-5*x_23 - 0.000247550156245059*x_24 + 0.000152533172340535*x_25 - 0.000282340800648736*x_26 - 0.000620723570882196*x_27 - 1.10004676835334e-5*x_28 - 0.000426408523493031*x_29 + 6.64103858076195e-5*x_3 + 0.000463241787517383*x_30 - 3.48656232701786e-5*x_31 + 7.60978583891474e-6*x_32 - 0.000276175160393341*x_33 - 0.000121586663069647*x_34 + 2.4033697112982e-5*x_35 + 0.000562916123292671*x_36 + 0.000172051583404023*x_37 - 6.65924271818897e-5*x_38 - 0.000150430030747836*x_39 - 5.98978065822489e-5*x_4 + 0.000182565504926793*x_40 - 0.000304844891540982*x_41 - 3.61049117032438e-5*x_42 - 0.000524955375323118*x_43 - 8.85098170038071e-5*x_44 - 0.000385307790992044*x_45 + 0.000108766311479053*x_46 - 0.000141918521706362*x_47 - 6.53942889960327e-5*x_48 + 0.000359659665525886*x_49 + 5.70970698312771e-5*x_5 - 4.41116792490953e-5*x_50 - 0.000160924696696488*x_51 + 0.000131917005545867*x_52 - 0.000121728652103813*x_53 - 0.000365103808049458*x_54 - 0.000262482986391616*x_55 + 0.000264378637258129*x_56 - 0.000263671540332966*x_57 + 0.00020811353449247*x_58 + 0.000299210108434967*x_59 + 0.000115563539347424*x_6 - 0.000496371552384354*x_60 + 4.836517138489e-5*x_61 - 3.14777243286579e-5*x_62 + 8.77922995637891e-5*x_63 - 6.45798960060768e-5*x_64 + 2.93254486685916e-5*x_65 - 3.80655381357686e-5*x_66 + 0.00010517266946112*x_67 + 2.33226901256269e-5*x_68 + 6.61861866454025e-5*x_69 + 0.000249918403483103*x_7 + 0.000118247476026163*x_70 + 0.000106932314485942*x_71 - 0.000102914980648576*x_72 - 1.95907831844087e-5*x_73 + 2.72051876248325e-5*x_74 + 0.00015401972996405*x_75 - 3.45681518140951e-5*x_76 + 8.19278604799685e-5*x_77 - 0.000169131708330639*x_78 - 0.000137145386430819*x_79 + 3.60772993553566e-5*x_8 + 2.63501757055142e-5*x_80 - 4.43508155708558e-5*x_81 - 1.9166952503695e-5*x_82 + 9.01647718890691e-5*x_83 - 8.80722221562875e-5*x_84 + 2.83877079849048e-5*x_85 + 7.77707516643621e-5*x_86 + 4.27693323920011e-5*x_87 + 3.64145879273742e-5*x_88 + 3.20277012371727e-6*x_89 - 0.000166277553761711*x_9 + 0.00024427019586896*x_90 - 1.53822419902772e-5*x_91 - 0.000121847219891738*x_92 - 8.90298275020654e-5*x_93 - 7.6912567796477e-5*x_94 + 5.72022104917158e-5*x_95 + 6.79373923351404e-5*x_96 + 0.000117620199305806*x_97 + 9.03997418519546e-6*x_98 + 0.000399752160547088*x_99 + 4.67967132131923e-8*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 9.02421547610728e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 3.57641229184619e-5*std::exp(0.690639853477478*x_23) - 4.32639595153963e-5*std::exp(0.522799849510193*x_26) - 4.28327567266258e-5*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 0.000289400558237384*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 0.000348612152594249*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 4.59365125542017e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) + 0.000156849020965055*std::sin(0.468799859285355*x_19 - 8.42119979858398) - 0.000122148384223519*std::sin(0.618319809436798*x_20 - 7.4270396232605) + 1.50161138259752e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 6.90051228352004e-5*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 0.000272816228663203*std::sin(1.19159984588623*x_31 + 7.59752035140991) + 5.68847494991821e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) - 3.70117884342731e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) - 0.000568915568841912*std::sin(0.621599853038788*x_41 - 1.78095996379852) + 0.000526849597726382*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.00018033836043059*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.00163913167264898*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000751825462234999*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 0.000232404847492637*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.000520516610282322*std::sin(0.56471985578537*x_52 - 1.59223985671997) - 7.5732849811311e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) - 2.18992817580847e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000732388049263903*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 0.000101843203705708*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 0.00108679430484754*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 0.000180595235560453*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 0.000248904024157365*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000394462911686786*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 6.88429540245499e-5*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 8.7081432064825e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 0.00013284670219343*std::sin(1.32183992862701*x_73 + 7.61008024215698) + 4.50572019570083e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 0.000599947035775732*std::sin(0.598719835281372*x_8 + 4.18455982208252) + 0.000119265524637872*std::sin(0.752159833908081*x_84 + 1.4015998840332) - 0.000112759222948473*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 1.75424846699372e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 0.000264226467803889*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 0.000469177578185902*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 6.56899663734334e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0949966503368049 + 1.6571185228269e-5*std::exp(-1.43183982372284*x_98) + 1.92612987848784e-5*std::exp(-2.46079969406128*x_46) + 9.05891692172791e-7*std::exp(-3.49255990982056*x_39) + 3.3978052201008e-5*std::exp(-2.12303996086121*x_25) + 4.18962272140277e-6*std::exp(-3.79119992256165*x_118) + 5.62746302835105e-6*std::exp(-4.05719995498657*x_115) + 1.46066566673546e-6*std::exp(-2.90335988998413*x_110) + 7.42451030199333e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000156821135337655*x_1 - 0.000270169047494208*x_10 - 0.00024812454988683*x_100 - 0.000353010439367781*x_101 - 0.000137382520690781*x_102 - 6.49810254597965e-5*x_103 + 6.23677048247906e-5*x_104 - 1.85092594812893e-5*x_105 - 0.000204060312767971*x_106 - 0.000191874221905147*x_107 + 2.44566167797928e-5*x_108 - 0.00010161736416488*x_109 + 0.000201301466856069*x_11 - 1.47394970388855e-5*x_110 - 0.000162338289587378*x_111 - 8.20930661851086e-5*x_112 - 0.000138447807739373*x_113 - 0.000236557366898945*x_114 + 3.06879661163137e-5*x_115 - 8.30890675293876e-5*x_116 - 0.000221129015761644*x_117 - 0.000215343241239551*x_118 - 0.000108180498304775*x_119 + 0.000209205306828773*x_12 - 0.000108855908263423*x_120 + 6.65616604191432e-5*x_13 - 2.18328256975766e-6*x_14 + 0.000522088462493594*x_15 + 5.88532896570129e-5*x_16 + 7.60539294131948e-5*x_17 + 0.00029659139822525*x_18 - 0.000745258465792273*x_19 + 0.000101824968884198*x_2 + 0.000188079330379766*x_20 + 0.000152225512493987*x_21 - 0.000250138420680366*x_22 + 0.00041998917707794*x_23 - 4.80971136842233e-6*x_24 - 0.000132145940466929*x_25 + 3.14730994861286e-5*x_26 - 1.5872367340947e-5*x_27 - 5.42191816988059e-5*x_28 + 0.000162091296286455*x_29 + 0.000179600595765065*x_3 + 0.000123197718700824*x_30 - 5.77512450494053e-5*x_31 - 0.000163351262925933*x_32 - 0.000336555627520889*x_33 - 6.50439345911131e-5*x_34 - 0.000209861816299992*x_35 - 0.000717919237945443*x_36 + 0.00092494586124746*x_37 - 0.000143024136536356*x_38 - 7.2126761083675e-5*x_39 + 0.000212299156672448*x_4 - 0.000305671458244706*x_40 - 0.000455243549791436*x_41 - 0.000202007561463531*x_42 - 0.000600615688910791*x_43 - 6.98498726331116e-5*x_44 + 0.000109679645661881*x_45 - 0.000261076607243413*x_46 - 0.00025243131659572*x_47 - 0.000253133703941077*x_48 - 0.000227355921828111*x_49 + 7.84595291453564e-5*x_5 + 0.000118973145564809*x_50 - 0.000262593792770661*x_51 + 0.000112051772996718*x_52 - 0.000175678493573404*x_53 - 0.00045483283917345*x_54 - 0.000354304282870476*x_55 - 0.000242828660129732*x_56 + 0.000167547825337901*x_57 - 0.000102038590671492*x_58 + 0.000593118270190717*x_59 - 1.31343843146548e-5*x_6 - 0.000191916888219342*x_60 - 9.47405449739661e-5*x_61 - 3.79835013027991e-5*x_62 - 0.000148107522981144*x_63 + 0.000291946416433171*x_64 + 9.34569780864805e-5*x_65 - 6.31938930615033e-6*x_66 - 0.000205517779603016*x_67 + 2.97893112342172e-5*x_68 - 6.49779541273919e-5*x_69 + 1.26795364322172e-6*x_7 + 6.71366870816808e-6*x_70 - 7.35974700063652e-5*x_71 - 0.000240270788902913*x_72 - 0.000108835909951483*x_73 + 5.12198384745065e-6*x_74 - 0.000163461163751654*x_75 - 0.000152998457263446*x_76 + 3.32026197377306e-5*x_77 + 0.000129218028549538*x_78 - 3.51870297644574e-5*x_79 + 0.000351161903228174*x_8 + 4.63446698552615e-5*x_80 + 1.16104902977954e-8*x_81 + 5.29489861700165e-5*x_82 + 7.4300721096582e-5*x_83 - 7.24648240479329e-5*x_84 + 8.1094279100056e-5*x_85 - 8.31466766900879e-5*x_86 - 6.99363818950078e-5*x_87 - 3.01544479163291e-6*x_88 - 0.000102497642903849*x_89 - 8.56574025859562e-5*x_9 + 9.18083755669125e-5*x_90 - 6.71969349031884e-5*x_91 - 0.000175607475959553*x_92 - 8.01871643448386e-5*x_93 - 0.000206635324395664*x_94 - 0.000142696681248509*x_95 - 7.59957152553241e-5*x_96 - 0.000169563635050411*x_97 + 7.61641177627816e-5*x_98 - 1.52445072059035e-5*x_99 + 3.07763019143727e-8*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 3.97760933196562e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 4.25106221290236e-5*std::exp(0.690639853477478*x_23) + 1.80145136375655e-5*std::exp(0.522799849510193*x_26) - 2.81693683664924e-5*std::sin(0.440479874610901*x_100 - 5.88263988494873) - 5.02713478693098e-5*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 0.000414373911036681*std::sin(0.614879846572876*x_13 - 1.78223991394043) - 7.97956443684869e-6*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 6.53097603377759e-5*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 0.000284300926700524*std::sin(0.618319809436798*x_20 - 7.4270396232605) + 1.58036388661642e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 4.53818729605953e-5*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 0.000120249386765587*std::sin(1.19159984588623*x_31 + 7.59752035140991) + 5.98680889407085e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) - 3.89528838809355e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 0.000883119056773422*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.00122624486453558*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.000118601231716209*std::sin(0.219599992036819*x_44 + 4.58184003829956) + 0.000284731166453901*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000112279115902364*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 0.000276245405912439*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.00141928792737538*std::sin(0.56471985578537*x_52 - 1.59223985671997) - 7.97046840876406e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) - 2.30477968097495e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000109376293833348*std::sin(0.622399806976318*x_58 - 8.2105598449707) + 1.7691034021486e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 0.000479027033467222*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 2.69704531216966e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 0.000109709588813941*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 5.89098789615362e-5*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 0.00018771345928597*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 0.000103508363993768*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 0.000157906737176451*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 1.87611949580393e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 0.000264439045643893*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 4.96605129106541e-5*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 0.00026244761060138*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 1.15369812847891e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 0.000116463272277982*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 0.000206799706665059*std::sin(1.18935990333557*x_92 - 8.00663948059082) + 1.1410908020341e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0350572460298055 - 2.87855635901627e-6*std::exp(-1.43183982372284*x_98) + 5.25196089633344e-5*std::exp(-2.46079969406128*x_46) + 9.53401480627586e-7*std::exp(-3.49255990982056*x_39) + 1.49765281951184e-5*std::exp(-2.12303996086121*x_25) - 6.50348815992736e-6*std::exp(-3.79119992256165*x_118) - 8.73542598199778e-6*std::exp(-4.05719995498657*x_115) + 1.53727075918679e-6*std::exp(-2.90335988998413*x_110) - 1.28970082996394e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.03057759278275e-5*x_1 + 0.000248822046180044*x_10 - 2.15908932593534e-5*x_100 - 0.000135371914162097*x_101 - 8.88964670841979e-6*x_102 - 1.57480834421211e-5*x_103 - 0.000169526996961668*x_104 - 0.000462868466949581*x_105 - 0.000140027967306067*x_106 - 8.411250915659e-5*x_107 - 0.000237573124512695*x_108 - 4.39333824884844e-5*x_109 - 3.03149530952699e-5*x_11 - 0.000178612263695876*x_110 - 0.000155375047447611*x_111 - 0.000267919727592823*x_112 - 0.000147812275828083*x_113 - 0.000241185414336475*x_114 - 0.00018529567769029*x_115 - 5.38667643725511e-5*x_116 - 0.00019963258504002*x_117 - 0.000142133106721611*x_118 - 0.000203961232148997*x_119 + 0.000121469125450967*x_12 - 0.000142093868889849*x_120 - 0.00040422170702129*x_13 + 0.000384787833265759*x_14 + 0.000277522440929783*x_15 + 0.000174337996092579*x_16 + 7.77454637061334e-5*x_17 + 0.000121922167497935*x_18 - 0.000337455201851493*x_19 - 8.26310798393807e-5*x_2 + 0.000205348234967132*x_20 + 0.000157209872066454*x_21 - 0.000401480971167488*x_22 - 1.18054618211942e-5*x_23 + 0.000119313095673138*x_24 - 4.80153510856538e-5*x_25 - 3.43064038872886e-5*x_26 - 0.000374065969212087*x_27 - 8.51830083029004e-5*x_28 + 0.000282840804631386*x_29 - 1.1745923447665e-5*x_3 - 0.00020426401125075*x_30 + 3.23553088944357e-5*x_31 + 7.32665240037507e-5*x_32 - 0.000400450335517323*x_33 - 0.000222054909385774*x_34 - 8.86066021908771e-5*x_35 + 0.00031254951089847*x_36 + 0.000214333467917928*x_37 - 0.000150518778814925*x_38 - 1.51319650520188e-5*x_39 + 0.000181883067477506*x_4 + 2.80996866467459e-5*x_40 + 0.000155743150335946*x_41 - 0.000106825576893636*x_42 - 9.19410096746506e-5*x_43 - 3.13610185818686e-5*x_44 - 0.000466678757237973*x_45 - 0.000190394403981848*x_46 - 0.000166051773318351*x_47 - 0.000368097964529567*x_48 + 0.000343368485484415*x_49 - 9.59314253135028e-6*x_5 - 0.0003269070727909*x_50 - 0.000565393587102022*x_51 - 0.000171103033993102*x_52 - 8.74724793923577e-5*x_53 - 8.06358154793212e-5*x_54 + 0.000281084799725997*x_55 + 4.25839377545125e-5*x_56 + 0.000243167884939939*x_57 - 0.000718393112056567*x_58 + 1.05437764964917e-5*x_59 + 6.34996321665348e-5*x_6 - 0.000114239937802479*x_60 - 0.000125758835432241*x_61 + 9.67900690783588e-5*x_62 + 5.6437580055044e-5*x_63 + 0.000168630089471536*x_64 + 8.44473285835975e-5*x_65 + 5.5876734556982e-5*x_66 - 3.25403226367547e-5*x_67 + 0.000158815479206335*x_68 + 2.56829127317782e-5*x_69 - 4.00379706454632e-5*x_7 + 8.55515016671672e-5*x_70 - 7.28794384547167e-5*x_71 - 0.000111968334356464*x_72 - 6.61120670070702e-5*x_73 + 8.66739237207619e-6*x_74 - 0.00014521287964919*x_75 - 4.92275737133849e-5*x_76 + 9.95208258918804e-5*x_77 - 1.74764671784683e-5*x_78 + 1.65096723386361e-5*x_79 + 0.00021298551353598*x_8 + 6.50735723793661e-5*x_80 + 3.63700877626946e-5*x_81 - 0.000153291282348412*x_82 - 0.000615427874329457*x_83 - 7.32513211329042e-5*x_84 + 7.6167174284637e-5*x_85 - 7.57641833372871e-5*x_86 - 9.88549773293433e-5*x_87 + 5.19669415041148e-5*x_88 - 5.50299646847068e-5*x_89 - 0.000180560561985862*x_9 + 5.41362988029449e-5*x_90 - 3.15898836888291e-5*x_91 + 2.69066509901839e-5*x_92 - 0.000315826753795926*x_93 - 9.45552984709342e-5*x_94 - 9.07822227732413e-5*x_95 - 7.375555680487e-5*x_96 - 2.82694987235992e-5*x_97 - 0.000111546819290859*x_98 - 7.8958993138016e-5*x_99 + 2.25035938035707e-8*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) - 4.68546421836272e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) - 4.15646860169833e-5*std::exp(0.690639853477478*x_23) + 3.52468864468279e-5*std::exp(0.522799849510193*x_26) - 2.05974072254165e-5*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 0.000740014386797013*std::sin(0.352959841489792*x_112 + 1.41575980186462) - 0.000405153362695908*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 0.000117462386307863*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 0.00012778394980894*std::sin(0.468799859285355*x_19 - 8.42119979858398) - 8.72166355970059e-5*std::sin(0.618319809436798*x_20 - 7.4270396232605) + 1.13739145482369e-6*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 3.31831692446958e-5*std::sin(1.07687973976135*x_3 + 1.17927992343903) - 0.000141648953415893*std::sin(1.19159984588623*x_31 + 7.59752035140991) + 4.30871986853456e-7*std::sin(0.778799831867218*x_32 - 7.9888801574707) - 2.80344784148242e-6*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 0.000661775243983869*std::sin(0.621599853038788*x_41 - 1.78095996379852) + 0.000376182212081064*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 8.6721073590012e-5*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.00419135687575259*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000515611615117616*std::sin(0.651199817657471*x_47 - 7.82536029815674) + 0.000270098459757553*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.00183096991305072*std::sin(0.56471985578537*x_52 - 1.59223985671997) - 5.73636409680297e-6*std::sin(0.609919846057892*x_52 - 7.80079984664917) - 1.6587551364545e-6*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000502281186182765*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 0.000260419110449342*std::sin(0.503999829292297*x_59 - 9.19999980926514) + 0.000564274627702054*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 0.000123854545725356*std::sin(0.823199868202209*x_62 + 4.60775995254517) + 0.000129233494267015*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000270527761050008*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 0.000242162065637285*std::sin(1.06479978561401*x_64 + 4.80335998535156) + 0.000101205120839557*std::sin(0.904719829559326*x_72 - 1.94167983531952) + 0.000154393034540523*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 3.67078302305017e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) - 0.000311498586938945*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 9.71649024041932e-5*std::sin(0.752159833908081*x_84 + 1.4015998840332) - 8.05125677315751e-5*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 8.43582641197857e-6*std::sin(1.23527991771698*x_91 - 8.61303997039795) + 0.00013718906244175*std::sin(1.50623989105225*x_91 + 6.02320003509521) + 0.000243601758010813*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 0.000167973138962222*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0817612114229686 + 4.23735031814915e-5*std::exp(-1.43183982372284*x_98) + 6.77535699432615e-5*std::exp(-2.46079969406128*x_46) + 6.86165196677436e-8*std::exp(-3.49255990982056*x_39) - 1.76417493818707e-5*std::exp(-2.12303996086121*x_25) - 4.87346233870973e-6*std::exp(-3.79119992256165*x_118) - 6.54599016542657e-6*std::exp(-4.05719995498657*x_115) + 1.10637723378563e-7*std::exp(-2.90335988998413*x_110) + 1.8984913062576e-5*std::exp(-2.07559990882874*x_107));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.85163441184476e-5*x_1 - 2.06676615683086e-5*x_10 - 8.8036314977462e-6*x_100 - 1.50723657973853e-6*x_101 + 0.000144403362567077*x_102 - 1.26720471093204e-7*x_103 - 0.000103626202762266*x_104 - 9.18307900695676e-5*x_105 - 7.22754209975117e-5*x_106 + 7.69377337604183e-5*x_107 - 2.70861998195997e-5*x_108 + 6.70367121061209e-5*x_109 - 9.50337568494953e-5*x_11 - 8.70124782252334e-5*x_110 + 1.70059628536864e-6*x_111 - 0.000118526468617888*x_112 - 7.68409712840498e-5*x_113 - 0.000122267462431563*x_114 - 4.75392614824885e-5*x_115 + 3.18832973907e-5*x_116 + 7.96615507430337e-7*x_117 + 2.08663136713779e-5*x_118 - 0.000127409938874572*x_119 - 3.94599581041042e-5*x_12 - 3.8774241898203e-5*x_120 - 0.000204942051189163*x_13 - 0.000130049774253432*x_14 + 0.00036340964279248*x_15 - 4.35580228192436e-5*x_16 + 1.61383259819316e-5*x_17 + 0.000520681039476147*x_18 - 0.000311452694276313*x_19 - 9.51746451457961e-5*x_2 - 0.000219688023345688*x_20 - 3.17471931380313e-5*x_21 - 0.000598168393139722*x_22 + 7.02654806614285e-5*x_23 + 9.56540967202167e-5*x_24 - 7.98193231365035e-5*x_25 - 0.000211524493565621*x_26 - 0.00030262517408293*x_27 + 0.000115811484118413*x_28 + 0.000518589528890743*x_29 - 0.000204554342569989*x_3 + 6.06807279070481e-5*x_30 + 3.80974712967312e-5*x_31 - 0.000102282533584193*x_32 - 8.55504466892003e-5*x_33 + 0.00010576312383376*x_34 + 9.36477731654535e-6*x_35 + 6.74602815659688e-5*x_36 + 0.00065330154976824*x_37 - 5.78853287911717e-5*x_38 + 9.29987419875082e-5*x_39 + 0.000168736318757979*x_4 - 0.000102802724564078*x_40 + 0.000150381021385341*x_41 - 0.000108869758300379*x_42 + 1.90855887257205e-5*x_43 - 2.21196567690797e-6*x_44 - 0.000119801217884253*x_45 - 0.000145797682014169*x_46 - 7.58919889777888e-5*x_47 - 0.000199834760460476*x_48 - 0.000109991874860687*x_49 - 2.85102963089216e-5*x_5 - 0.000100113091423799*x_50 - 4.58931361548165e-5*x_51 - 6.93055907581674e-5*x_52 - 4.41657847539165e-5*x_53 + 0.000118908632814467*x_54 + 6.57255764304766e-5*x_55 - 0.000176454291690464*x_56 + 0.000675962882994872*x_57 - 0.000117509412447601*x_58 + 3.03032325074974e-6*x_59 + 4.24910656668288e-6*x_6 + 8.8254329980303e-5*x_60 - 0.000106391548189268*x_61 - 4.72341611707238e-5*x_62 + 7.18233141054591e-5*x_63 + 0.000218390316115216*x_64 - 2.05424975766037e-5*x_65 + 6.77069434428507e-5*x_66 - 1.51079500296951e-5*x_67 + 8.83653906306777e-5*x_68 - 5.25557212466196e-5*x_69 - 9.10920683254261e-5*x_7 + 1.40010306706849e-5*x_70 - 1.95594520572287e-5*x_71 - 0.000128702371182319*x_72 - 0.00010411250266093*x_73 + 1.86291402365086e-5*x_74 - 0.000178383384742839*x_75 - 9.68678687785189e-5*x_76 + 6.16961286599985e-5*x_77 + 4.85556597443213e-5*x_78 - 1.33497559741327e-5*x_79 + 8.78925563419894e-5*x_8 + 1.62336711637243e-5*x_80 - 2.87787353121185e-7*x_81 - 3.62227080578113e-6*x_82 - 0.00028886463856897*x_83 - 2.50119704284588e-6*x_84 - 6.66008026245925e-6*x_85 - 2.83546892312885e-6*x_86 - 8.84592922579659e-5*x_87 + 3.62609992673836e-5*x_88 - 6.79964326351518e-5*x_89 - 5.74939009071336e-5*x_9 - 0.000106740224262401*x_90 - 2.89115600316964e-5*x_91 + 6.44184153064618e-5*x_92 - 0.000125154858205078*x_93 - 1.38688085708148e-5*x_94 - 7.80993603286344e-6*x_95 + 1.79408141272735e-5*x_96 - 3.10195001472907e-5*x_97 - 3.12454316681483e-5*x_98 - 3.14405519565251e-6*x_99 + 2.63481987304453e-9*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 3.61066832843486e-8*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) - 4.87622517068289e-5*std::exp(0.690639853477478*x_23) + 5.25564524255914e-5*std::exp(0.522799849510193*x_26) - 2.41163515323082e-6*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 0.000736965857079208*std::sin(0.352959841489792*x_112 + 1.41575980186462) - 0.000475311908853916*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 0.000116978493586623*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 0.000190537995150834*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 5.44115522810273e-5*std::sin(0.618319809436798*x_20 - 7.4270396232605) + 1.61607482880888e-6*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 3.88523160076998e-6*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 1.09156183041651e-5*std::sin(1.19159984588623*x_31 + 7.59752035140991) + 6.1220907669003e-7*std::sin(0.778799831867218*x_32 - 7.9888801574707) - 3.98330888744071e-6*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 0.000865185601979729*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.000234687545096546*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 1.0153685233621e-5*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.00417409035199085*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 9.15535564853614e-5*std::sin(0.651199817657471*x_47 - 7.82536029815674) + 0.000316870168944452*std::sin(0.822799861431122*x_5 - 4.80431985855103) + 6.15092890751984e-5*std::sin(0.56471985578537*x_52 - 1.59223985671997) - 8.15057435714893e-6*std::sin(0.609919846057892*x_52 - 7.80079984664917) - 2.35685999909073e-6*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 8.91865652410262e-5*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 0.00025934629968856*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 4.34836001691872e-5*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 2.19919874098425e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 9.95886987876594e-6*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 4.80357267485149e-5*std::sin(0.991199791431427*x_64 - 4.80087995529175) + 8.1351508794117e-6*std::sin(1.06479978561401*x_64 + 4.80335998535156) + 0.000118730346582724*std::sin(0.904719829559326*x_72 - 1.94167983531952) + 0.000181128566903404*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 5.47348582424837e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 2.40044108714948e-5*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 0.000144882089893157*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 5.02291077661879e-5*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 9.87703709454098e-7*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 1.057193438432e-5*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 1.87722093566227e-5*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 0.000167281164434354*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.032154197632417 + 4.21989432188733e-5*std::exp(-1.43183982372284*x_98) - 2.27610180255392e-6*std::exp(-2.46079969406128*x_46) + 9.74945167780421e-8*std::exp(-3.49255990982056*x_39) + 1.35949188346517e-6*std::exp(-2.12303996086121*x_25) - 6.37142214909582e-6*std::exp(-3.79119992256165*x_118) - 8.55803612074377e-6*std::exp(-4.05719995498657*x_115) + 1.57200794071846e-7*std::exp(-2.90335988998413*x_110) + 1.89067036754427e-5*std::exp(-2.07559990882874*x_107));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.06203646813261e-5*x_1 - 7.7174339728643e-5*x_10 - 4.14788252185884e-5*x_100 - 9.26858869515838e-5*x_101 - 5.17241495024797e-5*x_102 - 3.08274723729139e-5*x_103 - 0.000136041792441998*x_104 + 1.46531828585361e-5*x_105 - 0.00011085211931552*x_106 - 8.88374837029801e-5*x_107 + 9.32450243799518e-5*x_108 - 5.29850182993594e-5*x_109 - 2.98787091290781e-5*x_11 - 1.15801457475124e-5*x_110 - 8.89832552877997e-5*x_111 - 5.82349004077711e-5*x_112 + 5.4752412595951e-5*x_113 + 4.63032913841277e-5*x_114 + 2.62808510143372e-5*x_115 + 3.63646324887046e-5*x_116 + 1.87133243180008e-5*x_117 + 2.87217937259457e-5*x_118 + 0.000114990446383415*x_119 - 7.85211692032846e-5*x_12 + 4.43016283479004e-5*x_120 + 7.31444301739444e-5*x_13 - 0.000171014354550215*x_14 + 0.000146103710462496*x_15 - 3.7507672899835e-5*x_16 - 0.00011194633263405*x_17 + 0.000210827304756754*x_18 + 1.35401981918261e-5*x_19 + 0.000112165439658543*x_2 + 2.3745873988826e-5*x_20 - 2.65964567729926e-5*x_21 + 1.51609664586721e-5*x_22 + 0.000131576761755684*x_23 - 8.35826239612687e-5*x_24 + 4.40075155543802e-5*x_25 - 0.000207732671569494*x_26 - 0.000511294080336598*x_27 - 3.62043500985992e-5*x_28 - 0.00025104368367009*x_29 - 8.66407109766215e-5*x_3 + 0.000133070970629734*x_30 - 2.87812955262056e-5*x_31 - 3.35813516521207e-5*x_32 - 0.000226289310031288*x_33 - 0.000114899828897991*x_34 + 4.58227915077718e-5*x_35 + 0.000227868249196575*x_36 + 0.000284930120250999*x_37 - 7.80966252547243e-5*x_38 - 8.19568146308811e-5*x_39 - 4.2969786318234e-5*x_4 + 4.85151091327734e-5*x_40 - 0.000149418390543158*x_41 - 9.20001693743701e-5*x_42 - 0.00022370094077422*x_43 - 8.60412177554393e-5*x_44 - 0.000219896891241246*x_45 - 2.71878583923234e-5*x_46 - 4.07382115145982e-5*x_47 - 7.87189578229447e-5*x_48 + 5.0888358926845e-5*x_49 + 4.51453004378431e-5*x_5 + 1.10275957875892e-5*x_50 - 1.39675845642947e-5*x_51 + 4.97682291528987e-5*x_52 - 8.78026747430515e-5*x_53 - 0.000370279440753167*x_54 - 9.86418545802832e-5*x_55 + 0.000219129281760809*x_56 + 2.74190221223719e-5*x_57 + 0.000131564824380999*x_58 + 0.000278045581057163*x_59 - 5.33218478655474e-6*x_6 - 0.000378444763236983*x_60 + 2.41284964693305e-5*x_61 - 4.58674870230134e-5*x_62 + 6.85646326944505e-5*x_63 + 9.01333637520845e-6*x_64 - 4.90481048222105e-5*x_65 - 1.59004871546211e-5*x_66 + 4.17497501229951e-5*x_67 - 2.05904479816932e-5*x_68 + 1.47198744261328e-5*x_69 + 0.000124368644391767*x_7 + 3.12120129891375e-5*x_70 + 9.81948803836941e-5*x_71 - 0.000118986845212376*x_72 - 1.52252769812569e-5*x_73 + 4.94446420692401e-5*x_74 + 5.58031642000128e-5*x_75 - 7.97794397454259e-5*x_76 + 1.59859877936032e-5*x_77 - 1.77637967693853e-5*x_78 - 8.07751112510849e-5*x_79 + 1.92972018067529e-5*x_8 - 7.74505258322001e-6*x_80 - 3.86117234763891e-5*x_81 - 2.38426242673647e-5*x_82 + 0.000336665823920891*x_83 - 8.22966264065786e-5*x_84 - 2.31244455099066e-6*x_85 + 0.000118208354050644*x_86 + 3.84082958087169e-5*x_87 + 2.85776870556477e-5*x_88 - 1.54491283989779e-5*x_89 - 0.000188554214571381*x_9 + 9.43982346256246e-5*x_90 - 9.22388493048035e-7*x_91 - 6.89749135767465e-5*x_92 - 5.26033922504434e-5*x_93 - 9.58374648615635e-7*x_94 + 4.36109573944152e-5*x_95 + 2.83127173581576e-5*x_96 + 6.70274199825143e-5*x_97 + 6.17271477448985e-6*x_98 + 0.000335344035472199*x_99 + 6.56453469999662e-8*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 5.71809208110484e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) - 0.00299116829410195*std::pow(0.00711677493472022*x_1 - 0.0126713450234726*x_10 - 0.0125913824170071*x_100 - 0.0202986682759535*x_101 - 0.00554479395885323*x_102 - 0.00238162459673607*x_103 - 0.000302188733496561*x_104 + 0.0118220978398709*x_105 - 0.00364855941626846*x_106 - 0.00398678374498984*x_107 + 0.00308568750273011*x_108 + 0.0054732105046367*x_109 + 0.0134339489819945*x_11 + 0.012953351002154*x_110 - 0.00134923374017641*x_111 - 0.000299371030588801*x_112 - 0.00777923519524542*x_113 - 0.00103351363877755*x_114 + 0.0037857919735878*x_115 - 0.00623305860860456*x_116 - 0.00723571363793257*x_117 - 0.0116488674625047*x_118 - 0.0109154131202538*x_119 + 0.0147504681475463*x_12 - 0.008450766548157*x_120 + 0.0550207672619814*x_13 - 0.0213528536694632*x_14 + 0.019785620487624*x_15 - 0.0157665238811201*x_16 - 0.000424364779508575*x_17 - 0.02169948031619*x_18 + 0.0013858421319694*x_19 + 0.00189165113109748*x_2 + 0.00380385479064329*x_21 - 0.0190679292765782*x_22 + 0.0265254440269661*x_23 + 0.00176306133558671*x_24 - 0.015922410098721*x_25 - 0.0117843252386685*x_26 + 0.0381735833811653*x_27 + 0.00307437494985312*x_28 + 0.00563502644206249*x_29 + 0.00282991955304506*x_3 - 0.0067985932796831*x_30 - 0.000432622982509383*x_31 - 0.00403386734557958*x_32 - 0.00221978227196287*x_33 + 0.00208222102107142*x_34 - 0.000434727442908662*x_35 - 0.0470537163836493*x_36 + 0.0732880652873792*x_37 + 0.000350936592018838*x_38 + 0.00775359663524711*x_39 + 0.0131244926515393*x_4 - 0.0385444937137553*x_40 - 0.0123127777543059*x_41 - 0.00934673637082101*x_43 + 0.001865081500212*x_44 + 0.0392727324924661*x_45 - 0.0152287515271043*x_46 + 0.00363878025420039*x_47 + 0.00338347317180412*x_48 - 0.0307950860543184*x_49 + 0.0142435344628154*x_5 - 0.00387764355228427*x_50 + 0.0116916355444468*x_51 + 0.00335948124497963*x_52 + 0.000153500751239728*x_53 - 0.0242287082509596*x_54 + 0.0640139168388306*x_55 - 0.0284676674289544*x_56 - 0.0196591089768029*x_57 - 0.0156337730764502*x_58 + 0.035342497531069*x_59 - 0.0045304309024995*x_6 + 0.0084722595189722*x_60 - 0.00709357313271915*x_61 - 0.00430693255754939*x_62 - 0.0124678403776328*x_63 - 0.00563794129655015*x_64 - 0.00453538923106651*x_65 - 0.00730375273799376*x_66 - 0.0132995021313336*x_67 - 0.00397495188934438*x_68 - 0.00943364414249305*x_69 - 0.0109719940601405*x_7 - 0.00996156927468147*x_70 - 0.0125615003326841*x_71 - 0.00764085059434372*x_72 - 0.00096239796554657*x_73 + 0.00314658013517026*x_74 - 0.00929456423832103*x_75 - 0.00753291511440202*x_76 - 0.00455641008354859*x_77 + 0.0178600615380813*x_78 - 0.00259304686309532*x_79 + 0.0163745758564122*x_8 - 0.00318463621688194*x_80 - 0.00327341848041461*x_81 + 0.00558063208065693*x_82 + 0.0249358004554886*x_83 + 0.00273416237795477*x_84 - 0.00210292811307408*x_85 + 0.00280088644642001*x_86 + 0.00240748973347789*x_87 - 0.00214834828485005*x_89 + 0.00266771366078911*x_9 - 0.0117854143554525*x_90 + 0.000969002987413311*x_91 + 0.001160731188707*x_92 + 0.00937578822966698*x_93 - 0.00428495121884805*x_94 - 0.00723464166748786*x_95 - 0.0084947704374411*x_96 - 0.0109091125586503*x_97 + 0.00830291056778121*x_98 - 0.00408459907691061*x_99 + 0.0352577353978489*std::sin(0.618319809436798*x_20 - 7.4270396232605) - 0.152073429617445*std::sin(0.716559827327728*x_42 - 7.96776008605957) + 0.0325475844126544*std::sin(1.23471987247467*x_88 + 1.39911985397339) - 0.229164495591133, 2) + 1.06255795905931e-5*std::exp(0.690639853477478*x_23) - 3.22123054522067e-5*std::exp(0.522799849510193*x_26) - 6.00848005173969e-5*std::sin(0.440479874610901*x_100 - 5.88263988494873) - 0.000121042891453244*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 0.000103573242438612*std::sin(0.614879846572876*x_13 - 1.78223991394043) - 1.92131222438e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) + 0.000116782389540834*std::sin(0.468799859285355*x_19 - 8.42119979858398) - 2.45544446183647e-6*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 9.6798790390583e-5*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 0.000172866917999266*std::sin(1.19159984588623*x_31 + 7.59752035140991) - 9.30183033636205e-7*std::sin(0.778799831867218*x_32 - 7.9888801574707) + 6.0521911319287e-6*std::sin(0.441199868917465*x_40 + 0.308159857988358) - 0.000144512366869975*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.000252974481219202*std::sin(0.219599992036819*x_44 + 4.58184003829956) + 0.000685573097503429*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000686871332184858*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 6.90478614532975e-5*std::sin(0.822799861431122*x_5 - 4.80431985855103) + 3.40033666234201e-5*std::sin(0.56471985578537*x_52 - 1.59223985671997) + 1.23838836601387e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) + 3.58098445005583e-6*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000669113218882876*std::sin(0.622399806976318*x_58 - 8.2105598449707) + 4.25963098567658e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 0.000688634920652319*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 0.000164992669531155*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 0.000157715220038528*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000360383199635677*std::sin(0.991199791431427*x_64 - 4.80087995529175) + 4.4972478474152e-6*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 2.58720363247039e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 3.94689731584451e-5*std::sin(1.32183992862701*x_73 + 7.61008024215698) + 3.35474692681424e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 0.000380149654386505*std::sin(0.598719835281372*x_8 + 4.18455982208252) + 8.87994892882063e-5*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 2.46081917794812e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 0.000167424113172822*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 0.000297289066463428*std::sin(1.18935990333557*x_92 - 8.00663948059082) + 2.74750799298204e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0772206182832326 - 6.93096166453027e-6*std::exp(-1.43183982372284*x_98) - 1.2582672508188e-6*std::exp(-2.46079969406128*x_46) - 1.48131984370123e-7*std::exp(-3.49255990982056*x_39) + 2.15298085175776e-5*std::exp(-2.12303996086121*x_25) + 1.06422170339722e-6*std::exp(-3.79119992256165*x_118) + 1.429452885875e-6*std::exp(-4.05719995498657*x_115) - 2.38848976742313e-7*std::exp(-2.90335988998413*x_110) - 3.10532985855721e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.16837939276014e-5*x_1 + 7.3071107851047e-5*x_10 - 7.97616356857839e-6*x_100 - 0.00015388408654572*x_101 + 6.93431197297355e-5*x_102 - 6.91228868012174e-5*x_103 - 0.000134548063158903*x_104 - 0.000133847236922832*x_105 - 0.00011515755552906*x_106 - 1.46441489103355e-5*x_107 - 0.000117225859250013*x_108 + 0.000115033081215407*x_109 - 6.39138999144763e-5*x_11 + 7.40685153021557e-5*x_110 - 7.60820615601281e-5*x_111 - 0.000208406899725825*x_112 + 6.15724903068674e-5*x_113 + 5.90197041458866e-5*x_114 - 7.48448306511807e-5*x_115 + 8.14980421258704e-5*x_116 - 6.54432798598041e-6*x_117 + 5.42807009028537e-5*x_118 - 4.33125240875968e-5*x_119 + 3.76115520803097e-5*x_12 - 5.56152568053768e-6*x_120 + 0.00029942879251601*x_13 - 8.20485691188627e-5*x_14 + 0.000260878995383216*x_15 - 8.06266506383669e-5*x_16 - 9.2487116927211e-5*x_17 + 0.000586233592292544*x_18 + 0.000175780254956392*x_19 - 8.08153777618071e-5*x_2 - 7.29164185716141e-5*x_20 + 1.06503992426076e-5*x_21 - 0.000291958385621912*x_22 + 0.000104725224376201*x_23 + 0.000167408418116634*x_24 + 6.13726891043205e-6*x_25 - 0.000254996011267013*x_26 - 0.000275084912598153*x_27 + 1.13875984111602e-5*x_28 + 1.15760086935672e-5*x_29 - 0.000249434937248193*x_3 - 0.000385565448073729*x_30 + 5.15383690907634e-5*x_31 + 3.43511442368261e-6*x_32 - 0.000298318034358548*x_33 - 0.000173122187964437*x_34 + 9.68295842252501e-5*x_35 + 0.000392015066568172*x_36 + 0.000578835700284186*x_37 - 0.000157479371458099*x_38 - 6.95803704839793e-6*x_39 + 7.30766793749961e-5*x_4 - 0.000105341054962292*x_40 + 0.000187024023311958*x_41 - 0.000110524834438578*x_42 + 0.000219421991005418*x_43 - 7.35166060672927e-5*x_44 - 0.000237260898826934*x_45 - 0.000120644243451965*x_46 - 2.24586432475232e-5*x_47 - 0.000153132629085123*x_48 - 0.000113994146243092*x_49 + 7.65132474011361e-5*x_5 - 0.000188316915547755*x_50 + 2.92943879280609e-5*x_51 - 4.46994017647784e-5*x_52 - 3.97512967069507e-5*x_53 - 0.00035988061166144*x_54 + 0.000732481785329893*x_55 + 0.000126099658131929*x_56 + 0.000485333542972206*x_57 - 0.000148040298785244*x_58 + 0.000234616628386012*x_59 + 8.49093573900852e-6*x_6 + 5.89592666557195e-5*x_60 - 3.11629840706382e-5*x_61 + 3.90563473985573e-6*x_62 + 0.000138531254928254*x_63 - 3.34931212319894e-5*x_64 - 0.000159057601335964*x_65 - 3.82645450065388e-5*x_66 + 3.71203478809011e-5*x_67 + 5.76400951555056e-5*x_68 - 2.26190812252493e-5*x_69 + 4.08264878525736e-5*x_7 - 4.68981300895171e-5*x_70 + 4.52146576584813e-5*x_71 - 7.93788855822741e-5*x_72 + 1.22941421366394e-5*x_73 + 9.58937093557818e-5*x_74 - 7.09620196807163e-5*x_75 - 9.3880546492474e-5*x_76 + 2.93068090338435e-5*x_77 + 6.23221468728324e-5*x_78 - 4.32662604705338e-5*x_79 + 5.45274013885695e-5*x_8 - 4.66392250247296e-5*x_80 - 4.44335413401522e-5*x_81 - 9.23930679392135e-5*x_82 + 0.000277485331100119*x_83 - 5.803878583838e-5*x_84 - 4.31176352708749e-5*x_85 + 0.000152352899501329*x_86 + 3.63867546247405e-5*x_87 + 7.31894524250191e-5*x_88 - 7.55267689709144e-6*x_89 - 0.000181625106751384*x_9 - 5.3038779860818e-5*x_90 - 2.6942855502075e-6*x_91 + 3.15705173092002e-5*x_92 - 0.000123874991077101*x_93 + 4.90740748570781e-5*x_94 - 6.95997003608631e-7*x_95 - 8.45232788852868e-5*x_96 + 5.09313911948509e-5*x_97 - 0.000100921769144234*x_98 + 0.000273451432082306*x_99 + 6.90900106504655e-8*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) - 1.45735484220519e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) - 5.42582681480705e-5*std::exp(0.690639853477478*x_23) + 5.44970664205885e-5*std::exp(0.522799849510193*x_26) - 6.32376809232219e-5*std::sin(0.440479874610901*x_100 - 5.88263988494873) - 9.90135870670902e-6*std::sin(0.352959841489792*x_112 + 1.41575980186462) - 0.0005288845387949*std::sin(0.614879846572876*x_13 - 1.78223991394043) - 1.57164136553362e-6*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 0.000197573490944465*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 6.31167418281459e-5*std::sin(0.618319809436798*x_20 - 7.4270396232605) - 1.58877820332387e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 0.000101878194947176*std::sin(1.07687973976135*x_3 + 1.17927992343903) - 4.40581292553513e-5*std::sin(1.19159984588623*x_31 + 7.59752035140991) - 6.01868440484931e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) + 3.91602803574171e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 3.58791499332346e-5*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.000272234710703246*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.00026624902450039*std::sin(0.219599992036819*x_44 + 4.58184003829956) + 5.60801636226042e-5*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000932586101165611*std::sin(0.651199817657471*x_47 - 7.82536029815674) + 0.000352584755480123*std::sin(0.822799861431122*x_5 - 4.80431985855103) + 0.000428558915601168*std::sin(0.56471985578537*x_52 - 1.59223985671997) + 8.01290549940254e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) + 2.31705099794243e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000908475370563893*std::sin(0.622399806976318*x_58 - 8.2105598449707) + 3.48439580722408e-6*std::sin(0.503999829292297*x_59 - 9.19999980926514) + 0.000175510541259128*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 0.000224015566218965*std::sin(0.823199868202209*x_62 + 4.60775995254517) + 4.01964565020079e-5*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000489303232389633*std::sin(0.991199791431427*x_64 - 4.80087995529175) + 5.66807305295021e-5*std::sin(1.06479978561401*x_64 + 4.80335998535156) + 0.000132112500073425*std::sin(0.904719829559326*x_72 - 1.94167983531952) + 0.000201543653303941*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 5.67559085040083e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) - 9.68877261374492e-5*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 0.000150231770061717*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 5.82651568321834e-5*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 2.58994781783076e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) + 4.26709361398002e-5*std::sin(1.50623989105225*x_91 + 6.02320003509521) + 7.57692696094926e-5*std::sin(1.18935990333557*x_92 - 8.00663948059082) + 2.24747292975677e-6*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0340304560175587 - 5.66955537818358e-7*std::exp(-1.43183982372284*x_98) - 1.58584782065655e-5*std::exp(-2.46079969406128*x_46) - 9.58477667242135e-7*std::exp(-3.49255990982056*x_39) - 5.48724473999372e-6*std::exp(-2.12303996086121*x_25) - 2.64222162334015e-7*std::exp(-3.79119992256165*x_118) - 3.54900798635108e-7*std::exp(-4.05719995498657*x_115) - 1.54545563555764e-6*std::exp(-2.90335988998413*x_110) - 2.5401726993696e-7*std::exp(-2.07559990882874*x_107));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.90678399937412e-5*x_1 + 0.000226300225283485*x_10 + 1.92319333345179e-5*x_100 + 5.25283736689504e-5*x_101 - 0.000107147550050865*x_102 - 8.58653675771171e-5*x_103 - 4.04221121709915e-5*x_104 - 0.000202909327626657*x_105 - 0.000111306586990423*x_106 - 8.95216542211321e-5*x_107 - 7.31657935217678e-5*x_108 - 0.000141833219011233*x_109 - 7.47464075184526e-5*x_11 - 0.000128523244563686*x_110 - 8.00117385364391e-5*x_111 - 5.54831611734188e-5*x_112 - 1.26453065780423e-5*x_113 - 1.97419163324318e-5*x_114 - 8.88808400862418e-5*x_115 - 6.13683317082953e-5*x_116 - 6.45990902916263e-5*x_117 - 4.01289117845672e-5*x_118 + 1.34339461133957e-5*x_119 + 4.23123081658265e-5*x_12 - 3.82042516389567e-5*x_120 - 0.000262108729112502*x_13 + 0.000305819691745206*x_14 - 7.24398800274279e-5*x_15 + 0.00023201483360605*x_16 + 1.89716362982753e-5*x_17 + 0.000102466349369389*x_18 - 0.000162247428659766*x_19 + 5.19956972053238e-5*x_2 + 0.000286941043459546*x_20 + 1.51388309452035e-5*x_21 + 0.000241397155304533*x_22 - 9.68102831347736e-5*x_23 - 0.000126314073929034*x_24 + 3.5748624102788e-5*x_25 + 7.7363002333781e-5*x_26 - 0.000239487782412673*x_27 - 0.000122071473594797*x_28 - 0.000272224161514825*x_29 + 0.000131669535023009*x_3 + 0.000145329177788721*x_30 + 2.16829349438165e-5*x_31 + 5.67514045418799e-5*x_32 - 0.000230308026091443*x_33 - 0.000208541840752457*x_34 - 0.000122520317047717*x_35 + 0.000289113003567408*x_36 - 0.00051603747440876*x_37 - 7.83629281154065e-5*x_38 - 0.000124745385440002*x_39 + 1.97858331501516e-6*x_4 + 0.000220810056609399*x_40 - 5.51855058378788e-5*x_41 - 2.04035583121173e-7*x_42 - 2.16449302473075e-5*x_43 - 2.40841418073144e-5*x_44 - 0.000476852810988381*x_45 + 0.000113070885879951*x_46 - 0.000306075286426892*x_47 - 0.000124648004472845*x_48 + 0.00026438135874761*x_49 - 3.28165079454451e-5*x_5 - 7.85423522192687e-5*x_50 - 0.000332977819352759*x_51 + 4.92105316898239e-5*x_52 - 8.67342401408473e-5*x_53 - 1.19635182092714e-5*x_54 - 0.000207521822709683*x_55 + 1.15992792497324e-6*x_56 - 0.000192012719409243*x_57 - 6.36829008391668e-5*x_58 - 9.37733491982976e-5*x_59 + 8.29110709765696e-5*x_6 - 0.000206618885344659*x_60 + 2.94864390479789e-5*x_61 + 9.97806451311962e-5*x_62 + 7.89328433558877e-5*x_63 + 3.14706645735085e-5*x_64 + 6.25272799575746e-5*x_65 + 1.60942645764846e-5*x_66 + 2.89512024311323e-5*x_67 + 5.05579054938373e-5*x_68 + 0.000123267444906681*x_69 + 0.000162947815249302*x_7 + 0.000104227646290157*x_70 + 6.40004073867684e-5*x_71 - 3.19549138583286e-5*x_72 + 3.30113658094163e-5*x_73 - 2.78762366641033e-5*x_74 + 9.04666133032115e-5*x_75 + 2.23704747866298e-6*x_76 + 5.92111212816571e-5*x_77 - 0.000209933999811804*x_78 + 4.18390737772408e-6*x_79 - 4.08689249563256e-5*x_8 + 8.98102165156877e-7*x_80 + 8.48276427996792e-6*x_81 - 8.54018005423616e-5*x_82 - 0.000212809285698281*x_83 - 9.60703911565712e-5*x_84 + 6.78552005926817e-5*x_85 - 6.68682165567976e-5*x_86 + 1.51364924062341e-6*x_87 + 1.10722161750098e-5*x_88 + 3.93962462314406e-6*x_89 - 5.18994905630957e-5*x_9 + 9.00387257448455e-5*x_90 - 1.67394309408861e-5*x_91 - 7.84959474769646e-5*x_92 - 0.000173729702339084*x_93 - 7.02502990985669e-5*x_94 + 2.23121756001247e-6*x_95 + 7.27502572344861e-6*x_96 + 6.31628136134423e-5*x_97 - 7.3858390213458e-5*x_98 - 0.000196278280456092*x_99 + 1.42547486672951e-7*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 2.5827224974082e-8*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 1.31104373750356e-5*std::exp(0.690639853477478*x_23) + 5.71972547551887e-7*std::exp(0.522799849510193*x_26) - 0.000130472877247567*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 7.22169298528912e-5*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 0.000127794488492934*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 1.14629837793613e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 2.07362745128484e-6*std::sin(0.468799859285355*x_19 - 8.42119979858398) - 0.000223240271938294*std::sin(0.618319809436798*x_20 - 7.4270396232605) + 8.42931030430813e-6*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 0.000210196532027875*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 7.80797636417317e-6*std::sin(1.19159984588623*x_31 + 7.59752035140991) + 3.19323102280961e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) - 2.07766039366467e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) - 0.000206233159015665*std::sin(0.621599853038788*x_41 - 1.78095996379852) + 0.000962878454878265*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.000549328751209272*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.00040902843361569*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000216105894978802*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 8.51951327215145e-5*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.000959410620261888*std::sin(0.56471985578537*x_52 - 1.59223985671997) - 4.25127099253089e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) - 1.22931834108138e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000210518774380752*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 2.54139229820557e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 3.11039569989927e-5*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 5.19105789443193e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 7.1236111835836e-6*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000113385040608496*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 0.000126890592762314*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 3.19223727146111e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 4.86990376796824e-5*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 5.95680166068449e-7*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 1.71704311654994e-5*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 1.57675364729296e-6*std::sin(0.752159833908081*x_84 + 1.4015998840332) - 0.000206080495903286*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 5.34361695084469e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 7.56213816718592e-6*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 1.3427820841252e-5*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 1.63922548129218e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0453877586633816 + 4.13516866898213e-6*std::exp(-1.43183982372284*x_98) + 3.55022188518185e-5*std::exp(-2.46079969406128*x_46) + 5.08523194743652e-7*std::exp(-3.49255990982056*x_39) + 9.7244885242377e-7*std::exp(-2.12303996086121*x_25) + 1.51874755454055e-6*std::exp(-3.79119992256165*x_118) + 2.03996786367291e-6*std::exp(-4.05719995498657*x_115) + 8.19946112453149e-7*std::exp(-2.90335988998413*x_110) + 1.85271010856626e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000183836342503629*x_1 + 1.14038772524886e-5*x_10 - 0.000207270769138562*x_100 - 0.000201573501440496*x_101 - 6.09683371030587e-5*x_102 - 0.000277859186279662*x_103 + 0.000161765105855255*x_104 + 5.24575767866655e-5*x_105 - 0.000272656655713916*x_106 - 0.00010932098993211*x_107 - 3.06325200519438e-5*x_108 - 4.68549695247181e-6*x_109 + 6.5354623104665e-6*x_11 + 0.000107980469514593*x_110 - 8.06390104650708e-5*x_111 - 1.14810701964787e-5*x_112 + 2.37992709911281e-5*x_113 + 1.21477045758617e-5*x_114 - 8.98476041826335e-6*x_115 - 2.16827989042373e-5*x_116 - 3.41951406630201e-5*x_117 + 4.68311912719325e-5*x_118 + 4.88203919152087e-5*x_119 + 0.000304049736067106*x_12 - 1.67089824418829e-5*x_120 + 0.000453645438249552*x_13 + 2.35184497256504e-5*x_14 + 0.000351218710354777*x_15 + 9.15795561761461e-5*x_16 + 1.09281235665909e-5*x_17 + 0.000849101740521894*x_18 - 0.000302384432889758*x_19 + 1.16768492658776e-5*x_2 + 0.000109403017946582*x_20 - 1.99196006613908e-5*x_21 + 5.44291509035265e-5*x_22 + 0.000195706778520146*x_23 - 2.65412605904234e-5*x_24 + 7.55126757741531e-6*x_25 + 5.65169267896298e-6*x_26 + 0.000325009243677705*x_27 + 0.000129798724384222*x_28 - 8.38014549000705e-5*x_29 + 0.000143770593736495*x_3 + 0.000257948124010947*x_30 + 6.15278728369101e-5*x_31 - 0.000189729613833418*x_32 - 0.000288719184754261*x_33 - 0.00012426598031809*x_34 - 0.000191390242516939*x_35 - 0.000209329684350679*x_36 + 0.000674749335863685*x_37 - 0.000221518375512821*x_38 - 0.000146409869642047*x_39 + 0.000225903793790604*x_4 - 0.00026385345163734*x_40 - 0.00034864551981853*x_41 - 0.00011178371908772*x_42 - 7.86169239786298e-5*x_43 - 7.45346772461027e-5*x_44 - 4.64860040235251e-7*x_45 + 7.32030570707714e-5*x_46 - 0.00063381347741014*x_47 - 8.33654284955349e-5*x_48 - 0.00048161001533289*x_49 + 8.07718400681578e-5*x_5 + 9.64607981910738e-5*x_50 + 0.000152052157024116*x_51 + 0.000338051276851022*x_52 - 0.000134960644911495*x_53 - 0.000267172340717973*x_54 + 0.000215071966633362*x_55 - 0.000511889956542855*x_56 + 0.000470580457664421*x_57 + 0.000639035646870596*x_58 + 0.000437674231842028*x_59 + 0.000176994437614112*x_6 + 0.000361771273836117*x_60 + 4.56056264633577e-5*x_61 + 3.12134541444724e-5*x_62 + 7.02798400812016e-5*x_63 + 9.20616230071653e-5*x_64 - 5.48652301550013e-5*x_65 - 4.36884515628566e-5*x_66 - 8.85890209910317e-5*x_67 + 6.79516550992403e-5*x_68 + 3.34264884744458e-6*x_69 + 0.000271225970939733*x_7 - 2.52410335100149e-5*x_70 + 3.48896592847249e-5*x_71 - 0.000112034982913427*x_72 + 2.47096299593717e-5*x_73 + 3.02780862021228e-5*x_74 - 2.87451002858808e-5*x_75 - 0.000104317361241101*x_76 + 8.86420256267858e-5*x_77 - 0.000125880713069849*x_78 - 3.25103396573856e-5*x_79 + 8.98559858218582e-5*x_8 - 7.25781636592139e-5*x_80 - 5.42575815924174e-5*x_81 + 7.74477519957485e-5*x_82 + 0.000350525324491883*x_83 - 5.98986891427393e-5*x_84 + 1.20684843080258e-5*x_85 - 5.6111937144669e-5*x_86 + 6.57580754086126e-5*x_87 + 3.89105721901917e-5*x_88 + 3.48949771211804e-6*x_89 + 8.2952868706048e-5*x_9 - 8.60555765045204e-6*x_90 - 8.99846809111482e-5*x_91 - 0.000234088580963938*x_92 - 8.84783809808331e-5*x_93 - 0.000177624419786747*x_94 - 8.32330608205745e-5*x_95 - 9.1170981901189e-5*x_96 - 6.3284938566271e-5*x_97 - 5.09603400158811e-5*x_98 - 0.00029724960005301*x_99 + 2.08919882805914e-7*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 2.161125454299e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 3.20806869402703e-5*std::exp(0.690639853477478*x_23) + 0.000123170651299143*std::exp(0.522799849510193*x_26) - 0.000191223141565811*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 2.09620269922127e-5*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 0.000312707719869083*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 3.32729978806553e-6*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 0.000446542486732486*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 0.000128951506301477*std::sin(0.618319809436798*x_20 - 7.4270396232605) - 1.3512441151629e-6*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 0.000308067408710099*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 6.53342218690273e-5*std::sin(1.19159984588623*x_31 + 7.59752035140991) - 5.11884658667958e-7*std::sin(0.778799831867218*x_32 - 7.9888801574707) + 3.33055289091868e-6*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 1.37736963923891e-6*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.000556192778586612*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.000805105028528979*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.000118726524147458*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000156929049531035*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 0.000208468894171142*std::sin(0.822799861431122*x_5 - 4.80431985855103) + 0.000451315950430239*std::sin(0.56471985578537*x_52 - 1.59223985671997) + 6.81491688315724e-6*std::sin(0.609919846057892*x_52 - 7.80079984664917) + 1.97063474244038e-6*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000152871864857043*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 7.37676526284146e-6*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 0.000260266262703021*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 3.76957686190691e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 5.96077103553348e-5*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 8.23365168056822e-5*std::sin(0.991199791431427*x_64 - 4.80087995529175) + 5.96905509108788e-5*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 7.8112698772209e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 0.000119164489894837*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 0.000128275936204747*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 0.000143675737096368*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 0.000339543872352991*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 0.000119039410476213*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 7.83169071013871e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 6.32771399112045e-5*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 0.000112358975634887*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 4.75809326914968e-6*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0704708839973737 + 1.2002935798175e-6*std::exp(-1.43183982372284*x_98) - 1.6700583988863e-5*std::exp(-2.46079969406128*x_46) - 8.15178169404922e-8*std::exp(-3.49255990982056*x_39) + 8.1370877827015e-6*std::exp(-2.12303996086121*x_25) - 1.01432610608151e-8*std::exp(-3.79119992256165*x_118) - 1.36243357462837e-8*std::exp(-4.05719995498657*x_115) - 1.31439859158673e-7*std::exp(-2.90335988998413*x_110) + 5.3777638267956e-7*std::exp(-2.07559990882874*x_107));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000258561441026027*x_1 + 1.4304127088036e-5*x_10 - 0.000268871216598111*x_100 - 0.000413411071790678*x_101 - 0.000186957771426922*x_102 - 0.00017353388606888*x_103 - 0.000113140476623104*x_104 - 8.46309578786595e-5*x_105 - 0.00034774877480511*x_106 - 0.000211839529625286*x_107 - 2.37435216422425e-5*x_108 - 8.57126443555501e-5*x_109 + 0.000114833942205377*x_11 + 5.71769211113294e-6*x_110 - 0.000191875344758775*x_111 - 0.000159510257908343*x_112 - 0.000150411190204904*x_113 - 0.000116201051299268*x_114 - 4.42670684515598e-5*x_115 - 0.000131616993209526*x_116 - 0.000222815394052721*x_117 - 0.000204308629750705*x_118 - 0.000146295286938345*x_119 + 0.000329055385458644*x_12 - 0.000178703741979834*x_120 + 0.000565562302718067*x_13 - 0.000134978735077022*x_14 + 0.000583771019894848*x_15 + 6.83653704735936e-5*x_16 - 1.19695285211086e-5*x_17 + 0.000395144455402545*x_18 - 0.00036299628622327*x_19 + 0.000138723731969679*x_2 + 0.000213899228998285*x_20 + 5.65648406463621e-5*x_21 - 0.000214747789920323*x_22 + 0.000492596299771634*x_23 - 9.82377914469383e-5*x_24 - 0.000173199575107638*x_25 - 0.000326165627000232*x_26 + 5.14233497311889e-5*x_27 - 3.15667560411572e-5*x_28 - 7.39950449524505e-5*x_29 + 0.000176194408264133*x_3 + 0.000213012625308022*x_30 + 4.76160059937444e-5*x_31 - 0.000125639759803167*x_32 - 0.000541582992962152*x_33 - 0.000153733144948949*x_34 - 0.000165477097417221*x_35 - 0.000212709056329816*x_36 + 0.00123687847950028*x_37 - 0.000209967099611798*x_38 - 8.27120589753141e-5*x_39 + 0.000290306840197107*x_4 - 0.000417334841103694*x_40 - 0.000428190263084205*x_41 - 0.00014344187441367*x_42 - 0.000407498754690566*x_43 - 5.88523317749923e-5*x_44 - 0.000128708686184501*x_45 - 0.000103956540985612*x_46 - 0.000518429880801422*x_47 - 0.000277569150527459*x_48 - 0.000280310067037508*x_49 + 0.000195786615698418*x_5 - 7.2424311606309e-5*x_50 - 0.000312325245318283*x_51 + 0.000257620025178572*x_52 - 0.000241957883754154*x_53 - 0.000632527327118384*x_54 + 0.000491425386101473*x_55 - 0.000546351647644096*x_56 - 6.4925878413392e-6*x_57 - 0.000147919951088992*x_58 + 0.000754614791136404*x_59 + 0.000114909988322837*x_6 - 6.47751854072403e-5*x_60 - 0.000130001671326564*x_61 - 1.79989929987324e-6*x_62 - 4.69558336180814e-5*x_63 + 9.7022615944719e-5*x_64 - 3.48503474762523e-5*x_65 - 0.000154030937560198*x_66 - 0.000164064586797146*x_67 + 7.74070841216122e-5*x_68 - 7.65560766499103e-6*x_69 + 0.000140250374025174*x_7 + 3.25148578585164e-6*x_70 - 7.92921299639976e-5*x_71 - 0.000288999345889526*x_72 - 4.42484638551952e-5*x_73 + 4.28380458106566e-5*x_74 - 0.00014179465656919*x_75 - 0.00024818326075425*x_76 + 7.80981358196864e-5*x_77 - 9.31797852808992e-6*x_78 - 0.000114127153309918*x_79 + 0.000367616809112053*x_8 - 4.13423107422801e-5*x_80 - 7.73039560427287e-5*x_81 + 1.03032794760785e-5*x_82 + 0.000125652364307523*x_83 - 0.000138684427850526*x_84 + 5.26035440636928e-5*x_85 - 6.47545866374942e-6*x_86 - 1.38255417120277e-5*x_87 + 6.37968284265839e-6*x_88 - 0.000106004763659214*x_89 - 8.83373280503155e-5*x_9 + 1.62469660987237e-5*x_90 - 6.04818108031683e-5*x_91 - 0.000160661756204971*x_92 - 0.000153776599260388*x_93 - 0.000228679242962948*x_94 - 0.000116906246559063*x_95 - 0.000134984710846176*x_96 - 9.23906112535072e-5*x_97 + 1.72447318861547e-5*x_98 - 2.42317990329565e-5*x_99 + 1.87800272940318e-7*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 5.6135108482554e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 6.75408695225901e-6*std::exp(0.690639853477478*x_23) + 8.2183878437608e-5*std::exp(0.522799849510193*x_26) - 0.000171892486709493*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 0.000240623629950122*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 6.58357202441079e-5*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 3.81941571411023e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 0.000297949171006009*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 0.000343048919152708*std::sin(0.618319809436798*x_20 - 7.4270396232605) - 2.23797430323438e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 0.000276925023424029*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 0.000169705262827083*std::sin(1.19159984588623*x_31 + 7.59752035140991) - 8.47799964095083e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) + 5.51616965565132e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 0.000187099200206034*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.00147963631451193*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.000723717350750327*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.00136286472784026*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000647175060906521*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 4.38898655971646e-5*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.0012957817917423*std::sin(0.56471985578537*x_52 - 1.59223985671997) + 0.000112870862429957*std::sin(0.609919846057892*x_52 - 7.80079984664917) + 3.26382913727681e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000630443240084653*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 8.46780721871168e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 0.000676040109662308*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 0.000155457268267846*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 0.000154830682343647*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000339555617253708*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 0.000171378673711065*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 1.64454071873646e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 2.50882198336285e-5*std::sin(1.32183992862701*x_73 + 7.61008024215698) - 8.55903077261283e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) + 0.000373196894801818*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 0.000226555855923181*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 0.00031667983005153*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 7.03998888566564e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 0.000164362004358206*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 0.000291851788321975*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 5.46182711476027e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0864136917541947 + 1.37781998987411e-5*std::exp(-1.43183982372284*x_98) + 4.79493636854668e-5*std::exp(-2.46079969406128*x_46) - 1.35012450764008e-6*std::exp(-3.49255990982056*x_39) + 2.1136038377845e-5*std::exp(-2.12303996086121*x_25) - 1.37784076103796e-6*std::exp(-3.79119992256165*x_118) - 1.85070314376663e-6*std::exp(-4.05719995498657*x_115) - 2.17694955276379e-6*std::exp(-2.90335988998413*x_110) + 6.17314849131116e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.1967742070456e-5*x_1 + 0.000150244386594861*x_10 + 0.00014550722119013*x_100 + 0.000141675577051693*x_101 + 8.9518598260901e-6*x_102 + 0.000175681279792302*x_103 - 0.000344187755815887*x_104 - 1.83369570452435e-5*x_105 + 3.6885863247787e-5*x_106 + 8.5334746061646e-5*x_107 + 0.000124072852625053*x_108 - 5.15483402337788e-5*x_109 - 8.88980494903883e-5*x_11 - 0.000186284289512248*x_110 + 4.41915247423967e-5*x_111 - 5.22364286241193e-5*x_112 - 4.20414978886493e-5*x_113 + 5.2320803454348e-5*x_114 + 1.39590744391864e-5*x_115 - 6.83897394542031e-6*x_116 + 4.62786677562098e-5*x_117 - 1.34790929428499e-5*x_118 - 4.67178898244812e-5*x_119 - 0.000245473527559994*x_12 - 3.81193606012936e-5*x_120 - 9.45680209898849e-5*x_13 - 0.00042570588719635*x_14 - 7.88322178590371e-5*x_15 + 1.44414679052568e-5*x_16 - 9.67631135998361e-5*x_17 - 5.95858310655582e-5*x_18 + 0.000351432581747716*x_19 + 0.000147702189681293*x_2 - 0.000235982304223474*x_20 - 0.000191306049089869*x_21 - 2.37869477600314e-5*x_22 + 6.33225313413729e-5*x_23 - 0.000191737597936101*x_24 - 3.55631828628134e-5*x_25 - 0.000538417730441395*x_26 - 0.000441716385571913*x_27 - 0.000102168333871522*x_28 - 7.4934903201755e-5*x_29 - 9.47881534290276e-5*x_3 + 9.09408688514654e-5*x_30 + 5.32031167411957e-5*x_31 + 7.57381015642164e-5*x_32 + 3.80064551642053e-5*x_33 + 0.000250098146923981*x_34 + 0.000159345850116403*x_35 + 0.000645094144412801*x_36 - 4.88553825094403e-5*x_37 + 0.000142996280330766*x_38 + 9.32613833312594e-5*x_39 - 0.000127268827221523*x_4 + 0.000204550309673974*x_40 + 0.000157200350891647*x_41 + 9.08957473247201e-5*x_42 + 3.59636785590004e-5*x_43 + 8.39046746037877e-5*x_44 - 0.00045207329023719*x_45 + 0.000168796462731928*x_46 + 0.00019912015341804*x_47 - 3.50462261715082e-5*x_48 + 0.000291805574917453*x_49 + 1.12453521026144e-5*x_5 - 5.70536122384499e-5*x_50 - 0.000313074894133872*x_51 + 1.87318281405638e-5*x_52 - 7.53530518357047e-5*x_53 + 3.72162767458668e-5*x_54 - 0.000231382613373845*x_55 + 7.97295351515432e-6*x_56 - 0.000279034383137609*x_57 - 0.000373348909611851*x_58 - 0.000123470042840228*x_59 - 2.49264851501172e-5*x_6 - 0.000252662431053595*x_60 - 0.000113489519040814*x_61 - 7.54647677563641e-5*x_62 + 3.51291058166614e-5*x_63 - 0.000104811627359582*x_64 - 7.52112813170021e-5*x_65 - 0.000162394796918724*x_66 + 0.000144126110548306*x_67 + 1.92494709467324e-5*x_68 + 9.61100802230556e-5*x_69 - 4.06514937584962e-5*x_7 + 8.57015931715826e-5*x_70 + 5.65199831172074e-5*x_71 - 4.87806004152144e-5*x_72 - 3.23268947299956e-5*x_73 - 2.20222160233176e-5*x_74 + 1.61537468431789e-5*x_75 - 9.65691754951851e-5*x_76 + 1.1072172029629e-5*x_77 - 0.000105834207080108*x_78 - 0.000128003334497083*x_79 - 2.56781403617247e-5*x_8 - 1.38001344935984e-5*x_80 - 5.15348978965292e-5*x_81 - 5.09972885901999e-5*x_82 - 0.000384821537177607*x_83 - 6.18450039472166e-5*x_84 - 1.24162563077054e-5*x_85 + 0.000114563700507642*x_86 - 9.20809523397952e-5*x_87 - 5.78527199829697e-5*x_88 - 9.96675967080225e-5*x_89 - 1.25353781551159e-5*x_9 - 2.96871679820478e-6*x_90 + 5.13378726277341e-5*x_91 + 0.000175219320757387*x_92 + 2.46672273381827e-5*x_93 + 8.63478104111945e-5*x_94 + 0.00014854715318668*x_95 + 9.10196736791046e-5*x_96 + 0.000170297950755433*x_97 + 1.85084071044963e-5*x_98 + 0.000467120938834393*x_99 - 2.54811145848968e-8*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) + 8.17943183888758e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 0.000413698842749*std::pow(0.0127280799332244*x_1 + 0.0187445861288665*x_10 - 0.014137321869486*x_100 - 0.0215509076562093*x_101 + 0.00137750166696968*x_102 - 0.0137622711100712*x_103 + 0.0140313829416064*x_104 - 0.0103515158516647*x_105 - 0.0172852450839903*x_106 - 0.00545226933943702*x_107 - 0.0134889383934035*x_108 + 0.00573334700292179*x_109 + 0.00680721893562113*x_11 + 0.00443268388809341*x_110 - 0.00708859470930719*x_111 - 0.00597260092568919*x_112 + 0.00123877218761258*x_113 - 0.00884331950309013*x_114 - 0.0026281834323327*x_115 + 0.00333028097777703*x_116 - 0.00580938199191377*x_117 + 0.00858131851601979*x_118 + 0.00386323017245518*x_119 + 0.0330807044222015*x_12 - 0.00152907988826734*x_120 + 0.0243104089219406*x_13 + 0.0114681617839093*x_14 + 0.0220725996365093*x_15 + 0.0196370228459153*x_16 + 0.00770119845766004*x_17 + 0.0809553965242328*x_18 - 0.00296061829151845*x_2 - 0.00502792033257078*x_20 - 0.000313338578740424*x_21 + 0.0138371305827366*x_22 + 0.00595365057295173*x_23 + 0.0104078603447715*x_24 + 0.01595763127584*x_25 + 0.0564454885267899*x_27 + 0.0143933936714585*x_28 + 0.0126238033032643*x_29 + 0.0225278838916671*x_3 - 0.00916187074884918*x_30 + 0.00992455576698694*x_31 - 0.0102738010645744*x_32 - 0.0177153413551054*x_33 + 0.00655666882370739*x_34 - 0.0132300169856927*x_35 + 0.0188095791149842*x_36 + 0.0522143704864631*x_37 - 0.016905245299647*x_38 - 0.0122431945554423*x_39 + 0.0167827074450014*x_4 - 0.0127753260098841*x_40 - 0.0181421958710599*x_41 - 0.0050790899095114*x_42 - 0.00436381047210351*x_43 - 0.00190751675868828*x_44 - 0.0091583512280645*x_45 + 0.0179092252199732*x_46 - 0.04284589579465*x_47 - 0.00790600122079289*x_48 - 0.0221967964465663*x_49 + 0.00368154347398555*x_5 + 0.00777529136847513*x_50 - 0.005134477001416*x_51 + 0.0323563324390663*x_52 - 0.0103106476807303*x_53 - 0.0115163893578877*x_54 + 0.00199160835983696*x_55 - 0.0371685088878013*x_56 + 0.0651735681618991*x_57 + 0.0399567163859294*x_58 + 0.0268447465726188*x_59 + 0.0257784169419662*x_6 + 0.0762267288949687*x_60 + 0.000300761145213928*x_61 + 0.00485818071698935*x_62 + 0.00529044360925631*x_63 + 0.00128388535621349*x_64 - 0.00303368964951264*x_65 - 0.0138038891892215*x_66 + 0.00111250807319778*x_67 + 0.0179480438958439*x_68 + 0.00268726846069428*x_69 + 0.023426405018803*x_7 + 0.000507123095215363*x_70 + 0.000202357600454671*x_71 + 0.00496758462754625*x_72 + 0.00159243177873141*x_73 - 0.00736027639770243*x_75 - 0.00185177066574696*x_76 + 0.0139578111312482*x_77 - 0.0162059082983257*x_78 - 0.00450230930604066*x_79 + 0.0159482834226336*x_8 - 0.00186325069117666*x_80 - 0.00325010133535871*x_81 + 0.00539380719093794*x_82 - 0.0185944664204216*x_83 + 0.00122970889411152*x_85 - 0.00992634186655975*x_86 - 0.00232797927848112*x_87 + 0.0012267033373006*x_88 - 0.00115350628091012*x_89 + 0.0221419234277008*x_9 + 0.0121975886243876*x_90 - 0.0105141029577545*x_91 - 0.0153222321895059*x_92 - 0.00630315903012633*x_93 - 0.0167030927804877*x_94 - 0.00882010559725481*x_95 - 0.0125328461338405*x_96 - 0.00227211946850776*x_97 - 0.0114107425561861*x_98 - 0.00130973262225167*x_99 + 0.0205881409012611*std::exp(0.522799849510193*x_26) - 0.0746401804186281*std::sin(0.468799859285355*x_19 - 8.42119979858398) - 0.0214414961759879*std::sin(2.00959992408752*x_74 - 8.78632068634033) - 0.0567552173543784*std::sin(0.752159833908081*x_84 + 1.4015998840332) - 0.318592576182766, 2) - 6.16014143752867e-5*std::exp(0.690639853477478*x_23) + 2.33227145070198e-5*std::sin(0.440479874610901*x_100 - 5.88263988494873) + 0.000102734465909681*std::sin(0.352959841489792*x_112 + 1.41575980186462) - 0.000600462136795009*std::sin(0.614879846572876*x_13 - 1.78223991394043) + 1.63070282647425e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) - 7.5626779931579e-5*std::sin(0.618319809436798*x_20 - 7.4270396232605) - 1.19702453934029e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) - 3.75737380080134e-5*std::sin(1.07687973976135*x_3 + 1.17927992343903) + 0.000247277090490709*std::sin(1.19159984588623*x_31 + 7.59752035140991) - 4.53462472740174e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) + 2.95043175046116e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) - 0.000286634818217344*std::sin(0.621599853038788*x_41 - 1.78095996379852) + 0.000326192923775265*std::sin(0.716559827327728*x_42 - 7.96776008605957) + 9.81954096914839e-5*std::sin(0.219599992036819*x_44 + 4.58184003829956) - 0.000581876268556149*std::sin(0.141680032014847*x_46 - 1.72631990909576) - 0.000269551449695541*std::sin(0.651199817657471*x_47 - 7.82536029815674) + 0.000400302485981808*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.000458079813184359*std::sin(0.56471985578537*x_52 - 1.59223985671997) + 6.03711990391925e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) + 1.74572315861172e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) + 0.000262582567810224*std::sin(0.622399806976318*x_58 - 8.2105598449707) - 3.61533758019033e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) - 0.000985056259231326*std::sin(0.327919840812683*x_6 - 1.93431985378265) - 6.47486817069413e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) - 0.000225603378533045*std::sin(0.748959839344025*x_63 + 1.01175975799561) - 0.000141426507929393*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 6.05851319548107e-5*std::sin(1.06479978561401*x_64 + 4.80335998535156) + 0.000149992197299197*std::sin(0.904719829559326*x_72 - 1.94167983531952) + 0.000228819948104567*std::sin(1.32183992862701*x_73 + 7.61008024215698) + 0.000543784210279855*std::sin(0.598719835281372*x_8 + 4.18455982208252) - 6.98135877391171e-5*std::sin(1.23471987247467*x_88 + 1.39911985397339) - 9.55199695205206e-6*std::sin(1.23527991771698*x_91 - 8.61303997039795) - 0.000239491442680423*std::sin(1.50623989105225*x_91 + 6.02320003509521) - 0.000425256470356505*std::sin(1.18935990333557*x_92 - 8.00663948059082) - 2.3319317875897e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0575582211143408 + 5.8826143055335e-6*std::exp(-1.43183982372284*x_98) + 1.69508752934505e-5*std::exp(-2.46079969406128*x_46) - 7.22140627117222e-7*std::exp(-3.49255990982056*x_39) + 3.07972657271027e-5*std::exp(-2.12303996086121*x_25) + 2.11084352919552e-6*std::exp(-3.79119992256165*x_118) + 2.83526577667705e-6*std::exp(-4.05719995498657*x_115) - 1.16438425222223e-6*std::exp(-2.90335988998413*x_110) + 2.63563106153567e-6*std::exp(-2.07559990882874*x_107));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000126245834814067*x_1 - 7.80938376397546e-5*x_10 - 0.000123720835704239*x_100 - 0.000126474788780929*x_101 - 0.000255809569697011*x_102 - 0.000143389921773897*x_103 + 0.0001006850795116*x_104 - 9.51319498741798e-5*x_105 - 0.000140686033114358*x_106 - 0.000182503988792161*x_107 - 9.45743851712611e-5*x_108 - 0.000186703602081107*x_109 + 0.000110298170508999*x_11 - 1.23023034280598e-5*x_110 - 0.000104591323652762*x_111 - 5.2850165984223e-5*x_112 - 0.000173529037989122*x_113 - 9.44681194824695e-5*x_114 - 8.97320349832025e-5*x_115 - 0.000234056983238656*x_116 - 0.000272915369474121*x_117 - 0.00036922072880546*x_118 - 0.000282406279454152*x_119 + 0.000211611448259953*x_12 - 0.000212844709758619*x_120 + 9.22326332913766e-5*x_13 + 0.000368174101313908*x_14 + 0.000165299784935813*x_15 + 0.000117021559506606*x_16 + 0.000103721244958983*x_17 - 0.000304233357015283*x_18 - 0.000780861383449243*x_19 + 3.67160584498281e-5*x_2 + 0.000600294484320205*x_20 + 0.000197542143265642*x_21 - 6.37407291767162e-5*x_22 + 0.000249447914065636*x_23 - 0.000108277019048862*x_24 - 0.000345325348149983*x_25 + 0.000295499635070149*x_26 + 9.84856015689097e-5*x_27 - 0.000269045695382954*x_28 - 0.000189917248990055*x_29 + 0.000208402331617538*x_3 + 5.8967062294723e-5*x_30 - 4.55396897785983e-5*x_31 + 7.41324706434076e-6*x_32 - 0.000313963042709459*x_33 - 0.000375048461402229*x_34 - 0.000288364000516555*x_35 - 0.000927725986766499*x_36 - 0.000111038735824502*x_37 - 8.34784167272366e-5*x_38 - 3.77686752396233e-5*x_39 + 0.00018654217461928*x_4 - 0.000234130131844832*x_40 - 0.000230516668881034*x_41 - 6.14130661081238e-5*x_42 - 0.000113751184283625*x_43 - 9.63205182534547e-6*x_44 + 1.6541123670499e-5*x_45 - 0.000264149178049066*x_46 - 0.000335377678562244*x_47 - 0.000193397190826667*x_48 - 0.000133526163740247*x_49 + 7.11207730303335e-5*x_5 - 8.67783571872935e-5*x_50 - 0.000378517900262025*x_51 - 6.74322157633147e-5*x_52 - 9.53172342414806e-5*x_53 - 0.000227815868543348*x_54 + 0.00024586972276352*x_55 - 0.000368154643511684*x_56 - 0.000674956769538974*x_57 - 0.000541238172623238*x_58 + 0.000196400065650665*x_59 - 0.000125432709811887*x_6 - 0.000492449951778054*x_60 - 6.8011928494635e-5*x_61 + 0.000107567891399813*x_62 - 0.00015999410741736*x_63 + 0.000184374766062805*x_64 + 0.000118554517090831*x_65 + 7.3642856117708e-5*x_66 - 0.000284338423784167*x_67 - 7.68814097705166e-5*x_68 + 1.70310288623745e-5*x_69 - 8.93549353892504e-5*x_7 - 7.81105203963037e-6*x_70 - 0.000120073888745534*x_71 - 0.000213780149862687*x_72 + 7.5869537137206e-6*x_73 - 2.84995700416786e-5*x_74 - 5.5459836213413e-5*x_75 - 0.000106017726943718*x_76 - 6.7435163677097e-5*x_77 + 8.72252047553464e-5*x_78 + 9.03350933322193e-5*x_79 + 0.000148572144951617*x_8 - 1.69159894249108e-5*x_80 + 3.09071155678026e-5*x_81 - 6.25118108458717e-5*x_82 + 0.000108448760240069*x_83 - 0.000116120341044905*x_84 + 0.000112677269095937*x_85 - 0.000133460873807682*x_86 + 5.78883114095869e-6*x_87 - 1.11941588359736e-5*x_88 - 4.30918085360502e-5*x_89 - 0.000126417748043556*x_9 - 0.000130797688788347*x_90 + 1.01188636428974e-5*x_91 - 9.57173426219007e-5*x_92 - 0.00014043909756265*x_93 - 0.000140648562934149*x_94 - 0.000142210888256011*x_95 - 8.76164144832249e-5*x_96 - 0.000171160355991099*x_97 + 6.48102988254762e-5*x_98 - 0.000704316829074966*x_99 + 2.50910267577817e-7*std::pow(7.13983964920044 - 9.78407955169678*x_22, 2) - 3.56600871589281e-7*std::pow(8.78983974456787 - 6.74624013900757*x_28, 2) + 4.06598041021383e-5*std::exp(0.690639853477478*x_23) - 8.91537486104404e-5*std::exp(0.522799849510193*x_26) - 0.000229656694101832*std::sin(0.440479874610901*x_100 - 5.88263988494873) - 0.000167515159746123*std::sin(0.352959841489792*x_112 + 1.41575980186462) + 0.000396332991708566*std::sin(0.614879846572876*x_13 - 1.78223991394043) - 2.65896592790431e-5*std::sin(0.901759803295135*x_14 + 9.48032093048096) + 0.00032321771612087*std::sin(0.468799859285355*x_19 - 8.42119979858398) + 0.000208286468091082*std::sin(0.618319809436798*x_20 - 7.4270396232605) + 1.03441507596097e-5*std::sin(0.6975998878479*x_28 + 4.39544010162354) + 0.000369985254219507*std::sin(1.07687973976135*x_3 + 1.17927992343903) - 0.000107806052706273*std::sin(1.19159984588623*x_31 + 7.59752035140991) + 3.91861990100464e-6*std::sin(0.778799831867218*x_32 - 7.9888801574707) - 2.54963117544187e-5*std::sin(0.441199868917465*x_40 + 0.308159857988358) + 0.000407912799797447*std::sin(0.621599853038788*x_41 - 1.78095996379852) - 0.00089837980766762*std::sin(0.716559827327728*x_42 - 7.96776008605957) - 0.000966921460147085*std::sin(0.219599992036819*x_44 + 4.58184003829956) + 0.000948786711611998*std::sin(0.141680032014847*x_46 - 1.72631990909576) + 9.49199991590576e-5*std::sin(0.651199817657471*x_47 - 7.82536029815674) - 0.000264218294769365*std::sin(0.822799861431122*x_5 - 4.80431985855103) - 0.00189598168220161*std::sin(0.56471985578537*x_52 - 1.59223985671997) - 5.2170090409674e-5*std::sin(0.609919846057892*x_52 - 7.80079984664917) - 1.50857588493332e-5*std::sin(0.504719853401184*x_58 + 7.83799982070923) - 9.24659731709167e-5*std::sin(0.622399806976318*x_58 - 8.2105598449707) + 5.89504064599098e-5*std::sin(0.503999829292297*x_59 - 9.19999980926514) + 0.000429457604789016*std::sin(0.327919840812683*x_6 - 1.93431985378265) + 2.28006372071632e-5*std::sin(0.823199868202209*x_62 + 4.60775995254517) + 9.83569066935481e-5*std::sin(0.748959839344025*x_63 + 1.01175975799561) + 4.98020100759579e-5*std::sin(0.991199791431427*x_64 - 4.80087995529175) - 0.000250760450676875*std::sin(1.06479978561401*x_64 + 4.80335998535156) - 9.90018398259584e-5*std::sin(0.904719829559326*x_72 - 1.94167983531952) - 0.000151031828716024*std::sin(1.32183992862701*x_73 + 7.61008024215698) + 9.28490711751759e-5*std::sin(2.00959992408752*x_74 - 8.78632068634033) - 0.000237075052597612*std::sin(0.598719835281372*x_8 + 4.18455982208252) + 0.000245769659563249*std::sin(0.752159833908081*x_84 + 1.4015998840332) + 0.000192276143822377*std::sin(1.23471987247467*x_88 + 1.39911985397339) + 9.40576638889433e-5*std::sin(1.23527991771698*x_91 - 8.61303997039795) + 0.000104411723063674*std::sin(1.50623989105225*x_91 + 6.02320003509521) + 0.000185400197672819*std::sin(1.18935990333557*x_92 - 8.00663948059082) + 3.80236488754004e-5*std::sin(1.33919990062714*x_92 + 7.21216011047363) + 0.0570343409549667 - 9.59198129265217e-6*std::exp(-1.43183982372284*x_98) + 7.01592782058079e-5*std::exp(-2.46079969406128*x_46) + 6.24041635826156e-7*std::exp(-3.49255990982056*x_39) - 1.34267660849475e-5*std::exp(-2.12303996086121*x_25) - 3.0039619725318e-6*std::exp(-3.79119992256165*x_118) - 4.03489432416845e-6*std::exp(-4.05719995498657*x_115) + 1.00620879950717e-6*std::exp(-2.90335988998413*x_110) - 4.29756610301691e-6*std::exp(-2.07559990882874*x_107));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
