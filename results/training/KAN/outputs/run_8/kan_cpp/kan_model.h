
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.68765618146451e-6*x_1 + 1.29328420326501e-5*x_10 + 1.78392946948617e-5*x_100 - 2.36461464125593e-6*x_101 - 6.61371770816706e-5*x_102 + 1.72110430208991e-5*x_103 + 7.32499845313086e-6*x_104 + 2.18895410904975e-5*x_105 + 7.28074705632722e-6*x_106 + 1.06055109421728e-5*x_107 - 3.75715262674346e-6*x_108 - 2.90366239984765e-5*x_109 + 1.06251825392476e-5*x_11 + 4.13728526798975e-5*x_110 - 5.73732274394285e-5*x_111 - 1.35703433272346e-5*x_112 + 3.43608301534144e-5*x_113 - 1.24560584525659e-5*x_114 - 1.71398167968148e-5*x_115 - 2.73121521002974e-5*x_116 + 4.45666404512949e-5*x_117 - 6.13331924112979e-5*x_118 - 8.91424774143965e-5*x_119 + 3.76192633677603e-5*x_12 - 2.32935295564015e-5*x_120 + 4.55310094106598e-5*x_13 + 4.10963504026304e-6*x_14 - 1.04345423294842e-6*x_15 + 2.36038652246642e-5*x_16 + 8.56009089887489e-6*x_17 + 2.90754163287562e-5*x_18 + 7.64801840964171e-6*x_19 - 2.46463799049381e-5*x_2 + 3.60784645516596e-6*x_20 + 3.59456732903766e-5*x_21 + 3.72038206154103e-5*x_22 + 2.07427101426105e-5*x_23 + 5.88757569081275e-6*x_24 + 2.94706746475133e-5*x_25 + 1.96759134521809e-5*x_26 - 1.37374261344734e-5*x_27 + 2.24242582423842e-5*x_28 + 8.64126204458887e-6*x_29 - 2.31028235564183e-5*x_3 + 2.00288804070397e-5*x_30 - 0.00238534496951382*x_31 - 0.000240982948384841*x_32 + 6.11858012692529e-6*x_33 - 0.000389179772439064*x_34 + 8.48361702046053e-5*x_35 - 2.03408953861716e-5*x_36 - 3.16889033046925e-6*x_37 + 1.15299766195494e-5*x_38 + 3.87522620671458e-5*x_39 - 2.45412444695291e-6*x_4 - 3.52929545734315e-5*x_40 + 1.53178304503873e-5*x_41 - 5.6179969000436e-6*x_42 - 9.45189235996902e-6*x_43 + 4.62474295524852e-7*x_44 + 2.41040415978347e-5*x_45 - 1.0785386211234e-6*x_46 + 3.08039606811348e-5*x_47 - 2.4500645059563e-5*x_48 - 2.2709284923486e-5*x_49 + 1.04828119860183e-5*x_5 + 3.45160840056936e-5*x_50 + 9.82835620218896e-6*x_51 - 4.65656827714754e-5*x_52 + 8.10118290630942e-6*x_53 - 1.77700751173536e-5*x_54 + 3.36961472104318e-6*x_55 - 8.7491524199017e-5*x_56 - 3.28164950576614e-6*x_57 + 8.00683028903455e-6*x_58 + 5.32048397611937e-6*x_59 - 1.28801765820294e-5*x_6 - 2.81962059012245e-6*x_60 - 1.07393309833814e-5*x_61 + 2.78400089503756e-5*x_62 - 1.43500261688087e-5*x_63 - 3.04206158429759e-5*x_64 + 0.000100121738978243*x_65 - 6.90945000950522e-6*x_66 - 8.02100234893179e-6*x_67 - 1.58971408063571e-5*x_68 + 4.21455248101696e-5*x_69 - 8.17404130016921e-8*x_7 - 1.93444418889061e-5*x_70 - 1.41238731818238e-5*x_71 - 2.60645909911299e-5*x_72 - 4.57265122064607e-6*x_73 - 5.1697962318816e-5*x_74 - 4.66029352266489e-6*x_75 - 7.21615480237997e-6*x_76 + 5.18340639554978e-6*x_77 + 4.44666317302926e-5*x_78 + 3.1875461983405e-5*x_79 + 4.40096367468694e-5*x_8 + 6.87065828275904e-6*x_80 - 3.46954907299662e-5*x_81 + 1.37358038724233e-6*x_82 + 3.25723825451677e-5*x_83 - 4.60644566124255e-5*x_84 - 1.16620341857286e-5*x_85 + 3.56199554892241e-6*x_86 + 3.36678533709782e-5*x_87 + 6.76740377145328e-6*x_88 - 2.1662182614814e-5*x_89 + 8.85466199568217e-5*x_9 + 3.64438017554021e-6*x_90 + 3.26457147361374e-5*x_91 + 4.31506180530843e-5*x_92 + 1.18309689974093e-5*x_93 + 8.18953163132703e-6*x_94 - 9.52755996758337e-6*x_95 + 5.59897821119222e-6*x_96 + 6.67160583699549e-6*x_97 + 2.53507464477252e-5*x_98 - 1.02023558683749e-5*x_99 + 0.00219986356615917*std::sin(0.194159999489784*x_1 + 4.98071956634521) - 3.43067086047725e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 9.03643479330987e-7*std::sin(1.5881599187851*x_29 + 0.188880011439323) + 0.000271794145641251*std::sin(0.228479996323586*x_59 + 5.0370397567749) + 0.0138124030119662*std::sin(0.240879982709885*x_91 + 7.95879983901978) - 0.000827936720514022*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0120249682245335);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.74731554844151e-6*x_1 - 9.89271491755735e-6*x_10 + 4.67681613138958e-6*x_100 + 4.43969739595136e-6*x_101 - 9.2091573264064e-6*x_102 - 3.62517904243774e-6*x_103 - 4.82844468782763e-6*x_104 + 6.57935948592136e-7*x_105 - 5.35482359809175e-6*x_106 - 2.38356603907669e-6*x_107 + 5.56947509439874e-6*x_108 - 1.42344120395352e-5*x_109 - 4.14161378960744e-6*x_11 - 5.88698545120953e-6*x_110 + 5.65588384380256e-6*x_111 + 9.16198494916695e-6*x_112 - 1.18921138255677e-5*x_113 + 3.85562913602555e-6*x_114 - 2.2924654160855e-6*x_115 + 3.5769348577942e-6*x_116 - 1.31280461917988e-5*x_117 - 3.09681684093958e-6*x_118 + 4.20718775557447e-5*x_119 + 1.78250070113945e-6*x_12 + 1.93298707581035e-5*x_120 - 7.17289307169307e-6*x_13 - 5.88267279610733e-6*x_14 + 3.51826073602189e-7*x_15 - 1.2896258424829e-5*x_16 - 5.00036874933433e-7*x_17 - 8.85947536166731e-6*x_18 - 1.05643758236436e-6*x_19 - 1.68123533251138e-6*x_2 + 1.46875511732337e-5*x_20 - 6.6130260820996e-7*x_21 - 1.92632106152692e-5*x_22 - 1.23247371760186e-5*x_23 - 6.13048124415742e-7*x_24 - 4.21568480080319e-6*x_25 - 3.86318987620489e-6*x_26 + 5.79168682885296e-7*x_27 - 1.25364064219639e-5*x_28 + 1.35290325024677e-6*x_29 + 2.23852162869434e-6*x_3 - 1.86235579032808e-5*x_30 + 8.37308836409938e-5*x_31 - 1.8713283916463e-5*x_32 - 5.81062883783069e-7*x_33 - 2.68127188379946e-6*x_34 - 4.83947100622075e-5*x_35 + 3.19215639974953e-5*x_36 + 3.85382652827654e-6*x_37 - 1.9455277815366e-6*x_38 - 9.5567655773283e-6*x_39 + 5.80194596064107e-6*x_4 + 1.04882821093702e-5*x_40 + 3.10210778603168e-6*x_41 + 5.30838558786633e-6*x_42 - 4.13422920722217e-7*x_43 + 1.14413859568126e-6*x_44 - 5.12933936777016e-6*x_45 - 9.26693193251146e-6*x_46 + 2.56490688282792e-7*x_47 + 1.40361454902943e-6*x_48 - 2.22810190690887e-6*x_49 - 7.54734808168796e-6*x_5 - 5.1362974613249e-6*x_50 - 5.80859023617989e-7*x_51 + 1.41658349044893e-5*x_52 - 1.55573182475116e-6*x_53 + 1.74940674871884e-5*x_54 - 3.50289951392564e-6*x_55 + 5.37681639720481e-6*x_56 + 6.74757114730353e-6*x_57 - 3.96859125763355e-7*x_58 - 6.64667205629422e-8*x_59 + 2.88817466854601e-6*x_6 - 1.27309362640267e-5*x_60 - 3.15781263879148e-6*x_61 + 1.11110318959392e-5*x_62 - 7.25532001907179e-6*x_63 + 2.35125011185716e-8*x_64 - 1.10037942389262e-5*x_65 - 1.53105694460454e-6*x_66 + 5.76969316264768e-7*x_67 - 6.28549974893041e-6*x_68 - 3.15416454976864e-6*x_69 - 2.61333475024008e-7*x_7 + 8.33539198295245e-9*x_70 + 8.91516525721512e-6*x_71 - 7.37904079364045e-6*x_72 - 5.10657633008679e-8*x_73 + 3.62304881237716e-5*x_74 - 1.94220352252818e-6*x_75 + 9.28164420054594e-6*x_76 - 1.0887515316969e-5*x_77 - 1.35934247061511e-5*x_78 - 8.63671149839274e-6*x_79 - 1.69745202684496e-5*x_8 - 8.99871138416923e-6*x_80 + 2.78945714014444e-5*x_81 - 7.87929580864638e-6*x_82 - 8.34744757881111e-6*x_83 - 7.54908570765007e-6*x_84 - 5.31334367516439e-6*x_85 - 1.06262202421871e-5*x_86 + 5.92995021816687e-7*x_87 - 8.9015558408363e-6*x_88 + 2.98662484223938e-6*x_89 + 5.15417791509662e-6*x_9 - 3.49021956462425e-6*x_90 - 3.68389543657133e-5*x_91 - 4.60566774058836e-6*x_92 - 1.9054218737369e-5*x_93 + 7.05175679183874e-7*x_94 + 6.91546299039508e-6*x_95 + 6.66020038882325e-7*x_96 + 1.28784157270447e-5*x_97 - 3.49776518670433e-5*x_98 - 1.179316988033e-5*x_99 + 1.18646663170881e-6*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 3.39940168978856e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 1.64595688235747e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.000269316852459281*std::sin(0.228479996323586*x_59 + 5.0370397567749) + 7.44953256625116e-6*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.000820390413775175*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0506278789517338);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.06357799100836e-7*x_1 - 8.85429478141717e-6*x_10 - 4.32786752386787e-6*x_100 + 3.96614420559518e-6*x_101 + 1.21981025441802e-5*x_102 - 1.16955393043152e-5*x_103 - 4.51562760347836e-6*x_104 - 5.09743328760509e-6*x_105 - 4.46996390946983e-6*x_106 - 2.66487220394416e-6*x_107 + 4.4789114815976e-6*x_108 + 1.10481877291612e-6*x_109 - 5.05935963097727e-6*x_11 - 1.42118144600002e-5*x_110 + 1.83351814914555e-5*x_111 + 6.11424448361272e-6*x_112 - 1.53985033469022e-5*x_113 + 5.6027845730526e-6*x_114 + 4.00013559901287e-6*x_115 + 6.85285319875286e-6*x_116 - 1.1544648531808e-5*x_117 + 1.05508489775808e-5*x_118 + 4.34845983218221e-5*x_119 - 1.30583887264992e-5*x_12 + 1.5529989909709e-5*x_120 - 1.7956735648109e-5*x_13 - 3.85220369777272e-6*x_14 - 6.11304045435927e-7*x_15 - 1.29398050937059e-5*x_16 - 2.78325386136263e-6*x_17 - 9.02646662185826e-6*x_18 - 2.63496165618001e-6*x_19 + 5.69921186505038e-6*x_2 + 1.22352715070816e-5*x_20 - 7.51901322980676e-6*x_21 - 1.96873961320301e-5*x_22 - 1.17582843031176e-5*x_23 - 2.3693379955777e-6*x_24 - 1.07825500288518e-5*x_25 - 6.63321210870083e-6*x_26 + 4.5532943297947e-6*x_27 - 1.21277915254423e-5*x_28 - 1.39620877734183e-6*x_29 + 7.94102026302652e-6*x_3 - 1.36646171449262e-5*x_30 + 0.00055724603356997*x_31 + 5.12385562608553e-5*x_32 - 1.3665502322109e-5*x_33 + 9.34903452759605e-5*x_34 - 4.57910140578207e-5*x_35 + 1.87647037225954e-5*x_36 + 2.28902782964753e-6*x_37 - 6.33180212283089e-6*x_38 - 1.4735033341904e-5*x_39 + 5.13410588068137e-6*x_4 + 1.0577423862847e-5*x_40 - 5.33893711099047e-6*x_41 + 2.98796842879305e-6*x_42 + 5.89359779754404e-6*x_43 + 1.77377895007087e-6*x_44 - 8.26229294059122e-6*x_45 - 4.22181359117329e-6*x_46 - 7.01390000273017e-6*x_47 + 1.04722966452919e-5*x_48 + 5.26707481573701e-6*x_49 - 6.74559775337016e-6*x_5 - 6.91868122242131e-6*x_50 - 7.99751930579957e-6*x_51 + 1.90094645800221e-5*x_52 - 2.27542129865429e-6*x_53 + 1.4692957350011e-5*x_54 - 7.08875538785363e-6*x_55 + 2.47390015581258e-5*x_56 + 2.04023783347838e-6*x_57 - 3.43578719063837e-6*x_58 - 1.31193062121093e-6*x_59 + 4.74939422178209e-6*x_6 - 3.62703939828301e-6*x_60 + 2.63050812498752e-6*x_61 - 8.35348028678999e-7*x_62 - 5.65624766603086e-7*x_63 + 6.30902447523276e-6*x_64 - 3.16242727891369e-5*x_65 + 6.05556942447682e-7*x_66 - 1.10797575851075e-6*x_67 + 7.28582882346461e-7*x_68 - 1.26815824528444e-5*x_69 - 1.38581886914371e-6*x_7 + 4.9047210336602e-6*x_70 + 7.67648510115209e-6*x_71 + 5.4561511575673e-7*x_72 + 8.32527440663766e-8*x_73 + 3.25701598160899e-5*x_74 + 2.83917237020418e-7*x_75 + 5.78138456934538e-6*x_76 - 7.88599475019635e-6*x_77 - 1.79907320052728e-5*x_78 - 1.02783125729584e-5*x_79 - 2.10946292438289e-5*x_8 - 7.23703394995254e-6*x_80 + 2.38426654043454e-5*x_81 - 4.54626518987445e-6*x_82 - 1.34467966141344e-5*x_83 + 7.03507333876426e-6*x_84 - 9.33396945938362e-8*x_85 - 6.7019349076282e-6*x_86 - 7.8037934161671e-6*x_87 - 7.41796366646469e-6*x_88 + 7.56924365753979e-6*x_89 - 1.99603299400286e-5*x_9 - 2.46088749064726e-6*x_90 + 1.17320196364041e-5*x_91 - 1.28822982134114e-5*x_92 + 1.19319916553873e-6*x_93 - 6.05592763743912e-7*x_94 + 1.07901066387121e-5*x_95 - 2.13601331201748e-6*x_96 + 1.22655611390011e-5*x_97 - 2.49776169698091e-5*x_98 - 2.04370091815494e-6*x_99 - 0.000555156693341463*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 2.69223161574149e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 3.88609958670565e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.000213291458617814*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 0.00348569252256438*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.000649726396221843*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.014321560081492);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.93748809279863e-7*x_1 + 4.56250894629482e-6*x_10 - 1.22400774742986e-6*x_100 - 3.39255479538435e-6*x_101 + 3.84802808733961e-6*x_102 + 8.62090853561868e-6*x_103 + 1.35286676471821e-6*x_104 - 5.87064079839536e-7*x_105 + 3.23875198906735e-6*x_106 + 1.37356863229796e-6*x_107 - 2.77928088656245e-6*x_108 + 7.06392807678055e-6*x_109 + 2.07308660705563e-6*x_11 + 4.21953980505004e-6*x_110 - 2.8850249077182e-6*x_111 - 1.65952778523915e-6*x_112 + 4.27750443136989e-6*x_113 - 2.81011054371879e-6*x_114 + 2.18269417725736e-6*x_115 - 2.49298755017092e-6*x_116 + 7.82959753627694e-6*x_117 + 3.87335363078718e-6*x_118 - 2.09382825568248e-5*x_119 - 3.16048371912674e-6*x_12 - 1.01507837030512e-5*x_120 + 7.20071012619557e-6*x_13 + 2.89697139884247e-6*x_14 + 8.9267986745359e-7*x_15 + 6.14041190651153e-6*x_16 - 8.28883920009735e-8*x_17 - 8.84556373636862e-8*x_18 - 7.24804837066542e-7*x_19 + 6.71926496478282e-7*x_2 - 1.26205293680164e-5*x_20 - 1.95154206379891e-6*x_21 + 1.07534506389615e-5*x_22 + 5.77510898209773e-6*x_23 + 1.0974232541498e-6*x_24 + 3.15192891800543e-6*x_25 + 2.54234173256106e-6*x_26 - 9.18418854746393e-8*x_27 + 6.93134483402358e-6*x_28 - 9.51745917394333e-7*x_29 - 1.51384407464564e-6*x_3 + 6.37794295955521e-6*x_30 + 6.13289267358545e-5*x_31 + 1.22263385316786e-5*x_32 + 2.18794751733608e-5*x_33 - 5.98542148451278e-6*x_34 + 2.17029396907569e-5*x_35 - 1.28032422270368e-5*x_36 - 1.14111607953679e-6*x_37 + 1.99992563379038e-6*x_38 + 4.30397402336152e-6*x_39 - 3.86398114517276e-6*x_4 - 2.79926401289905e-6*x_40 + 6.52949913392444e-7*x_41 - 1.67912098978019e-6*x_42 - 3.67991652918456e-6*x_43 - 5.4374305209236e-8*x_44 + 4.94256593289064e-6*x_45 + 4.43698967118577e-6*x_46 - 2.12906877068459e-6*x_47 - 2.63386713887527e-6*x_48 + 8.74483321981866e-7*x_49 + 3.91680884645259e-6*x_5 - 2.93469015589306e-6*x_50 + 7.50220026452889e-6*x_51 - 7.09585980176746e-6*x_52 + 9.14490820203828e-7*x_53 - 8.24030228083416e-6*x_54 + 2.74059269382993e-6*x_55 - 2.32457618211173e-6*x_56 - 4.93898460757261e-6*x_57 + 5.35264836362539e-8*x_58 - 2.23252762349392e-7*x_59 - 9.29322737736033e-7*x_6 + 4.72644250918683e-6*x_60 + 3.58158264232047e-6*x_61 - 5.62716520968505e-6*x_62 + 4.1825034213616e-6*x_63 - 1.80791951282834e-7*x_64 + 5.57264966996435e-6*x_65 + 3.71914236329299e-7*x_66 + 3.74969024653281e-6*x_67 + 3.90173884833545e-6*x_68 + 3.03354696961793e-6*x_69 + 2.16889873287946e-6*x_7 + 6.00557033849381e-7*x_70 - 3.64695972149973e-6*x_71 + 5.83306847942788e-6*x_72 + 1.34525552593677e-6*x_73 - 1.85940501215753e-5*x_74 - 3.9730863130275e-8*x_75 - 3.90542924917146e-6*x_76 + 6.89596598522088e-6*x_77 + 6.63517174031651e-6*x_78 + 1.88287957579255e-6*x_79 + 8.52870979526441e-6*x_8 + 5.27045983805081e-6*x_80 - 1.41765325535741e-5*x_81 + 3.08721643706409e-6*x_82 + 3.78658027628982e-6*x_83 + 3.75553379499861e-6*x_84 + 2.72244280894331e-6*x_85 + 6.40319749487001e-6*x_86 + 2.12579559124065e-8*x_87 + 4.23455509146061e-6*x_88 - 2.21816069575152e-6*x_89 - 2.41414093177966e-6*x_9 + 1.57458974048922e-6*x_90 - 2.52288765954297e-5*x_91 + 2.18328325054997e-6*x_92 - 7.84829135927424e-6*x_93 - 3.9704040387289e-7*x_94 - 9.41992224732676e-6*x_95 - 1.78419817610545e-7*x_96 - 1.09538700782894e-5*x_97 + 1.85252749724902e-5*x_98 + 3.36588394172088e-6*x_99 - 6.58386803145728e-6*std::sin(0.194159999489784*x_1 + 4.98071956634521) - 1.83377977634713e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 1.21103515621409e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) + 0.000145280800133982*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 4.13384902714048e-5*std::sin(0.240879982709885*x_91 + 7.95879983901978) - 0.000442552980428607*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0806418330581808);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.22432773541204e-6*x_1 - 1.19875506279496e-5*x_10 + 6.09514419455843e-6*x_100 + 5.53684348834292e-6*x_101 - 1.07943131866447e-5*x_102 - 4.49570000602642e-6*x_103 - 5.41005236744825e-6*x_104 + 6.7424186881563e-7*x_105 - 7.51254116343814e-6*x_106 - 3.6461457399436e-6*x_107 + 6.19080135281199e-6*x_108 - 1.86220456925343e-5*x_109 - 4.6562642187716e-6*x_11 - 7.89978808312813e-6*x_110 + 7.10245242920626e-6*x_111 + 1.10427274089674e-5*x_112 - 1.39321210084699e-5*x_113 + 5.02826618490617e-6*x_114 - 4.40562362068404e-6*x_115 + 8.08500967527927e-6*x_116 - 2.20620305101717e-5*x_117 - 1.61149894130926e-6*x_118 + 5.39968954319044e-5*x_119 + 6.06372375637042e-6*x_12 + 2.54852290954073e-5*x_120 - 9.91746237546416e-6*x_13 - 7.48283936687186e-6*x_14 + 7.05260896463544e-7*x_15 - 1.56243681360293e-5*x_16 - 2.72457405806078e-7*x_17 - 1.00735812374534e-5*x_18 - 3.14826995857788e-7*x_19 - 2.14196489075845e-6*x_2 + 1.79887476591993e-5*x_20 - 7.86062926638812e-7*x_21 - 2.5409470457558e-5*x_22 - 1.48320486997838e-5*x_23 - 9.89221558965423e-7*x_24 - 5.39456905336421e-6*x_25 - 5.01925546339114e-6*x_26 - 3.38818420741273e-9*x_27 - 1.64012824470263e-5*x_28 + 1.79827701743632e-6*x_29 + 2.84172007418548e-6*x_3 - 2.16815530040015e-5*x_30 + 0.000130902271354594*x_31 - 2.44906937304522e-5*x_32 - 9.01237225696507e-6*x_33 + 7.09267808526211e-6*x_34 - 6.05685791578067e-5*x_35 + 4.07470713481025e-5*x_36 + 4.3377613993848e-6*x_37 - 2.36668304267043e-6*x_38 - 1.12135154111099e-5*x_39 + 7.41353319447028e-6*x_4 + 1.53588244035554e-5*x_40 + 3.78078693490696e-6*x_41 + 8.06376886167396e-6*x_42 - 8.15845806142537e-7*x_43 + 6.22518143135609e-7*x_44 - 9.40515609767964e-6*x_45 - 1.1505650852333e-5*x_46 + 7.4697802762975e-7*x_47 + 6.71498344257359e-7*x_48 - 2.98698214363979e-6*x_49 - 9.41969779297506e-6*x_5 - 6.51375651522595e-6*x_50 - 1.81456450067568e-6*x_51 + 1.82317961801702e-5*x_52 - 2.44377754586952e-6*x_53 + 2.14593201450588e-5*x_54 - 2.18281695881674e-6*x_55 + 7.36148039176267e-6*x_56 + 1.08016896346995e-5*x_57 + 4.1093736874982e-7*x_58 - 7.1576471423109e-8*x_59 + 3.47481577934702e-6*x_6 - 1.62291971234764e-5*x_60 - 5.26368559005291e-6*x_61 + 1.36567943817239e-5*x_62 - 8.90590742977554e-6*x_63 + 1.50671464868444e-6*x_64 - 1.37137980123524e-5*x_65 - 9.80834825907226e-7*x_66 + 6.18798965580155e-7*x_67 - 7.96622181187326e-6*x_68 - 5.18149768483183e-6*x_69 - 9.38516792917114e-7*x_7 - 2.1429717277161e-7*x_70 + 1.12358874644989e-5*x_71 - 8.24729350960645e-6*x_72 - 1.04798419118627e-7*x_73 + 4.59342102623405e-5*x_74 - 1.39936325591648e-6*x_75 + 1.1927046913721e-5*x_76 - 1.39164876172367e-5*x_77 - 1.77632355900527e-5*x_78 - 1.1314523811316e-5*x_79 - 1.99677599404868e-5*x_8 - 1.11578785734273e-5*x_80 + 3.46329758802013e-5*x_81 - 8.74891672625283e-6*x_82 - 9.38633047235528e-6*x_83 - 8.75633063886679e-6*x_84 - 6.09469158312882e-6*x_85 - 1.40810690594611e-5*x_86 - 3.97982259762219e-8*x_87 - 1.03381970194986e-5*x_88 + 3.5699293352122e-6*x_89 + 5.76013578931464e-6*x_9 - 4.52085954215732e-6*x_90 - 4.74391855496633e-5*x_91 - 6.34034502202325e-6*x_92 - 2.24591317158035e-5*x_93 - 2.22015275325273e-7*x_94 + 9.13162120463063e-6*x_95 + 1.48423447529404e-6*x_96 + 1.19193992115927e-5*x_97 - 4.49425950842421e-5*x_98 - 1.43477916607276e-5*x_99 - 1.50724700437496e-5*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 4.35512529151079e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) + 9.27612354295942e-7*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.00034503384495536*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 9.46363373768399e-5*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.00105103879034887*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0187986192290634);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.22571161065254e-6*x_1 - 6.20964916244043e-6*x_10 + 1.13083460839738e-5*x_100 + 4.3627782715737e-6*x_101 - 3.71548192974748e-5*x_102 + 2.77291406110933e-6*x_103 - 2.45390115295101e-6*x_104 + 9.42699602182936e-6*x_105 - 4.28812578147688e-6*x_106 + 2.24619855027026e-6*x_107 + 3.90384929270148e-6*x_108 - 2.90016284943198e-5*x_109 + 6.71824787778486e-7*x_11 + 9.68371397385823e-6*x_110 - 1.61629519925522e-5*x_111 + 4.091030774329e-6*x_112 + 1.92050766818759e-7*x_113 - 6.17340647541965e-7*x_114 - 1.11567967305953e-5*x_115 - 2.02360037690086e-6*x_116 + 1.18172211702163e-6*x_117 - 2.61049103902323e-5*x_118 + 1.33673679460184e-5*x_119 + 1.77277048810286e-5*x_12 + 1.46863250631343e-5*x_120 + 8.52106301578376e-6*x_13 - 5.06422677521994e-6*x_14 + 2.67366603000824e-7*x_15 - 4.51251240466145e-6*x_16 + 2.93982276653559e-6*x_17 + 3.69991062183193e-6*x_18 + 2.78627879309447e-6*x_19 - 1.20799757741178e-5*x_2 + 1.99037362478203e-5*x_20 + 1.4730010684155e-5*x_21 - 9.0746161624566e-6*x_22 - 4.69423434155495e-6*x_23 + 1.26915672956695e-6*x_24 + 6.66405781457861e-6*x_25 + 4.64871366219042e-6*x_26 - 5.48160581975797e-6*x_27 - 6.01800836307542e-6*x_28 + 5.27375891929841e-6*x_29 - 6.00236678043158e-6*x_3 - 1.08827219457633e-5*x_30 - 0.000856129816361137*x_31 - 0.000122285120471167*x_32 - 1.17256575036841e-5*x_33 - 0.000154808863223613*x_34 - 2.22107039532612e-5*x_35 + 2.96353188650185e-5*x_36 + 2.02983295107743e-6*x_37 + 1.61567233058671e-7*x_38 + 6.60955660552714e-6*x_39 + 7.31362831230382e-6*x_4 - 4.56350150368143e-8*x_40 + 7.54702637463712e-6*x_41 + 6.73229686853199e-6*x_42 - 4.04114708470446e-6*x_43 + 2.17411552409551e-6*x_44 + 2.6724343388169e-7*x_45 - 1.068981601719e-5*x_46 + 1.29142994141411e-5*x_47 - 8.14392319940115e-6*x_48 - 1.18479904450626e-5*x_49 - 4.37595356417379e-6*x_5 + 8.7578416148336e-6*x_50 + 1.19421074734758e-6*x_51 - 2.09640277935162e-6*x_52 + 1.43575843563374e-6*x_53 + 1.41099148020101e-5*x_54 - 2.88567642533456e-6*x_55 - 2.87991771560116e-5*x_56 + 6.86053945566301e-6*x_57 + 3.119749901909e-6*x_58 + 1.9838279672468e-6*x_59 - 1.8064245956762e-6*x_6 - 1.50718425186822e-5*x_60 - 6.56125038042565e-6*x_61 + 2.45701818557251e-5*x_62 - 1.40026445040085e-5*x_63 - 1.14385220245066e-5*x_64 + 2.86641576155562e-5*x_65 - 3.32397328237139e-6*x_66 - 3.51329088166161e-6*x_67 - 1.33366849338342e-5*x_68 + 1.20893837197151e-5*x_69 - 1.43509474041342e-6*x_7 - 7.9463359495982e-6*x_70 + 4.74977728551588e-6*x_71 - 1.78985081457496e-5*x_72 - 2.14226859272368e-6*x_73 + 2.22695568105896e-5*x_74 - 2.62846662428908e-6*x_75 + 8.04007008891224e-6*x_76 - 1.08738631259192e-5*x_77 + 1.33032390863239e-6*x_78 + 2.74402586996437e-6*x_79 + 3.22583816049624e-7*x_8 - 7.65013537166614e-6*x_80 + 1.76765267806472e-5*x_81 - 6.92410310865119e-6*x_82 + 4.86840735198405e-6*x_83 - 2.75023743653203e-5*x_84 - 1.00150229159629e-5*x_85 - 1.19366156240008e-5*x_86 + 1.38887626933418e-5*x_87 - 7.4249590022337e-6*x_88 - 6.11326648937909e-6*x_89 + 4.12711364588414e-5*x_9 - 2.67556713958672e-6*x_90 - 2.33603233616183e-5*x_91 + 1.18712906416307e-5*x_92 - 1.23496094462353e-5*x_93 + 3.14185395906479e-6*x_94 + 5.57378520789683e-6*x_95 + 3.27313505050581e-6*x_96 + 1.30667619980875e-5*x_97 - 3.22465465847877e-5*x_98 - 1.76210239890735e-5*x_99 + 0.000878056355960612*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 2.68550133851477e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 2.38769194335125e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.000212758253882309*std::sin(0.228479996323586*x_59 + 5.0370397567749) + 0.00551310019508225*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.000648102153068868*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.021999534172782);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.01976559766278e-7*x_1 - 1.89598382977723e-6*x_10 + 1.14455020625808e-5*x_100 + 2.87157237591882e-6*x_101 - 5.37252151205087e-5*x_102 + 1.14755407066617e-5*x_103 - 8.47365485157064e-7*x_104 + 1.46135504919418e-5*x_105 - 2.66056802531481e-6*x_106 + 8.80813259788748e-6*x_107 + 3.3338311830171e-7*x_108 - 3.48391797369735e-5*x_109 + 6.65184599939006e-6*x_11 + 2.25141094844125e-5*x_110 - 3.08298187082655e-5*x_111 - 1.80410688545926e-6*x_112 + 8.94084853930259e-6*x_113 - 5.52816854073099e-6*x_114 - 1.64793443869212e-5*x_115 - 2.48144870018716e-6*x_116 + 2.11801767774057e-5*x_117 - 3.77605200309789e-5*x_118 - 1.78728460561242e-5*x_119 + 2.04934473648492e-5*x_12 + 7.52130671859376e-6*x_120 + 2.07064308991903e-5*x_13 - 2.48290697480053e-6*x_14 + 8.38711825157879e-7*x_15 + 5.44715137412269e-6*x_16 + 4.62541247375384e-6*x_17 + 1.50849415974913e-5*x_18 + 5.17235965481178e-6*x_19 - 1.87156164734342e-5*x_2 + 2.02635270124337e-5*x_20 + 2.57410752594806e-5*x_21 + 1.7978442056507e-6*x_22 + 5.14344528889938e-6*x_23 + 2.56726691504726e-6*x_24 + 1.48106129180197e-5*x_25 + 1.45175953099265e-5*x_26 - 9.49982377139922e-6*x_27 + 2.08406081245839e-6*x_28 + 7.56866502269311e-6*x_29 - 1.05544238386084e-5*x_3 + 7.61841804182014e-7*x_30 - 0.00145310769279706*x_31 - 0.000187573884555836*x_32 - 2.30378040405665e-5*x_33 - 0.000262040988616306*x_34 + 6.02851275047262e-6*x_35 + 2.13733317594316e-5*x_36 - 1.55221080514404e-6*x_37 - 2.56936120280306e-6*x_38 + 2.26909526317305e-5*x_39 + 9.44087368736536e-6*x_4 - 7.83131020079238e-6*x_40 + 5.83880600056974e-6*x_41 + 1.05604775508769e-5*x_42 - 7.19941746285555e-6*x_43 + 5.72513510401856e-6*x_44 + 3.81910603709091e-6*x_45 - 8.17542972355497e-6*x_46 + 1.95616496460254e-5*x_47 - 1.347746099137e-5*x_48 - 1.73917136319997e-5*x_49 + 1.21247462278318e-7*x_5 + 1.8120406118286e-5*x_50 + 3.505780263943e-6*x_51 - 1.67751403032954e-5*x_52 + 4.680670730256e-6*x_53 + 1.03479773748911e-5*x_54 - 5.33578059295929e-6*x_55 - 5.25328252588097e-5*x_56 + 8.2829692944426e-7*x_57 + 4.57504831820709e-6*x_58 + 2.96638770126325e-6*x_59 - 5.00574643472339e-6*x_6 - 1.14855665318809e-5*x_60 - 1.22579160687636e-6*x_61 + 3.15237926490011e-5*x_62 - 1.58677731693819e-5*x_63 - 1.96924400377905e-5*x_64 + 5.94047604318095e-5*x_65 - 3.12631046010952e-6*x_66 - 6.11556755528053e-6*x_67 - 1.46961329844912e-5*x_68 + 2.28696624486562e-5*x_69 - 2.42785521073283e-6*x_7 - 1.26660178764586e-5*x_70 + 1.3063012131799e-7*x_71 - 2.05616183546676e-5*x_72 - 3.23608591828499e-6*x_73 + 4.42679010464904e-6*x_74 - 1.50644869844752e-6*x_75 + 4.913774983266e-6*x_76 - 7.31034525710854e-6*x_77 + 1.40263832968273e-5*x_78 + 1.18335474094255e-5*x_79 + 1.89615798501564e-5*x_8 - 4.0263370850326e-6*x_80 + 2.20712833298695e-6*x_81 - 2.80606742840095e-6*x_82 + 1.67403597032933e-5*x_83 - 3.97933261796509e-5*x_84 - 1.05793640393997e-5*x_85 - 1.02137172671723e-5*x_86 + 2.29420344331567e-5*x_87 - 5.16586269570556e-6*x_88 - 1.47478362057266e-5*x_89 + 6.33187686695238e-5*x_9 - 1.21988173143773e-6*x_90 - 1.11286662726107e-5*x_91 + 2.42323653722212e-5*x_92 - 3.15990919942869e-6*x_93 + 4.24305582146147e-6*x_94 + 1.94506414393305e-6*x_95 + 4.22307393319874e-6*x_96 + 4.41916199526945e-6*x_97 - 2.24296098339445e-5*x_98 - 1.97501202736347e-5*x_99 + 0.00144135604251466*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 1.3175013398873e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 9.07078950250983e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.000104378754365861*std::sin(0.228479996323586*x_59 + 5.0370397567749) + 0.00904992057198549*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.000317957560774972*std::sin(0.337039858102798*x_94 - 4.41983985900879) - 0.0202501056638595);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.97981383548542e-6*x_1 + 8.40848522805387e-6*x_10 - 3.06685045244167e-6*x_100 - 4.15962833376847e-6*x_101 - 5.45365800186898e-6*x_102 + 9.41107369738952e-6*x_103 + 2.75384083607819e-6*x_104 + 2.92849165249379e-6*x_105 + 6.28517995331689e-6*x_106 + 6.76185148479607e-6*x_107 - 4.37092274382971e-6*x_108 + 7.49765870543994e-6*x_109 + 5.327007171522e-6*x_11 + 1.30425984915226e-5*x_110 - 1.27816863088206e-5*x_111 - 8.06455843954065e-6*x_112 + 1.10779731594426e-5*x_113 - 6.15210893459631e-6*x_114 + 1.51868953464955e-6*x_115 - 9.8780099530728e-6*x_116 + 3.16446361180863e-5*x_117 - 8.72867565007966e-6*x_118 - 4.95489438056957e-5*x_119 - 7.12933066217362e-6*x_12 - 1.99056611937805e-5*x_120 + 1.49934445004079e-5*x_13 + 5.69647952532907e-6*x_14 - 1.16972253055573e-7*x_15 + 1.35580445048239e-5*x_16 + 6.20713849014876e-7*x_17 + 9.59001236777781e-6*x_18 - 9.47882535648036e-8*x_19 - 2.86232243537075e-6*x_2 - 1.03971410347286e-5*x_20 + 6.35870907150154e-6*x_21 + 2.22996236600071e-5*x_22 + 1.29117828754955e-5*x_23 + 1.84623157665551e-6*x_24 + 8.28358493378157e-6*x_25 + 8.95589590618609e-6*x_26 - 1.3912845013539e-6*x_27 + 1.48146881350526e-5*x_28 + 2.05008907161141e-7*x_29 - 4.50378096195326e-6*x_3 + 1.55367666357581e-5*x_30 - 0.00043969654648866*x_31 - 2.41106213445335e-5*x_32 + 1.55338309881062e-5*x_33 - 8.47424224464459e-5*x_34 + 4.88612028613923e-5*x_35 - 2.7047153641452e-5*x_36 - 3.55092894863249e-6*x_37 - 2.12532542666343e-9*x_38 + 1.44704591241821e-5*x_39 - 3.26380586882262e-6*x_4 - 1.53495958299094e-5*x_40 - 2.13735644635489e-6*x_41 - 3.82108755875941e-6*x_42 - 2.13980770076824e-6*x_43 + 2.93777258860971e-6*x_44 + 1.19724167902539e-5*x_45 + 7.45345129766678e-6*x_46 + 2.54635502315644e-6*x_47 - 2.71726682520847e-6*x_48 - 1.56824394534969e-6*x_49 + 7.74986957779234e-6*x_5 + 7.75535689309276e-6*x_50 + 5.85848871252869e-6*x_51 - 1.93206264482716e-5*x_52 + 3.95213151553315e-6*x_53 - 1.31431591744658e-5*x_54 - 2.87680078838363e-6*x_55 - 1.90808936006527e-5*x_56 - 1.29052628969138e-5*x_57 - 5.74412717606357e-7*x_58 + 5.60608379046424e-7*x_59 - 3.48663790098703e-6*x_6 + 1.07159264036355e-5*x_60 + 8.12623525250508e-6*x_61 - 2.81219167746196e-6*x_62 + 3.52537989428532e-6*x_63 - 7.83568467583519e-6*x_64 + 2.58305551144846e-5*x_65 - 7.79352750340314e-7*x_66 - 6.29945051436654e-7*x_67 + 3.72104370703246e-6*x_68 + 1.13981430584786e-5*x_69 + 1.32265923644467e-6*x_7 - 2.28882037250103e-6*x_70 - 8.70213710407901e-6*x_71 + 1.96742449233779e-6*x_72 - 1.87189413621855e-7*x_73 - 3.63483302134921e-5*x_74 - 3.04974236578854e-7*x_75 - 8.49113293514848e-6*x_76 + 1.03801182564521e-5*x_77 + 1.81948798003802e-5*x_78 + 1.1580667207576e-5*x_79 + 2.01334601507519e-5*x_8 + 8.22429453225119e-6*x_80 - 2.75222207859632e-5*x_81 + 5.36092867590038e-6*x_82 + 1.06201471728539e-5*x_83 - 3.66482469326643e-6*x_84 + 2.13462673132247e-6*x_85 + 9.95520409215874e-6*x_86 + 6.64211241114895e-6*x_87 + 5.78697511930059e-6*x_88 - 7.04278386033725e-6*x_89 + 1.12796174628859e-5*x_9 + 3.45868951880079e-6*x_90 + 2.2451491940754e-5*x_91 + 1.16176172473403e-5*x_92 + 1.07640684808799e-5*x_93 + 2.28857379894766e-6*x_94 - 9.38591502136759e-6*x_95 - 1.03515841851888e-6*x_96 - 6.96672525952299e-6*x_97 + 3.190971444713e-5*x_98 + 5.15981578377159e-6*x_99 + 0.000370747220169156*std::sin(0.194159999489784*x_1 + 4.98071956634521) - 3.33253110638918e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 8.9174485149031e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) + 0.000264019045172389*std::sin(0.228479996323586*x_59 + 5.0370397567749) + 0.00232783073428656*std::sin(0.240879982709885*x_91 + 7.95879983901978) - 0.000804252284012752*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0267415792937689);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.64102289978849e-6*x_1 - 1.24207883056991e-5*x_10 - 9.76284017438495e-6*x_100 + 3.80950950441588e-6*x_101 + 4.74591279916015e-5*x_102 - 1.94209069786546e-5*x_103 - 6.03824406258989e-6*x_104 - 1.58217915568282e-5*x_105 - 6.46056325667348e-6*x_106 - 1.10679957414602e-5*x_107 + 6.00147703164968e-6*x_108 + 1.78149296236019e-5*x_109 - 1.12443891942456e-5*x_11 - 3.41922874084174e-5*x_110 + 4.41655930167933e-5*x_111 + 1.27249029501298e-5*x_112 - 2.77648716252145e-5*x_113 + 1.16618026394057e-5*x_114 + 1.29415421988934e-5*x_115 + 1.60792205147627e-5*x_116 - 4.14000197777301e-5*x_117 + 4.09785221661241e-5*x_118 + 8.12312570158796e-5*x_119 - 2.29427968747467e-5*x_12 + 2.22811769518876e-5*x_120 - 3.72255960832475e-5*x_13 - 5.35181261181695e-6*x_14 - 2.23314661052552e-7*x_15 - 2.31523997260267e-5*x_16 - 6.10843852829463e-6*x_17 - 2.48324266354034e-5*x_18 - 5.97891698982192e-6*x_19 + 1.84058366699345e-5*x_2 + 3.01917859356625e-6*x_20 - 2.74193549521566e-5*x_21 - 3.30407099714669e-5*x_22 - 2.13028910565382e-5*x_23 - 4.65926148734705e-6*x_24 - 2.37779067671484e-5*x_25 - 1.91477467768558e-5*x_26 + 1.08497237771888e-5*x_27 - 2.12096228405408e-5*x_28 - 6.15585629103587e-6*x_29 + 1.69683412266702e-5*x_3 - 2.27123802935315e-5*x_30 + 0.00174691252111021*x_31 + 0.000178112491358224*x_32 - 2.44804091595324e-6*x_33 + 0.000296754572212201*x_34 - 7.73574784483071e-5*x_35 + 2.26869864967139e-5*x_36 + 4.92977291613278e-6*x_37 - 5.48684260798102e-6*x_38 - 3.5349713488182e-5*x_39 + 1.48552307894724e-6*x_4 + 2.6278426508282e-5*x_40 - 7.72553702408195e-6*x_41 + 9.16957253001441e-7*x_42 + 9.14103691678519e-6*x_43 - 2.53559080490399e-6*x_44 - 1.7570067572722e-5*x_45 - 3.0565997913301e-6*x_46 - 2.14370080259746e-5*x_47 + 1.90125350696134e-5*x_48 + 1.64864183049757e-5*x_49 - 1.07857863371309e-5*x_5 - 2.5071936312645e-5*x_50 - 9.99104914934767e-6*x_51 + 3.9697956875917e-5*x_52 - 7.15904434130896e-6*x_53 + 1.63574684470238e-5*x_54 - 1.84388770536308e-6*x_55 + 6.73037779050543e-5*x_56 + 7.61984369296505e-6*x_57 - 5.81297375519127e-6*x_58 - 3.63148244778818e-6*x_59 + 1.00135860356004e-5*x_6 - 2.88243637355324e-6*x_60 + 1.19409729569473e-6*x_61 - 1.82861414821102e-5*x_62 + 7.67619660235213e-6*x_63 + 2.28415739521829e-5*x_64 - 8.09362299264389e-5*x_65 + 3.41304361382442e-6*x_66 + 4.91326156782035e-6*x_67 + 8.38814953777741e-6*x_68 - 3.25254388911969e-5*x_69 + 8.41925847245706e-9*x_7 + 1.41331046789062e-5*x_70 + 1.28259303263916e-5*x_71 + 1.40517083028231e-5*x_72 + 2.83801087598989e-6*x_73 + 4.96823034534869e-5*x_74 + 1.623225893175e-6*x_75 + 7.90095164104453e-6*x_76 - 8.27585418455108e-6*x_77 - 3.68632155428247e-5*x_78 - 2.5256561564326e-5*x_79 - 4.20380194593374e-5*x_8 - 8.69494213476332e-6*x_80 + 3.66719831275299e-5*x_81 - 5.25423997584572e-6*x_82 - 2.87286547332691e-5*x_83 + 3.30947455547803e-5*x_84 + 5.75403074877288e-6*x_85 - 5.7471263435274e-6*x_86 - 2.53397731500654e-5*x_87 - 7.42085232956683e-6*x_88 + 1.93530071704855e-5*x_89 - 6.46881035623184e-5*x_9 - 3.73184942410387e-6*x_90 - 1.71058007357883e-5*x_91 - 3.40316476863168e-5*x_92 - 1.05499486737768e-5*x_93 - 5.01317758523147e-6*x_94 + 1.17241479390915e-5*x_95 - 3.92405335636125e-6*x_96 + 7.78161549278164e-6*x_97 - 2.88794771933579e-5*x_98 + 5.72602757550356e-6*x_99 - 0.00164100981246366*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 3.66392352774939e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) + 4.98847117419622e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.000290273536990077*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 0.010303497555493*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.000884228465262038*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0803482486511224);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.67919613993353e-6*x_1 + 6.52528454530336e-6*x_10 - 5.22833302141939e-6*x_100 - 3.32787359735948e-6*x_101 + 9.63474011933014e-6*x_102 + 3.09345262970285e-6*x_103 + 2.76221061826524e-6*x_104 - 1.60202473897064e-6*x_105 + 3.7490336388463e-6*x_106 + 2.28129612372029e-6*x_107 - 4.11570388278776e-6*x_108 + 1.22706069626664e-5*x_109 + 2.98632768492182e-6*x_11 + 2.94881848073691e-6*x_110 - 1.24915312284355e-6*x_111 - 6.12211525544896e-6*x_112 + 6.40550639570887e-6*x_113 - 2.6584296855006e-6*x_114 + 2.8775377957781e-6*x_115 - 1.08403835980061e-6*x_116 + 1.11692766591194e-5*x_117 + 5.47381667203967e-6*x_118 - 2.81354516177459e-5*x_119 - 6.11340186925336e-6*x_12 - 1.34725429291043e-5*x_120 + 3.57075883495932e-6*x_13 + 4.39659720927883e-6*x_14 - 4.53412687340579e-8*x_15 + 8.76202504584826e-6*x_16 - 3.16094950932801e-7*x_17 + 5.17909945261435e-6*x_18 + 5.15212085116915e-8*x_19 + 2.34754419945675e-6*x_2 - 1.10159558389772e-5*x_20 - 1.04016827892355e-6*x_21 + 1.28144599845479e-5*x_22 + 8.59557855861502e-6*x_23 + 2.28951872245344e-7*x_24 + 1.81436828354334e-6*x_25 + 2.97356518437861e-6*x_26 + 4.13897524200135e-7*x_27 + 8.70393240758895e-6*x_28 - 1.42970255461928e-6*x_29 - 2.08711483879496e-7*x_3 + 1.30784599908492e-5*x_30 + 5.70279129630628e-5*x_31 + 2.5007384392614e-5*x_32 + 1.44124768707905e-6*x_33 + 1.52713165801057e-5*x_34 + 3.18548142986784e-5*x_35 - 2.26731097866098e-5*x_36 - 3.00577181862501e-6*x_37 - 3.87746939622535e-7*x_38 + 6.02686289761198e-6*x_39 - 3.54450835386488e-6*x_4 - 6.15209488059988e-6*x_40 - 4.05517515647136e-6*x_41 - 2.80842760675751e-6*x_42 + 4.71816587049808e-7*x_43 + 2.27309623272972e-7*x_44 + 3.10168438332702e-6*x_45 + 7.27501641922415e-6*x_46 - 2.23672345197163e-6*x_47 + 6.67219950409376e-7*x_48 + 2.82832118753897e-6*x_49 + 5.30099941181426e-6*x_5 + 1.81180418903479e-6*x_50 + 6.95310445965206e-7*x_51 - 8.66426079952123e-6*x_52 + 1.15864289185187e-6*x_53 - 1.13253289634192e-5*x_54 + 9.07089931795369e-7*x_55 - 5.7247135880723e-8*x_56 - 6.74229204306648e-6*x_57 - 5.64845171508103e-7*x_58 - 3.16510027158758e-7*x_59 - 1.33929132309002e-6*x_6 + 1.02314118982111e-5*x_60 + 5.15448239307344e-6*x_61 - 9.29533384559741e-6*x_62 + 6.28199372970406e-6*x_63 + 8.48049576176191e-7*x_64 + 4.09313711856302e-6*x_65 + 1.52236966706799e-6*x_66 + 1.33465359699591e-7*x_67 + 5.96885252740312e-6*x_68 + 7.09150020462952e-7*x_69 + 3.10897073254535e-7*x_7 + 1.10919368224905e-6*x_70 - 5.90486350568707e-6*x_71 + 7.24194844126652e-6*x_72 + 3.70410391567286e-7*x_73 - 2.47120683817519e-5*x_74 + 1.71392640364819e-6*x_75 - 6.65336965731696e-6*x_76 + 8.2392381586901e-6*x_77 + 8.11358710031012e-6*x_78 + 4.87019212053321e-6*x_79 + 1.12049207675415e-5*x_8 + 6.54095744645823e-6*x_80 - 1.9684269069937e-5*x_81 + 5.97962333501207e-6*x_82 + 4.7780216929409e-6*x_83 + 7.32587379401385e-6*x_84 + 4.72999630324134e-6*x_85 + 7.96670076120417e-6*x_86 - 1.69075349617044e-6*x_87 + 5.87880178696579e-6*x_88 - 1.74605552653844e-6*x_89 - 7.9317531411788e-6*x_9 + 2.48421891693927e-6*x_90 + 2.35711082425894e-5*x_91 + 1.67084327855776e-6*x_92 + 1.29402678161316e-5*x_93 - 7.44998707558992e-7*x_94 - 5.27636396293335e-6*x_95 - 1.07743961800676e-6*x_96 - 1.06572840304e-5*x_97 + 2.50577585737876e-5*x_98 + 8.77652876666584e-6*x_99 - 0.000103392350660716*std::sin(0.194159999489784*x_1 + 4.98071956634521) - 2.42210717695991e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 1.3619998404173e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) + 0.000191890909267169*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 0.000649175175064932*std::sin(0.240879982709885*x_91 + 7.95879983901978) - 0.000584536247976493*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0771450545474054);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.1185759818829e-7*x_1 - 1.20218535543474e-5*x_10 + 3.69359585847866e-6*x_100 + 7.13892120865342e-6*x_101 - 9.98671502992443e-6*x_102 - 1.39103189886652e-5*x_103 - 4.88942382408774e-6*x_104 + 9.78010732614472e-7*x_105 - 7.22101480567073e-6*x_106 - 2.81340158493036e-6*x_107 + 7.11234870969895e-6*x_108 - 1.69219353016066e-5*x_109 - 5.27223457439811e-6*x_11 - 9.19012856475093e-6*x_110 + 7.73048911855596e-6*x_111 + 7.50288929772635e-6*x_112 - 1.32473640548908e-5*x_113 + 5.96928164584009e-6*x_114 - 3.56074979656412e-6*x_115 + 4.71212638791618e-6*x_116 - 1.57576557523046e-5*x_117 - 7.08352398018659e-6*x_118 + 5.21374984443225e-5*x_119 + 2.98021915695382e-6*x_12 + 2.44103671690139e-5*x_120 - 1.40416669595093e-5*x_13 - 7.16187923974059e-6*x_14 - 1.08904507436227e-6*x_15 - 1.58394091967465e-5*x_16 - 4.26692102921297e-7*x_17 - 5.20462328084519e-6*x_18 - 3.02014647947425e-8*x_19 - 1.60370947591207e-6*x_2 + 2.57302239432426e-5*x_20 + 2.07377922674363e-6*x_21 - 2.53482783095287e-5*x_22 - 1.49763840977001e-5*x_23 - 1.85241035582375e-6*x_24 - 6.93307956664813e-6*x_25 - 5.4780836368566e-6*x_26 + 8.52488673960008e-7*x_27 - 1.63398488375828e-5*x_28 + 1.94014902438543e-6*x_29 + 3.6595276013405e-6*x_3 - 1.95553827442484e-5*x_30 - 2.35023874991116e-5*x_31 - 2.45520926691135e-5*x_32 - 2.83702637453871e-5*x_33 + 6.29864128990293e-6*x_34 - 5.72993504344869e-5*x_35 + 3.50728439468325e-5*x_36 + 3.75270836527431e-6*x_37 - 4.38289127543126e-6*x_38 - 1.15514595393206e-5*x_39 + 8.71857171378549e-6*x_4 + 9.22620598343161e-6*x_40 + 2.99684738105727e-7*x_41 + 5.09592215414095e-6*x_42 + 5.06778129106367e-6*x_43 + 1.25408486679955e-6*x_44 - 8.93205756182259e-6*x_45 - 1.11133635732323e-5*x_46 + 2.52298981619644e-6*x_47 + 5.19926534000916e-6*x_48 - 2.10282083822989e-6*x_49 - 9.60518546137243e-6*x_5 + 9.62743821301315e-7*x_50 - 1.04452698075811e-5*x_51 + 1.77799787634209e-5*x_52 - 1.93731267111492e-6*x_53 + 2.15098480657129e-5*x_54 - 6.88400950939438e-6*x_55 + 6.78284956480716e-6*x_56 + 9.32805986504903e-6*x_57 - 7.82897091609353e-7*x_58 + 1.87616102548659e-7*x_59 + 3.08223752382559e-6*x_6 - 1.31454822663694e-5*x_60 - 5.54271263612783e-6*x_61 + 1.37364117674133e-5*x_62 - 9.60973367628356e-6*x_63 - 3.6424164334377e-8*x_64 - 1.45605505112253e-5*x_65 - 1.53154456017197e-6*x_66 - 4.81271940251566e-6*x_67 - 8.49872661683651e-6*x_68 - 5.91151431146122e-6*x_69 - 2.98117465027884e-6*x_7 - 5.19383116431531e-7*x_70 + 1.00324348981499e-5*x_71 - 1.20317038918564e-5*x_72 - 1.83071349596114e-6*x_73 + 4.58184325418553e-5*x_74 - 1.22394573442942e-6*x_75 + 1.04082803943686e-5*x_76 - 1.53777743081385e-5*x_77 - 1.67978948627242e-5*x_78 - 7.44559281012255e-6*x_79 - 2.17009308979546e-5*x_8 - 1.22775038897856e-5*x_80 + 3.51204948426013e-5*x_81 - 8.84267568048147e-6*x_82 - 1.04012740700134e-5*x_83 - 9.20030606341469e-6*x_84 - 6.65011814100047e-6*x_85 - 1.4427803638763e-5*x_86 + 2.81032614832485e-7*x_87 - 1.11506765408777e-5*x_88 + 4.82361722917616e-6*x_89 + 5.48784473441723e-6*x_9 - 4.05418086126737e-6*x_90 + 1.53135554640279e-5*x_91 - 5.71321520963462e-6*x_92 + 1.74188805997311e-7*x_93 + 1.23144261208322e-6*x_94 + 1.6748546405676e-5*x_95 + 2.60971709733584e-7*x_96 + 2.32616377367527e-5*x_97 - 4.46061345604518e-5*x_98 - 1.11961867864338e-5*x_99 - 6.96722425712563e-6*std::sin(0.194159999489784*x_1 + 4.98071956634521) + 4.38596826303411e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) - 8.40911870807223e-7*std::sin(1.5881599187851*x_29 + 0.188880011439323) - 0.000347477372602035*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 4.37454898542573e-5*std::sin(0.240879982709885*x_91 + 7.95879983901978) + 0.00105848224083784*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.042950537480626);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.87535458586328e-6*x_1 + 6.31090621272306e-6*x_10 - 1.95462075227575e-5*x_100 - 5.80830188757712e-6*x_101 + 6.34762028441218e-5*x_102 - 6.38598653660298e-6*x_103 + 1.76713617689342e-6*x_104 - 1.70687307069561e-5*x_105 + 5.15042016259629e-6*x_106 - 4.31064798678423e-6*x_107 - 4.65332462155061e-6*x_108 + 4.641725576302e-5*x_109 - 2.78916409955748e-6*x_11 - 2.03825860255632e-5*x_110 + 3.28152663792832e-5*x_111 - 3.28149585181348e-6*x_112 - 6.88526461274179e-6*x_113 + 2.77697509345545e-6*x_114 + 1.94343881616221e-5*x_115 + 6.37158714050828e-6*x_116 - 5.73170914049831e-6*x_117 + 4.67321266146202e-5*x_118 - 4.51370457167526e-6*x_119 - 3.42510077779537e-5*x_12 - 1.73059030266549e-5*x_120 - 1.93762198223938e-5*x_13 + 6.58993959004251e-6*x_14 - 2.25277847434653e-7*x_15 + 2.25611913135065e-6*x_16 - 5.88095603186897e-6*x_17 - 1.05999669881233e-5*x_18 - 5.78162525727975e-6*x_19 + 2.12978931679497e-5*x_2 - 2.85517990961901e-5*x_20 - 2.69350474808176e-5*x_21 + 7.00336676724052e-6*x_22 + 3.03210864939008e-6*x_23 - 2.7061380033695e-6*x_24 - 1.44181506586478e-5*x_25 - 9.43412608442174e-6*x_26 + 1.04624474673587e-5*x_27 + 5.09903383793743e-6*x_28 - 8.98421685828621e-6*x_29 + 1.26065945351432e-5*x_3 + 1.14296803443508e-5*x_30 + 0.0016133680069112*x_31 + 0.000214536759402172*x_32 + 1.90326243405498e-5*x_33 + 0.000279703769110195*x_34 + 1.67471015184272e-5*x_35 - 3.86399178910034e-5*x_36 - 2.27769213040263e-6*x_37 - 2.81265734743763e-6*x_38 - 1.59472182600687e-5*x_39 - 9.67584225559494e-6*x_4 + 5.30380467325133e-6*x_40 - 1.37273109119985e-5*x_41 - 8.68309137638075e-6*x_42 + 7.33692845512055e-6*x_43 - 2.37146142624172e-6*x_44 - 3.2560184551011e-6*x_45 + 1.54077914261359e-5*x_46 - 2.39610260547005e-5*x_47 + 1.63743188783273e-5*x_48 + 2.07690046226971e-5*x_49 + 4.45201662292097e-6*x_5 - 1.84303183886119e-5*x_50 - 2.68806357520012e-6*x_51 + 1.06455143158429e-5*x_52 - 3.07194875029952e-6*x_53 - 1.63526435729943e-5*x_54 + 2.00939547266165e-6*x_55 + 5.5438069296787e-5*x_56 - 1.08180007930687e-5*x_57 - 6.33090175379569e-6*x_58 - 3.77315173648103e-6*x_59 + 4.90680571140365e-6*x_6 + 2.21799112192266e-5*x_60 + 1.26100201667412e-5*x_61 - 3.92983790398439e-5*x_62 + 2.22853542428998e-5*x_63 + 2.06082926888033e-5*x_64 - 5.747552982369e-5*x_65 + 5.57213784408255e-6*x_66 + 6.44842138348771e-6*x_67 + 2.1858013132548e-5*x_68 - 2.37356367330245e-5*x_69 + 2.30729095870116e-6*x_7 + 1.47277777813794e-5*x_70 - 4.28879174865334e-6*x_71 + 2.96430750373675e-5*x_72 + 3.87567917941042e-6*x_73 - 2.28851649020163e-5*x_74 + 4.16607096750291e-6*x_75 - 1.02783244142922e-5*x_76 + 1.47479003584255e-5*x_77 - 9.20982294265869e-6*x_78 - 9.18920898647667e-6*x_79 - 8.2016100629496e-6*x_8 + 9.66538940757127e-6*x_80 - 1.91664194859688e-5*x_81 + 9.22872153480797e-6*x_82 - 1.28222089709885e-5*x_83 + 4.63365141233773e-5*x_84 + 1.60586596473596e-5*x_85 + 1.6641135037191e-5*x_86 - 2.49865652477222e-5*x_87 + 8.85050241578219e-6*x_88 + 1.21882183261316e-5*x_89 - 7.32745400800855e-5*x_9 + 3.2376589673473e-6*x_90 + 2.70464897155754e-5*x_91 - 2.38653111054017e-5*x_92 + 1.46830035938226e-5*x_93 - 5.37239873807562e-6*x_94 - 6.64697259507263e-6*x_95 - 5.96808951190515e-6*x_96 - 1.84035136137367e-5*x_97 + 4.17414680011867e-5*x_98 + 2.63079685957502e-5*x_99 - 0.00161276001383986*std::sin(0.194159999489784*x_1 + 4.98071956634521) - 3.26618591498986e-5*std::sin(1.97079980373383*x_27 - 8.98295974731445) + 1.28286729981625e-6*std::sin(1.5881599187851*x_29 + 0.188880011439323) + 0.000258762861951339*std::sin(0.228479996323586*x_59 + 5.0370397567749) - 0.0101261240085144*std::sin(0.240879982709885*x_91 + 7.95879983901978) - 0.000788240949080614*std::sin(0.337039858102798*x_94 - 4.41983985900879) + 0.0640330607929153);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
