
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.14680042741921e-5*x_1 + 0.000101496085525886*x_10 + 0.000119538772726342*x_100 - 0.000135943436134301*x_101 + 6.28179416476018e-5*x_102 + 0.000152449198399176*x_103 + 0.000111981034915276*x_104 - 3.51210384491458e-5*x_105 - 6.27061293596302e-5*x_106 + 1.63518528723513e-5*x_107 - 6.51395079710685e-6*x_108 + 1.58568594518437e-7*x_109 + 8.8883029467946e-5*x_11 + 0.000126959151363599*x_110 + 1.31860520201918e-5*x_111 + 0.000126685183740098*x_112 - 5.00587659858393e-5*x_113 + 0.000114384046398902*x_114 + 3.54854983628538e-5*x_115 - 2.8000946802094e-5*x_116 + 6.01266896798565e-5*x_117 - 1.68836222253489e-5*x_118 + 7.2870548055642e-5*x_119 + 0.000221161149329177*x_12 + 0.000115715346669166*x_120 + 1.58855078079436e-6*x_13 - 3.27231090022334e-5*x_14 + 1.94559680836582e-5*x_15 + 8.01558211538373e-5*x_16 + 3.51138388483867e-5*x_17 + 7.83415251700033e-5*x_18 + 4.14816468916551e-5*x_19 - 6.93361322323556e-5*x_2 - 1.21420155237657e-6*x_20 + 3.50144213894805e-5*x_21 - 0.000270297610426091*x_22 + 3.85820126287214e-5*x_23 - 4.64942273092103e-5*x_24 + 6.42501038350312e-5*x_25 + 4.44665064715929e-5*x_26 - 0.000317711549956783*x_27 + 5.86462886740973e-6*x_28 - 0.000151841541239902*x_29 - 6.66642588578518e-5*x_3 + 0.000338882426656758*x_30 + 9.22551072696346e-6*x_31 + 9.06366922182578e-5*x_32 + 0.000164790086946292*x_33 + 0.000114382883265489*x_34 - 0.000145256851072219*x_35 + 0.000117527460939541*x_36 - 8.8886010551783e-5*x_37 + 0.000191175552143624*x_38 + 8.1427572267785e-5*x_39 + 9.10966457154303e-6*x_4 + 5.44896073981067e-5*x_40 - 7.79374643235365e-5*x_41 + 2.89359605027682e-5*x_42 + 5.33243438567165e-5*x_43 - 0.000176007518371399*x_44 + 0.000153737365407135*x_45 + 8.656103559689e-5*x_46 + 7.42161792294763e-5*x_47 + 0.000171092595724918*x_48 + 0.000463465248915946*x_49 - 3.59726964990466e-5*x_5 + 2.75622012418256e-5*x_50 - 0.000114837820440974*x_51 + 4.80226145877447e-5*x_52 - 1.0528386869797e-5*x_53 - 0.000129630706789089*x_54 - 0.000268275041528706*x_55 - 0.000284897896293408*x_56 - 2.30859258772427e-5*x_57 - 0.000379840021348104*x_58 - 0.000317095228306024*x_59 + 4.19585359285393e-5*x_6 + 5.01153095009126e-5*x_60 - 7.10834530579006e-5*x_61 + 1.07229409198575e-5*x_62 + 9.86942556295582e-5*x_63 - 1.75028850476335e-6*x_64 + 6.4696583868829e-5*x_65 + 0.000170131925814085*x_66 + 2.55054899109712e-5*x_67 - 4.2392711776757e-5*x_68 - 2.15571797528305e-5*x_69 - 2.80841039142791e-5*x_7 - 8.67444732124285e-6*x_70 - 0.000141074756767268*x_71 + 2.34558347643227e-5*x_72 + 6.80706516045016e-5*x_73 - 0.00011757674739112*x_74 - 4.37017276201208e-5*x_75 - 2.82500216009183e-5*x_76 + 2.44032431191159e-5*x_77 + 5.42679693885831e-6*x_78 - 6.74686729384054e-6*x_79 - 5.33990294660972e-5*x_8 - 4.53210031152489e-5*x_80 - 4.30290267476123e-5*x_81 - 1.44225345242758e-5*x_82 - 6.14581697117234e-5*x_83 - 3.04372622423578e-5*x_84 - 9.58944209698491e-5*x_85 + 3.9287166635566e-5*x_86 - 4.38986671197165e-5*x_87 - 1.13423005892478e-5*x_88 - 2.29686428421725e-5*x_89 - 5.25883956564501e-5*x_9 - 3.8450833487797e-5*x_90 - 2.28560612617145e-6*x_91 + 1.1260021862283e-5*x_92 + 4.06817805143791e-5*x_93 + 4.13304602829322e-5*x_94 - 0.000101823725605698*x_95 + 6.61374136206808e-5*x_96 - 2.24303155362708e-5*x_97 + 0.000214075130880069*x_98 + 0.000284452262008787*x_99 - 6.00281008736185e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) - 4.28621008424882e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) - 8.6965863357602e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) - 0.000202095283162207*std::sin(0.472559869289398*x_14 - 1.83487987518311) - 0.000103862095947074*std::sin(0.911839842796326*x_28 + 4.78895998001099) + 3.59643819228015e-7*std::sin(2.75216007232666*x_62 + 4.60391998291016) - 5.81679732338156e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 0.000103794123161325*std::sin(1.75111997127533*x_73 - 1.76647984981537) + 0.000104387838607699*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 2.62237272780359e-5*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0318818631909573 - 1.36194151641551e-6*std::exp(-4.89391994476318*x_113) - 1.66360008848259e-6*std::exp(-4.83752012252808*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.94249865439689e-5*x_1 - 9.16243810235948e-6*x_10 - 9.69024876094467e-5*x_100 - 0.000101004984744241*x_101 + 7.00724328343382e-5*x_102 + 0.000105583742500594*x_103 - 0.000176156455292489*x_104 - 9.66909850713943e-5*x_105 + 6.02458030789705e-6*x_106 + 0.000186781849503081*x_107 - 1.25512767927061e-5*x_108 + 0.000185226282872075*x_109 + 0.00012374911946398*x_11 + 0.00011744501134427*x_110 - 3.57397625675368e-5*x_111 + 0.000127475008347877*x_112 + 1.6381450642301e-6*x_113 + 0.000190504344883426*x_114 - 2.41393531183766e-6*x_115 + 7.0465567482491e-6*x_116 - 6.48731296549573e-5*x_117 - 0.000108267630962364*x_118 - 3.36136502822024e-5*x_119 + 0.000106760893666188*x_12 + 4.46805670148485e-5*x_120 - 0.000261699185321056*x_13 + 3.66903534348315e-5*x_14 + 0.000114683649870816*x_15 + 8.64916207275432e-5*x_16 + 8.53660016480475e-5*x_17 + 7.24793667676308e-5*x_18 - 0.00067675498910047*x_19 + 0.000211945163684986*x_2 - 0.000170383712303888*x_20 - 2.55226506426689e-5*x_21 - 0.00035505492508434*x_22 + 0.00026212260642426*x_23 - 0.000101969114924237*x_24 + 0.000133233414936814*x_25 + 0.000341949576844381*x_26 - 0.000291989315264155*x_27 + 0.00018094698377724*x_28 + 0.000263387295406811*x_29 + 0.000142503861310392*x_3 + 8.65845099299207e-5*x_30 + 0.000161947357007915*x_31 + 2.78945339323063e-5*x_32 + 0.000271213355824146*x_33 + 5.33643697747077e-6*x_34 - 2.60895904890865e-5*x_35 + 0.00040145270811177*x_36 + 6.61230743329586e-5*x_37 + 9.19597348793306e-5*x_38 + 9.61647051826007e-5*x_39 + 8.67357792941384e-5*x_4 - 0.000167741834791462*x_40 + 0.000220453219235072*x_41 - 0.000268650814204027*x_42 - 0.000128525528526305*x_43 - 0.000399855640152433*x_44 - 0.000128264082443747*x_45 - 0.000119629997706273*x_46 + 1.70696069015361e-5*x_47 + 0.000137420458057835*x_48 - 2.39503501891981e-5*x_49 + 3.24666434039361e-5*x_5 - 2.80619379293139e-5*x_50 - 7.64386870642768e-5*x_51 + 5.82519744770889e-5*x_52 - 3.51876758284337e-5*x_53 - 0.000698443065593047*x_54 - 0.000385705421180644*x_55 + 0.000298982097626936*x_56 + 1.84690605039307e-5*x_57 + 1.6985090624571e-5*x_58 - 0.000568002585818106*x_59 + 8.0591899185862e-5*x_6 + 2.63572287402894e-6*x_60 + 0.000102171148835042*x_61 - 2.17284442514492e-5*x_62 + 3.02746254747395e-5*x_63 + 2.47431663560009e-5*x_64 - 8.86120413188217e-5*x_65 + 3.50708597826997e-5*x_66 - 5.53776542326298e-5*x_67 + 0.000118901441362454*x_68 + 6.33063716120654e-5*x_69 + 0.000219470974886173*x_7 - 8.68277088932905e-6*x_70 + 6.1993442002124e-5*x_71 - 8.44990696436798e-5*x_72 + 9.77430507342185e-5*x_73 - 6.80800583816886e-5*x_74 - 6.30714202596534e-5*x_75 - 6.4607406547973e-5*x_76 + 4.13772193870293e-6*x_77 - 2.29814581971655e-5*x_78 - 3.25003665601926e-5*x_79 + 0.000106785835656186*x_8 - 8.35736985318769e-5*x_80 + 5.48047223615992e-5*x_81 + 0.000117518416692175*x_82 + 0.000280236188927116*x_83 + 0.000136199199776811*x_84 - 2.50803995064944e-5*x_85 + 6.85687597897428e-5*x_86 - 4.25971811751195e-5*x_87 - 6.54005186501644e-6*x_88 + 0.000103213436598754*x_89 + 0.000119885788346473*x_9 + 9.72530172341028e-5*x_90 - 5.24029895042212e-5*x_91 + 0.000111306469559932*x_92 + 0.000242053243573076*x_93 + 0.000251100545534245*x_94 + 1.66935445944092e-6*x_95 - 2.50568915523569e-5*x_96 - 0.000118902213377657*x_97 - 6.96494006570995e-5*x_98 + 0.000182164508477449*x_99 - 5.69611979490702e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) + 0.000155447330435117*std::sin(2.30183982849121*x_102 + 1.37711989879608) + 7.2067643216107e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) + 0.000732935895432196*std::sin(0.472559869289398*x_14 - 1.83487987518311) + 0.00037667508663888*std::sin(0.911839842796326*x_28 + 4.78895998001099) + 1.30151803759947e-6*std::sin(2.75216007232666*x_62 + 4.60391998291016) - 5.51961063143302e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 7.51771199021563e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 4.08583995526094e-6*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000137172969182551*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.00732458895072341*std::sin(0.00459578530508064*x_1 - 0.00825180070171064*x_10 - 0.0167785770625897*x_100 - 0.0428293878193021*x_101 - 0.00708432274586045*x_102 - 0.000474700140874704*x_103 + 0.00527201040913232*x_104 - 0.010849767414288*x_105 + 0.00100678912708073*x_106 + 0.000603888682816489*x_107 + 0.00624626217598326*x_108 + 0.00548440683812382*x_109 - 0.00236449606594851*x_11 - 0.00141220971430137*x_110 + 0.000181888650709718*x_111 - 0.00408925727163238*x_112 - 0.00511652783779276*x_113 + 0.000647497256234857*x_114 - 0.00681104017956939*x_115 + 0.00883810820319169*x_116 + 0.00221331505719787*x_117 + 0.00951413051363373*x_118 + 0.00585809394811144*x_119 + 0.00293237743702286*x_12 + 0.000525356831252105*x_120 - 0.0172244808497191*x_13 + 0.000802143656629558*x_14 + 0.011076114702975*x_15 + 0.018410592887666*x_16 + 0.000124503752438141*x_17 + 0.00951539239296671*x_18 + 0.0474965885248977*x_19 - 0.00416997273456724*x_2 - 0.00465915788892672*x_20 + 0.00753516557606119*x_21 - 0.00424581145241296*x_22 - 0.00555775586058097*x_23 - 0.00480079006199186*x_24 - 0.00576249252904765*x_25 - 0.0129552133095888*x_26 - 0.0294013521475416*x_27 + 0.00754203894665257*x_28 - 0.0145897894158458*x_29 - 0.00259573852029629*x_3 + 0.0601326281536377*x_30 + 0.000881623991821743*x_31 + 0.00366489298368651*x_32 + 0.0230526041367002*x_33 - 0.00300822360957746*x_34 + 0.00483728907651138*x_35 - 0.00179206305986638*x_36 - 0.0272211013223646*x_37 + 0.00786848290276432*x_38 - 0.000314994767319059*x_39 - 0.00277415655024547*x_4 + 0.00250056785831808*x_40 - 0.0124978566928728*x_41 - 0.0083297322729681*x_42 + 0.00772019698483246*x_43 - 0.0128961954719054*x_44 + 0.00100759656428321*x_45 + 0.024853286943366*x_46 + 0.00711238276534474*x_47 + 0.0106613294565067*x_48 + 0.019214450253856*x_49 + 0.00379885764904124*x_5 + 0.00909098107721114*x_50 - 0.0137138202057735*x_51 + 0.00193040571746293*x_52 + 0.00154701432843039*x_53 - 0.00536011980601665*x_54 - 0.0147468821442737*x_55 - 0.0440853272902604*x_56 + 0.00669083252875391*x_57 + 0.0331385114768824*x_58 + 0.0223661889660193*x_59 - 0.0153839369257643*x_6 + 0.0125635815636757*x_60 + 0.00274848658662948*x_61 + 0.000551957814572576*x_62 + 0.00368756288215283*x_63 + 0.00104499417664802*x_64 - 0.00439331532578689*x_65 + 0.000841277551788533*x_66 - 0.00245395588468124*x_67 + 9.72786702360613e-5*x_68 - 0.00075087690987261*x_69 + 0.00363000706005228*x_7 - 0.00715994687906163*x_70 + 0.00279989617059213*x_71 - 0.00179120241251157*x_72 - 0.000797740094088925*x_73 - 0.00522371488147236*x_74 + 4.37834642426399e-6*x_75 - 0.00157015643095046*x_76 - 0.00261712741888512*x_77 - 0.0012658862683856*x_78 + 0.00351264075326997*x_79 - 0.000167648897004261*x_8 - 0.00331978022251489*x_80 + 0.00029547737820297*x_81 - 0.00414963600973624*x_82 - 0.0193693464314117*x_83 - 0.00757394853610044*x_84 - 3.53634014984691e-5*x_85 - 0.00133228381647499*x_86 + 0.0009798972628532*x_87 - 0.000378863229058054*x_88 + 0.00233885533974233*x_89 - 0.00321834142654164*x_9 - 0.0047632837439874*x_90 - 0.00256239138804058*x_91 + 0.00433049417103777*x_92 + 0.00077393716050982*x_93 - 0.00137408806639972*x_94 + 0.00337570211079324*x_95 + 0.00357595526860168*x_96 - 0.0103044874925612*x_97 + 0.00372451347274633*x_98 - 0.0112341724851492*x_99 + 7.80040512049693) + 0.0668093648060716 - 2.37601977838277e-7*std::exp(-4.89391994476318*x_113) - 1.20493010116487e-6*std::exp(-4.83752012252808*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.50635025910561e-5*x_1 + 5.8858983176875e-5*x_10 + 2.76935202867964e-5*x_100 - 7.88776591606681e-5*x_101 - 3.96068958335095e-5*x_102 + 0.000124503032915656*x_103 + 8.15970739636431e-5*x_104 + 0.000200175729779234*x_105 - 4.42006582447815e-5*x_106 + 0.000255939467503391*x_107 + 0.00014737210269908*x_108 - 5.57080815384743e-6*x_109 + 6.65013014424172e-5*x_11 + 0.000245545989146168*x_110 + 3.07188645889102e-5*x_111 + 8.57732115707852e-5*x_112 + 4.24779885711954e-5*x_113 + 2.25507744286978e-5*x_114 + 2.76975080703623e-5*x_115 + 7.00638373910056e-5*x_116 - 0.000117663979067731*x_117 - 0.000198994013887483*x_118 - 0.000206803569303589*x_119 - 2.5509543314298e-5*x_12 - 0.000104591977015947*x_120 + 0.000106403981570466*x_13 - 0.000136331511526569*x_14 - 0.000150154124294289*x_15 - 8.63270080584955e-5*x_16 - 8.9533850370276e-5*x_17 - 8.21472989654189e-5*x_18 - 0.00141997275405054*x_19 + 0.000327591810748499*x_2 - 1.50797650471258e-5*x_20 - 4.26160839124615e-5*x_21 - 0.000210351269751211*x_22 + 0.000191852053621812*x_23 + 0.000280827544749579*x_24 + 0.000172952384889926*x_25 + 0.000358705460919674*x_26 + 0.00060607518541615*x_27 - 1.34247887090946e-5*x_28 + 0.000371380350698919*x_29 + 0.000193060137500424*x_3 - 0.00105966250630216*x_30 + 5.16012651999837e-5*x_31 - 0.000116639928342682*x_32 - 0.00030912838818697*x_33 - 2.35434707594303e-5*x_34 - 0.000116092175746813*x_35 + 0.000257735436307728*x_36 + 0.000337698095394237*x_37 - 0.000254754809615541*x_38 + 5.39979063504512e-5*x_39 + 1.07884063351572e-5*x_4 - 4.01292610907676e-5*x_40 + 0.000158134391177422*x_41 - 0.000237415184624846*x_42 + 3.41346547939439e-5*x_43 + 0.000414644833000697*x_44 + 0.000141623728526748*x_45 - 3.87233212786962e-5*x_46 + 0.000186101664154032*x_47 - 5.43116146949671e-5*x_48 - 0.000505206593075937*x_49 - 6.57777637283455e-5*x_5 - 3.87920569950595e-5*x_50 + 0.000212055468680685*x_51 + 0.000174399949991015*x_52 - 7.04278407959288e-5*x_53 - 0.000156120789242746*x_54 + 0.000418482708898537*x_55 + 0.000546177676322755*x_56 + 9.92699114739373e-5*x_57 + 0.000228952230137758*x_58 + 4.66314945476548e-6*x_59 + 8.29145330850979e-5*x_6 + 6.04643273190525e-5*x_60 + 8.60818028309217e-5*x_61 + 0.000116856431341174*x_62 + 4.12180611738064e-5*x_63 - 8.97994750876646e-5*x_64 - 1.27393793408542e-5*x_65 - 0.000107319069808487*x_66 - 2.29058766813059e-5*x_67 + 0.000111443410015268*x_68 + 9.89624328753059e-5*x_69 + 0.000122060766644171*x_7 + 0.000108593135566337*x_70 - 4.19442726077705e-5*x_71 + 3.77006737260866e-5*x_72 - 9.03687722763311e-6*x_73 + 7.22535645120269e-5*x_74 - 4.24937902091213e-5*x_75 - 4.00818611000404e-5*x_76 - 2.4809850007097e-5*x_77 - 5.38313509000952e-5*x_78 - 0.000103842364033878*x_79 + 4.56100756381449e-5*x_8 + 6.69987599040444e-6*x_80 - 7.51607707131509e-5*x_81 + 3.98368742475549e-5*x_82 + 0.000291882225259828*x_83 + 0.000102316497865574*x_84 + 8.22204133667584e-5*x_85 - 1.97938579211137e-6*x_86 - 3.94853430532649e-5*x_87 + 2.84727937075373e-5*x_88 + 8.53213894832466e-6*x_89 + 0.000261325484327889*x_9 + 8.27944513840296e-5*x_90 + 6.03250351883707e-5*x_91 - 9.42120930261575e-6*x_92 - 2.26348433803507e-5*x_93 - 0.000249663155344323*x_94 - 8.27345313017269e-6*x_95 + 0.000208552718690342*x_96 + 8.31632187806807e-5*x_97 - 6.82151260028984e-5*x_98 + 2.08319827243037e-5*x_99 - 1.06788828728341e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) + 4.42288077953837e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) + 0.000135457606887898*std::sin(1.18727993965149*x_117 + 7.21080017089844) + 0.000208539321676796*std::sin(0.472559869289398*x_14 - 1.83487987518311) + 0.000107173857290616*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 1.18319134044841e-5*std::sin(2.75216007232666*x_62 + 4.60391998291016) - 1.03479697687231e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) + 3.26841902262217e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) + 7.05203919582081e-6*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000428795521106395*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0337605457105288 + 1.33199531571126e-6*std::exp(-4.89391994476318*x_113) + 5.23858385197909e-7*std::exp(-4.83752012252808*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.64883361565283e-5*x_1 + 0.000113708355391751*x_10 + 3.5379706747918e-5*x_100 - 0.000156094980938994*x_101 + 3.01553476819293e-5*x_102 + 0.000206715062359175*x_103 + 0.000380736027019884*x_104 - 1.21288707672871e-5*x_105 + 0.00023060195935943*x_106 + 0.000202483688606051*x_107 + 0.000224880193689413*x_108 + 0.000111680831540932*x_109 + 0.000353173974331127*x_11 - 1.51302714241895e-5*x_110 + 3.98964062737734e-5*x_111 + 0.000102223281436865*x_112 - 4.82491177994274e-5*x_113 + 0.000145130864927098*x_114 - 9.85776635598194e-5*x_115 - 5.47626253010793e-5*x_116 + 0.000102072222427305*x_117 + 0.000172202965471894*x_118 + 0.000176736038957572*x_119 + 0.000136750710047815*x_12 + 0.000160236797445026*x_120 + 0.000308762531628188*x_13 - 8.38145402956878e-6*x_14 - 1.97348072320829e-5*x_15 + 0.000136970066113047*x_16 - 3.35345966517929e-5*x_17 + 0.00021751820713243*x_18 + 0.00118307014042897*x_19 - 7.39255265678559e-5*x_2 - 0.000287847696239401*x_20 + 0.000186515493928627*x_21 + 9.2212983711327e-5*x_22 - 0.000145490746491958*x_23 + 8.90296732054214e-5*x_24 - 3.89443175511048e-5*x_25 - 0.000164405208533737*x_26 - 0.000360645609805551*x_27 - 0.000201298021016729*x_28 - 8.42410118505358e-5*x_29 - 2.42371835805575e-5*x_3 - 0.000368013556893331*x_30 + 5.82496343516755e-5*x_31 + 0.000271692987952401*x_32 + 0.000319980870043068*x_33 + 0.000202632074362205*x_34 + 6.07833896742139e-5*x_35 + 7.19242030544349e-5*x_36 - 9.64574506322047e-5*x_37 + 1.29397062040968e-5*x_38 + 0.000221873363005748*x_39 + 0.000210032171087387*x_4 + 0.000315528729511445*x_40 + 5.97381749462287e-5*x_41 + 0.000413683313917962*x_42 + 0.000688588679398937*x_43 - 0.000131182867262261*x_44 + 0.000131380056363327*x_45 + 0.000630548117447144*x_46 + 0.000670517737739801*x_47 + 0.000423313864070237*x_48 + 0.000666093251577016*x_49 + 7.91702854567476e-5*x_5 + 0.000256527583151504*x_50 - 0.000299245394227357*x_51 + 6.78993236997882e-5*x_52 + 0.000177125290326723*x_53 + 4.16968075199761e-5*x_54 - 0.000100590602602091*x_55 - 0.000940185796601552*x_56 + 0.000106316385912626*x_57 + 0.000261775512970635*x_58 + 0.000302400799077184*x_59 - 0.000346473819904132*x_6 + 0.000193983371830751*x_60 - 2.37402092212028e-5*x_61 + 4.66192306047735e-5*x_62 + 0.000173486220928231*x_63 - 0.00020629399756726*x_64 - 6.40798197318921e-5*x_65 - 4.38908691846821e-5*x_66 - 7.36266540357823e-5*x_67 + 6.65607661825104e-5*x_68 - 6.55532710970995e-5*x_69 + 8.9024587341991e-5*x_7 - 0.000116314775516567*x_70 + 2.04519839274274e-5*x_71 + 8.35524586206739e-5*x_72 + 0.00019089811936604*x_73 - 9.23656820961309e-5*x_74 - 3.14526835935166e-5*x_75 - 7.64751173895221e-5*x_76 - 3.83857904287762e-6*x_77 - 7.24819763210279e-5*x_78 - 4.24071517964577e-5*x_79 + 2.10227230271578e-6*x_8 - 2.25520820009865e-6*x_80 - 5.8206441219447e-5*x_81 - 8.68899338827314e-5*x_82 - 7.39791849153365e-5*x_83 - 6.73334591727852e-5*x_84 + 9.11119206067738e-5*x_85 + 1.33457740781021e-5*x_86 - 3.85714303956476e-5*x_87 + 8.92396226600089e-6*x_88 - 5.75783821847376e-5*x_89 - 3.62941903525877e-5*x_9 - 8.50440006166611e-6*x_90 + 0.000128236113641824*x_91 + 8.94166717350579e-5*x_92 + 2.61357672264226e-5*x_93 - 0.000241617467931178*x_94 - 7.04293475385535e-5*x_95 - 7.62875160456849e-5*x_96 + 1.56611874075173e-5*x_97 - 7.88422412230689e-5*x_98 - 6.38673320000577e-5*x_99 - 6.37486790513105e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) - 5.13806408030223e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) - 0.000116587216914103*std::sin(1.18727993965149*x_117 + 7.21080017089844) - 0.000242260294013616*std::sin(0.472559869289398*x_14 - 1.83487987518311) - 0.000124503954309577*std::sin(0.911839842796326*x_28 + 4.78895998001099) + 3.75455535862454e-5*std::sin(2.75216007232666*x_62 + 4.60391998291016) - 6.17732595697925e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 5.63144738388762e-6*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 0.000108561987141582*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000596937978774237*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0590783264023158 - 2.00936537530185e-6*std::exp(-4.89391994476318*x_113) - 9.02601812200807e-8*std::exp(-4.83752012252808*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.34400944201558e-5*x_1 + 0.000248032614346889*x_10 + 9.56223665537128e-5*x_100 + 0.000513353804133483*x_101 + 0.000130144276398793*x_102 - 0.000143427929727149*x_103 - 0.000232840820847718*x_104 + 6.86153787249139e-5*x_105 - 6.10860389314124e-5*x_106 - 2.04023224935486e-6*x_107 - 0.000228105398769277*x_108 + 3.58055052372528e-5*x_109 - 3.81844326335448e-5*x_11 - 5.7711501743349e-5*x_110 - 1.54605370606816e-5*x_111 - 0.000152646458497113*x_112 + 3.63800474675882e-5*x_113 - 7.41524676254441e-5*x_114 + 0.000120669131320773*x_115 - 0.000245331694659778*x_116 + 0.000127312480076074*x_117 + 0.00012546283189757*x_118 + 0.000162437026224213*x_119 - 6.35368853941919e-5*x_12 + 8.96763961079769e-6*x_120 + 0.000329341463411173*x_13 + 0.000211709055400137*x_14 + 5.41735035980762e-5*x_15 - 0.000133854541102228*x_16 + 2.57372131795189e-5*x_17 + 2.80984123026514e-5*x_18 + 8.14513603985958e-5*x_19 + 0.000148885830889183*x_2 - 4.45563319259841e-5*x_20 + 2.15955418424086e-5*x_21 + 0.000545371579232478*x_22 + 0.000146846430606697*x_23 + 0.00015503278856684*x_24 + 3.21293251575106e-5*x_25 - 6.12602783870137e-6*x_26 + 0.000652799108957048*x_27 + 0.000144192276190013*x_28 - 6.5051442771261e-5*x_29 - 3.79388736576387e-6*x_3 - 0.000344219474921595*x_30 - 7.60801063100079e-5*x_31 - 8.50305657435941e-5*x_32 - 0.000475184685151182*x_33 + 1.50457094151583e-5*x_34 + 1.04448249786913e-5*x_35 - 0.00066292732756366*x_36 + 0.000349146048390812*x_37 - 0.00012529059696337*x_38 - 0.000100187139483229*x_39 + 9.69373649765457e-5*x_4 + 0.000126624133372572*x_40 + 0.000363140029972868*x_41 + 0.000145630990211302*x_42 - 0.000129639286188417*x_43 + 0.000197738090742327*x_44 - 0.000103709112105839*x_45 - 0.000231155596574683*x_46 - 0.000268180273710654*x_47 + 1.54351319997082e-5*x_48 - 3.63742455177433e-5*x_49 + 8.78050571596759e-5*x_5 - 4.86076899708224e-5*x_50 + 0.000111714364153224*x_51 + 0.000160080915536754*x_52 + 8.83250675498726e-5*x_53 + 4.30735704069214e-5*x_54 + 8.80211773675159e-5*x_55 + 0.000931099423787344*x_56 + 1.37495708516741e-5*x_57 - 0.000870426834680449*x_58 - 0.000118248360530452*x_59 + 0.000114151056148293*x_6 - 0.000278060128496192*x_60 - 6.17130339124926e-5*x_61 - 4.52714262399438e-5*x_62 - 0.000119198625205033*x_63 - 9.02771551644377e-5*x_64 - 0.000215316915649587*x_65 - 0.000214916286976302*x_66 - 7.63351375664511e-5*x_67 - 0.000107499805263013*x_68 + 5.42680809830733e-5*x_69 - 9.40658615536008e-5*x_7 - 1.98365943222706e-5*x_70 + 7.52914661102297e-5*x_71 - 4.11670515505074e-6*x_72 + 3.82416086402767e-5*x_73 + 6.63061605483305e-5*x_74 + 2.43598657413979e-5*x_75 + 6.75506174247801e-5*x_76 - 1.78943053873168e-5*x_77 - 2.75987737652708e-5*x_78 - 5.81244588178852e-5*x_79 - 0.000146591278297494*x_8 + 8.2319060143067e-5*x_80 - 9.92176634290968e-5*x_81 - 7.77623776217016e-6*x_82 + 0.000239445357687921*x_83 - 7.69506959783139e-5*x_84 + 6.62006887155058e-5*x_85 - 1.07044458025626e-5*x_86 - 2.15418954010218e-5*x_87 - 2.54056260971456e-5*x_88 - 3.90111191544623e-5*x_89 + 3.35965126550719e-5*x_9 + 7.74545471440701e-5*x_90 - 0.00010661946554464*x_91 - 0.000327927549319897*x_92 - 0.000239742228730804*x_93 - 0.000159245972728716*x_94 + 3.74318593763113e-5*x_95 - 0.000818997170716643*x_96 + 9.57027114600667e-5*x_97 - 0.000439029868134446*x_98 - 7.95438309217775e-5*x_99 + 0.000100661462420961*std::sin(1.11151993274689*x_1 - 2.1865599155426) + 6.81355056328193e-6*std::sin(2.30183982849121*x_102 + 1.37711989879608) - 2.51502476176671e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) + 3.21259668415857e-5*std::sin(0.472559869289398*x_14 - 1.83487987518311) + 1.65103816293188e-5*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 4.60945801000844e-6*std::sin(2.75216007232666*x_62 + 4.60391998291016) + 9.75422038439417e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) + 1.75423324856316e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 0.000163892605480494*std::sin(2.29767990112305*x_78 + 0.972239851951599) + 0.000210226379478893*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0348060318386075 - 3.01412535799722e-6*std::exp(-4.89391994476318*x_113) + 2.81166457082823e-7*std::exp(-4.83752012252808*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.85772477082348e-6*x_1 + 0.000145992270364303*x_10 + 8.57544090199453e-5*x_100 - 0.000210694912397968*x_101 + 7.17097842971778e-5*x_102 + 0.000113058058282313*x_103 + 0.000218583175474707*x_104 + 0.000285231292415121*x_105 + 0.000121596649180187*x_106 - 3.09565919093155e-5*x_107 + 9.89053179900631e-6*x_108 + 0.000130949931438381*x_109 + 5.52721196188097e-5*x_11 - 6.29166755331842e-5*x_110 + 0.000132102004369007*x_111 - 4.56077057183664e-6*x_112 + 2.23734161871323e-5*x_113 - 3.48879801958204e-5*x_114 - 3.97790970495288e-5*x_115 - 0.000211916518676065*x_116 - 6.11363302888465e-5*x_117 - 0.000226398143051605*x_118 - 9.24398804116964e-5*x_119 + 6.71310102437319e-5*x_12 - 1.79912698355574e-5*x_120 + 0.000617568247115142*x_13 - 6.99929287492063e-6*x_14 - 2.04467445392085e-5*x_15 - 2.87522144411861e-5*x_16 + 0.000233112064362143*x_17 + 0.000297949410633974*x_18 - 1.14719088952879e-5*x_19 - 3.73149252422415e-6*x_2 + 7.43782939684957e-5*x_20 + 0.000167686457102208*x_21 + 0.000492862499522179*x_22 - 0.000190732261060886*x_23 - 0.000226881922230702*x_24 - 0.000163833136757673*x_25 - 0.000321281836456715*x_26 - 0.000412246330960701*x_27 - 0.000566809480244416*x_28 - 3.31548450797414e-6*x_29 - 1.63310000746215e-5*x_3 - 0.000816379657902156*x_30 + 1.77206611901801e-5*x_31 - 2.66942887478646e-5*x_32 - 0.000219230616572925*x_33 - 0.00017812884554965*x_34 + 2.87989800091874e-6*x_35 - 0.000322735670040367*x_36 - 0.000303561922531632*x_37 - 8.04873735606586e-5*x_38 - 2.52893443048506e-5*x_39 + 0.0001773749978751*x_4 + 0.000137697759346745*x_40 + 8.87581319263838e-5*x_41 + 0.000587168944950755*x_42 - 0.000111654911478373*x_43 - 8.30194261525294e-5*x_44 - 0.000198191259921924*x_45 + 0.000175304191888423*x_46 + 0.000312371054459928*x_47 - 0.000393310838353715*x_48 + 8.38722506130043e-5*x_49 + 9.14905560089368e-5*x_5 + 0.000155958750207047*x_50 - 0.000228833277302233*x_51 - 8.52433057709944e-5*x_52 - 8.52145139943166e-5*x_53 + 9.40306306819628e-5*x_54 - 4.77215111176157e-5*x_55 - 0.000535540446486416*x_56 - 0.000454892062134707*x_57 - 0.000446854895856029*x_58 - 9.46778585480248e-5*x_59 - 8.33953474292344e-5*x_6 - 0.000150401881040444*x_60 + 3.48127296803775e-5*x_61 + 2.35874469976108e-5*x_62 - 9.73219195271995e-7*x_63 - 0.000186353767711772*x_64 + 7.92419462227732e-5*x_65 - 0.000128728498695467*x_66 - 8.9297692376684e-5*x_67 + 0.000111792858282561*x_68 - 1.24532269327785e-5*x_69 + 0.000146385865500227*x_7 + 4.34889669128349e-5*x_70 + 0.000148327566001155*x_71 + 7.91548525622371e-5*x_72 + 0.000103941179188464*x_73 + 2.73838744788074e-5*x_74 - 0.000100837716595922*x_75 - 4.68512407874322e-5*x_76 - 3.72713247896924e-5*x_77 + 7.83199973904415e-6*x_78 + 3.68364721575758e-5*x_79 - 4.12626807017268e-5*x_8 - 7.4655098045167e-5*x_80 - 2.71089552245902e-5*x_81 - 3.38323999570431e-6*x_82 - 0.000124770333561266*x_83 - 6.91066716218956e-5*x_84 + 0.000159873609813037*x_85 - 0.000131165079334033*x_86 - 4.52768035734069e-5*x_87 - 1.77294980109495e-5*x_88 + 1.77535681159813e-5*x_89 + 0.000138821670812814*x_9 + 4.05954243825977e-5*x_90 + 1.16249273180822e-5*x_91 + 0.000297026094933305*x_92 + 8.39384828253371e-5*x_93 - 0.000135168260264002*x_94 - 6.69140948884713e-5*x_95 + 3.08781863126479e-5*x_96 - 3.95663879350202e-5*x_97 - 0.000198601847652082*x_98 - 0.000258867159597156*x_99 + 2.89935355658693e-6*std::sin(1.11151993274689*x_1 - 2.1865599155426) - 7.55554512260561e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) - 0.000170471210105937*std::sin(1.18727993965149*x_117 + 7.21080017089844) - 0.000356244794581836*std::sin(0.472559869289398*x_14 - 1.83487987518311) - 0.000183083595304928*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 6.01152738585295e-6*std::sin(2.75216007232666*x_62 + 4.60391998291016) + 2.8095095067223e-6*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 1.62500962161242e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 8.4765766133636e-5*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000280610518612004*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0629868469564511 + 2.29869295296584e-6*std::exp(-4.89391994476318*x_113) - 2.60454645018554e-7*std::exp(-4.83752012252808*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.13359803727022e-6*x_1 + 0.000165719594963189*x_10 + 0.000175310121230436*x_100 - 0.000486455068658982*x_101 - 4.82596719484398e-5*x_102 - 0.000112590463048451*x_103 + 2.38311018696027e-7*x_104 + 0.0003637098527441*x_105 - 0.000205086912852352*x_106 - 4.92460742426183e-5*x_107 + 7.63594204724802e-5*x_108 + 5.61462943392851e-5*x_109 - 0.00019230920796056*x_11 + 1.47231270529357e-5*x_110 + 0.000144057856091526*x_111 + 8.69424702554093e-5*x_112 + 0.000117166995166277*x_113 - 1.00350914885822e-5*x_114 - 2.06581109799243e-6*x_115 - 9.8950289217002e-5*x_116 - 3.37909341622719e-5*x_117 - 0.000189548000269375*x_118 - 8.84840629546989e-5*x_119 - 8.2845647034187e-5*x_12 + 4.4575176695326e-5*x_120 + 0.000317520740141878*x_13 - 0.000163450296153808*x_14 - 0.000135194061739289*x_15 - 0.000223227933422594*x_16 - 4.72766434767296e-5*x_17 + 0.000186999801608512*x_18 - 0.000815277921069933*x_19 + 0.000144837131973382*x_2 - 8.52237350172064e-5*x_20 - 0.000100858765907953*x_21 - 0.000318741758174719*x_22 - 0.000127420348649192*x_23 + 6.24579263652046e-5*x_24 - 0.000220656479743324*x_25 - 0.000265159104770063*x_26 + 0.00011081676489833*x_27 - 0.000634649768869684*x_28 - 0.000120338239517431*x_29 + 0.00014602089544378*x_3 - 3.69488012677417e-5*x_30 - 0.000161397656885393*x_31 - 0.000108389544152338*x_32 - 0.000292846307867598*x_33 - 0.000281161630019773*x_34 - 0.000162096020883986*x_35 - 0.000150264369149976*x_36 - 4.92548931598963e-5*x_37 - 8.10978903211104e-5*x_38 - 7.36929057049876e-5*x_39 - 0.000106619864133909*x_4 + 8.68821395434068e-5*x_40 - 3.64937553298024e-5*x_41 + 0.000191791520669477*x_42 - 0.000606374110540591*x_43 + 0.00011644606442246*x_44 - 5.72444668463675e-5*x_45 - 0.000232866676615977*x_46 + 4.94465051256269e-5*x_47 + 5.89617259326016e-5*x_48 + 5.3707852802013e-6*x_49 - 9.09726837811541e-5*x_5 - 7.11451654709444e-6*x_50 - 3.77059195073204e-5*x_51 + 0.000294970646439277*x_52 - 1.41090414811799e-5*x_53 - 8.59066711003683e-5*x_54 - 5.78193604525509e-6*x_55 + 0.000116198134165212*x_56 - 0.000436986898834971*x_57 - 0.00119442764736926*x_58 - 0.000409735735663359*x_59 - 9.03634627489143e-5*x_6 + 0.000180646597662016*x_60 + 9.26933644468205e-6*x_61 + 2.61701052058887e-5*x_62 + 1.08604554046946e-6*x_63 - 0.000147616372017305*x_64 + 3.08162852188722e-5*x_65 - 0.000160678001460222*x_66 + 2.55464423554661e-5*x_67 - 3.20630962234881e-5*x_68 - 4.34423410020642e-5*x_69 - 8.4034011173115e-5*x_7 + 8.36747359920949e-5*x_70 - 4.76181737095517e-5*x_71 + 0.00010234281856564*x_72 - 3.83921301064035e-5*x_73 + 3.6354395567027e-5*x_74 - 6.38517540047048e-5*x_75 - 7.64065815823871e-5*x_76 - 6.71699027768146e-5*x_77 + 5.42270284663158e-6*x_78 + 2.7211319125637e-5*x_79 - 0.00020810344917749*x_8 + 2.29069996796282e-5*x_80 - 0.000145586291279358*x_81 - 2.37836158897379e-5*x_82 + 0.000121548733868194*x_83 - 3.33411980564446e-5*x_84 + 4.3339941075041e-5*x_85 - 0.000146473436484759*x_86 - 9.23442350825153e-5*x_87 + 3.28610867284012e-5*x_88 - 2.41766134473251e-5*x_89 + 0.000118522516173362*x_9 + 8.04274830568374e-5*x_90 - 0.000160531901538663*x_91 - 5.33318339697876e-5*x_92 - 9.89348533132515e-6*x_93 - 0.000251858672980757*x_94 + 1.39142600494561e-5*x_95 + 0.00013113502206594*x_96 - 7.56391027842561e-5*x_97 - 2.04017640134937e-5*x_98 + 0.000157077085817347*x_99 + 1.36469343647695e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) - 3.74140507781356e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) - 4.56277168628031e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) - 0.000176407666391314*std::sin(0.472559869289398*x_14 - 1.83487987518311) - 9.06605522199561e-5*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 5.01453817661889e-5*std::sin(2.75216007232666*x_62 + 4.60391998291016) + 1.32240484256669e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 0.000130136443674918*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 3.46527361158874e-5*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000229704219299398*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0237768210869754 + 2.43487630200372e-6*std::exp(-4.89391994476318*x_113) - 2.08581172631432e-6*std::exp(-4.83752012252808*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.21102015997506e-5*x_1 - 0.000334279219472539*x_10 + 4.73462437429373e-5*x_100 + 0.000422144624508322*x_101 - 6.91919494060227e-5*x_102 - 8.02007737123015e-5*x_103 - 6.40135285447078e-5*x_104 + 3.31479582156539e-5*x_105 - 0.000282705221633353*x_106 - 0.000102808260744098*x_107 + 0.000109257329234812*x_108 - 0.000246850354170933*x_109 - 4.11452951129236e-5*x_11 - 3.93751042510851e-5*x_110 + 7.49479768272065e-5*x_111 + 0.000155782683901783*x_112 + 0.000144368974934263*x_113 - 4.37302594609552e-5*x_114 + 5.56789402243807e-5*x_115 + 0.000154122864240629*x_116 + 1.47308433042697e-7*x_117 - 6.37751284364817e-5*x_118 - 0.00016556279990836*x_119 - 9.54348289097986e-5*x_12 - 7.1464185287192e-6*x_120 - 3.20126025484743e-5*x_13 - 0.000236761764107034*x_14 - 0.000227271745216243*x_15 - 0.00025451585566413*x_16 - 7.75717679770943e-5*x_17 - 0.000196731310587563*x_18 - 0.00114370554394093*x_19 + 0.000169644883597811*x_2 + 8.09115973996774e-5*x_20 - 0.00016340687945822*x_21 - 0.000367228245904155*x_22 + 0.000290020288555465*x_23 + 0.000141367300592129*x_24 - 8.15455436120061e-5*x_25 + 0.000441150400921508*x_26 + 0.000614420507230689*x_27 - 0.000176213759509483*x_28 + 0.00057126102957382*x_29 + 0.000253229077173318*x_3 - 0.000945258778468639*x_30 + 2.13580551565419e-5*x_31 - 0.000211717030638362*x_32 - 0.000323243079577169*x_33 + 1.76553594595143e-5*x_34 - 0.000138572139307618*x_35 + 0.000598318851438784*x_36 + 0.000357632318846165*x_37 - 9.09456700949018e-5*x_38 + 3.51526779429129e-5*x_39 - 0.000121813918779405*x_4 - 5.55443569495135e-5*x_40 - 0.000150259874458216*x_41 - 0.0001498939851604*x_42 - 7.26452931744403e-5*x_43 + 0.000420498632637271*x_44 + 9.90691787329251e-5*x_45 - 0.000212228457438719*x_46 + 0.000200289225640921*x_47 - 0.000178226694060207*x_48 - 0.000732650050222211*x_49 - 0.000199100171960353*x_5 - 0.00018417419716377*x_50 + 0.000613232820163544*x_51 + 1.93069260800891e-5*x_52 + 5.20479293365491e-5*x_53 + 0.000420398054080793*x_54 + 0.000658438295447424*x_55 + 6.27887828342149e-5*x_56 + 0.000196512215538414*x_57 + 0.000718489212606006*x_58 + 0.000259853580774938*x_59 + 0.000147300887197372*x_6 - 4.38934855098506e-5*x_60 - 6.49593846806497e-5*x_61 + 1.81643699714442e-6*x_62 - 6.14069366246723e-5*x_63 - 3.86758833653051e-5*x_64 + 0.00021179174967*x_65 + 8.1495116759865e-5*x_66 + 0.000139796336895776*x_67 - 8.66869832315204e-6*x_68 + 7.8502460567949e-5*x_69 - 3.34665520150918e-5*x_7 + 0.000258503687995409*x_70 - 0.000150385977340883*x_71 - 3.55107231761815e-6*x_72 - 0.000112247201323363*x_73 + 9.16782351756113e-5*x_74 + 0.000104312444740547*x_75 - 1.52483725825867e-6*x_76 - 4.89935806238972e-6*x_77 + 7.22475892971283e-5*x_78 - 2.59992338501423e-5*x_79 - 7.00872195136711e-5*x_8 + 0.000139515067812496*x_80 + 2.42425927920714e-5*x_81 + 8.44865447921186e-5*x_82 + 1.63725966922827e-5*x_83 + 8.64569530567964e-5*x_84 - 9.12728393431121e-5*x_85 + 3.72826161665815e-5*x_86 + 2.99350573652837e-5*x_87 - 2.21665272967148e-5*x_88 - 1.26401111105609e-5*x_89 - 0.000143228235297751*x_9 + 8.25762305678608e-5*x_90 + 0.000161733137734804*x_91 - 0.000183093831674925*x_92 - 3.03352327107247e-5*x_93 - 0.000200274052727618*x_94 + 4.52178659739498e-5*x_95 + 0.000410118723875769*x_96 + 3.91939691874663e-5*x_97 + 0.000447032649650229*x_98 + 0.000270670878330105*x_99 - 3.41142427569544e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) + 3.52953423299748e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) + 4.92640443068989e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) + 0.000166417932445637*std::sin(0.472559869289398*x_14 - 1.83487987518311) + 8.55265644825043e-5*std::sin(0.911839842796326*x_28 + 4.78895998001099) + 8.98191982020647e-7*std::sin(2.75216007232666*x_62 + 4.60391998291016) - 3.30571237586912e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) + 7.08991948703357e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) + 0.000185614925292063*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000192724020212227*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0496546209757218 + 6.01616705451497e-7*std::exp(-4.89391994476318*x_113) + 1.13636401818542e-6*std::exp(-4.83752012252808*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.85984969523551e-5*x_1 - 0.000354568359860639*x_10 - 8.93652402042318e-5*x_100 - 0.000645963655631739*x_101 - 0.000186246425755071*x_102 - 0.000218601392926865*x_103 - 6.58838649339588e-5*x_104 - 2.16051942704476e-5*x_105 - 0.000315367141984676*x_106 - 4.43966194334645e-5*x_107 + 0.000239891991524833*x_108 - 0.000173201212439015*x_109 - 0.000207831636675709*x_11 + 2.79798773220937e-5*x_110 + 0.000190025723587565*x_111 + 0.000221070256182727*x_112 + 0.000200178272209384*x_113 - 4.8338582068219e-5*x_114 - 0.000102169625128779*x_115 + 0.000283313234323727*x_116 - 6.37505075161534e-5*x_117 - 0.00011406491146753*x_118 - 0.000124426351477446*x_119 - 0.000267031751448064*x_12 + 1.67294908750994e-5*x_120 - 0.000606495355603162*x_13 - 0.000281860932942683*x_14 - 0.000299766088299435*x_15 - 0.000303724891184515*x_16 - 0.000223428872044513*x_17 - 0.000121266364960107*x_18 - 0.000733378947611033*x_19 - 0.000106068631354814*x_2 - 5.49443445018381e-5*x_20 - 0.00037355373954563*x_21 - 0.00104700003340539*x_22 - 0.000138717363552885*x_23 - 0.000120736937989803*x_24 - 0.000627297351351793*x_25 - 0.000249391029564498*x_26 - 0.00071682965488366*x_27 - 0.000617331313114302*x_28 - 0.000198835181829927*x_29 + 0.000309483575109135*x_3 - 0.000259417508005544*x_30 - 0.000100272851129468*x_31 - 8.18611124021604e-5*x_32 + 0.000210849215675758*x_33 - 0.000364977928929627*x_34 - 0.000135594732555272*x_35 + 0.00108841230081132*x_36 - 6.08358372686065e-5*x_37 + 8.25037365683339e-6*x_38 + 1.54893893052879e-5*x_39 - 0.000373723825279149*x_4 - 0.000264995465804948*x_40 - 0.000427550596048982*x_41 - 0.000194041932534608*x_42 - 0.000351718480303955*x_43 + 0.000115984577768653*x_44 + 0.000173511371192133*x_45 - 0.000484058921382596*x_46 + 0.000109734362568554*x_47 + 0.000215738751766389*x_48 - 8.41388773660269e-5*x_49 - 0.000272446273605997*x_5 - 0.000226295435576569*x_50 + 0.000344591979821792*x_51 + 9.89349085167114e-5*x_52 + 0.000138652453343983*x_53 + 0.000134953979769666*x_54 - 0.000298858449483196*x_55 - 0.000226855537054476*x_56 - 0.000344896768157742*x_57 - 0.000402638099481607*x_58 - 0.000738238113530177*x_59 - 0.000104868859948567*x_6 + 0.000415126974720106*x_60 - 9.62110942443625e-5*x_61 - 0.000119550678552505*x_62 - 0.000137542228786013*x_63 + 6.67340575876108e-5*x_64 + 0.000220683480321368*x_65 + 8.96501938619458e-5*x_66 + 0.000218565367164949*x_67 - 8.06218718697902e-5*x_68 - 0.000150136285308297*x_69 - 0.000187688405653447*x_7 + 3.23298863001565e-5*x_70 - 0.000113400297170492*x_71 - 2.71518848305368e-5*x_72 - 0.00015022995084337*x_73 - 5.24356614537149e-5*x_74 + 3.00682649340531e-5*x_75 - 7.1952227049322e-5*x_76 - 7.55942759312583e-5*x_77 + 1.67638496917547e-6*x_78 + 0.000115455240446936*x_79 - 4.67120346476553e-5*x_8 + 8.03345091906973e-5*x_80 + 4.66560432438721e-5*x_81 - 1.03716297444718e-5*x_82 + 0.000146599292143015*x_83 + 7.85304436736891e-5*x_84 - 0.00028540425756141*x_85 - 7.22942678187882e-5*x_86 - 4.04439142197101e-5*x_87 + 2.21920429551682e-5*x_88 - 2.85613290568552e-5*x_89 - 0.000134123062913865*x_9 + 6.84022161913287e-5*x_90 - 0.000103481039994763*x_91 - 7.7045133632222e-5*x_92 + 0.000137862334463525*x_93 + 0.000158709665319575*x_94 + 7.74279703765761e-5*x_95 + 0.000675460582168141*x_96 - 0.000257939415747523*x_97 + 0.000713664585459691*x_98 + 0.000426380930274998*x_99 + 3.97607597373944e-6*std::sin(1.11151993274689*x_1 - 2.1865599155426) + 7.64511192969442e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) + 8.87584367995998e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) + 0.000360467879518122*std::sin(0.472559869289398*x_14 - 1.83487987518311) + 0.00018525395003059*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 7.00579041675842e-5*std::sin(2.75216007232666*x_62 + 4.60391998291016) + 3.85286686485424e-6*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 0.000116424446199471*std::sin(1.75111997127533*x_73 - 1.76647984981537) + 0.000193562266777047*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000490508664564223*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0528410222663362 + 2.97581637475604e-6*std::exp(-4.89391994476318*x_113) - 1.86603743159851e-6*std::exp(-4.83752012252808*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.50938650944906e-5*x_1 + 0.000416671902688473*x_10 + 0.000119706218032129*x_100 - 6.83952447793591e-5*x_101 + 2.41223728036955e-5*x_102 + 0.000262433234511789*x_103 + 0.000172681274685904*x_104 - 0.000242451062897639*x_105 + 0.000106842575430076*x_106 + 0.000295042489471894*x_107 - 0.00010547235798191*x_108 - 5.16700806154708e-5*x_109 + 0.00010595630585171*x_11 + 0.000245873330198113*x_110 + 1.25990833990798e-5*x_111 - 0.000110317008193195*x_112 - 0.000173480841589871*x_113 - 0.000134867619041887*x_114 - 0.000127111762606565*x_115 - 4.15727790292574e-5*x_116 - 0.000132429240873526*x_117 - 0.000208537841798932*x_118 - 0.00014044791274736*x_119 + 5.98440889533387e-5*x_12 - 0.000228205088823478*x_120 + 0.00010017159914271*x_13 - 9.13711565415967e-5*x_14 - 0.000198470581480423*x_15 + 9.78182728730845e-5*x_16 + 9.27160738112781e-5*x_17 + 0.000227183401426237*x_18 - 9.85355270121107e-6*x_19 + 6.37269341740211e-5*x_2 + 9.68660783915702e-5*x_20 + 0.000180392922817764*x_21 + 0.000369040636856811*x_22 + 0.000136523270882993*x_23 + 2.05755331034991e-5*x_24 + 0.000171105713040056*x_25 - 0.000473988908127503*x_26 - 0.000673716661774199*x_27 - 9.54757827245422e-5*x_28 + 0.000213692328655751*x_29 + 5.9567824232066e-6*x_3 + 5.30566540051173e-5*x_30 - 2.22375479531129e-5*x_31 + 7.44230083007172e-5*x_32 - 0.000389430623475203*x_33 - 0.000143646119931457*x_34 - 0.000212119633135784*x_35 - 0.000301386462747769*x_36 - 1.70043833888994e-5*x_37 - 0.000338729561023816*x_38 + 8.64902038808593e-5*x_39 + 2.67111566672741e-5*x_4 + 0.000200949429005215*x_40 - 9.22084691479238e-5*x_41 + 2.95094764704434e-5*x_42 + 0.000293546519538869*x_43 + 2.21017196965965e-7*x_44 + 4.89747085020727e-5*x_45 - 0.000223523358999915*x_46 + 0.000163101684196384*x_47 - 0.000367536960103868*x_48 + 0.000327053880717379*x_49 + 1.62617795332413e-5*x_5 - 0.000107237837824257*x_50 - 0.000544726279552736*x_51 - 6.67688378046764e-6*x_52 - 0.000207554803082549*x_53 - 0.000223517835945673*x_54 - 0.000137608099091188*x_55 + 0.000362121726600502*x_56 - 0.000308012087353115*x_57 - 0.000740825966356968*x_58 - 0.000331097086298379*x_59 + 1.44960662888059e-6*x_6 - 0.000225670754253557*x_60 + 2.80568709228205e-5*x_61 + 1.10409095688734e-5*x_62 - 1.00309102426733e-6*x_63 - 8.00219056741245e-5*x_64 - 0.000157081896447525*x_65 - 0.000147151931795667*x_66 - 9.97319872450295e-5*x_67 + 2.85544378381661e-5*x_68 - 4.68554331012832e-6*x_69 + 7.84868161955705e-5*x_7 - 8.75690925682499e-5*x_70 + 7.14028005076086e-5*x_71 + 6.80538387551521e-6*x_72 + 0.000247859946135274*x_73 - 2.51032456813296e-6*x_74 - 0.000124239136298641*x_75 + 2.62944518431573e-5*x_76 - 4.0990953947239e-5*x_77 - 7.47037685181613e-5*x_78 - 4.71403442019933e-5*x_79 - 7.86178861315699e-5*x_8 - 0.000127797043028016*x_80 - 0.000103693396568017*x_81 - 0.000101517702344262*x_82 + 1.48312350213457e-6*x_83 - 7.57008894241786e-5*x_84 + 4.44122486242355e-5*x_85 - 5.04035953118488e-5*x_86 - 5.75771166043484e-5*x_87 - 2.08132319202544e-5*x_88 - 9.00911933799645e-5*x_89 + 0.000166804988197617*x_9 - 1.96693348412856e-5*x_90 - 0.000114155281759962*x_91 - 4.30055437879628e-5*x_92 - 0.000297980989066006*x_93 - 0.000149240654623464*x_94 - 0.000199328493848637*x_95 - 0.000342904692054141*x_96 - 5.93383226781395e-5*x_97 - 0.000220518264421511*x_98 - 0.000154037812882149*x_99 + 4.28966361996132e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) + 3.05956618408692e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) - 0.000124837122567945*std::sin(1.18727993965149*x_117 + 7.21080017089844) + 0.000144258886562469*std::sin(0.472559869289398*x_14 - 1.83487987518311) + 7.41384463948296e-5*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 5.79652480733267e-5*std::sin(2.75216007232666*x_62 + 4.60391998291016) + 4.15673717803128e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 1.78519713015702e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 7.14685814493726e-5*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000348277793707045*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0634233674355498 + 1.92853811870467e-6*std::exp(-4.89391994476318*x_113) - 2.86129311875599e-7*std::exp(-4.83752012252808*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.49520202970712e-5*x_1 - 3.61384668916015e-5*x_10 - 5.31262126231597e-5*x_100 - 0.00081451714692457*x_101 - 3.51569543373612e-5*x_102 + 0.000130815730027108*x_103 + 0.000261145959033376*x_104 + 0.00024026409578004*x_105 - 0.000165294504256149*x_106 + 2.09006492580498e-5*x_107 + 0.000250416345436086*x_108 - 7.20156216963971e-5*x_109 - 7.39656946742903e-6*x_11 + 0.000158277957884807*x_110 + 0.000180898154847095*x_111 + 0.000149961157177087*x_112 + 8.44633429865016e-5*x_113 + 5.40796236587012e-5*x_114 - 3.06550165162239e-5*x_115 + 0.000197348056709213*x_116 + 3.63878369843147e-5*x_117 - 3.42045619446754e-5*x_118 + 2.39374951287796e-5*x_119 + 2.59465299315897e-5*x_12 + 6.49276227678271e-5*x_120 - 0.000139073792648973*x_13 - 0.000101839782523841*x_14 - 0.000146923142492247*x_15 - 5.94200707753988e-5*x_16 - 0.000133487102763507*x_17 - 2.01197880827556e-5*x_18 - 0.000272299571303317*x_19 - 0.00013504610972995*x_2 + 1.31039433651016e-5*x_20 - 7.95917004248833e-5*x_21 - 0.000573648085286862*x_22 - 0.000226872283114764*x_23 - 1.88032396617806e-5*x_24 - 0.000269874993790349*x_25 - 8.0105433898806e-5*x_26 - 0.000353663691432338*x_27 - 0.000359938208694475*x_28 - 0.000540351671288079*x_29 + 4.64916881951583e-5*x_3 - 0.000287265338281531*x_30 - 5.93935835037725e-5*x_31 + 1.03365336874297e-5*x_32 + 0.000202208078647574*x_33 - 7.35206547951882e-5*x_34 - 0.000168268002718526*x_35 + 0.000572631560267072*x_36 - 0.000275228860329117*x_37 + 4.10278597233183e-5*x_38 + 3.81604495670306e-5*x_39 - 0.000152518711548217*x_4 - 3.10775571991548e-5*x_40 - 0.000220433916292383*x_41 + 0.000114845746723455*x_42 + 7.05345503705761e-5*x_43 + 0.000222664322225078*x_44 + 0.000351231105484817*x_45 + 0.000186947150986935*x_46 + 0.000208828819065195*x_47 + 0.000272879271231324*x_48 + 0.000337855247345099*x_49 - 0.000129832030316311*x_5 + 3.18007946878781e-5*x_50 + 0.000100750598302112*x_51 + 0.000103605095479546*x_52 + 3.21143702061774e-5*x_53 + 9.10624817564552e-5*x_54 - 0.000142134054581635*x_55 - 0.000520043935095488*x_56 - 0.000129591192963434*x_57 - 0.000350716313617834*x_58 - 0.000333892406898665*x_59 - 4.1971997301866e-5*x_6 + 0.000344372168519173*x_60 - 9.26609557629193e-5*x_61 + 8.96780221622269e-6*x_62 + 3.49213949046547e-5*x_63 - 3.5900089680712e-5*x_64 + 0.000178051507760655*x_65 + 0.000138412817454758*x_66 + 8.37123552065842e-5*x_67 - 2.53799656239566e-5*x_68 - 0.000102993716489041*x_69 - 0.000110925188459832*x_7 - 3.95192365938931e-5*x_70 - 0.000172004821260079*x_71 + 6.22413639195261e-5*x_72 - 7.64382341634057e-5*x_73 - 0.00013349840697137*x_74 - 1.51131163774849e-5*x_75 - 9.74226210717558e-5*x_76 - 6.43374493099872e-5*x_77 - 3.57021628608615e-5*x_78 + 6.35489373224589e-5*x_79 - 4.25301167651957e-5*x_8 - 1.44570812552725e-5*x_80 - 6.37071301946166e-5*x_81 - 9.99149271222563e-5*x_82 - 3.97850531795001e-6*x_83 - 5.83890415774781e-5*x_84 - 0.000109621447958989*x_85 - 7.75275321869639e-5*x_86 - 6.10421879378049e-5*x_87 + 2.29420670771865e-5*x_88 - 1.29571932253092e-6*x_89 - 1.75742907690411e-5*x_9 - 2.42473515696432e-5*x_90 - 1.64114055101695e-5*x_91 + 4.06492474078854e-5*x_92 + 0.000101747459594943*x_93 - 5.6199881663302e-5*x_94 - 3.40083052139074e-5*x_95 + 0.000569908176103462*x_96 - 9.53966425758603e-5*x_97 + 0.000409629596895667*x_98 + 0.000562420258744132*x_99 - 1.28102720746814e-6*std::sin(1.11151993274689*x_1 - 2.1865599155426) - 6.8541894300105e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) + 1.06499334062312e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) - 0.000323175795511232*std::sin(0.472559869289398*x_14 - 1.83487987518311) - 0.000166088564542196*std::sin(0.911839842796326*x_28 + 4.78895998001099) + 4.79436316722538e-6*std::sin(2.75216007232666*x_62 + 4.60391998291016) - 1.2413312303962e-6*std::sin(1.29303991794586*x_64 + 1.5875198841095) - 0.000130537797916389*std::sin(1.75111997127533*x_73 - 1.76647984981537) + 0.000141585966053665*std::sin(2.29767990112305*x_78 + 0.972239851951599) - 0.000389061021139545*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.05361013489788 + 8.82367676262764e-7*std::exp(-4.89391994476318*x_113) - 2.09224458524013e-6*std::exp(-4.83752012252808*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.96209995732542e-5*x_1 - 0.000109082253317961*x_10 - 0.000178180609443288*x_100 - 0.000211266505581383*x_101 + 3.61786657544171e-5*x_102 - 6.97284744936387e-5*x_103 - 6.92897035565308e-5*x_104 - 6.56967419084898e-6*x_105 - 8.11058573760551e-5*x_106 - 0.000260356668367924*x_107 - 0.000177190522403324*x_108 - 6.17964738282605e-6*x_109 - 0.000200236269454286*x_11 - 0.000144983637754173*x_110 - 4.35151481295689e-5*x_111 - 0.000287427208517742*x_112 + 2.69602099948114e-6*x_113 - 0.00018980372713549*x_114 + 7.15848629624906e-6*x_115 - 0.000130423184298351*x_116 + 4.04034978873493e-5*x_117 + 9.74004191580144e-5*x_118 + 9.3269518523247e-5*x_119 - 9.87161946242632e-5*x_12 - 3.15705821755774e-6*x_120 + 0.000110931226147618*x_13 - 6.07051524869966e-5*x_14 + 3.79097193799569e-5*x_15 - 8.09124114827031e-6*x_16 + 3.13337790570102e-5*x_17 - 2.95069156036315e-5*x_18 - 8.34335531080065e-5*x_19 - 0.00021373788881577*x_2 + 0.000287831350508201*x_20 + 3.36239156311926e-5*x_21 + 0.000287213962180859*x_22 - 0.000115614386102141*x_23 - 0.000161675254465405*x_24 - 0.000119395549300979*x_25 + 3.48058637870008e-5*x_26 + 0.000270453273224334*x_27 + 0.000339708076221517*x_28 - 0.000162513957074773*x_29 - 0.000192972204113912*x_3 + 0.000311838513476521*x_30 - 7.79518456786431e-5*x_31 - 0.000109775450974156*x_32 - 0.000394611350767035*x_33 + 4.90738436305327e-5*x_34 - 2.42008088622595e-6*x_35 - 0.000598376150044906*x_36 - 0.000247109403910183*x_37 + 8.18396108033745e-5*x_38 - 0.000231949177054368*x_39 - 0.000126860099325097*x_4 - 6.8624751511038e-5*x_40 - 1.89252261083541e-5*x_41 - 5.06212495443097e-5*x_42 - 0.000268776609217589*x_43 + 0.000171754052021885*x_44 - 0.000249645336702761*x_45 + 0.000172763973701238*x_46 - 0.00043222591108498*x_47 - 0.000401448561332308*x_48 - 0.000278988611918034*x_49 + 9.66112533659518e-5*x_5 - 0.000114396955629686*x_50 + 0.000111179387822768*x_51 - 0.000246940090303327*x_52 - 3.41896141653801e-5*x_53 + 0.00011981212288522*x_54 - 0.000259372186710874*x_55 + 0.000235289298122736*x_56 - 1.48680065274057e-5*x_57 - 8.35381687080309e-6*x_58 + 0.00026680461646055*x_59 + 0.000129603136861824*x_6 - 0.000148840134399039*x_60 + 3.98793637856839e-5*x_61 + 3.52052269602406e-5*x_62 - 4.30239450331336e-5*x_63 + 2.03859505567881e-5*x_64 - 6.61540715750034e-5*x_65 - 6.32356257655283e-5*x_66 - 6.25929397763849e-5*x_67 - 9.67600569731557e-5*x_68 - 2.39683765943965e-5*x_69 - 9.0999829349806e-5*x_7 - 4.75756387428876e-5*x_70 + 9.36742765788268e-5*x_71 - 6.91987233962444e-6*x_72 - 0.000147649798924119*x_73 - 7.34274355096179e-5*x_74 + 5.46212114401399e-5*x_75 + 1.69236045793548e-5*x_76 - 3.47661553397987e-6*x_77 + 1.65491916953877e-5*x_78 - 1.60227405181744e-5*x_79 - 4.46255111916578e-5*x_8 - 1.81796793042206e-5*x_80 + 4.9923994034698e-6*x_81 - 6.28602980149755e-5*x_82 - 0.000119930306462915*x_83 - 6.79996475577277e-5*x_84 + 7.40379215962369e-5*x_85 - 1.14791428967286e-5*x_86 + 6.63674944424167e-5*x_87 + 2.36978532391064e-5*x_88 + 4.68918691087249e-5*x_89 - 5.89908160393218e-5*x_9 - 9.39616186055695e-5*x_90 - 6.94005836459997e-5*x_91 - 4.01305538988379e-6*x_92 - 0.000106163148662978*x_93 + 7.75054678286087e-5*x_94 + 0.000139061810362533*x_95 - 7.19522239356277e-5*x_96 + 8.24238349961939e-5*x_97 - 0.000136118068984552*x_98 - 4.36635890785903e-5*x_99 + 7.06532562905551e-5*std::sin(1.11151993274689*x_1 - 2.1865599155426) - 7.27061131819429e-5*std::sin(2.30183982849121*x_102 + 1.37711989879608) + 8.89929398858332e-5*std::sin(1.18727993965149*x_117 + 7.21080017089844) - 0.000342810133948517*std::sin(0.472559869289398*x_14 - 1.83487987518311) - 0.000176179168888433*std::sin(0.911839842796326*x_28 + 4.78895998001099) - 1.0374025432386e-5*std::sin(2.75216007232666*x_62 + 4.60391998291016) + 6.84638804323242e-5*std::sin(1.29303991794586*x_64 + 1.5875198841095) + 4.37899185350678e-5*std::sin(1.75111997127533*x_73 - 1.76647984981537) - 1.57035461270968e-6*std::sin(2.29767990112305*x_78 + 0.972239851951599) + 0.000618197634767643*std::sin(0.404719859361649*x_8 + 1.39943981170654) + 0.0305020308111888 + 1.9045420433054e-7*std::exp(-4.89391994476318*x_113) + 7.01859701982907e-7*std::exp(-4.83752012252808*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
