
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (12844.2781650548*x_1 - 339.106889854492*x_10 - 138.325891330617*x_100 + 664.561180872665*x_101 - 62.133896118596*x_102 - 31.985892665577*x_103 - 310.880326504888*x_104 + 62.448095530198*x_105 - 8.65037309762077*x_106 - 285.550921080359*x_107 - 7.46663415073995*x_108 + 385.243622979549*x_109 + 39.2447581617106*x_11 + 216.987700702545*x_110 + 4.13665377599323*x_111 - 249.55584612488*x_112 + 646.607486542264*x_113 - 114.690727012289*x_114 - 5.56970326541566*x_115 + 1673.79692320743*x_116 - 156.175254256137*x_117 + 37.2764143921546*x_118 - 241.38976017145*x_119 - 1944.43629975316*x_12 - 135.139411625807*x_120 + 641.539368295866*x_13 - 168.004484846009*x_14 + 93.4111407293633*x_15 - 95.1563147328825*x_16 - 407.563117359148*x_17 - 30.4764137445542*x_18 + 59.3156989854598*x_19 - 62.9911609412775*x_2 + 443.699439808735*x_20 + 1377.27756448352*x_21 + 126.274459900911*x_22 - 24.9238014631491*x_23 + 259.127885565465*x_24 + 484.894912484429*x_25 + 200.331659041238*x_26 + 255.603211365282*x_27 + 0.319394456748551*x_28 + 197.392352788141*x_29 - 381.224140147386*x_3 - 984.458638497149*x_30 - 1002.87421347299*x_31 + 21.0598575295587*x_32 + 76.0196441990315*x_33 + 122.802497686944*x_34 - 299.740075355456*x_35 - 1.6542936835441*x_36 - 3230.49596816029*x_37 + 257.048122512184*x_38 - 310.519349141547*x_39 - 89.8253710707025*x_4 - 117.342476844441*x_40 + 28.2795792456663*x_41 + 344380.212095196*x_42 + 434.686511846671*x_43 + 593.632121724194*x_44 - 11.8759484793145*x_45 - 231.041019893822*x_46 + 1704.84667409295*x_47 + 968.994847298473*x_48 + 157.852082679816*x_49 + 88.3755261285879*x_5 - 1612.65534158351*x_50 - 217.701563959412*x_51 - 34.1393714615427*x_52 - 0.0156751694132577*x_53 + 572.035786785959*x_54 - 61.2271386921682*x_55 + 99.5687748754597*x_56 + 5692.94983340463*x_57 + 238.332595047081*x_58 + 155.549165835979*x_59 - 86.576258643549*x_6 + 260.411713938194*x_60 + 96.845059591955*x_61 + 30.0432526635211*x_62 - 22.3267379515597*x_63 - 136.980646374565*x_64 + 37.1679757136573*x_65 - 88.7682118636314*x_66 - 220.095941228237*x_67 + 405.447444415284*x_68 + 6.93987011773509*x_69 - 25.8581789631291*x_7 + 142.822300750339*x_70 - 148.064304662178*x_72 - 80.8390510204079*x_73 + 549.847073640956*x_74 - 222.981097554002*x_75 + 181.411332451786*x_76 - 5.67986258261402*x_77 - 25.332150269661*x_78 + 75.7661368893862*x_79 + 1073.18465981472*x_8 - 69.0142575304377*x_80 + 68.1476824437336*x_81 - 300.893322037669*x_82 - 171.771668408093*x_83 - 385.295500930228*x_84 - 467.213922238113*x_85 + 249.682492078163*x_86 + 10.4967078133794*x_87 - 274.886314566505*x_88 + 0.18230995203919*x_89 - 95.2244369661003*x_9 - 270.416976079348*x_90 + 268.233755958784*x_91 - 131.394358771456*x_92 - 455.667593100642*x_93 + 37.6118632033122*x_94 + 1.25120049939443*x_95 + 205.518518786073*x_96 + 1188.56712380183*x_97 - 119.487373655883*x_98 + 38.7420673901345*x_99 + 1.87935317236927*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 2.9990988634852*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.00517589085814748*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 136.349198445989*std::exp(0.833039879798889*x_108) - 1.06696589775508*std::exp(1.13703989982605*x_50) + 0.17448292968439*std::exp(2.49991989135742*x_71) - 0.386586266442114*std::exp(2.57559990882874*x_71) + 3.87063646309557*std::exp(2.60271978378296*x_71) + 0.0663212272997973*std::exp(2.62631988525391*x_71) + 0.000979364376812133*std::exp(2.71295976638794*x_71) - 9.80854737073413*std::exp(1.8686398267746*x_89) + 0.298568092133518*std::exp(1.89503979682922*x_89) - 0.119447043178753*std::sin(0.321279853582382*x_102 - 7.443039894104) - 41.0270589513631*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 7.38419071383833*std::sin(0.435039848089218*x_108 - 4.17264032363892) + 7.59090052310885*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 8.63745818661926*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 9.0923666701893*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 1948.82733216617*std::sin(0.315759837627411*x_28 - 4.29776000976563) + 43.5921318756732*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 1810.301795105*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 10.7749755232887*std::sin(0.346159845590591*x_45 + 5.14376020431519) + 89.8886985980663*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 2049.30868122667*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 2.89396759995405*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 8.49288436130333*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.0298358504119745*std::sin(0.457359850406647*x_80 - 4.13359975814819) - 8.21676848197404*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.16888989217606*std::sin(0.415199846029282*x_87 + 5.20800018310547) - 9.22512216136722*std::sin(0.404799848794937*x_92 + 8.1943998336792) + 41.2150035638494*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 778.038168284254*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 5.49120531076695*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.140208337815292*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 236487.291724075 - 0.00829872468628248*std::exp(-2.89071989059448*x_74) + 0.0465348715310281*std::exp(-4.75799989700317*x_111) - 1.33097996667409e-5*std::exp(-4.64391994476318*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (22752.4806188906*x_1 - 586.801275191168*x_10 - 218.464788436415*x_100 + 1070.32559431989*x_101 - 93.0658877909898*x_102 - 59.4711356995276*x_103 - 530.966133179502*x_104 + 89.6075664535969*x_105 - 34.3850797113812*x_106 - 501.980320865064*x_107 + 9.71072060930222*x_108 + 650.673803649381*x_109 + 82.7487478950126*x_11 + 374.718785337047*x_110 - 10.3895588903758*x_111 - 451.270088703145*x_112 + 1179.16738135266*x_113 - 229.762807252186*x_114 + 1.55654232731169*x_115 + 2997.78520232992*x_116 - 262.646919320881*x_117 + 80.8401880572224*x_118 - 412.017922318238*x_119 - 3438.3113146996*x_12 - 238.866275126956*x_120 + 1111.01983672682*x_13 - 294.089434197617*x_14 + 181.050386500431*x_15 - 153.827145039923*x_16 - 704.06318670081*x_17 - 49.455514171577*x_18 + 105.302743842804*x_19 - 90.9766369257121*x_2 + 700.085305939048*x_20 + 2469.23011063199*x_21 + 168.591650279331*x_22 - 33.5604170522096*x_23 + 423.858804238065*x_24 + 908.462063774524*x_25 + 361.193016517736*x_26 + 426.316947024821*x_27 + 5.13096491963599*x_28 + 361.574088071364*x_29 - 612.901824278707*x_3 - 1821.47585577026*x_30 - 1374.2251221565*x_31 + 64.6159927569877*x_32 + 129.547852273992*x_33 + 223.324125483919*x_34 - 498.341434391901*x_35 + 0.72427425188339*x_36 - 5541.20065256282*x_37 + 426.82825992547*x_38 - 519.584048436286*x_39 - 149.342561041967*x_4 - 205.737763501227*x_40 + 48.1698878710411*x_41 + 612940.867159605*x_42 + 766.118671309215*x_43 + 984.025594211062*x_44 - 33.4608570247947*x_45 - 388.404737775365*x_46 + 3151.66400715534*x_47 + 1645.26743177949*x_48 + 312.968660582574*x_49 + 168.82781450672*x_5 - 2755.48032600898*x_50 - 347.292825216204*x_51 - 32.2927323869243*x_52 + 1.47823647024797*x_53 + 967.628467803491*x_54 - 107.83338644347*x_55 + 194.131350843164*x_56 + 10109.7131467445*x_57 + 413.764400819505*x_58 + 272.310152880639*x_59 - 158.889030556761*x_6 + 443.991526861399*x_60 + 173.073602838104*x_61 + 42.5496860052491*x_62 - 1.54975766425055*x_63 - 220.398384480168*x_64 + 39.2267688098356*x_65 - 152.646012039746*x_66 - 394.40919523429*x_67 + 717.838693529723*x_68 + 19.9384073252172*x_69 - 43.8159607278411*x_7 + 290.499785523358*x_70 - 242.028490699036*x_72 - 176.987058899773*x_73 + 944.950050213894*x_74 - 379.488121939677*x_75 + 331.811224011577*x_76 + 5.92962560278379*x_77 - 42.4157638316703*x_78 + 125.418395487296*x_79 + 1996.01637605903*x_8 - 119.029380790476*x_80 + 128.608506592539*x_81 - 540.481086408791*x_82 - 289.771143304631*x_83 - 683.918085395168*x_84 - 805.723732521582*x_85 + 426.236101517474*x_86 + 5.77403874524527*x_87 - 460.432915654695*x_88 - 1.91443547813387*x_89 - 144.395282454988*x_9 - 431.47615802925*x_90 + 500.01846782733*x_91 - 235.962549736787*x_92 - 820.203045131437*x_93 + 65.7540319537292*x_94 - 2.91981853639681*x_95 + 340.189514650002*x_96 + 2146.97601092913*x_97 - 177.077469741637*x_98 + 85.7395834440531*x_99 + 3.28156653801378*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 5.23677115047029*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) + 0.0139970583943897*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 238.081364207494*std::exp(0.833039879798889*x_108) + 2.88537459250936*std::exp(1.13703989982605*x_50) - 0.471850706004011*std::exp(2.49991989135742*x_71) + 0.296747191520262*std::exp(2.57559990882874*x_71) + 6.75857592114929*std::exp(2.60271978378296*x_71) + 0.0598711296631063*std::exp(2.62631988525391*x_71) - 8.7780999197838e-5*std::exp(2.71295976638794*x_71) - 17.1268505098199*std::exp(1.8686398267746*x_89) + 0.269530732243351*std::exp(1.89503979682922*x_89) + 0.0107061080122067*std::sin(0.321279853582382*x_102 - 7.443039894104) + 31.4927496835333*std::sin(0.39319983124733*x_107 - 7.39888000488281) + 19.9689196409945*std::sin(0.435039848089218*x_108 - 4.17264032363892) + 6.85264443953045*std::sin(0.289599925279617*x_11 + 8.30231952667236) + 23.3581058663359*std::sin(0.38663986325264*x_11 + 5.18735980987549) - 24.5883058035332*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 3402.87640217237*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 33.4617233704133*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 3160.9949007262*std::sin(0.359679847955704*x_36 + 5.16408014297485) + 29.138551358784*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 68.9993959275363*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 3578.32838087404*std::sin(0.337439835071564*x_53 + 5.13800001144409) + 7.82609884910259*std::sin(0.50791984796524*x_66 - 1.10575985908508) + 22.967137754622*std::sin(0.371919840574265*x_80 - 7.42863988876343) - 0.00267420464036619*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 6.30726743823194*std::sin(0.488959848880768*x_80 - 7.31591987609863) - 0.0151376993493338*std::sin(0.415199846029282*x_87 + 5.20800018310547) - 8.32792919504522*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 31.6370177053386*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 1358.54402242043*std::sin(0.375439822673798*x_95 + 5.17463970184326) + 14.8497569784339*std::sin(0.400319844484329*x_95 - 1.17215991020203) - 0.0125669549359719*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 412302.592726702 - 0.0074916288790144*std::exp(-2.89071989059448*x_74) + 0.081255231593579*std::exp(-4.75799989700317*x_111) + 1.19296509198403e-6*std::exp(-4.64391994476318*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (15130.1770906907*x_1 - 399.203923245322*x_10 - 155.559963343551*x_100 + 757.204773580977*x_101 - 69.6453513082424*x_102 - 40.2091857460339*x_103 - 374.69914675171*x_104 + 60.2958335332786*x_105 - 14.1470944091785*x_106 - 338.784789664459*x_107 - 1.05342270895286*x_108 + 445.349182411478*x_109 + 50.0947181857631*x_11 + 254.945831604839*x_110 - 5.28634119173842*x_111 - 296.490671119461*x_112 + 772.289992688042*x_113 - 147.448231951305*x_114 - 4.26409632287237*x_115 + 1990.61404216569*x_116 - 175.581720474747*x_117 + 50.9606712297297*x_118 - 278.32467992174*x_119 - 2322.19022415814*x_12 - 164.288127725786*x_120 + 751.1014993361*x_13 - 196.179376019237*x_14 + 118.635145098886*x_15 - 106.563173191671*x_16 - 480.107913819757*x_17 - 36.2018223792376*x_18 + 70.7201741539953*x_19 - 67.6747284325777*x_2 + 494.648772166036*x_20 + 1653.48991306907*x_21 + 131.709596549612*x_22 - 23.0051653469399*x_23 + 294.51050640738*x_24 + 585.373240672151*x_25 + 239.103679257654*x_26 + 293.235509254753*x_27 + 4.75145672085227*x_28 + 238.659430333859*x_29 - 425.414804014626*x_3 - 1176.58552566416*x_30 - 893.803792042632*x_31 + 37.2175496275904*x_32 + 84.0017049241088*x_33 + 140.66840710825*x_34 - 339.449421996169*x_35 - 0.579685050979356*x_36 - 3785.54045882753*x_37 + 296.367518057689*x_38 - 353.909716664134*x_39 - 99.9275400086885*x_4 - 141.286446362239*x_40 + 35.1731853480695*x_41 + 408507.982891045*x_42 + 507.465972643732*x_43 + 685.551241921731*x_44 - 17.8556338763784*x_45 - 265.638419560291*x_46 + 2065.21008737486*x_47 + 1107.07870693635*x_48 + 206.036561228489*x_49 + 110.548430784812*x_5 - 1866.32789503024*x_50 - 246.117494336291*x_51 - 35.6350667970132*x_52 + 1.29322685590487*x_53 + 660.396000339604*x_54 - 72.3479525769536*x_55 + 124.245092163279*x_56 + 6711.83888100644*x_57 + 275.204948556883*x_58 + 180.639279039377*x_59 - 105.573934878038*x_6 + 295.551756835375*x_60 + 114.226162945669*x_61 + 30.9498592067014*x_62 - 13.9924460880628*x_63 - 154.134962408307*x_64 + 32.1848406556161*x_65 - 103.836621044393*x_66 - 265.874013747665*x_67 + 476.293050475404*x_68 + 7.32244780835956*x_69 - 29.1337682214289*x_7 + 190.142955239443*x_70 - 164.847860982662*x_72 - 109.827338020137*x_73 + 638.077148205042*x_74 - 257.267955087287*x_75 + 227.489021003414*x_76 - 1.25816685498262*x_77 - 32.144144400222*x_78 + 88.4745745779559*x_79 + 1310.32578157007*x_8 - 81.5690558284663*x_80 + 79.1006346272925*x_81 - 358.061684705025*x_82 - 199.79737351786*x_83 - 436.074779548645*x_84 - 544.887959168867*x_85 + 291.366140391707*x_86 + 9.46274605932198*x_87 - 308.451014313994*x_88 - 1.90118946572893*x_89 - 106.505877906592*x_9 - 307.227679062173*x_90 + 330.563780762927*x_91 - 157.160903846887*x_92 - 546.568308931393*x_93 + 46.5900594151018*x_94 - 0.615292682603477*x_95 + 233.929495988315*x_96 + 1420.63904915671*x_97 - 127.961948670267*x_98 + 53.1161787883109*x_99 + 2.20639707456167*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 3.52100023348608*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) + 0.00881760516462464*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 160.076603478842*std::exp(0.833039879798889*x_108) + 1.8176743421307*std::exp(1.13703989982605*x_50) - 0.297247686261022*std::exp(2.49991989135742*x_71) - 0.179316433548075*std::exp(2.57559990882874*x_71) + 4.54420227896782*std::exp(2.60271978378296*x_71) + 0.0984943619400873*std::exp(2.62631988525391*x_71) + 0.000367688333795493*std::exp(2.71295976638794*x_71) - 11.5154248507769*std::exp(1.8686398267746*x_89) + 0.443406657681829*std::exp(1.89503979682922*x_89) - 0.0448446822480442*std::sin(0.321279853582382*x_102 - 7.443039894104) - 19.0302308404083*std::sin(0.39319983124733*x_107 - 7.39888000488281) + 12.5796466655439*std::sin(0.435039848089218*x_108 - 4.17264032363892) + 11.27332731939*std::sin(0.289599925279617*x_11 + 8.30231952667236) + 14.7147028410917*std::sin(0.38663986325264*x_11 + 5.18735980987549) - 15.4896811982657*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 2287.96108561994*std::sin(0.315759837627411*x_28 - 4.29776000976563) + 20.2200292592999*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 2125.32941839662*std::sin(0.359679847955704*x_36 + 5.16408014297485) + 18.3561598238297*std::sin(0.346159845590591*x_45 + 5.14376020431519) + 41.6944993861974*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 2405.92813826051*std::sin(0.337439835071564*x_53 + 5.13800001144409) + 4.93013943975325*std::sin(0.50791984796524*x_66 - 1.10575985908508) + 14.4684080594372*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.011201442879778*std::sin(0.457359850406647*x_80 - 4.13359975814819) - 3.81131392234399*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.0634072920349116*std::sin(0.415199846029282*x_87 + 5.20800018310547) - 13.7003273023869*std::sin(0.404799848794937*x_92 + 8.1943998336792) + 19.117408168061*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 913.431899676174*std::sin(0.375439822673798*x_95 + 5.17463970184326) + 9.35477227693377*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.0526392130815978*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 281370.061140674 - 0.0123245245326505*std::exp(-2.89071989059448*x_74) + 0.05463284172486*std::exp(-4.75799989700317*x_111) - 4.99697372957904e-6*std::exp(-4.64391994476318*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-13319.7172580287*x_1 + 352.959518053704*x_10 + 149.695181120462*x_100 - 711.90425778425*x_101 + 67.6663763915968*x_102 + 32.7157712019338*x_103 + 326.59036273739*x_104 - 70.5012386163946*x_105 + 4.79451248354776*x_106 + 297.025053514021*x_107 + 10.636856362657*x_108 - 403.801370153482*x_109 - 38.08187556569*x_11 - 224.488672765673*x_110 - 7.95906658829128*x_111 + 255.211004270266*x_112 - 661.98377484067*x_113 + 112.758978922961*x_114 + 8.93601936816149*x_115 - 1717.7478957909*x_116 + 165.413591216633*x_117 - 35.1661747438953*x_118 + 254.549155132489*x_119 + 2018.8730713398*x_12 + 138.112898628009*x_120 - 668.780511635774*x_13 + 175.123938601734*x_14 - 93.4599112271674*x_15 + 100.382214221248*x_16 + 424.277083733943*x_17 + 30.9558865633542*x_18 - 60.4699613538976*x_19 + 70.4188545626124*x_2 - 481.514929381882*x_20 - 1422.35109769378*x_21 - 144.150952477561*x_22 + 27.6130054647943*x_23 - 275.883474058284*x_24 - 490.919962902209*x_25 - 206.958656423476*x_26 - 271.415736398724*x_27 - 0.0853867623135938*x_28 - 200.677809365251*x_29 + 409.953434845322*x_3 + 1020.07153173295*x_30 + 1090.99863338345*x_31 - 16.934027888419*x_32 - 80.9708148692972*x_33 - 128.694548064287*x_34 + 316.20336288384*x_35 + 3.1399815309886*x_36 + 3395.14633848983*x_37 - 274.65009330633*x_38 + 329.520510000657*x_39 + 95.8584610301*x_4 + 120.938918305988*x_40 - 27.5373391382152*x_41 - 356784.021243296*x_42 - 450.638463702621*x_43 - 632.17540935658*x_44 + 10.2120672944751*x_45 + 243.071623268646*x_46 - 1733.24633568301*x_47 - 1022.24303566674*x_48 - 155.789924245693*x_49 - 88.7503071628735*x_5 + 1676.42205511338*x_50 + 231.791328154722*x_51 + 44.0853293893664*x_52 + 0.207348209252478*x_53 - 596.58744611281*x_54 + 63.7711997365501*x_55 - 99.4276080176093*x_56 - 5871.69469579652*x_57 - 249.655409117992*x_58 - 162.794985345177*x_59 + 88.2247409951486*x_6 - 273.093226815104*x_60 - 98.7956456200288*x_61 - 35.632183515373*x_62 + 32.4199412403688*x_63 + 146.379761489323*x_64 - 43.7248160688384*x_65 + 93.1675491020155*x_66 + 227.197714223558*x_67 - 418.882528920258*x_68 - 6.46255716404062*x_69 + 28.5665631901906*x_7 - 139.405595638158*x_70 + 158.631090233292*x_72 + 76.3945815356389*x_73 - 575.477508102646*x_74 + 235.56489475842*x_75 - 189.235244397677*x_76 + 8.83399532789031*x_77 + 26.7879312422661*x_78 - 80.9257848024018*x_79 - 1084.70857123503*x_8 + 73.2428360257452*x_80 - 70.4588328138647*x_81 + 308.796045162692*x_82 + 180.290352089052*x_83 + 393.906442917978*x_84 + 486.275868809821*x_85 - 261.055216011967*x_86 - 14.188809697599*x_87 + 289.898014300049*x_88 - 0.929816055785141*x_89 + 122.476977687432*x_9 + 292.136672232853*x_90 - 268.080950441471*x_91 + 135.071807092369*x_92 + 466.096540941422*x_93 - 40.8061331449798*x_94 - 1.49670526915278*x_95 - 217.631559554229*x_96 - 1223.51204257446*x_97 + 131.928718616335*x_98 - 37.6538755683606*x_99 - 1.95420238980058*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) + 3.11854432282268*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) + 0.0115717996199434*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) - 141.779593834739*std::exp(0.833039879798889*x_108) + 2.38542811440847*std::exp(1.13703989982605*x_50) - 0.390093522978785*std::exp(2.49991989135742*x_71) + 0.589454780628025*std::exp(2.57559990882874*x_71) - 4.02479275180343*std::exp(2.60271978378296*x_71) - 0.124990549815282*std::exp(2.62631988525391*x_71) + 0.000702868296668866*std::exp(2.71295976638794*x_71) + 10.1991935279499*std::exp(1.8686398267746*x_89) - 0.56268847113422*std::exp(1.89503979682922*x_89) - 0.085724518645921*std::sin(0.321279853582382*x_102 - 7.443039894104) + 62.5567903809897*std::sin(0.39319983124733*x_107 - 7.39888000488281) + 16.5089213891514*std::sin(0.435039848089218*x_108 - 4.17264032363892) - 14.305990232774*std::sin(0.289599925279617*x_11 + 8.30231952667236) + 19.3108661099109*std::sin(0.38663986325264*x_11 + 5.18735980987549) - 20.3279103176725*std::sin(0.320639848709106*x_26 - 4.25831985473633) - 2026.44350504201*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 66.4679342294494*std::sin(0.348559856414795*x_28 - 4.26224040985107) + 1882.40089530088*std::sin(0.359679847955704*x_36 + 5.16408014297485) + 24.0897385749587*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 137.059507055706*std::sin(0.233519986271858*x_53 + 5.05207967758179) - 2130.92673648109*std::sin(0.337439835071564*x_53 + 5.13800001144409) + 6.47007715020923*std::sin(0.50791984796524*x_66 - 1.10575985908508) + 18.9876407207567*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.021412534349056*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 12.5286744084027*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.121208565115236*std::sin(0.415199846029282*x_87 + 5.20800018310547) + 17.3858828916146*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 62.8433625123356*std::sin(0.365999847650528*x_94 + 5.18839979171753) + 809.025184925916*std::sin(0.375439822673798*x_95 + 5.17463970184326) + 12.2767518229523*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.100624443682324*std::sin(0.438399881124496*x_96 - 7.37599945068359) + 248891.680397674 + 0.0156399723517672*std::exp(-2.89071989059448*x_74) - 0.0483882212731486*std::exp(-4.75799989700317*x_111) - 9.55215080542037e-6*std::exp(-4.64391994476318*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5011.75140894992*x_1 + 144.058235168848*x_10 + 66.8793274037762*x_100 - 320.96115969722*x_101 + 35.3852821709971*x_102 + 8.79609426011344*x_103 + 122.167863754257*x_104 - 37.2372742887935*x_105 - 7.37021816982492*x_106 + 110.231543729083*x_107 + 26.812036362926*x_108 - 178.104864938742*x_109 - 6.09991172239739*x_11 - 99.4293312868275*x_110 - 16.5741248051111*x_111 + 97.3712214792083*x_112 - 233.746451102119*x_113 + 26.1518946714976*x_114 + 5.17001498581933*x_115 - 666.446706936771*x_116 + 69.8431557451976*x_117 - 4.72182125906231*x_118 + 100.028195538801*x_119 + 726.882733296445*x_12 + 57.9598238507721*x_120 - 269.524567750023*x_13 + 66.9648992769292*x_14 - 23.9867930431332*x_15 + 53.0331423045468*x_16 + 174.703147891771*x_17 + 20.4188595400543*x_18 - 26.2010816535783*x_19 + 34.754641063502*x_2 - 214.33183259774*x_20 - 493.824000309839*x_21 - 78.3685424036282*x_22 + 20.4351751751775*x_23 - 123.784266145733*x_24 - 162.327990402505*x_25 - 70.2294334015227*x_26 - 112.600094545532*x_27 + 8.01215458289636*x_28 - 72.940726107564*x_29 + 185.116891313827*x_3 + 271.870656595962*x_30 + 947.307324139666*x_31 + 15.6905010550327*x_32 - 30.8944711611514*x_33 - 36.3582236309512*x_34 + 146.366543782458*x_35 + 0.0951807379265455*x_36 + 1312.19133523316*x_37 - 108.567338679801*x_38 + 137.691982915681*x_39 + 40.260042722916*x_4 + 48.745596016692*x_40 - 20.1711474291761*x_41 - 128866.658848942*x_42 - 176.958242019438*x_43 - 260.935321308172*x_44 - 6.14611833825546*x_45 + 106.40974258057*x_46 - 589.731895230971*x_47 - 420.506537363879*x_48 - 35.7193202459833*x_49 - 25.5062697373521*x_5 + 763.429860137393*x_50 + 117.0543307927*x_51 + 15.6421628669503*x_52 + 2.22103048273506*x_53 - 275.256230048952*x_54 + 23.2584142082486*x_55 - 26.3441577046895*x_56 - 2300.23006548306*x_57 - 96.212756389643*x_58 - 60.2878603253774*x_59 + 30.2282792705032*x_6 - 118.100400065428*x_60 - 41.9818740543557*x_61 - 10.0337384754899*x_62 + 29.0511217918315*x_63 + 69.1299330144994*x_64 - 35.6225098131728*x_65 + 36.6163433251975*x_66 + 78.9699808688356*x_67 - 164.999329412445*x_68 + 3.5033334427941*x_69 + 6.10522708835649*x_7 - 26.7314165809462*x_70 + 68.5663607384104*x_72 + 8.11931594125147*x_73 - 236.283266541237*x_74 + 92.0328835682065*x_75 - 42.3927162634535*x_76 + 14.8317454612254*x_77 + 9.48000637275416*x_78 - 31.7317113918213*x_79 - 376.431991051608*x_8 + 23.8150127673142*x_80 - 18.1272315094436*x_81 + 118.041535854894*x_82 + 77.9760094168093*x_83 + 186.58644278308*x_84 + 205.877373382096*x_85 - 110.835148747835*x_86 - 9.19768843948756*x_87 + 130.648633244462*x_88 - 1.38124809887143*x_89 - 25.600827284935*x_9 + 126.327987742782*x_90 - 104.660166178089*x_91 + 49.4914137884964*x_92 + 178.541556372257*x_93 - 6.68328505278076*x_94 - 7.87354695251697*x_95 - 97.7221397055644*x_96 - 428.967313251464*x_97 + 67.2309808686779*x_98 + 2.44545068738955*x_99 - 0.77241490554279*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) + 1.23263083246454*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) + 0.016868851730337*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) - 56.0395750979155*std::exp(0.833039879798889*x_108) + 3.477370374266*std::exp(1.13703989982605*x_50) - 0.568660883891637*std::exp(2.49991989135742*x_71) + 0.845665304248813*std::exp(2.57559990882874*x_71) - 1.59083313449985*std::exp(2.60271978378296*x_71) + 0.144992287460632*std::exp(2.62631988525391*x_71) + 0.000862493678300099*std::exp(2.71295976638794*x_71) + 4.03131689257018*std::exp(1.8686398267746*x_89) + 0.652733256058542*std::exp(1.89503979682922*x_89) - 0.105193043643934*std::sin(0.321279853582382*x_102 - 7.443039894104) + 89.7475241680204*std::sin(0.39319983124733*x_107 - 7.39888000488281) + 24.0659669444523*std::sin(0.435039848089218*x_108 - 4.17264032363892) + 16.5953206166771*std::sin(0.289599925279617*x_11 + 8.30231952667236) + 28.1505165913053*std::sin(0.38663986325264*x_11 + 5.18735980987549) - 29.6331181318953*std::sin(0.320639848709106*x_26 - 4.25831985473633) - 800.968813007418*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 95.3586732523397*std::sin(0.348559856414795*x_28 - 4.26224040985107) + 744.034761868178*std::sin(0.359679847955704*x_36 + 5.16408014297485) + 35.1169430503451*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 196.633352622851*std::sin(0.233519986271858*x_53 + 5.05207967758179) - 842.266687661566*std::sin(0.337439835071564*x_53 + 5.13800001144409) + 9.43178897970361*std::sin(0.50791984796524*x_66 - 1.10575985908508) + 27.6793330810303*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.0262754424975085*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 17.9743478272038*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.148735718573701*std::sin(0.415199846029282*x_87 + 5.20800018310547) - 20.1680761761851*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 90.1586568224806*std::sin(0.365999847650528*x_94 + 5.18839979171753) + 319.773998362606*std::sin(0.375439822673798*x_95 + 5.17463970184326) + 17.8964995102931*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.123476826269995*std::sin(0.438399881124496*x_96 - 7.37599945068359) + 84952.603675771 - 0.0181427745573971*std::exp(-2.89071989059448*x_74) - 0.0191258508121551*std::exp(-4.75799989700317*x_111) - 1.17214984982111e-5*std::exp(-4.64391994476318*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (25164.6426197224*x_1 - 644.020489863623*x_10 - 244.929549327031*x_100 + 1190.98356818708*x_101 - 103.283876669099*x_102 - 60.7847732279925*x_103 - 555.604819362125*x_104 + 119.297504781903*x_105 - 38.1464965922688*x_106 - 546.879326986255*x_107 + 0.944262291162675*x_108 + 726.356731521812*x_109 + 88.5835578278471*x_11 + 414.029071578577*x_110 + 4.42296678240676*x_111 - 499.239102614734*x_112 + 1296.26567859097*x_113 - 237.828144814337*x_114 + 3.0254177534295*x_115 + 3297.44680250596*x_116 - 302.947906406096*x_117 + 80.1352834533775*x_118 - 460.895652823361*x_119 - 3717.5492683073*x_12 - 253.880129562166*x_120 + 1228.31362284133*x_13 - 327.259044942781*x_14 + 187.18225167226*x_15 - 177.799509376096*x_16 - 771.728308533255*x_17 - 53.6281431811907*x_18 + 115.569018181951*x_19 - 105.08919374546*x_2 + 794.301806456891*x_20 + 2666.41635382515*x_21 + 198.072220801134*x_22 - 47.767642711706*x_23 + 477.002938889135*x_24 + 996.530204823334*x_25 + 394.117984581165*x_26 + 475.957152843007*x_27 - 3.65403813045153*x_28 + 392.441377203989*x_29 - 701.754540901698*x_3 - 1993.04927786185*x_30 - 2076.48903249144*x_31 + 54.0086519103172*x_32 + 152.823081379385*x_33 + 256.205622184129*x_34 - 569.572100579095*x_35 + 0.252651977948603*x_36 - 6071.36808871531*x_37 + 470.719250665362*x_38 - 586.696539290009*x_39 - 173.657156223723*x_4 - 220.095776949193*x_40 + 50.5745935445076*x_41 + 671674.645404784*x_42 + 857.196015034385*x_43 + 1084.60532257922*x_44 - 33.0500987166868*x_45 - 435.574557770236*x_46 + 3419.10010910646*x_47 + 1863.69586515773*x_48 + 314.580331997751*x_49 + 177.405992290322*x_5 - 3096.82962940337*x_50 - 392.206382950056*x_51 - 28.5088605044301*x_52 - 1.01505804761472*x_53 + 1086.23752623856*x_54 - 118.162622360238*x_55 + 206.724694627481*x_56 + 11206.4755327432*x_57 + 465.556793223275*x_58 + 304.808258872458*x_59 - 170.123542032203*x_6 + 509.939004963931*x_60 + 193.257524875563*x_61 + 49.7160311403484*x_62 - 11.0977211958778*x_63 - 250.337175559292*x_64 + 58.6294661507953*x_65 - 168.11305554521*x_66 - 422.153199213917*x_67 + 798.554542438371*x_68 + 27.0620107311665*x_69 - 48.9842194899106*x_7 + 287.418448626585*x_70 - 279.318627973594*x_72 - 177.647618370181*x_73 + 1054.48203887973*x_74 - 423.329158781177*x_75 + 334.249968665765*x_76 + 0.856208346268469*x_77 - 40.0413452090059*x_78 + 135.453812248351*x_79 + 2151.87044036965*x_8 - 128.039510005951*x_80 + 147.478146665768*x_81 - 594.566306344387*x_82 - 320.069582010745*x_83 - 808.226478581261*x_84 - 896.227094338307*x_85 + 471.21468407063*x_86 + 6.20641276505942*x_87 - 533.554883556684*x_88 + 1.59805900192222*x_89 - 138.488576497328*x_9 - 478.291494544487*x_90 + 536.166394230549*x_91 - 257.075688809388*x_92 - 893.46011964821*x_93 + 64.6700459281398*x_94 + 0.35527989130618*x_95 + 384.437969928301*x_96 + 2344.40965659197*x_97 - 208.523696815558*x_98 + 83.7578267803463*x_99 + 3.62666501995976*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 5.78748427890791*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.00761824662710819*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 263.118649423525*std::exp(0.833039879798889*x_108) - 1.57043677592563*std::exp(1.13703989982605*x_50) + 0.256816464447594*std::exp(2.49991989135742*x_71) + 0.131401719915328*std::exp(2.57559990882874*x_71) + 7.46932618736725*std::exp(2.60271978378296*x_71) - 0.0666138775025988*std::exp(2.62631988525391*x_71) - 0.000824305665633075*std::exp(2.71295976638794*x_71) - 18.9279567933548*std::exp(1.8686398267746*x_89) - 0.299885558897484*std::exp(1.89503979682922*x_89) + 0.1005354868592*std::sin(0.321279853582382*x_102 - 7.443039894104) + 13.9452085530407*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 10.8685804127942*std::sin(0.435039848089218*x_108 - 4.17264032363892) - 7.62439626297946*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 12.7132291812953*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 13.3827960472862*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 3760.73216009653*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 14.817083793371*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 3493.41374064399*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 15.8593801892583*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 30.5534123222793*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 3954.63514712089*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 4.25954864805654*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 12.5004350773881*std::sin(0.371919840574265*x_80 - 7.42863988876343) - 0.0251120636158172*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 2.79290188090299*std::sin(0.488959848880768*x_80 - 7.31591987609863) - 0.14215025406789*std::sin(0.415199846029282*x_87 + 5.20800018310547) + 9.26582909610455*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 14.009091436302*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 1501.41221490202*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 8.08234900696528*std::sin(0.400319844484329*x_95 - 1.17215991020203) - 0.118009731583601*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 445099.053562451 + 0.00833534378338478*std::exp(-2.89071989059448*x_74) + 0.0898002532313499*std::exp(-4.75799989700317*x_111) + 1.12025141341652e-5*std::exp(-4.64391994476318*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-10224.3312499525*x_1 + 255.055558293177*x_10 + 91.9944833092869*x_100 - 447.912897349255*x_101 + 35.4825313309852*x_102 + 26.8875046214084*x_103 + 225.588694379986*x_104 - 40.7175558396154*x_105 + 21.831149800702*x_106 + 223.012317741622*x_107 - 14.3402037029156*x_108 - 279.153044994723*x_109 - 41.3947287015276*x_11 - 159.81543247641*x_110 + 7.0496207803542*x_111 + 203.055991231887*x_112 - 537.912148144245*x_113 + 107.736022177963*x_114 - 2.98688574337605*x_115 - 1333.3289629876*x_116 + 117.843520995698*x_117 - 38.395213838881*x_118 + 183.855899924947*x_119 + 1530.22170018809*x_12 + 100.340170401529*x_120 - 488.217126937687*x_13 + 132.175112153434*x_14 - 83.4591380093135*x_15 + 62.9973734405938*x_16 + 304.668771292477*x_17 + 16.9094836289303*x_18 - 45.2776848396143*x_19 + 36.6782229578666*x_2 - 298.428787681035*x_20 - 1109.98434837433*x_21 - 63.2694808263026*x_22 + 13.1265064350997*x_23 - 180.602323511446*x_24 - 420.927420318419*x_25 - 164.841473389475*x_26 - 185.849731104092*x_27 - 3.29958342867211*x_28 - 162.075287264917*x_29 + 263.684778461887*x_3 + 874.715221842768*x_30 + 513.295276594156*x_31 - 35.9761966324658*x_32 - 61.2748602344411*x_33 - 110.724574500182*x_34 + 214.239288506495*x_35 + 0.204117922425014*x_36 + 2437.58984203144*x_37 - 186.271688124198*x_38 + 228.58881544384*x_39 + 67.4465948331682*x_4 + 87.899443704061*x_40 - 15.3303315942995*x_41 - 276251.992858282*x_42 - 344.120359188217*x_43 - 423.375181061654*x_44 + 19.7768805192253*x_45 + 167.591471517785*x_46 - 1434.96741605474*x_47 - 732.182606923707*x_48 - 143.318686990724*x_49 - 77.4562667029403*x_5 + 1181.0409977797*x_50 + 140.679189021917*x_51 + 10.2372838775437*x_52 - 0.903494877382185*x_53 - 411.501118279487*x_54 + 48.3889716753656*x_55 - 91.3967839024858*x_56 - 4510.29941781402*x_57 - 187.28747743628*x_58 - 124.024115887645*x_59 + 71.2901621136111*x_6 - 197.580658822816*x_60 - 76.1930641664563*x_61 - 21.0277955094399*x_62 - 7.58826531619575*x_63 + 92.5652374226668*x_64 - 11.4197604418076*x_65 + 67.1333213276871*x_66 + 175.72846593065*x_67 - 320.665472837233*x_68 - 14.5201998736064*x_69 + 22.158380991584*x_7 - 134.095828726669*x_70 + 107.154479757183*x_72 + 86.0153641448461*x_73 - 415.814126677393*x_74 + 169.054297851368*x_75 - 152.445348456554*x_76 - 7.74795852489394*x_77 + 16.5382905478222*x_78 - 53.7618231760202*x_79 - 900.277398006012*x_8 + 53.8155589365496*x_80 - 64.7193303086066*x_81 + 241.382916368046*x_82 + 123.779344790038*x_83 + 307.002753148945*x_84 + 350.654898120425*x_85 - 183.75901623825*x_86 + 0.506130775848537*x_87 + 203.166598520888*x_88 + 0.159197862670317*x_89 + 91.8114356073194*x_9 + 182.087963220159*x_90 - 218.218567913565*x_91 + 105.628987932262*x_92 + 363.120945588264*x_93 - 30.8963438865694*x_94 + 4.14124022963054*x_95 - 145.98651778318*x_96 - 973.453427740376*x_97 + 72.555910548925*x_98 - 44.3421802093558*x_99 - 1.45156584202275*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) + 2.31642967968396*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.00582904536271787*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) - 105.312743746757*std::exp(0.833039879798889*x_108) - 1.20160814610247*std::exp(1.13703989982605*x_50) + 0.196501228488856*std::exp(2.49991989135742*x_71) - 0.459982299363218*std::exp(2.57559990882874*x_71) - 2.98958373514978*std::exp(2.60271978378296*x_71) - 0.0705574126926931*std::exp(2.62631988525391*x_71) - 0.00159235683174251*std::exp(2.71295976638794*x_71) + 7.57587904846563*std::exp(1.8686398267746*x_89) - 0.317638755361196*std::exp(1.89503979682922*x_89) + 0.194209958765546*std::sin(0.321279853582382*x_102 - 7.443039894104) - 48.8163252312121*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 8.31601434759181*std::sin(0.435039848089218*x_108 - 4.17264032363892) - 8.07575979402612*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 9.72743378255909*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 10.2397479443697*std::sin(0.320639848709106*x_26 - 4.25831985473633) - 1505.22596229556*std::sin(0.315759837627411*x_28 - 4.29776000976563) + 51.8683947023224*std::sin(0.348559856414795*x_28 - 4.26224040985107) + 1398.23226850657*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 12.134688081484*std::sin(0.346159845590591*x_45 + 5.14376020431519) + 106.954679607319*std::sin(0.233519986271858*x_53 + 5.05207967758179) - 1582.83526756132*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 3.25916231247689*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 9.56461593938497*std::sin(0.371919840574265*x_80 - 7.42863988876343) - 0.0485103617807702*std::sin(0.457359850406647*x_80 - 4.13359975814819) - 9.77677788313149*std::sin(0.488959848880768*x_80 - 7.31591987609863) - 0.27459950554276*std::sin(0.415199846029282*x_87 + 5.20800018310547) + 9.81436529420325*std::sin(0.404799848794937*x_92 + 8.1943998336792) + 49.0399524071076*std::sin(0.365999847650528*x_94 + 5.18839979171753) + 600.937410528109*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 6.18414988447306*std::sin(0.400319844484329*x_95 - 1.17215991020203) - 0.227965923484133*std::sin(0.438399881124496*x_96 - 7.37599945068359) + 183935.324958733 + 0.008828795339782*std::exp(-2.89071989059448*x_74) - 0.0359423821825891*std::exp(-4.75799989700317*x_111) + 2.16405159614302e-5*std::exp(-4.64391994476318*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (24336.6019859159*x_1 - 618.877860932737*x_10 - 236.563680616897*x_100 + 1142.92914568308*x_101 - 97.4405533143753*x_102 - 60.6499615708593*x_103 - 544.074360107042*x_104 + 112.929981832077*x_105 - 38.305796242404*x_106 - 531.287462399514*x_107 + 11.1613250457198*x_108 + 692.535310096812*x_109 + 88.0152675860224*x_11 + 392.516076205302*x_110 - 0.952914646489054*x_111 - 479.527197099288*x_112 + 1255.88835250815*x_113 - 234.873575689505*x_114 + 1.06865497959994*x_115 + 3167.08061958421*x_116 - 291.149390228442*x_117 + 79.7771788303834*x_118 - 446.900982475197*x_119 - 3622.9169109548*x_12 - 241.7422485629*x_120 + 1182.40566940616*x_13 - 316.697437625129*x_14 + 185.095045074443*x_15 - 164.955397905482*x_16 - 740.790848062075*x_17 - 46.9091981194095*x_18 + 109.341313217508*x_19 - 101.22168804091*x_2 + 767.445849014826*x_20 + 2602.45253381688*x_21 + 188.97593040208*x_22 - 41.7049919623018*x_23 + 456.534858757811*x_24 + 966.694581009131*x_25 + 385.066496816904*x_26 + 459.965674489374*x_27 + 1.16472152869361*x_28 + 378.449734874734*x_29 - 673.097824995265*x_3 - 1986.41503086761*x_30 - 1718.73019699141*x_31 + 60.9103305947882*x_32 + 148.667651595158*x_33 + 254.626807108424*x_34 - 539.835754638626*x_35 - 1.52444264312593*x_36 - 5898.38378648972*x_37 + 459.185931721682*x_38 - 565.618701285194*x_39 - 167.434345555828*x_4 - 211.416192699403*x_40 + 42.5284480123764*x_41 + 652876.444051883*x_42 + 824.738965605807*x_43 + 1050.77194246556*x_44 - 35.8456349652247*x_45 - 416.258837594306*x_46 + 3317.96664548784*x_47 + 1795.29227344889*x_48 + 312.375326393921*x_49 + 174.132868013747*x_5 - 2927.78131621445*x_50 - 368.339907959328*x_51 - 36.1332678776313*x_52 + 0.206790108636762*x_53 + 1026.86458856501*x_54 - 115.00383973592*x_55 + 203.216419664189*x_56 + 10768.2759678096*x_57 + 450.826572388112*x_58 + 296.259454893771*x_59 - 165.3144425536*x_6 + 486.643700096588*x_60 + 183.115942626458*x_61 + 53.2540433766392*x_62 - 8.709543774267*x_63 - 238.031243157165*x_64 + 49.9467612231968*x_65 - 162.719026723527*x_66 - 412.080733305677*x_67 + 767.18700446068*x_68 + 28.1672938873829*x_69 - 51.1877487345177*x_7 + 287.015374851333*x_70 - 269.128348922465*x_72 - 177.759062504484*x_73 + 1013.51385969368*x_74 - 411.170666953749*x_75 + 341.635798258484*x_76 + 4.82388358033507*x_77 - 39.9604240461879*x_78 + 132.534963402203*x_79 + 2079.79739172507*x_8 - 127.436343941445*x_80 + 146.272898633409*x_81 - 571.839707025873*x_82 - 306.373856500896*x_83 - 752.669255178638*x_84 - 856.497011775533*x_85 + 451.194616559007*x_86 + 6.70811612256525*x_87 - 507.481499884422*x_88 + 1.32404028063795*x_89 - 191.433716090724*x_9 - 463.734980954577*x_90 + 509.548517626167*x_91 - 248.892174037725*x_92 - 858.939358238274*x_93 + 69.0921369071215*x_94 - 3.52902443838724*x_95 + 366.876301190079*x_96 + 2279.47966697749*x_97 - 198.212753740008*x_98 + 88.4646642149095*x_99 + 3.49466606189522*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 5.57683844025827*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.00416255931871588*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 253.541975708113*std::exp(0.833039879798889*x_108) - 0.85807621570329*std::exp(1.13703989982605*x_50) + 0.140322809120159*std::exp(2.49991989135742*x_71) + 0.309588889388693*std::exp(2.57559990882874*x_71) + 7.19746670523962*std::exp(2.60271978378296*x_71) + 0.0894039176861218*std::exp(2.62631988525391*x_71) + 0.00141060815868152*std::exp(2.71295976638794*x_71) - 18.2390399617029*std::exp(1.8686398267746*x_89) + 0.402482858348567*std::exp(1.89503979682922*x_89) - 0.172043192123021*std::sin(0.321279853582382*x_102 - 7.443039894104) + 32.8555945158978*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 5.93852009430976*std::sin(0.435039848089218*x_108 - 4.17264032363892) + 10.2328662053218*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 6.94642392007454*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 7.31227080505409*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 3623.85358874779*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 34.9097752946065*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 3366.26470115027*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 8.6654599184214*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 71.9853362192246*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 3810.69912985091*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 2.32738906816171*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 6.83015463613786*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.0429734785221883*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 6.58021365350096*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.243257224239526*std::sin(0.415199846029282*x_87 + 5.20800018310547) - 12.4358685135764*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 33.0061057184342*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 1446.7656327386*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 4.41614177419037*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.20194631326208*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 436683.24850817 - 0.0111870441630753*std::exp(-2.89071989059448*x_74) + 0.0865318124475354*std::exp(-4.75799989700317*x_111) - 1.91705073666599e-5*std::exp(-4.64391994476318*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (10541.7483776879*x_1 - 262.530724780882*x_10 - 98.2968887610894*x_100 + 473.816070764651*x_101 - 38.2097976480376*x_102 - 26.1996710930766*x_103 - 226.273351648448*x_104 + 49.4574922119698*x_105 - 20.6306490296706*x_106 - 228.129420464574*x_107 + 10.4935867598192*x_108 + 291.834040470947*x_109 + 40.6933495419372*x_11 + 164.937549134798*x_110 - 1.53002771410105*x_111 - 208.011903093216*x_112 + 548.758332781962*x_113 - 104.151712607023*x_114 + 2.17764329064701*x_115 + 1363.78780747607*x_116 - 126.054480759133*x_117 + 35.7089796249082*x_118 - 192.490651533694*x_119 - 1556.11529375645*x_12 - 100.337614864517*x_120 + 504.97835947629*x_13 - 137.097901237757*x_14 + 81.169235629946*x_15 - 67.9757838244725*x_16 - 313.463825442234*x_17 - 17.2280217493999*x_18 + 46.1599753075926*x_19 - 41.0979831668579*x_2 + 321.642807197932*x_20 + 1124.44338521814*x_21 + 73.8616416838814*x_22 - 17.13312622108*x_23 + 191.517864038821*x_24 + 426.612367020265*x_25 + 168.03660466959*x_26 + 195.394686489017*x_27 + 0.741381727321045*x_28 + 163.610289013075*x_29 - 284.198278004307*x_3 - 892.372002595374*x_30 - 705.816687332038*x_31 + 30.2292770060342*x_32 + 66.3081955796676*x_33 + 116.446115819012*x_34 - 228.31134715935*x_35 - 0.820202467919317*x_36 - 2516.50352150028*x_37 + 194.94762422762*x_38 - 241.894390257753*x_39 - 72.7534459150805*x_4 - 88.5711510761986*x_40 + 14.8295671788526*x_41 + 282905.811694906*x_42 + 357.314551451979*x_43 + 442.626292962156*x_44 - 18.2542255804776*x_45 - 175.997440685385*x_46 + 1447.45753979702*x_47 + 773.287862047346*x_48 + 136.201770410749*x_49 + 76.1872245409121*x_5 - 1235.44329081323*x_50 - 150.288243686736*x_51 - 11.9103723335254*x_52 + 0.128952723648127*x_53 + 430.968403227479*x_54 - 49.6909031672724*x_55 + 90.4396750423645*x_56 + 4646.26558585977*x_57 + 195.978427744421*x_58 + 129.275791815746*x_59 - 71.4212124591716*x_6 + 209.916412340508*x_60 + 78.5194003437796*x_61 + 23.8964882538377*x_62 + 1.42949421787693*x_63 - 99.1193223073109*x_64 + 18.0906613994547*x_65 - 69.5187811947161*x_66 - 177.069186591854*x_67 + 331.328804653032*x_68 + 15.7361266196311*x_69 - 23.4631687080826*x_7 + 125.748067133308*x_70 - 115.463539505919*x_72 - 80.7558000602251*x_73 + 433.593580019702*x_74 - 176.862688649073*x_75 + 148.563177928896*x_76 + 5.08604065033156*x_77 - 15.54953362417*x_78 + 55.553867834244*x_79 + 902.646513755349*x_8 - 55.0931293764506*x_80 + 67.6652801711674*x_81 - 246.896164643852*x_82 - 128.614233452225*x_83 - 328.553527852816*x_84 - 364.112957540179*x_85 + 190.590721060472*x_86 + 0.809491341053106*x_87 - 217.85363287109*x_88 + 1.06045720602912*x_89 - 96.005456043835*x_9 - 192.92012564664*x_90 + 217.238285761579*x_91 - 107.400823834746*x_92 - 368.566319566833*x_93 + 30.2637235886492*x_94 - 3.06817651985272*x_95 + 154.707555203726*x_96 + 991.550685485977*x_97 - 81.5109014068799*x_98 + 41.4658131801404*x_99 + 1.49873856396153*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 2.3917085888502*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.00241026001920381*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 108.735178081841*std::exp(0.833039879798889*x_108) - 0.496854612219043*std::exp(1.13703989982605*x_50) + 0.0812515644123057*std::exp(2.49991989135742*x_71) + 0.333978777843486*std::exp(2.57559990882874*x_71) + 3.08673868201349*std::exp(2.60271978378296*x_71) + 0.0550071036887562*std::exp(2.62631988525391*x_71) + 2.07797708229983e-5*std::exp(2.71295976638794*x_71) - 7.82207858378746*std::exp(1.8686398267746*x_89) + 0.247633626077253*std::exp(1.89503979682922*x_89) - 0.00253438070804508*std::sin(0.321279853582382*x_102 - 7.443039894104) + 35.4440087414243*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 3.43860026022856*std::sin(0.435039848089218*x_108 - 4.17264032363892) + 6.29592468604631*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 4.02221003211112*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 4.23404752258285*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 1554.14252103425*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 37.6600210385626*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 1443.67176570234*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 5.01758893752591*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 77.6564516272563*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 1634.27395934502*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 1.34763552675393*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 3.95488625722243*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.000633045420631035*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 7.09861299701259*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.00358343976647686*std::sin(0.415199846029282*x_87 + 5.20800018310547) - 7.65135495725846*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 35.6063774477888*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 620.466564872183*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 2.5570926784415*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.00297488574861056*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 188739.498263196 - 0.00688299701148891*std::exp(-2.89071989059448*x_74) + 0.0371104311621336*std::exp(-4.75799989700317*x_111) - 2.82402130732134e-7*std::exp(-4.64391994476318*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-18639.6618460603*x_1 + 504.678091775394*x_10 + 199.721074360971*x_100 - 976.492532214891*x_101 + 94.2600180926906*x_102 + 50.6562523109551*x_103 + 487.778672699312*x_104 - 68.977607857458*x_105 + 8.80907702953474*x_106 + 423.220915791318*x_107 + 11.630729112938*x_108 - 564.781601491213*x_109 - 56.8127701223647*x_11 - 325.222410557883*x_110 + 7.29547716296096*x_111 + 364.708553892803*x_112 - 942.875020709768*x_113 + 179.759468395929*x_114 + 9.04829552315306*x_115 - 2473.96993046458*x_116 + 213.847275719279*x_117 - 62.2113544121129*x_118 + 343.986656919698*x_119 + 2905.21477679787*x_12 + 213.960294071416*x_120 - 940.740976914596*x_13 + 241.405570547854*x_14 - 146.63436485971*x_15 + 137.293995574789*x_16 + 608.802779967705*x_17 + 51.5673462239347*x_18 - 89.942141360228*x_19 + 88.2344449541367*x_2 - 627.869025168245*x_20 - 2055.34149960527*x_21 - 176.78380645443*x_22 + 28.2418342591258*x_23 - 374.410041158448*x_24 - 706.087731933849*x_25 - 292.883875393662*x_26 - 368.406486100209*x_27 - 7.11642815142438*x_28 - 296.283588659131*x_29 + 534.776528667832*x_3 + 1384.03440988888*x_30 + 1079.24786633548*x_31 - 41.0563823446858*x_32 - 97.3820670317118*x_33 - 158.029879014689*x_34 + 426.413326039763*x_35 + 0.16914926533784*x_36 + 4755.21613520837*x_37 - 373.572212110906*x_38 + 440.0799722159*x_39 + 120.838880715826*x_4 + 182.009200858134*x_40 - 51.7785969212524*x_41 - 504177.02695983*x_42 - 623.074770448283*x_43 - 871.717391604731*x_44 + 16.8897968253226*x_45 + 335.253649212009*x_46 - 2535.96524212589*x_47 - 1363.98759462162*x_48 - 258.224711166675*x_49 - 136.430813047219*x_5 + 2360.69356094024*x_50 + 321.504396599959*x_51 + 52.8770013269684*x_52 - 2.01382770716743*x_53 - 840.279198736918*x_54 + 89.5881452620113*x_55 - 149.505694109579*x_56 - 8304.07874671485*x_57 - 335.818227165515*x_58 - 219.699582416407*x_59 + 131.597844171983*x_6 - 362.202959202794*x_60 - 142.165998939576*x_61 - 35.5871260425399*x_62 + 26.336179734327*x_63 + 197.066476363734*x_64 - 44.1876279393558*x_65 + 130.106568014446*x_66 + 333.340446955946*x_67 - 588.059426670525*x_68 - 0.422978797212617*x_69 + 32.8826427923054*x_7 - 237.983025022316*x_70 + 202.967791534037*x_72 + 130.948582137275*x_73 - 795.777843218563*x_74 + 318.68026780032*x_75 - 285.136783075932*x_76 + 6.84475706909903*x_77 + 44.7170700912925*x_78 - 113.529370377898*x_79 - 1622.2921702716*x_8 + 101.314730179951*x_80 - 87.1068689281753*x_81 + 443.610536346847*x_82 + 254.976189908657*x_83 + 522.295151130624*x_84 + 685.123552184235*x_85 - 369.397149572994*x_86 - 16.0877365814348*x_87 + 379.307429647278*x_88 + 4.1460702208363*x_89 + 105.589729635878*x_9 + 394.963616094072*x_90 - 418.570801436323*x_91 + 195.260809654684*x_92 + 683.758129439964*x_93 - 58.1043635394077*x_94 - 1.90197580547896*x_95 - 295.528665208407*x_96 - 1747.08595023139*x_97 + 164.274943547316*x_98 - 60.7986828419535*x_99 - 2.75077207258601*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) + 4.38972169674692*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.0168925664692555*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) - 199.571625343774*std::exp(0.833039879798889*x_108) - 3.48225896608403*std::exp(1.13703989982605*x_50) + 0.569460324458796*std::exp(2.49991989135742*x_71) + 0.608934669115474*std::exp(2.57559990882874*x_71) - 5.66537404589772*std::exp(2.60271978378296*x_71) - 0.108427754715857*std::exp(2.62631988525391*x_71) - 0.00131182964040805*std::exp(2.71295976638794*x_71) + 14.3565768141588*std::exp(1.8686398267746*x_89) - 0.48812528322939*std::exp(1.89503979682922*x_89) + 0.159995784419925*std::sin(0.321279853582382*x_102 - 7.443039894104) + 64.6241233483397*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 24.0997996043174*std::sin(0.435039848089218*x_108 - 4.17264032363892) - 12.4102694341217*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 28.1900914338644*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 29.6747772602742*std::sin(0.320639848709106*x_26 - 4.25831985473633) - 2852.46002637*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 68.6645199376886*std::sin(0.348559856414795*x_28 - 4.26224040985107) + 2649.70293723414*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 35.1663115046635*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 141.588953590595*std::sin(0.233519986271858*x_53 + 5.05207967758179) - 2999.53258988554*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 9.44504847221462*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 27.7182455196448*std::sin(0.371919840574265*x_80 - 7.42863988876343) - 0.039964239913044*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 12.9427132598838*std::sin(0.488959848880768*x_80 - 7.31591987609863) - 0.226223019508883*std::sin(0.415199846029282*x_87 + 5.20800018310547) + 15.0820381898993*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 64.9201659146463*std::sin(0.365999847650528*x_94 + 5.18839979171753) + 1138.79908054971*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 17.9216589473565*std::sin(0.400319844484329*x_95 - 1.17215991020203) - 0.187804925044488*std::sin(0.438399881124496*x_96 - 7.37599945068359) + 351198.220690313 + 0.013567482409081*std::exp(-2.89071989059448*x_74) - 0.0681121711932164*std::exp(-4.75799989700317*x_111) + 1.78280833202832e-5*std::exp(-4.64391994476318*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (10466.4166337667*x_1 - 262.532811979333*x_10 - 102.95968028445*x_100 + 492.097173659246*x_101 - 41.3984897768661*x_102 - 23.8866577695727*x_103 - 218.552359907063*x_104 + 58.2649942920483*x_105 - 16.9948614502985*x_106 - 224.532073847351*x_107 + 1.93806432673799*x_108 + 298.823806381187*x_109 + 36.9388634370593*x_11 + 166.906138164809*x_110 + 6.57963354133129*x_111 - 205.663505868125*x_112 + 536.617977884806*x_113 - 93.7711337706987*x_114 + 0.955650837951879*x_115 + 1348.33710885602*x_116 - 131.031580219723*x_117 + 30.1349501138933*x_118 - 194.796334628591*x_119 - 1518.57717026693*x_12 - 97.8768015655798*x_120 + 506.620329583055*x_13 - 137.160793054004*x_14 + 73.8067559978783*x_15 - 73.360810855069*x_16 - 313.60898907729*x_17 - 18.6260801581896*x_18 + 46.0589916551676*x_19 - 45.4950466689167*x_2 + 339.018131365436*x_20 + 1090.02066087977*x_21 + 86.1041901318833*x_22 - 22.4178750934922*x_23 + 199.130228634635*x_24 + 412.475924559753*x_25 + 163.5857058173*x_26 + 199.642445833784*x_27 - 3.36972009682121*x_28 + 158.747621693706*x_29 - 299.875138569203*x_3 - 855.20685604414*x_30 - 970.145296913732*x_31 + 19.1916259646229*x_32 + 68.9229790908231*x_33 + 115.526690678347*x_34 - 239.10810141005*x_35 - 1.19736678928543*x_36 - 2508.86768610175*x_37 + 197.206061135876*x_38 - 248.712234766901*x_39 - 76.1272056415935*x_4 - 86.6937755294046*x_40 + 15.6941218315916*x_41 + 278108.52993222*x_42 + 358.763549143046*x_43 + 449.537125002845*x_44 - 14.2111862668746*x_45 - 180.788419825456*x_46 + 1395.51607738137*x_47 + 792.336930191942*x_48 + 119.906074434899*x_49 + 70.6728256942541*x_5 - 1269.9627998282*x_50 - 159.99985232954*x_51 - 12.9568416588827*x_52 - 1.04489037600536*x_53 + 444.488463643283*x_54 - 49.0087680255711*x_55 + 84.0875789126258*x_56 + 4629.18929062835*x_57 + 197.85988907211*x_58 + 129.504403163559*x_59 - 68.3898086345158*x_6 + 217.43796422938*x_60 + 78.9393039054295*x_61 + 25.1254818205156*x_62 - 7.79826845987562*x_63 - 104.663272153985*x_64 + 27.703762179145*x_65 - 69.5900965313743*x_66 - 170.675904507528*x_67 + 331.224121605664*x_68 + 15.190445870125*x_69 - 22.9699177671241*x_7 + 108.057733961439*x_70 - 121.184579793852*x_72 - 68.6629618183325*x_73 + 439.0439423383*x_74 - 178.743744970358*x_75 + 133.639400323169*x_76 + 0.0781775809465424*x_77 - 13.8613405044877*x_78 + 55.4963097638685*x_79 + 866.262655733284*x_8 - 53.5799823811289*x_80 + 66.4224715519901*x_81 - 243.701547076433*x_82 - 130.676806006299*x_83 - 345.109018185044*x_84 - 368.585017803359*x_85 + 192.807864401511*x_86 + 2.77683896907535*x_87 - 228.649255168604*x_88 + 2.4162387406101*x_89 - 82.1547575898303*x_9 - 199.582401378274*x_90 + 209.093449836238*x_91 - 105.031593412278*x_92 - 361.288067680751*x_93 + 26.8001970750623*x_94 - 0.470219676698513*x_95 + 160.705670921638*x_96 + 967.220977089791*x_97 - 90.6824161673298*x_98 + 33.9272808692995*x_99 + 1.49784913129355*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) - 2.39028921938687*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) - 0.0128100971968124*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) + 108.670648735717*std::exp(0.833039879798889*x_108) - 2.64069263253721*std::exp(1.13703989982605*x_50) + 0.431837407259705*std::exp(2.49991989135742*x_71) + 0.0783070956437905*std::exp(2.57559990882874*x_71) + 3.084906844035*std::exp(2.60271978378296*x_71) - 0.00107286758797684*std::exp(2.62631988525391*x_71) - 0.000518298646618958*std::exp(2.71295976638794*x_71) - 7.81743653854275*std::exp(1.8686398267746*x_89) - 0.00482988692905436*std::exp(1.89503979682922*x_89) + 0.0632136948085663*std::sin(0.321279853582382*x_102 - 7.443039894104) + 8.31046032456219*std::sin(0.39319983124733*x_107 - 7.39888000488281) - 18.2755400676908*std::sin(0.435039848089218*x_108 - 4.17264032363892) - 0.122796749492976*std::sin(0.289599925279617*x_11 + 8.30231952667236) - 21.3773207234122*std::sin(0.38663986325264*x_11 + 5.18735980987549) + 22.5031987702828*std::sin(0.320639848709106*x_26 - 4.25831985473633) + 1553.22020865627*std::sin(0.315759837627411*x_28 - 4.29776000976563) - 8.83004270048532*std::sin(0.348559856414795*x_28 - 4.26224040985107) - 1442.81501265606*std::sin(0.359679847955704*x_36 + 5.16408014297485) - 26.6675800416712*std::sin(0.346159845590591*x_45 + 5.14376020431519) - 18.2078969933315*std::sin(0.233519986271858*x_53 + 5.05207967758179) + 1633.30409262989*std::sin(0.337439835071564*x_53 + 5.13800001144409) - 7.16243971440809*std::sin(0.50791984796524*x_66 - 1.10575985908508) - 21.0195070049299*std::sin(0.371919840574265*x_80 - 7.42863988876343) - 0.0157897114244522*std::sin(0.457359850406647*x_80 - 4.13359975814819) + 1.66439248171577*std::sin(0.488959848880768*x_80 - 7.31591987609863) - 0.0893798106353479*std::sin(0.415199846029282*x_87 + 5.20800018310547) + 0.149233284199009*std::sin(0.404799848794937*x_92 + 8.1943998336792) - 8.34853047351278*std::sin(0.365999847650528*x_94 + 5.18839979171753) - 620.098346394688*std::sin(0.375439822673798*x_95 + 5.17463970184326) - 13.5904862923933*std::sin(0.400319844484329*x_95 - 1.17215991020203) - 0.0742009750966256*std::sin(0.438399881124496*x_96 - 7.37599945068359) - 182837.02993454 + 0.000134247104584009*std::exp(-2.89071989059448*x_74) + 0.0370884078215777*std::exp(-4.75799989700317*x_111) + 7.04380444844849e-6*std::exp(-4.64391994476318*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8458.60026910062*x_1 + 208.395070337875*x_10 + 82.5119698776063*x_100 - 388.225246492182*x_101 + 31.0032826334571*x_102 + 21.4192051035832*x_103 + 184.909928250238*x_104 - 43.4346984131083*x_105 + 15.0631926502647*x_106 + 184.192134905923*x_107 - 12.1401818610638*x_108 - 231.048006556847*x_109 - 32.3301962811919*x_11 - 127.089687774478*x_110 + 0.807923191100692*x_111 + 162.813770850965*x_112 - 435.999829544248*x_113 + 81.4360022160901*x_114 + 1.04812939145607*x_115 - 1068.5262260068*x_116 + 103.177088721935*x_117 - 27.1628155718339*x_118 + 158.044826267911*x_119 + 1258.39479544194*x_12 + 75.9737657424413*x_120 - 403.612498129536*x_13 + 110.818859150133*x_14 - 64.4120589876819*x_15 + 51.9298706602729*x_16 + 248.271903195056*x_17 + 10.2813982520317*x_18 - 34.8413123474937*x_19 + 36.0479238911197*x_2 - 271.677002336045*x_20 - 906.90554427577*x_21 - 66.3001135338113*x_22 + 13.016585156724*x_23 - 155.548905256229*x_24 - 336.503333390625*x_25 - 136.249606687644*x_26 - 160.58634033549*x_27 - 2.43364402946713*x_28 - 127.554462615444*x_29 + 235.207425802484*x_3 + 749.88101739869*x_30 + 472.788117174373*x_31 - 25.1218988404056*x_32 - 55.8921148268353*x_33 - 99.3216435958259*x_34 + 181.234392672609*x_35 + 2.60264165557246*x_36 + 2055.18709209543*x_37 - 163.324027425341*x_38 + 198.429453516535*x_39 + 60.4250227363393*x_4 + 68.9812821480438*x_40 - 6.67667149401642*x_41 - 228188.327770278*x_42 - 284.918485255792*x_43 - 365.326373687137*x_44 + 15.4479207863838*x_45 + 140.65388175285*x_46 - 1141.88639729478*x_47 - 630.226972941627*x_48 - 106.672902847191*x_49 - 60.1353231876818*x_5 + 956.716304638984*x_50 + 118.007808358306*x_51 + 19.0017881037322*x_52 - 0.463269749676247*x_53 - 334.548416828849*x_54 + 40.365827505925*x_55 - 71.634670737894*x_56 - 3668.79524021024*x_57 - 159.77596319857*x_58 - 105.843044537237*x_59 + 56.3453522329317*x_6 - 167.951080110611*x_60 - 59.8965946069162*x_61 - 25.1774524899281*x_62 + 3.80200494368455*x_63 + 80.0982354712825*x_64 - 14.7726553129517*x_65 + 56.428681065486*x_66 + 142.42422222698*x_67 - 262.2250315802*x_68 - 13.9537177689926*x_69 + 22.2277063828686*x_7 - 98.1752243753482*x_70 + 96.0212664228215*x_72 + 62.4770563580099*x_73 - 347.904662400365*x_74 + 145.784975741907*x_75 - 127.949862214355*x_76 - 4.31803226984031*x_77 + 12.8566373501133*x_78 - 46.5345365817538*x_79 - 701.844841552107*x_8 + 47.0257709456822*x_80 - 56.9646214881193*x_81 + 193.974762397589*x_82 + 102.38732245867*x_83 + 247.717489307381*x_84 + 287.260919516054*x_85 - 151.289346496141*x_86 - 2.94112551673333*x_87 + 174.615566190492*x_88 - 1.50317969066464*x_89 + 124.015964805853*x_9 + 162.244373237783*x_90 - 161.383296029573*x_91 + 85.2557738263491*x_92 + 287.467153892897*x_93 - 28.5600053144187*x_94 + 4.39165390302594*x_95 - 124.432654976334*x_96 - 794.909338188633*x_97 + 69.0601674493162*x_98 - 35.3506613838048*x_99 - 1.19719786312718*std::pow(-6.41175985336304*x_115 - 9.80992031097412, 2) + 1.9105055949357*std::pow(-3.93224000930786*x_77 - 5.79079961776733, 2) + 0.00576121455773934*std::pow(-7.80232000350952*x_87 - 8.60567951202393, 2) - 86.8580591549227*std::exp(0.833039879798889*x_108) + 1.18762540231732*std::exp(1.13703989982605*x_50) - 0.194214604234237*std::exp(2.49991989135742*x_71) - 0.254701359547308*std::exp(2.57559990882874*x_71) - 2.4656981831245*std::exp(2.60271978378296*x_71) - 0.158164950655345*std::exp(2.62631988525391*x_71) + 8.00892006854653e-5*std::exp(2.71295976638794*x_71) + 6.24830506861078*std::exp(1.8686398267746*x_89) - 0.712034585037039*std::exp(1.89503979682922*x_89) - 0.00976798670538499*std::sin(0.321279853582382*x_102 - 7.443039894104) - 27.0305714409139*std::sin(0.39319983124733*x_107 - 7.39888000488281) + 8.21924345076228*std::sin(0.435039848089218*x_108 - 4.17264032363892) - 18.1030185288928*std::sin(0.289599925279617*x_11 + 8.30231952667236) + 9.61423863261797*std::sin(0.38663986325264*x_11 + 5.18735980987549) - 10.1205911523697*std::sin(0.320639848709106*x_26 - 4.25831985473633) - 1241.45474729044*std::sin(0.315759837627411*x_28 - 4.29776000976563) + 28.7205630879855*std::sin(0.348559856414795*x_28 - 4.26224040985107) + 1153.21030266107*std::sin(0.359679847955704*x_36 + 5.16408014297485) + 11.9934804549325*std::sin(0.346159845590591*x_45 + 5.14376020431519) + 59.2229360643722*std::sin(0.233519986271858*x_53 + 5.05207967758179) - 1305.46403418127*std::sin(0.337439835071564*x_53 + 5.13800001144409) + 3.2212364447825*std::sin(0.50791984796524*x_66 - 1.10575985908508) + 9.4533154505213*std::sin(0.371919840574265*x_80 - 7.42863988876343) + 0.0024398778103857*std::sin(0.457359850406647*x_80 - 4.13359975814819) - 5.41359661507176*std::sin(0.488959848880768*x_80 - 7.31591987609863) + 0.013811260434307*std::sin(0.415199846029282*x_87 + 5.20800018310547) + 22.0003617370729*std::sin(0.404799848794937*x_92 + 8.1943998336792) + 27.1543982616658*std::sin(0.365999847650528*x_94 + 5.18839979171753) + 495.630968247982*std::sin(0.375439822673798*x_95 + 5.17463970184326) + 6.11218683758125*std::sin(0.400319844484329*x_95 - 1.17215991020203) + 0.0114657771621383*std::sin(0.438399881124496*x_96 - 7.37599945068359) + 157095.550186517 + 0.0197910598755185*std::exp(-2.89071989059448*x_74) - 0.0296439485547096*std::exp(-4.75799989700317*x_111) - 1.08843168266211e-6*std::exp(-4.64391994476318*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
