
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.20935258409149*x_1 - 9.98579183654833*x_100 - 3.90297292111753*x_101 - 7.17608712556873*x_102 - 6.02978732920432*x_103 + 40.0658528228829*x_104 - 11.0262048690456*x_105 + 2.06379789987049*x_106 - 1.92829368419468*x_107 - 8.91147336137433*x_108 + 1.35073120742836*x_109 - 3.38889123759493*x_110 - 7.62636982124661*x_111 - 2.17621816492636*x_112 + 4.18227448964601*x_113 + 15.8948620877246*x_114 + 5.03170239374397*x_115 + 10.5756547011334*x_116 - 5.76536466780603*x_117 - 14.1713131190194*x_118 - 5.96614174124627*x_119 + 7.71015272450267*x_12 + 2.75181620975192*x_120 - 7.21280177938915*x_13 + 1.61735641981517*x_14 - 0.0436552545980679*x_15 - 0.241420537645802*x_16 + 1.19573939424642*x_17 + 44.2356245117403*x_18 - 0.0882208923611782*x_19 + 1.16190112142627*x_2 + 0.364719927846844*x_20 + 0.512187024610586*x_21 + 0.300755864308817*x_22 - 0.0419542246359854*x_23 + 2.11753994531366*x_24 + 0.0590814474848929*x_25 + 0.294442226528988*x_26 + 14.722018174294*x_27 - 0.0284422172349528*x_28 + 2.39089767860105*x_29 - 1.77070244854272*x_3 + 0.300544988712646*x_30 - 0.59764949761335*x_31 - 2.7889441171638*x_32 + 25.2575601270695*x_33 - 33.4087051653492*x_34 - 132.995726211175*x_35 + 44.8438111994448*x_36 - 156.162962361166*x_37 + 48.4012336719435*x_38 - 1.47199244197755*x_39 - 3.34670189098983*x_4 - 1596.75360594445*x_40 - 1.1482928454955*x_42 + 3.58766699882583*x_43 + 0.407891060001059*x_44 - 11.5921299671558*x_45 - 70.8853000524235*x_46 + 65.3587350411812*x_47 - 58.0204294382491*x_48 + 14.5427395662788*x_5 + 0.139602082121285*x_50 + 0.737282397978507*x_52 - 0.540009284551326*x_53 + 6.90193931258382*x_54 + 6.91386057008734*x_58 - 0.0594120786384329*x_59 + 7.59954488146189*x_6 + 0.130328062166994*x_60 + 4.9791644577198*x_61 + 3.79361766636079*x_62 + 4.71896967895904*x_63 + 4.82068164968237*x_64 - 0.442657382931257*x_65 - 0.0360112418530174*x_66 + 4.96029410944383*x_67 + 6.4352518783687*x_68 + 16.6253211191933*x_69 + 14.2028706569418*x_7 - 4.39246626252833*x_70 - 2.73694321838541*x_71 + 5.24593696747468*x_72 + 8.64995272282745*x_73 - 1.26623548699124*x_74 - 6.10326321984026*x_75 + 5.83904361660481*x_76 + 1.66447670504629*x_77 - 6.26948524575698*x_78 - 3.93632395737858*x_79 + 1.8671807610802*x_8 + 0.507677369730707*x_80 + 2.4925060820623*x_81 + 0.342120736526927*x_82 + 15.0245939473864*x_83 + 7.74153386739939*x_84 + 2.76271501659451*x_85 + 55.7940661991882*x_86 + 39.1036969178724*x_87 + 20.1316978458182*x_88 + 1.61168452240761*x_89 + 4.29520273047889*x_9 + 3.22800620670126*x_90 + 4.02436999779814*x_91 - 2.12687087859587*x_92 - 13.4410438827942*x_93 + 1.18413918223913*x_94 + 1.53860365192689*x_95 - 2.18458093171008*x_96 + 0.103364148861285*x_97 - 8.01218667700599*x_98 - 13.0552123522727*x_99 + 0.00226270623134942*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.00299402617782984*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.000557092235140973*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) + 0.0273633917871746*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.00136050600968875*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.00869034394653101*std::exp(1.10983991622925*x_1) - 0.517155709107295*std::exp(1.242959856987*x_1) + 1.09748147575518*std::exp(1.24823987483978*x_1) + 0.00862329968784228*std::exp(1.43383979797363*x_1) + 0.00334280059937956*std::exp(1.77823996543884*x_1) + 0.00574606423377998*std::exp(0.619279801845551*x_10) + 0.0419059386895559*std::exp(0.783999860286713*x_10) - 1.6703744834045*std::exp(0.794399857521057*x_10) - 0.00792804632027552*std::exp(0.803679883480072*x_10) - 0.0252672250429366*std::exp(0.826399862766266*x_10) - 0.805272552633335*std::exp(0.846799850463867*x_10) + 0.0697026452342528*std::exp(0.947519838809967*x_10) + 0.00800216145722626*std::exp(0.968719840049744*x_10) + 0.0392224038230869*std::exp(0.975119829177856*x_10) + 0.0169843230996785*std::exp(1.1814398765564*x_10) - 0.118480857067346*std::exp(0.822239875793457*x_11) - 0.00809870245794869*std::exp(0.89359986782074*x_11) - 0.000781184139874445*std::exp(0.906559824943542*x_11) - 1.93363991844787*std::exp(0.921199858188629*x_11) + 0.055816526944957*std::exp(0.932559847831726*x_11) + 0.250146556045283*std::exp(0.940079808235168*x_11) - 0.587926024544018*std::exp(0.943679809570313*x_11) - 0.0251796390770094*std::exp(0.948239862918854*x_11) + 0.310335509039442*std::exp(0.976479828357697*x_11) - 0.00615220274474757*std::exp(1.0525598526001*x_11) - 0.00469799676476198*std::exp(0.547999858856201*x_12) + 0.0522129751258083*std::exp(0.748719871044159*x_12) - 0.0716973791980787*std::exp(0.869919836521149*x_12) + 0.00319950026179481*std::exp(0.872399866580963*x_12) + 0.0464940728594347*std::exp(1.18807995319366*x_12) + 0.000928983162069418*std::exp(1.12631988525391*x_13) - 3.56959536104181e-5*std::exp(1.31047987937927*x_13) + 0.000329968119577069*std::exp(1.34023988246918*x_13) + 26.4951200449407*std::exp(0.269759833812714*x_14) + 0.0734506062127182*std::exp(0.473199844360352*x_14) - 0.0594578711206282*std::exp(0.679999828338623*x_14) + 0.00118353512310624*std::exp(0.895599842071533*x_14) + 0.124473030823386*std::exp(0.71207982301712*x_15) - 0.928009512295132*std::exp(0.832959890365601*x_15) - 0.180274718279326*std::exp(0.923279821872711*x_15) + 0.004098945360899*std::exp(0.930639863014221*x_15) - 0.867642994018299*std::exp(0.947279810905457*x_15) + 0.000260692483891323*std::exp(0.964959800243378*x_15) - 0.065725508606836*std::exp(1.01871979236603*x_15) - 0.0026579888778921*std::exp(1.03775978088379*x_15) - 2.89509696115677*std::exp(0.382159829139709*x_16) + 0.0444639278063303*std::exp(0.548479855060577*x_16) - 5.28334305763912*std::exp(0.570239841938019*x_16) + 0.0444503323243593*std::exp(0.715919852256775*x_16) - 0.146234749853754*std::exp(0.887839913368225*x_16) + 0.0193269066731151*std::exp(0.618079841136932*x_17) + 5.43033499210922*std::exp(0.642879843711853*x_17) + 0.722187695155491*std::exp(0.658879816532135*x_17) - 3.45041995656619*std::exp(0.666479825973511*x_17) + 0.0316125305534973*std::exp(0.713679850101471*x_17) - 0.369017402580381*std::exp(0.826239883899689*x_17) + 1.36819478315081*std::exp(0.442959845066071*x_18) - 0.0463729636776042*std::exp(0.693519830703735*x_19) - 0.00664299883400322*std::exp(0.705919861793518*x_19) + 1.07181213928337*std::exp(0.7219198346138*x_19) - 9.62060153782299*std::exp(0.723199844360352*x_19) - 0.0286069131078028*std::exp(0.725599884986877*x_19) - 7.01544852229563*std::exp(0.73967981338501*x_19) - 0.394938301203462*std::exp(0.765519857406616*x_19) + 2.11033645657823*std::exp(0.819519877433777*x_19) + 0.0422951373206393*std::exp(1.02399981021881*x_19) - 0.0330597944402628*std::exp(0.747839868068695*x_2) + 3.62644936612329*std::exp(0.754719853401184*x_2) - 0.175365850022574*std::exp(0.769999861717224*x_2) + 4.46263026038367*std::exp(0.827439904212952*x_2) + 0.0204577673328099*std::exp(1.00447976589203*x_2) - 0.273922864191143*std::exp(1.09567987918854*x_2) - 0.116163488619678*std::exp(0.44583985209465*x_20) - 0.340376474876533*std::exp(0.488959848880768*x_20) + 2.09480049075769*std::exp(0.627359867095947*x_20) + 0.969096881671843*std::exp(0.851519882678986*x_20) - 0.175074194230023*std::exp(0.915279805660248*x_20) - 0.0329195498441248*std::exp(1.0039998292923*x_20) + 0.0313508809557564*std::exp(0.855839908123016*x_21) + 0.0489186637104302*std::exp(0.53279983997345*x_22) - 0.888001154664754*std::exp(0.742159843444824*x_22) - 0.000531152306906928*std::exp(1.19607996940613*x_22) - 0.00956863830765718*std::exp(1.36079978942871*x_22) - 0.00585992352043281*std::exp(1.40143978595734*x_22) - 0.429116905310015*std::exp(0.62527984380722*x_23) + 0.00767937824998527*std::exp(0.664479851722717*x_23) - 0.105735717731218*std::exp(0.685359835624695*x_23) + 0.177910649704539*std::exp(0.735519826412201*x_23) - 1.66938175622113*std::exp(0.743439853191376*x_23) - 1.40205039281808*std::exp(0.744559824466705*x_23) + 0.33952190892961*std::exp(0.782239854335785*x_23) + 0.385338705391584*std::exp(0.818959891796112*x_23) - 0.315230294330336*std::exp(0.834479868412018*x_23) + 9.2211861784185*std::exp(0.368799835443497*x_24) + 1.13900156418801*std::exp(0.424879848957062*x_24) - 1.96134609493784*std::exp(0.609519839286804*x_24) - 0.0529971507905002*std::exp(0.61167985200882*x_24) + 0.0324667088932731*std::exp(0.653759837150574*x_24) - 0.310955847736081*std::exp(0.761439859867096*x_24) - 0.00210912366324*std::exp(0.780959844589233*x_24) - 0.136938877354357*std::exp(0.418559849262238*x_25) + 1.3210414837935*std::exp(0.545919835567474*x_25) - 6.86341394155714*std::exp(0.627679824829102*x_25) + 0.157497212957352*std::exp(0.643359839916229*x_25) - 0.142934642441551*std::exp(0.765359818935394*x_25) + 0.866343165829644*std::exp(0.878879845142365*x_25) + 0.193974188580941*std::exp(0.964159786701202*x_25) + 0.00172088802659779*std::exp(1.00615978240967*x_25) + 0.196395359848542*std::exp(0.429119855165482*x_26) + 0.520522722948988*std::exp(0.569839835166931*x_26) + 1.33832277114725*std::exp(0.698879837989807*x_26) - 0.0268979678446972*std::exp(0.736239850521088*x_26) - 0.449954230137365*std::exp(0.79943984746933*x_26) - 0.00236933047591451*std::exp(0.822479903697968*x_26) - 0.000308765547687461*std::exp(0.984079837799072*x_26) + 0.0551954535015283*std::exp(1.10487985610962*x_26) + 7.32873955678995e-5*std::exp(1.14151990413666*x_27) + 0.0863269470296699*std::exp(1.18543982505798*x_27) - 0.047024139998786*std::exp(1.24655985832214*x_27) + 0.00207043835182745*std::exp(1.2630398273468*x_27) - 0.00349996645091846*std::exp(1.27247989177704*x_27) + 0.268474443962325*std::exp(0.549759864807129*x_28) - 5.1783332336319*std::exp(0.565279841423035*x_28) + 0.00712904221820841*std::exp(0.650239825248718*x_28) + 0.0428373572907089*std::exp(0.667519807815552*x_28) - 0.581062915338759*std::exp(0.768079876899719*x_28) - 0.085220968048335*std::exp(0.905439794063568*x_28) + 0.000642313251470816*std::exp(1.13103985786438*x_29) - 0.0534138309330887*std::exp(1.1431999206543*x_29) + 0.00924479033451061*std::exp(1.1509598493576*x_29) - 0.0759506044006876*std::exp(1.16863989830017*x_29) + 0.164154783348911*std::exp(1.17591977119446*x_29) + 7.8313971403814*std::exp(0.575039863586426*x_3) + 0.98953364939923*std::exp(0.670239865779877*x_3) - 0.00608854210634125*std::exp(0.670399844646454*x_3) - 0.0200045311777439*std::exp(0.915599822998047*x_3) + 0.0397657188938408*std::exp(0.947999835014343*x_3) + 0.193823756096118*std::exp(0.739759802818298*x_30) - 2.3668958086669*std::exp(0.847439885139465*x_30) + 0.10097523438395*std::exp(0.853279888629913*x_30) + 1.28692794889981*std::exp(0.882479906082153*x_30) + 0.221860149832823*std::exp(0.916479825973511*x_30) + 0.900778732939435*std::exp(0.9440798163414*x_30) + 0.000487728175169351*std::exp(1.00999975204468*x_30) + 0.00585116818414026*std::exp(1.03159987926483*x_30) - 0.00154940224402164*std::exp(1.09999978542328*x_30) + 2.20178608029841*std::exp(0.787999868392944*x_32) + 0.00145234693820343*std::exp(0.823919892311096*x_32) - 1.01279195877387*std::exp(0.357519835233688*x_33) + 3.06737430347367*std::exp(0.36575984954834*x_33) + 0.0267393790949322*std::exp(0.395519852638245*x_33) + 0.650219810770865*std::exp(0.41407984495163*x_33) + 9.13032172781488*std::exp(0.379279851913452*x_34) + 0.751853652764661*std::exp(0.408159852027893*x_34) + 0.317987721244998*std::exp(0.431119859218597*x_36) + 0.896053891528559*std::exp(0.250399857759476*x_37) - 5.17639096778793*std::exp(0.375039845705032*x_38) + 0.0580869315357324*std::exp(0.385999858379364*x_4) + 0.0088133771667724*std::exp(0.527999818325043*x_4) - 4.12972300703475*std::exp(0.554479837417603*x_4) - 0.078889554215831*std::exp(0.638399839401245*x_4) - 2.45712307015162*std::exp(0.723759829998016*x_4) + 0.0123456457289995*std::exp(1.10615980625153*x_4) - 0.00338926120166554*std::exp(1.13591980934143*x_4) + 2.33582290235155*std::exp(0.685679852962494*x_41) - 0.176241543147881*std::exp(0.7497598528862*x_41) - 0.0201032451455591*std::exp(0.769599854946136*x_41) + 0.236875916803656*std::exp(0.797759890556335*x_41) + 0.00205648608632838*std::exp(0.798159837722778*x_41) - 0.082585296414076*std::exp(0.798719823360443*x_41) + 0.0512952651789439*std::exp(0.803759872913361*x_41) - 0.216072493984491*std::exp(0.805199861526489*x_41) + 0.377629112404651*std::exp(0.812879860401154*x_41) - 0.114880549292502*std::exp(0.866879880428314*x_41) - 0.412473270758696*std::exp(0.19999985396862*x_42) + 0.207131350876438*std::exp(0.596879839897156*x_42) - 0.130857035792265*std::exp(0.690479874610901*x_42) - 0.670894603887826*std::exp(0.718159854412079*x_42) - 0.00745761082552351*std::exp(0.841359853744507*x_42) - 0.125328936977635*std::exp(0.705839812755585*x_43) + 0.0224378146831053*std::exp(0.787679851055145*x_43) - 0.000296856435955697*std::exp(0.83271986246109*x_43) - 0.0196091511471194*std::exp(0.886719882488251*x_44) + 0.000106336043341069*std::exp(0.908799827098846*x_44) - 0.0157123152708238*std::exp(0.942639827728271*x_44) - 2.31844773602819*std::exp(0.515199840068817*x_45) - 0.340468724186814*std::exp(0.504559814929962*x_46) + 0.000400135546276605*std::exp(0.663999855518341*x_46) - 0.624177326882454*std::exp(0.700479865074158*x_46) + 0.128266457250737*std::exp(0.75791984796524*x_46) + 0.0120285724266618*std::exp(0.759199857711792*x_46) - 0.250020573484079*std::exp(0.801999866962433*x_46) - 0.10288724092999*std::exp(0.802399873733521*x_46) + 0.0548582687095848*std::exp(0.424159854650497*x_47) - 0.337598077295524*std::exp(0.552239894866943*x_47) - 0.00328699512627792*std::exp(0.608879864215851*x_48) - 0.370057353282385*std::exp(0.608959853649139*x_48) - 0.0199834915538931*std::exp(0.639919817447662*x_49) - 0.0197480523387988*std::exp(0.685839831829071*x_49) + 12.2125303610559*std::exp(0.703679859638214*x_49) + 0.00779106102203263*std::exp(0.705999851226807*x_49) + 1.31553374058264*std::exp(0.708399832248688*x_49) - 0.233337351875949*std::exp(0.708639860153198*x_49) + 2.49552356422681*std::exp(0.715839862823486*x_49) - 1.00006504873227*std::exp(0.719119846820831*x_49) - 2.24481968973409*std::exp(0.719919860363007*x_49) + 6.72462452021288*std::exp(0.720319867134094*x_49) + 0.000859747775877312*std::exp(1.93999981880188*x_5) - 1.04832683446808*std::exp(0.52215987443924*x_50) - 0.209457925568112*std::exp(0.537359833717346*x_50) + 0.516307920654857*std::exp(0.541919827461243*x_50) + 0.420895851267551*std::exp(0.543199837207794*x_50) + 10.4164943197472*std::exp(0.546079874038696*x_50) + 0.608255351922831*std::exp(0.599439859390259*x_50) + 1.65341596757443*std::exp(0.610719859600067*x_50) + 0.0113863584014923*std::exp(0.658079862594604*x_50) + 0.022993029690536*std::exp(0.463519841432571*x_51) + 0.0365821741386883*std::exp(0.48039984703064*x_51) + 1.70930378156996*std::exp(0.491039842367172*x_51) - 7.66322098375899*std::exp(0.493919849395752*x_51) + 76.4259846971856*std::exp(0.49415984749794*x_51) + 15.1202657567107*std::exp(0.496719866991043*x_51) - 31.3607253584995*std::exp(0.497119843959808*x_51) + 0.622560359868872*std::exp(0.499279826879501*x_51) + 15.1594026357769*std::exp(0.501199841499329*x_51) + 2.39461979774512*std::exp(0.510319828987122*x_51) + 0.28896641478399*std::exp(0.504639863967896*x_52) + 0.13275237724022*std::exp(0.546399831771851*x_52) - 0.00549802922883535*std::exp(0.600159823894501*x_52) + 0.0446993402477838*std::exp(0.641199827194214*x_52) - 0.0751804712026176*std::exp(0.673519849777222*x_52) - 0.855219317449382*std::exp(0.712159812450409*x_52) + 0.00376692782081646*std::exp(0.714239835739136*x_52) - 0.0362834780618572*std::exp(0.88375985622406*x_52) - 6.22384751418063*std::exp(0.474319845438004*x_54) + 0.237359144100101*std::exp(0.502159833908081*x_54) + 0.0107503173814562*std::exp(0.506399810314178*x_54) + 1.35686581185993*std::exp(0.519279837608337*x_54) + 6.05996195186299*std::exp(0.532479882240295*x_54) + 0.0549145035353634*std::exp(0.532879829406738*x_54) + 3.98017105003823*std::exp(0.542559862136841*x_54) - 3.61159792209579*std::exp(0.612959861755371*x_55) - 0.0116098926295277*std::exp(0.631199836730957*x_55) - 0.604585132240778*std::exp(0.650959849357605*x_55) + 0.9750005897195*std::exp(0.652479827404022*x_55) + 3.97129963971852*std::exp(0.653439819812775*x_55) + 0.553115493188736*std::exp(0.655679821968079*x_55) + 79.2474502255452*std::exp(0.655759811401367*x_55) - 6.17357697685329*std::exp(0.656879842281342*x_55) + 3.6236855641766*std::exp(0.657759845256805*x_55) - 18.9015944564725*std::exp(0.659119844436646*x_55) - 14.3991221876089*std::exp(0.347199827432632*x_56) + 16.4717044355065*std::exp(0.442879855632782*x_56) + 1.11033310961321*std::exp(0.466319859027863*x_56) + 0.559052475322461*std::exp(0.52183985710144*x_56) + 7.02423268802695*std::exp(0.525679886341095*x_56) + 0.789144804935295*std::exp(0.574079871177673*x_56) - 0.565786755078026*std::exp(0.655039846897125*x_56) - 0.0400902464145822*std::exp(0.658559858798981*x_56) + 0.000801393971990874*std::exp(0.754159867763519*x_56) + 0.00377145061186107*std::exp(0.859519898891449*x_56) - 2.25691395888058*std::exp(0.599999845027924*x_57) + 0.468048339817792*std::exp(0.609679877758026*x_57) - 0.201302114252513*std::exp(0.617039859294891*x_57) - 0.0823246293965354*std::exp(0.626319825649261*x_57) + 12.7451727215386*std::exp(0.628239870071411*x_57) - 2.62500243346169*std::exp(0.632079839706421*x_57) - 34.3915680108581*std::exp(0.634159862995148*x_57) + 0.0274898950217582*std::exp(0.637119889259338*x_57) - 8.97234723778617*std::exp(0.641199827194214*x_57) + 0.333852480422324*std::exp(0.671519815921783*x_57) + 0.738341234826524*std::exp(0.37679985165596*x_58) + 0.124902624507558*std::exp(0.451519846916199*x_58) + 0.0950187235869039*std::exp(0.558799862861633*x_58) + 0.592879525660735*std::exp(0.595039844512939*x_58) + 0.00532836440344029*std::exp(0.603839874267578*x_58) - 0.0298959538232644*std::exp(0.653759837150574*x_58) - 5.54268331765917*std::exp(0.512399852275848*x_59) + 0.318525167199652*std::exp(0.545279860496521*x_59) + 1.3782485220206*std::exp(0.696399867534637*x_59) + 0.269504290942794*std::exp(0.807599902153015*x_59) + 0.0170705364792343*std::exp(0.839199841022491*x_59) - 0.0161667372135378*std::exp(0.866959869861603*x_59) + 0.0115766500263894*std::exp(0.778479874134064*x_60) - 0.857229837092894*std::exp(0.780239880084991*x_60) - 3.23734138799597*std::exp(0.821839869022369*x_60) - 0.00201194374825171*std::exp(0.842239856719971*x_60) - 0.018158027734297*std::exp(0.845599889755249*x_60) + 0.0882766763093045*std::exp(0.847439885139465*x_60) - 0.0738993483049156*std::exp(0.850079894065857*x_60) + 0.170214695656275*std::exp(0.897759795188904*x_60) - 0.101246030106159*std::exp(0.979119837284088*x_60) + 0.036645627453301*std::exp(1.01919984817505*x_61) + 0.521817869192768*std::exp(1.04719984531403*x_61) + 0.863256283917397*std::exp(1.3343198299408*x_61) - 0.0311438074960502*std::exp(1.36879980564117*x_61) - 0.123293636967112*std::exp(0.578399837017059*x_66) - 3.23606073013605*std::exp(0.930159866809845*x_66) + 0.111257603348615*std::exp(1.03991973400116*x_66) + 0.00142733362842033*std::exp(1.46671986579895*x_66) - 1.11690236535776e-5*std::exp(1.60799980163574*x_7) - 0.000140235398082033*std::exp(1.8828798532486*x_7) + 0.437915085820127*std::exp(0.481679856777191*x_8) + 0.023259914345547*std::exp(0.549919843673706*x_8) - 0.519457286545448*std::exp(0.583999812602997*x_8) + 0.240337626309319*std::exp(0.832639873027802*x_8) - 0.0235207435126062*std::exp(0.863359868526459*x_8) + 0.007187644171466*std::exp(1.34103989601135*x_8) + 10.3799779677167*std::log(9.5269603729248 - 1.42447984218597*x_5) - 2.14300358233143*std::sin(0.289279937744141*x_103 - 7.47775983810425) - 1.54775700660443*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 26.3381391837233*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.372590273072338*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 6.43477847242629*std::sin(0.305919915437698*x_113 - 1.22279989719391) + 0.918053634013089*std::sin(0.32423985004425*x_113 - 7.54616022109985) + 0.965170334515081*std::sin(0.291599929332733*x_114 + 8.11127948760986) + 18.8343078143081*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0433006019412263*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.353805278016133*std::sin(0.272479951381683*x_117 + 1.92951989173889) - 2.56958457119637*std::sin(0.262239962816238*x_120 + 8.34039974212646) - 36.9144273891411*std::sin(0.264879941940308*x_120 + 5.15752029418945) + 59.4387390370628*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 0.871171212258987*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 2.46129141818066*std::sin(0.121840052306652*x_18 - 4.63351964950562) - 19.5101597348665*std::sin(0.408319860696793*x_21 - 7.41095972061157) + 1.17599371710654*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.440256544196747*std::sin(0.197599992156029*x_3 - 7.60056018829346) + 1.63296831027631*std::sin(0.563679814338684*x_3 - 0.974079847335815) + 0.268168836984189*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 107.572234341326*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 50.5212073729204*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 1.32663653079602*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 21.976240638722*std::sin(0.202879995107651*x_47 + 8.19711971282959) + 1.06810294738044*std::sin(0.441279858350754*x_5 - 7.41847991943359) - 3.61709841986297*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.00923938883214855*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0144316938153394*std::sin(0.603359878063202*x_64 - 7.20143985748291) + 10.3995079865365*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.140705299205397*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 11.0647285777851*std::sin(0.613759815692902*x_65 - 0.975039839744568) - 6.85761504376224*std::sin(0.515199840068817*x_72 + 2.14071989059448) + 2.67852424572096*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.243832542910237*std::sin(0.296639919281006*x_9 - 1.20775985717773) + 19.2779917526097*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 9.33169273948747*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 5.03934549713334*std::sin(0.357359826564789*x_91 - 7.3996000289917) + 39.6335701418593*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 6.58520961298404*std::sin(0.383279830217361*x_91 - 1.19735991954803) + 15.4047669711998*std::sin(0.388719856739044*x_91 - 4.3930401802063) + 1.37956867059466*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 7.21578152280207*std::sin(0.299439936876297*x_92 - 1.17271983623505) + 1.90927116161406*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 22.3343780171831*std::sin(0.310879945755005*x_92 + 8.21879959106445) + 2.15569730820431*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 2.40964609297462*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.330333287667296*std::sin(0.299599945545197*x_97 - 7.45336008071899) - 2.45431723013912*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 5.51242331682678*std::sin(0.334719836711884*x_97 + 1.83487987518311) + 22.0929942247203*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.31244105232606*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 5.45247702979328*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 849.259694733028);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.12411215298106*x_1 + 1.81244802243857*x_100 + 5.74385486032242*x_101 + 0.94762345008279*x_102 - 8.71128553390497*x_103 + 53.4596229584527*x_104 + 15.5434841678054*x_105 + 10.2270863361279*x_106 + 2.58291518334741*x_107 + 4.10421109815762*x_108 - 15.0966508756701*x_109 + 8.40279362253978*x_110 + 13.1439242129645*x_111 + 1.90486218016273*x_112 - 9.10949245067219*x_113 - 27.9065727423343*x_114 - 0.431481864066632*x_115 - 4.20969587872989*x_116 + 16.6248340909748*x_117 + 11.5625801372482*x_118 + 8.76391779484748*x_119 + 6.7177201692646*x_12 + 3.08155694981707*x_120 - 9.53193109429487*x_13 + 4.50830465621534*x_14 - 0.00903845676506204*x_15 + 1.92643699582311*x_16 + 2.31180442330383*x_17 - 32.4713822877418*x_18 + 0.0459293802519032*x_19 + 0.808293163221474*x_2 - 0.249308434910108*x_20 - 11.6386406026266*x_21 + 0.0615433350991667*x_22 - 0.0688018835616161*x_23 - 4.95955980229744*x_24 - 0.0992894918581863*x_25 + 0.0889382966873844*x_26 - 29.2948800664756*x_27 + 0.507545828106071*x_28 + 1.16082753772373*x_29 + 0.378016476126139*x_3 - 0.156469116327614*x_30 - 4.7672201137551*x_31 - 8.14937433242893*x_32 - 26.4204111974431*x_33 + 16.640262137145*x_34 - 5.56482139035826*x_35 - 40.7929411407334*x_36 + 155.335703154144*x_37 - 41.8561958699232*x_38 + 72.0006484209972*x_39 + 9.24295480361526*x_4 + 1466.91723356289*x_40 + 7.34836966733134*x_42 - 26.7805459372696*x_43 + 29.493055339672*x_44 - 1.27904605110122*x_45 + 140.615311260276*x_46 - 37.656588096294*x_47 + 84.3079816072787*x_48 - 29.2773849874151*x_5 + 0.209242369867483*x_50 - 7.57076252118109*x_52 - 5.85036952459755*x_53 - 25.086112063574*x_54 - 14.5138760910847*x_58 - 0.0613402640676091*x_59 - 6.41751147757843*x_6 + 0.282107217085889*x_60 - 8.30113352316861*x_61 - 11.895211530981*x_62 - 3.43740689359907*x_63 - 15.8763283888526*x_64 - 0.597337413424551*x_65 + 3.42670873316398*x_66 - 2.63796077456167*x_67 - 7.72007788242936*x_68 - 13.0978784253079*x_69 - 28.8307044773155*x_7 + 6.2666210603879*x_70 + 7.66643458800055*x_71 + 5.13558614007383*x_72 - 13.3925898040454*x_73 + 8.80471251034024*x_74 + 2.56865958041174*x_75 - 1.16341350713758*x_76 + 3.49746024755173*x_77 + 2.17858959978209*x_78 + 23.5880797144316*x_79 - 1.13407807911824*x_8 + 6.03970434233521*x_80 - 3.63830506907204*x_81 + 9.94198582485328*x_82 - 8.41925678712517*x_83 - 10.6980034375603*x_84 + 2.00235597937256*x_85 - 191.40206272003*x_86 - 40.7282924229014*x_87 - 14.2878441661391*x_88 - 0.720489920288173*x_89 - 4.95534226772338*x_9 + 6.5322236203298*x_90 + 2.97904092532486*x_91 + 8.47276109427248*x_92 + 7.36762329647486*x_93 - 2.53075011970753*x_94 + 4.64242806830053*x_95 + 22.2123156158061*x_96 + 6.99128753464688*x_97 + 15.3012174187175*x_98 + 29.2939649521301*x_99 + 0.000749450409178983*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.00648084824454472*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.000134735145538208*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.0532397259188683*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.0029449418478281*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.0142515333677928*std::exp(1.10983991622925*x_1) - 0.410706867498871*std::exp(1.242959856987*x_1) - 0.60027129197737*std::exp(1.24823987483978*x_1) + 0.00208558200091768*std::exp(1.43383979797363*x_1) - 0.00525496909839261*std::exp(1.77823996543884*x_1) - 0.000440438025913339*std::exp(0.619279801845551*x_10) + 0.0101351309389975*std::exp(0.783999860286713*x_10) - 1.32655264081553*std::exp(0.794399857521057*x_10) - 0.0130014205847302*std::exp(0.803679883480072*x_10) + 0.0131545709394585*std::exp(0.826399862766266*x_10) + 0.440446610026388*std::exp(0.846799850463867*x_10) + 0.150877861172864*std::exp(0.947519838809967*x_10) - 0.0125796050131968*std::exp(0.968719840049744*x_10) + 0.0129911900126183*std::exp(0.975119829177856*x_10) - 0.0330456368047258*std::exp(1.1814398765564*x_10) - 0.256462839310787*std::exp(0.822239875793457*x_11) - 0.0132812842650899*std::exp(0.89359986782074*x_11) + 5.98780637394253e-5*std::exp(0.906559824943542*x_11) - 1.53562878605239*std::exp(0.921199858188629*x_11) - 0.0290590859124392*std::exp(0.932559847831726*x_11) + 0.0828531941908547*std::exp(0.940079808235168*x_11) + 1.14390133543183*std::exp(0.943679809570313*x_11) - 0.0060898036656029*std::exp(0.948239862918854*x_11) - 0.169739080861822*std::exp(0.976479828357697*x_11) + 0.00967142201562821*std::exp(1.0525598526001*x_11) + 0.000360103252702038*std::exp(0.547999858856201*x_12) - 0.0271830121465843*std::exp(0.748719871044159*x_12) - 0.0237475061643399*std::exp(0.869919836521149*x_12) + 0.00524694822457886*std::exp(0.872399866580963*x_12) - 0.0904614353052678*std::exp(1.18807995319366*x_12) + 0.000224678560655749*std::exp(1.12631988525391*x_13) - 5.85387732757262e-5*std::exp(1.31047987937927*x_13) - 0.000171787326442072*std::exp(1.34023988246918*x_13) - 51.5503684759326*std::exp(0.269759833812714*x_14) + 0.0177643440236353*std::exp(0.473199844360352*x_14) + 0.0309548350575255*std::exp(0.679999828338623*x_14) + 0.00194091170645051*std::exp(0.895599842071533*x_14) - 0.0648028943120275*std::exp(0.71207982301712*x_15) - 0.736992501662228*std::exp(0.832959890365601*x_15) + 0.0986018811642584*std::exp(0.923279821872711*x_15) + 0.00672197290959124*std::exp(0.930639863014221*x_15) + 1.68813411569144*std::exp(0.947279810905457*x_15) - 1.9982178810418e-5*std::exp(0.964959800243378*x_15) - 0.0217695114975282*std::exp(1.01871979236603*x_15) - 0.000642846005942097*std::exp(1.03775978088379*x_15) + 1.58348330396877*std::exp(0.382159829139709*x_16) + 0.0729176146184636*std::exp(0.548479855060577*x_16) - 4.19584515632733*std::exp(0.570239841938019*x_16) + 0.010750503448372*std::exp(0.715919852256775*x_16) - 0.0484356703471497*std::exp(0.887839913368225*x_16) - 0.00148141480425436*std::exp(0.618079841136932*x_17) - 10.5655595942255*std::exp(0.642879843711853*x_17) - 0.37598387837934*std::exp(0.658879816532135*x_17) + 1.88721913849826*std::exp(0.666479825973511*x_17) + 0.051842255818123*std::exp(0.713679850101471*x_17) - 0.122225430560245*std::exp(0.826239883899689*x_17) + 2.96158491339755*std::exp(0.442959845066071*x_18) - 0.0112155000842167*std::exp(0.693519830703735*x_19) + 0.000509188406804193*std::exp(0.705919861793518*x_19) + 2.32003710348023*std::exp(0.7219198346138*x_19) + 18.7183735493057*std::exp(0.723199844360352*x_19) - 0.0469132613408406*std::exp(0.725599884986877*x_19) - 5.57142237038292*std::exp(0.73967981338501*x_19) + 0.620853235751204*std::exp(0.765519857406616*x_19) - 1.15425582962618*std::exp(0.819519877433777*x_19) + 0.0140089365256799*std::exp(1.02399981021881*x_19) - 0.0542156635567744*std::exp(0.747839868068695*x_2) - 1.98349903336222*std::exp(0.754719853401184*x_2) + 0.275679657037582*std::exp(0.769999861717224*x_2) - 8.68273983678566*std::exp(0.827439904212952*x_2) + 0.00494779873978218*std::exp(1.00447976589203*x_2) - 0.0907283498879571*std::exp(1.09567987918854*x_2) + 0.182612011967208*std::exp(0.44583985209465*x_20) - 0.73677655059343*std::exp(0.488959848880768*x_20) + 1.66361684197456*std::exp(0.627359867095947*x_20) - 1.88552840124233*std::exp(0.851519882678986*x_20) + 0.0957574365344425*std::exp(0.915279805660248*x_20) - 0.0109035674887207*std::exp(1.0039998292923*x_20) - 0.0163218314178233*std::exp(0.855839908123016*x_21) + 0.0802230581972908*std::exp(0.53279983997345*x_22) - 0.705219271768834*std::exp(0.742159843444824*x_22) - 0.000128461462680323*std::exp(1.19607996940613*x_22) + 0.0052335998431766*std::exp(1.36079978942871*x_22) + 0.0114013907544751*std::exp(1.40143978595734*x_22) + 0.223405964154321*std::exp(0.62527984380722*x_23) - 0.000588627286270404*std::exp(0.664479851722717*x_23) - 0.0255726366631148*std::exp(0.685359835624695*x_23) - 0.279680148030914*std::exp(0.735519826412201*x_23) + 0.913074129949005*std::exp(0.743439853191376*x_23) + 2.72790665786771*std::exp(0.744559824466705*x_23) + 0.11245597419899*std::exp(0.782239854335785*x_23) + 0.834101482106051*std::exp(0.818959891796112*x_23) - 0.250344808043681*std::exp(0.834479868412018*x_23) + 7.32314160564824*std::exp(0.368799835443497*x_24) - 0.592984660990851*std::exp(0.424879848957062*x_24) + 1.072765035613*std::exp(0.609519839286804*x_24) - 0.0869114810110888*std::exp(0.61167985200882*x_24) + 0.00785221274314626*std::exp(0.653759837150574*x_24) - 0.673092865671609*std::exp(0.761439859867096*x_24) + 0.000161665137187901*std::exp(0.780959844589233*x_24) - 0.0331192545979558*std::exp(0.418559849262238*x_25) + 0.43755352190859*std::exp(0.545919835567474*x_25) + 13.3538371251005*std::exp(0.627679824829102*x_25) - 0.0819958763613278*std::exp(0.643359839916229*x_25) - 0.309395333084025*std::exp(0.765359818935394*x_25) + 0.688019259095383*std::exp(0.878879845142365*x_25) - 0.106094853864957*std::exp(0.964159786701202*x_25) + 0.00282213146961618*std::exp(1.00615978240967*x_25) + 0.0474990598020558*std::exp(0.429119855165482*x_26) + 1.12671986646248*std::exp(0.569839835166931*x_26) - 2.60391467845211*std::exp(0.698879837989807*x_26) + 0.0422843019292495*std::exp(0.736239850521088*x_26) - 0.14903321395246*std::exp(0.79943984746933*x_26) - 0.00388553002557545*std::exp(0.822479903697968*x_26) + 2.36669975761923e-5*std::exp(0.984079837799072*x_26) - 0.0301893443457356*std::exp(1.10487985610962*x_26) - 5.61750696041585e-6*std::exp(1.14151990413666*x_27) + 0.0685578238254367*std::exp(1.18543982505798*x_27) + 0.0257200161412955*std::exp(1.24655985832214*x_27) - 0.0032547826995722*std::exp(1.2630398273468*x_27) - 0.00757600304144351*std::exp(1.27247989177704*x_27) - 0.422048777600438*std::exp(0.549759864807129*x_28) + 10.0752510587649*std::exp(0.565279841423035*x_28) + 0.0116911118453208*std::exp(0.650239825248718*x_28) + 0.0103603985210373*std::exp(0.667519807815552*x_28) + 0.317814372830782*std::exp(0.768079876899719*x_28) - 0.184468714824258*std::exp(0.905439794063568*x_28) + 0.00105334711632051*std::exp(1.13103985786438*x_29) + 0.103924898684793*std::exp(1.1431999206543*x_29) - 0.0145330497840609*std::exp(1.1509598493576*x_29) + 0.0415414459717342*std::exp(1.16863989830017*x_29) + 0.130365952974908*std::exp(1.17591977119446*x_29) + 6.21942005284592*std::exp(0.575039863586426*x_3) + 0.327751958324855*std::exp(0.670239865779877*x_3) + 0.000466689086112618*std::exp(0.670399844646454*x_3) - 0.00483818163248119*std::exp(0.915599822998047*x_3) - 0.0625127397671538*std::exp(0.947999835014343*x_3) + 0.0641980347701666*std::exp(0.739759802818298*x_30) + 4.60516317246194*std::exp(0.847439885139465*x_30) - 0.158735683034488*std::exp(0.853279888629913*x_30) + 1.0220328950864*std::exp(0.882479906082153*x_30) + 0.480236937547645*std::exp(0.916479825973511*x_30) - 0.492684045929092*std::exp(0.9440798163414*x_30) - 3.73845515668019e-5*std::exp(1.00999975204468*x_30) + 0.00141513011154998*std::exp(1.03159987926483*x_30) - 0.00254090723182732*std::exp(1.09999978542328*x_30) - 4.28391656848657*std::exp(0.787999868392944*x_32) - 0.000111322949479595*std::exp(0.823919892311096*x_32) + 0.527277674772928*std::exp(0.357519835233688*x_33) - 1.67771099266833*std::exp(0.36575984954834*x_33) - 0.00204958365649403*std::exp(0.395519852638245*x_33) - 1.0221623788741*std::exp(0.41407984495163*x_33) - 4.99386107264656*std::exp(0.379279851913452*x_34) - 1.1819334101248*std::exp(0.408159852027893*x_34) - 0.499884931551376*std::exp(0.431119859218597*x_36) - 1.40861991928295*std::exp(0.250399857759476*x_37) + 10.0714720790975*std::exp(0.375039845705032*x_38) + 0.0952583520407886*std::exp(0.385999858379364*x_4) - 0.000675548737889651*std::exp(0.527999818325043*x_4) - 3.27968070348686*std::exp(0.554479837417603*x_4) + 0.0410713181028363*std::exp(0.638399839401245*x_4) + 1.34393196828439*std::exp(0.723759829998016*x_4) - 0.0194076747556035*std::exp(1.10615980625153*x_4) - 0.000819707352693314*std::exp(1.13591980934143*x_4) - 4.54470601025783*std::exp(0.685679852962494*x_41) - 0.381491218742014*std::exp(0.7497598528862*x_41) - 0.0329678630392091*std::exp(0.769599854946136*x_41) + 0.0784577115285858*std::exp(0.797759890556335*x_41) - 0.000157630446742305*std::exp(0.798159837722778*x_41) - 0.0199736080127752*std::exp(0.798719823360443*x_41) - 0.0806374850654373*std::exp(0.803759872913361*x_41) + 0.112491219172454*std::exp(0.805199861526489*x_41) - 0.206545550151931*std::exp(0.812879860401154*x_41) - 0.0912340900536868*std::exp(0.866879880428314*x_41) - 0.0997584289650535*std::exp(0.19999985396862*x_42) - 0.10783629956435*std::exp(0.596879839897156*x_42) - 0.283252229716753*std::exp(0.690479874610901*x_42) + 0.36694812582534*std::exp(0.718159854412079*x_42) + 0.0117235573199424*std::exp(0.841359853744507*x_42) - 0.0415112760987268*std::exp(0.705839812755585*x_43) - 0.0116815291142484*std::exp(0.787679851055145*x_43) + 2.27541595973399e-5*std::exp(0.83271986246109*x_43) + 0.0107252930948665*std::exp(0.886719882488251*x_44) - 8.15069847936002e-6*std::exp(0.908799827098846*x_44) - 0.0052042111988375*std::exp(0.942639827728271*x_44) - 1.84122961490199*std::exp(0.515199840068817*x_45) - 0.736976232808978*std::exp(0.504559814929962*x_46) - 3.06705429890207e-5*std::exp(0.663999855518341*x_46) + 0.341395949460465*std::exp(0.700479865074158*x_46) - 0.0667778202074275*std::exp(0.75791984796524*x_46) + 0.0197259858021974*std::exp(0.759199857711792*x_46) - 0.198557542221028*std::exp(0.801999866962433*x_46) - 0.0340781687635571*std::exp(0.802399873733521*x_46) + 0.0899635793271536*std::exp(0.424159854650497*x_47) + 0.175759619398736*std::exp(0.552239894866943*x_47) + 0.000251949436293065*std::exp(0.608879864215851*x_48) - 0.801023573594592*std::exp(0.608959853649139*x_48) - 0.00483309310924789*std::exp(0.639919817447662*x_49) - 0.0323853726143549*std::exp(0.685839831829071*x_49) - 23.761373380007*std::exp(0.703679859638214*x_49) - 0.000597187813554435*std::exp(0.705999851226807*x_49) - 0.6848904810219*std::exp(0.708399832248688*x_49) + 0.366812359025082*std::exp(0.708639860153198*x_49) + 0.82656384218741*std::exp(0.715839862823486*x_49) - 2.16473385019128*std::exp(0.719119846820831*x_49) + 1.2278118994999*std::exp(0.719919860363007*x_49) + 5.3404601808809*std::exp(0.720319867134094*x_49) + 0.000682781432461057*std::exp(1.93999981880188*x_5) + 0.573385990781932*std::exp(0.52215987443924*x_50) + 0.329273282551804*std::exp(0.537359833717346*x_50) - 0.268799171943784*std::exp(0.541919827461243*x_50) + 0.911068232810386*std::exp(0.543199837207794*x_50) - 20.2669064906903*std::exp(0.546079874038696*x_50) + 0.201465491219339*std::exp(0.599439859390259*x_50) + 1.31308478424672*std::exp(0.610719859600067*x_50) + 0.00275383959711275*std::exp(0.658079862594604*x_50) + 0.0377068999659247*std::exp(0.463519841432571*x_51) - 0.0028040376692174*std::exp(0.48039984703064*x_51) - 2.6870698041585*std::exp(0.491039842367172*x_51) + 3.98961040970284*std::exp(0.493919849395752*x_51) + 60.694827916877*std::exp(0.49415984749794*x_51) + 5.00811338266557*std::exp(0.496719866991043*x_51) + 61.0171588262674*std::exp(0.497119843959808*x_51) + 0.150568892190762*std::exp(0.499279826879501*x_51) - 8.2914877442659*std::exp(0.501199841499329*x_51) + 5.18337736239077*std::exp(0.510319828987122*x_51) - 0.454262686337023*std::exp(0.504639863967896*x_52) - 0.069113270682504*std::exp(0.546399831771851*x_52) + 0.000421426047715637*std::exp(0.600159823894501*x_52) + 0.0108107270822452*std::exp(0.641199827194214*x_52) - 0.162735125172049*std::exp(0.673519849777222*x_52) - 0.679185090116225*std::exp(0.712159812450409*x_52) + 0.00617748824013606*std::exp(0.714239835739136*x_52) + 0.0198453739172561*std::exp(0.88375985622406*x_52) + 3.40415494105411*std::exp(0.474319845438004*x_54) + 0.0574063266508443*std::exp(0.502159833908081*x_54) - 0.000824015947749972*std::exp(0.506399810314178*x_54) - 2.13302818998917*std::exp(0.519279837608337*x_54) + 4.81260855595742*std::exp(0.532479882240295*x_54) + 0.09005580036017*std::exp(0.532879829406738*x_54) + 1.31830671641123*std::exp(0.542559862136841*x_54) - 2.86820399181101*std::exp(0.612959861755371*x_55) + 0.000889902719979026*std::exp(0.631199836730957*x_55) - 0.146221506322171*std::exp(0.650959849357605*x_55) - 1.53272617303033*std::exp(0.652479827404022*x_55) + 8.59624758434348*std::exp(0.653439819812775*x_55) + 0.907069266294008*std::exp(0.655679821968079*x_55) - 154.188214772216*std::exp(0.655759811401367*x_55) - 2.04480357516024*std::exp(0.656879842281342*x_55) - 1.8865557549454*std::exp(0.657759845256805*x_55) + 10.3382925137864*std::exp(0.659119844436646*x_55) + 7.87564972151216*std::exp(0.347199827432632*x_56) - 32.0482576276967*std::exp(0.442879855632782*x_56) - 1.74547239850997*std::exp(0.466319859027863*x_56) - 0.291052754428408*std::exp(0.52183985710144*x_56) + 5.57839844572651*std::exp(0.525679886341095*x_56) + 1.70817735717445*std::exp(0.574079871177673*x_56) - 0.18739910167145*std::exp(0.655039846897125*x_56) - 0.0657450945573361*std::exp(0.658559858798981*x_56) - 6.14271551173239e-5*std::exp(0.754159867763519*x_56) + 0.000912141500142572*std::exp(0.859519898891449*x_56) + 1.17498992176222*std::exp(0.599999845027924*x_57) - 0.735784109513732*std::exp(0.609679877758026*x_57) - 0.0486857793918056*std::exp(0.617039859294891*x_57) - 0.135006417473757*std::exp(0.626319825649261*x_57) - 6.97101633607831*std::exp(0.628239870071411*x_57) - 0.869449653073361*std::exp(0.632079839706421*x_57) + 66.9141336373514*std::exp(0.634159862995148*x_57) - 0.00210711098994855*std::exp(0.637119889259338*x_57) - 7.12552247466106*std::exp(0.641199827194214*x_57) + 0.722654757564679*std::exp(0.671519815921783*x_57) - 0.384393701110759*std::exp(0.37679985165596*x_58) + 0.0302082352428974*std::exp(0.451519846916199*x_58) - 0.149371893827758*std::exp(0.558799862861633*x_58) + 0.196372731441716*std::exp(0.595039844512939*x_58) - 0.000408421173818714*std::exp(0.603839874267578*x_58) - 0.0490271945616515*std::exp(0.653759837150574*x_58) + 10.7841506996793*std::exp(0.512399852275848*x_59) - 0.165829920017355*std::exp(0.545279860496521*x_59) - 0.753837799776913*std::exp(0.696399867534637*x_59) + 0.2140308250714*std::exp(0.807599902153015*x_59) - 0.0268353253580276*std::exp(0.839199841022491*x_59) - 0.0349944069514837*std::exp(0.866959869861603*x_59) + 0.0189848658641649*std::exp(0.778479874134064*x_60) + 0.468864826606048*std::exp(0.780239880084991*x_60) + 6.29875015287754*std::exp(0.821839869022369*x_60) + 0.000154216259456211*std::exp(0.842239856719971*x_60) - 0.00439159685801083*std::exp(0.845599889755249*x_60) - 0.13877322093346*std::exp(0.847439885139465*x_60) + 0.0384733273244231*std::exp(0.850079894065857*x_60) + 0.0563782746255104*std::exp(0.897759795188904*x_60) - 0.0804060346609646*std::exp(0.979119837284088*x_60) + 0.00886290211352531*std::exp(1.01919984817505*x_61) + 0.414409390995689*std::exp(1.04719984531403*x_61) - 0.472161012556602*std::exp(1.3343198299408*x_61) + 0.0489588718000133*std::exp(1.36879980564117*x_61) - 0.02981909470789*std::exp(0.578399837017059*x_66) + 6.29625843423431*std::exp(0.930159866809845*x_66) - 0.0579227055332146*std::exp(1.03991973400116*x_66) + 0.00234072356141037*std::exp(1.46671986579895*x_66) - 1.83163881963691e-5*std::exp(1.60799980163574*x_7) - 4.64485734019827e-5*std::exp(1.8828798532486*x_7) - 0.227986454867558*std::exp(0.481679856777191*x_8) + 0.0381445714309028*std::exp(0.549919843673706*x_8) - 0.172053919575904*std::exp(0.583999812602997*x_8) + 0.190867686279638*std::exp(0.832639873027802*x_8) + 0.0369752178316902*std::exp(0.863359868526459*x_8) - 0.00393130685883392*std::exp(1.34103989601135*x_8) + 3.43804185775134*std::log(9.5269603729248 - 1.42447984218597*x_5) + 3.36885712087837*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 2.43311409093217*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 20.9168234042487*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.611021006979256*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 13.9286767349795*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 1.44320408411475*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 1.51727275731115*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 10.3014898519492*std::sin(0.239199981093407*x_117 - 7.43759965896606) + 0.00331900773537076*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.580214978414163*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 4.0394534809673*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 20.1904738357767*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 115.647292554557*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 0.210696492731961*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 4.03633929679686*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 10.6711493992867*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 1.84869257365987*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.72198878072181*std::sin(0.197599992156029*x_3 - 7.60056018829346) - 0.850152616399888*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.421568355517633*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 35.6299257616505*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 109.357854162917*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 0.320852732775703*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 7.27893984235134*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 1.67908549000142*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 5.68617237467068*std::sin(0.217119991779327*x_53 + 1.98423981666565) - 0.000708202695325642*std::sin(0.551839888095856*x_6 - 4.35479974746704) - 0.00110619486243237*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 5.68804689000489*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.230746478964327*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 8.78721811222339*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 3.75079628507633*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 4.21070947012857*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.399867674147253*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 10.5441643177671*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 3.09083028324476*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 10.9081322202812*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 77.1132624182883*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 2.18114396407393*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 8.42569061682751*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 2.16871767177231*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 15.6192305068509*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 3.00142370340493*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 17.7371771623811*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 3.3888119866331*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 5.21590317655404*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.541722617729348*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 3.85825023617246*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 1.82581717994377*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 12.0838396637136*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.512380650304479*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 11.8023938630254*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 556.928197686024);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.46828687669757*x_1 + 1.31211609617639*x_100 - 15.3736014330793*x_101 - 46.5458960265734*x_102 + 4.06582683168604*x_103 - 388.451955933026*x_104 - 13.9675345568105*x_105 - 9.45935272469431*x_106 + 7.49588924868807*x_107 - 15.7071865336753*x_108 + 8.03122823972007*x_109 - 31.3542879854701*x_110 - 15.0338529347185*x_111 - 2.67109929726038*x_112 + 23.3656869398528*x_113 + 28.0444646909504*x_114 + 45.5082125438882*x_115 - 6.74047512805259*x_116 - 24.7981167798473*x_117 - 31.3506130837275*x_118 - 0.452173757288351*x_119 + 12.6765784237587*x_12 + 5.41162198709026*x_120 + 41.3605157797674*x_13 + 15.3102285521106*x_14 - 0.135821416610467*x_15 - 1.55704281470198*x_16 + 5.58590027402225*x_17 + 156.457146487385*x_18 - 0.0173882913676173*x_19 + 1.3627839291372*x_2 + 0.0717009077486312*x_20 + 6.30847896079267*x_21 + 0.441573920672314*x_22 - 0.0135309126379457*x_23 + 9.43041829158045*x_24 + 0.0116811273412883*x_25 + 0.251851544888688*x_26 + 62.0043440904457*x_27 + 1.71633080930952*x_28 + 3.84189995335542*x_29 + 3.22619830180377*x_3 + 0.0592372588050631*x_30 - 7.31291304766663*x_31 - 26.0754306206174*x_32 + 72.3570390087924*x_33 - 107.441198760714*x_34 + 135.098202625889*x_35 + 154.903077311401*x_36 - 584.690248091399*x_37 - 178.893986743912*x_38 + 34.9693276000279*x_39 - 10.5995597946995*x_4 - 3723.53129787019*x_40 - 3.10950902622544*x_42 - 25.6482337706205*x_43 - 28.9565001421732*x_44 + 154.246753160411*x_45 - 295.177614929787*x_46 + 90.3564192211276*x_47 - 141.08649424857*x_48 + 57.2789429167876*x_5 + 0.061319711530249*x_50 + 13.4456580954952*x_52 + 15.0526885804871*x_53 + 51.0675839616513*x_54 - 57.4696735264628*x_58 - 0.0165580709164762*x_59 + 5.76239858652784*x_6 + 0.808294698187904*x_60 + 22.3878916281407*x_61 + 16.9286764892225*x_62 + 22.7207826846412*x_63 + 44.3844080170537*x_64 - 0.0385419854444266*x_65 + 10.6820414394198*x_66 + 20.099099776174*x_67 + 9.78341932513867*x_68 + 34.7443357444864*x_69 + 31.0412143872386*x_7 + 1.40091774557179*x_70 - 10.4885558701026*x_71 + 2.00085434070644*x_72 + 38.3514401734356*x_73 - 12.7235703169497*x_74 - 3.95205821917306*x_75 + 2.20100546886765*x_76 + 13.7851601605774*x_77 + 6.52843284455123*x_78 - 5.62538287993155*x_79 + 8.3892635637504*x_8 - 2.105026838543*x_80 - 5.20790547673298*x_81 - 6.16846281107634*x_82 + 19.3125192964349*x_83 + 7.0427609839934*x_84 - 4.2632334501399*x_85 + 761.531997661897*x_86 + 126.176813195664*x_87 + 81.7707197099271*x_88 + 6.21869303198328*x_89 + 14.5937358003248*x_9 + 3.73485102631776*x_90 + 4.93048089292564*x_91 - 34.2197984092072*x_92 - 16.7608972243853*x_93 + 27.8388425080231*x_94 - 7.87677864317434*x_95 - 33.8756507596899*x_96 + 0.469972853689811*x_97 - 35.4048555007675*x_98 - 42.0364364079273*x_99 + 0.00044188459731227*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.0185689516558203*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.000263039503138333*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) + 0.111388317972414*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.00843785886323646*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.00280277578132984*std::exp(1.10983991622925*x_1) - 0.645981604206729*std::exp(1.242959856987*x_1) - 3.23445801661315*std::exp(1.24823987483978*x_1) + 0.00407162103907082*std::exp(1.43383979797363*x_1) + 0.00101040054511972*std::exp(1.77823996543884*x_1) + 0.010014424274795*std::exp(0.619279801845551*x_10) + 0.0197865211469998*std::exp(0.783999860286713*x_10) - 2.08647254475491*std::exp(0.794399857521057*x_10) - 0.00255692252877969*std::exp(0.803679883480072*x_10) - 0.0049801567331581*std::exp(0.826399862766266*x_10) + 2.37327036579928*std::exp(0.846799850463867*x_10) + 0.432295836028991*std::exp(0.947519838809967*x_10) + 0.00241874681368016*std::exp(0.968719840049744*x_10) + 0.00765975533140586*std::exp(0.975119829177856*x_10) + 0.0691381827475033*std::exp(1.1814398765564*x_10) - 0.734818327012215*std::exp(0.822239875793457*x_11) - 0.00261196187964412*std::exp(0.89359986782074*x_11) - 0.00136147266984121*std::exp(0.906559824943542*x_11) - 2.41531862547412*std::exp(0.921199858188629*x_11) + 0.0110014080301285*std::exp(0.932559847831726*x_11) + 0.0488511980281241*std::exp(0.940079808235168*x_11) - 2.39327388488663*std::exp(0.943679809570313*x_11) - 0.0118889464512875*std::exp(0.948239862918854*x_11) - 0.914609674265028*std::exp(0.976479828357697*x_11) - 0.0018595751742218*std::exp(1.0525598526001*x_11) - 0.00818781881472128*std::exp(0.547999858856201*x_12) + 0.0102911498666412*std::exp(0.748719871044159*x_12) - 0.0140018032815483*std::exp(0.869919836521149*x_12) + 0.00103189032577894*std::exp(0.872399866580963*x_12) + 0.189263692592622*std::exp(1.18807995319366*x_12) + 0.000438633414649518*std::exp(1.12631988525391*x_13) - 1.15125195143387e-5*std::exp(1.31047987937927*x_13) + 6.50365423843262e-5*std::exp(1.34023988246918*x_13) + 107.853839145278*std::exp(0.269759833812714*x_14) + 0.034680811802221*std::exp(0.473199844360352*x_14) - 0.0117191150471595*std::exp(0.679999828338623*x_14) + 0.000381709124495532*std::exp(0.895599842071533*x_14) + 0.0245335687436311*std::exp(0.71207982301712*x_15) - 1.15918100277056*std::exp(0.832959890365601*x_15) + 0.531299179633092*std::exp(0.923279821872711*x_15) + 0.00132197584551391*std::exp(0.930639863014221*x_15) - 3.53191937812131*std::exp(0.947279810905457*x_15) + 0.00045434318739254*std::exp(0.964959800243378*x_15) - 0.0128355548331854*std::exp(1.01871979236603*x_15) - 0.001255009547227*std::exp(1.03775978088379*x_15) + 8.53232585856856*std::exp(0.382159829139709*x_16) + 0.014340332300441*std::exp(0.548479855060577*x_16) - 6.59944841339867*std::exp(0.570239841938019*x_16) + 0.0209878949864999*std::exp(0.715919852256775*x_16) - 0.0285582293701686*std::exp(0.887839913368225*x_16) + 0.0336835502475089*std::exp(0.618079841136932*x_17) + 22.1052962111699*std::exp(0.642879843711853*x_17) + 0.142342813922812*std::exp(0.658879816532135*x_17) + 10.168953860035*std::exp(0.666479825973511*x_17) + 0.0101955498616669*std::exp(0.713679850101471*x_17) - 0.0720655222853232*std::exp(0.826239883899689*x_17) + 8.48554463958893*std::exp(0.442959845066071*x_18) - 0.0218956943848307*std::exp(0.693519830703735*x_19) - 0.011577630543979*std::exp(0.705919861793518*x_19) + 6.64737935354328*std::exp(0.7219198346138*x_19) - 39.1626385908489*std::exp(0.723199844360352*x_19) - 0.00922618986434505*std::exp(0.725599884986877*x_19) - 8.76302941426492*std::exp(0.73967981338501*x_19) - 0.119374716786487*std::exp(0.765519857406616*x_19) - 6.21950786461668*std::exp(0.819519877433777*x_19) + 0.0082598304031946*std::exp(1.02399981021881*x_19) - 0.0106623157567772*std::exp(0.747839868068695*x_2) - 10.6877414181665*std::exp(0.754719853401184*x_2) - 0.0530063774940927*std::exp(0.769999861717224*x_2) + 18.1660549358475*std::exp(0.827439904212952*x_2) + 0.00965944347291112*std::exp(1.00447976589203*x_2) - 0.0534944805740603*std::exp(1.09567987918854*x_2) - 0.0351117719214589*std::exp(0.44583985209465*x_20) - 2.11101504507957*std::exp(0.488959848880768*x_20) + 2.61662504673606*std::exp(0.627359867095947*x_20) + 3.94490830819932*std::exp(0.851519882678986*x_20) + 0.515972381802375*std::exp(0.915279805660248*x_20) - 0.00642886903524238*std::exp(1.0039998292923*x_20) + 0.00617924210580832*std::exp(0.855839908123016*x_21) + 0.0157770563220738*std::exp(0.53279983997345*x_22) - 1.10920637696905*std::exp(0.742159843444824*x_22) - 0.000250791574691797*std::exp(1.19607996940613*x_22) + 0.0282003474008316*std::exp(1.36079978942871*x_22) - 0.023854024730002*std::exp(1.40143978595734*x_22) - 0.0845787157735016*std::exp(0.62527984380722*x_23) + 0.0133838656919076*std::exp(0.664479851722717*x_23) - 0.0499247142602098*std::exp(0.685359835624695*x_23) + 0.0537755729364875*std::exp(0.735519826412201*x_23) + 4.91994199763759*std::exp(0.743439853191376*x_23) - 5.70733468216347*std::exp(0.744559824466705*x_23) + 0.0663053382394142*std::exp(0.782239854335785*x_23) + 2.38987081827024*std::exp(0.818959891796112*x_23) - 0.393755628411369*std::exp(0.834479868412018*x_23) + 11.5182265908*std::exp(0.368799835443497*x_24) + 0.224496607733117*std::exp(0.424879848957062*x_24) + 5.78040881807081*std::exp(0.609519839286804*x_24) - 0.0170924340427737*std::exp(0.61167985200882*x_24) + 0.0153296463980733*std::exp(0.653759837150574*x_24) - 1.92854830277108*std::exp(0.761439859867096*x_24) - 0.0036758480852903*std::exp(0.780959844589233*x_24) - 0.0646577568084327*std::exp(0.418559849262238*x_25) + 0.257986598530187*std::exp(0.545919835567474*x_25) - 27.9389390191312*std::exp(0.627679824829102*x_25) + 0.0310426176293726*std::exp(0.643359839916229*x_25) - 0.886480714528329*std::exp(0.765359818935394*x_25) + 1.08215328227201*std::exp(0.878879845142365*x_25) - 0.571673766830498*std::exp(0.964159786701202*x_25) + 0.000555014083792867*std::exp(1.00615978240967*x_25) + 0.0927310319810183*std::exp(0.429119855165482*x_26) + 3.22828215389941*std::exp(0.569839835166931*x_26) + 5.44791828227025*std::exp(0.698879837989807*x_26) - 0.00813022511062701*std::exp(0.736239850521088*x_26) - 0.0878717002845862*std::exp(0.79943984746933*x_26) - 0.000764147209445111*std::exp(0.822479903697968*x_26) - 0.000538126458420668*std::exp(0.984079837799072*x_26) - 0.162670059588725*std::exp(1.10487985610962*x_26) + 0.000127727613780758*std::exp(1.14151990413666*x_27) + 0.107831391487019*std::exp(1.18543982505798*x_27) + 0.138587857702795*std::exp(1.24655985832214*x_27) + 0.000625814186975887*std::exp(1.2630398273468*x_27) - 0.0217067934493496*std::exp(1.27247989177704*x_27) + 0.081149538079117*std::exp(0.549759864807129*x_28) - 21.0794711884095*std::exp(0.565279841423035*x_28) + 0.00229923084704242*std::exp(0.650239825248718*x_28) + 0.0202263044909537*std::exp(0.667519807815552*x_28) + 1.71248776967358*std::exp(0.768079876899719*x_28) - 0.528540480864719*std::exp(0.905439794063568*x_28) + 0.000207156360706327*std::exp(1.13103985786438*x_29) - 0.217431991997728*std::exp(1.1431999206543*x_29) + 0.00279434591319649*std::exp(1.1509598493576*x_29) + 0.223838895414048*std::exp(1.16863989830017*x_29) + 0.205046504212403*std::exp(1.17591977119446*x_29) + 9.78223463230488*std::exp(0.575039863586426*x_3) + 0.193246331376808*std::exp(0.670239865779877*x_3) - 0.0106113056497708*std::exp(0.670399844646454*x_3) - 0.0094454411847573*std::exp(0.915599822998047*x_3) + 0.0120196532377288*std::exp(0.947999835014343*x_3) + 0.037851901066718*std::exp(0.739759802818298*x_30) - 9.63493652372929*std::exp(0.847439885139465*x_30) + 0.0305209445888191*std::exp(0.853279888629913*x_30) + 1.60750769311589*std::exp(0.882479906082153*x_30) + 1.37597674566254*std::exp(0.916479825973511*x_30) - 2.65474275266996*std::exp(0.9440798163414*x_30) + 0.000850028241627282*std::exp(1.00999975204468*x_30) + 0.00276271732910728*std::exp(1.03159987926483*x_30) - 0.000499707159095289*std::exp(1.09999978542328*x_30) + 8.96282339291235*std::exp(0.787999868392944*x_32) + 0.00253119663157694*std::exp(0.823919892311096*x_32) - 0.199620761053302*std::exp(0.357519835233688*x_33) - 9.04005545879189*std::exp(0.36575984954834*x_33) + 0.0466022439371651*std::exp(0.395519852638245*x_33) + 0.196536536272149*std::exp(0.41407984495163*x_33) - 26.9085565079513*std::exp(0.379279851913452*x_34) + 0.227256552707531*std::exp(0.408159852027893*x_34) + 0.096115504749807*std::exp(0.431119859218597*x_36) + 0.270842759997454*std::exp(0.250399857759476*x_37) - 21.0715647955509*std::exp(0.375039845705032*x_38) + 0.018733970245804*std::exp(0.385999858379364*x_4) + 0.0153602352237869*std::exp(0.527999818325043*x_4) - 5.1584562367468*std::exp(0.554479837417603*x_4) - 0.0155490895393612*std::exp(0.638399839401245*x_4) + 7.24154492592993*std::exp(0.723759829998016*x_4) + 0.0037316156927671*std::exp(1.10615980625153*x_4) - 0.00160029080690118*std::exp(1.13591980934143*x_4) + 9.50844786340893*std::exp(0.685679852962494*x_41) - 1.09305012718101*std::exp(0.7497598528862*x_41) - 0.00648362009222905*std::exp(0.769599854946136*x_41) + 0.0462595708004633*std::exp(0.797759890556335*x_41) + 0.00358410963501485*std::exp(0.798159837722778*x_41) - 0.0389938935871066*std::exp(0.798719823360443*x_41) + 0.0155045933366427*std::exp(0.803759872913361*x_41) - 0.0425877746344741*std::exp(0.805199861526489*x_41) - 1.11293496692804*std::exp(0.812879860401154*x_41) - 0.143497829023723*std::exp(0.866879880428314*x_41) - 0.194755477377557*std::exp(0.19999985396862*x_42) + 0.0408254800423281*std::exp(0.596879839897156*x_42) - 0.811575392841678*std::exp(0.690479874610901*x_42) + 1.97723649809607*std::exp(0.718159854412079*x_42) - 0.00225415002163104*std::exp(0.841359853744507*x_42) - 0.0244755267301798*std::exp(0.705839812755585*x_43) + 0.00442248144311589*std::exp(0.787679851055145*x_43) - 0.000517370878119858*std::exp(0.83271986246109*x_43) + 0.0577913864861695*std::exp(0.886719882488251*x_44) + 0.000185325852687157*std::exp(0.908799827098846*x_44) - 0.00306846289195515*std::exp(0.942639827728271*x_44) - 2.89598386214127*std::exp(0.515199840068817*x_45) - 2.11158717534202*std::exp(0.504559814929962*x_46) + 0.000697369010301639*std::exp(0.663999855518341*x_46) + 1.83955301599412*std::exp(0.700479865074158*x_46) + 0.0252812510922786*std::exp(0.75791984796524*x_46) + 0.00387940819015307*std::exp(0.759199857711792*x_46) - 0.312301862475278*std::exp(0.801999866962433*x_46) - 0.0200928809922468*std::exp(0.802399873733521*x_46) + 0.0176926745236918*std::exp(0.424159854650497*x_47) - 0.0665404030275391*std::exp(0.552239894866943*x_47) - 0.00572868009205601*std::exp(0.608879864215851*x_48) - 2.29509586584916*std::exp(0.608959853649139*x_48) - 0.00943550700895152*std::exp(0.639919817447662*x_49) - 0.00636906469573204*std::exp(0.685839831829071*x_49) + 49.7136183147678*std::exp(0.703679859638214*x_49) + 0.0135785099941575*std::exp(0.705999851226807*x_49) + 0.259291006619295*std::exp(0.708399832248688*x_49) - 0.0705289413840627*std::exp(0.708639860153198*x_49) + 0.48735156600687*std::exp(0.715839862823486*x_49) - 6.20240386677091*std::exp(0.719119846820831*x_49) + 6.6158520227554*std::exp(0.719919860363007*x_49) + 8.39975979913967*std::exp(0.720319867134094*x_49) + 0.00107391494997335*std::exp(1.93999981880188*x_5) + 3.08959122197736*std::exp(0.52215987443924*x_50) - 0.0633111057276185*std::exp(0.537359833717346*x_50) + 0.101764018924228*std::exp(0.541919827461243*x_50) + 2.61039625244275*std::exp(0.543199837207794*x_50) + 42.4024839636172*std::exp(0.546079874038696*x_50) + 0.118786375148293*std::exp(0.599439859390259*x_50) + 2.06528958366997*std::exp(0.610719859600067*x_50) + 0.00537624089433881*std::exp(0.658079862594604*x_50) + 0.00741562211490569*std::exp(0.463519841432571*x_51) + 0.0637565815163642*std::exp(0.48039984703064*x_51) + 0.516657042898114*std::exp(0.491039842367172*x_51) - 1.51041681526537*std::exp(0.493919849395752*x_51) + 95.464053337027*std::exp(0.49415984749794*x_51) + 2.95284135986756*std::exp(0.496719866991043*x_51) - 127.660286972004*std::exp(0.497119843959808*x_51) + 0.29395126588345*std::exp(0.499279826879501*x_51) - 44.677247375511*std::exp(0.501199841499329*x_51) + 14.8514330260898*std::exp(0.510319828987122*x_51) + 0.0873434757290716*std::exp(0.504639863967896*x_52) + 0.0261654235568872*std::exp(0.546399831771851*x_52) - 0.00958214094598815*std::exp(0.600159823894501*x_52) + 0.0211054678340886*std::exp(0.641199827194214*x_52) - 0.466269315064933*std::exp(0.673519849777222*x_52) - 1.06825843146579*std::exp(0.712159812450409*x_52) + 0.00121489484549302*std::exp(0.714239835739136*x_52) + 0.106933364325833*std::exp(0.88375985622406*x_52) + 18.342700019212*std::exp(0.474319845438004*x_54) + 0.112072700696737*std::exp(0.502159833908081*x_54) + 0.018735996495428*std::exp(0.506399810314178*x_54) + 0.410128547964255*std::exp(0.519279837608337*x_54) + 7.56952669023716*std::exp(0.532479882240295*x_54) + 0.017710811160024*std::exp(0.532879829406738*x_54) + 0.777288831096383*std::exp(0.542559862136841*x_54) - 4.51126378067518*std::exp(0.612959861755371*x_55) - 0.0202340916924316*std::exp(0.631199836730957*x_55) - 0.285463990983817*std::exp(0.650959849357605*x_55) + 0.294705322096531*std::exp(0.652479827404022*x_55) + 24.6300020910842*std::exp(0.653439819812775*x_55) + 0.178388648150863*std::exp(0.655679821968079*x_55) + 322.593056185508*std::exp(0.655759811401367*x_55) - 1.20563975057699*std::exp(0.656879842281342*x_55) + 0.714226514016297*std::exp(0.657759845256805*x_55) + 55.7061008017836*std::exp(0.659119844436646*x_55) + 42.4365761252205*std::exp(0.347199827432632*x_56) + 67.0514629721371*std::exp(0.442879855632782*x_56) + 0.335611157729805*std::exp(0.466319859027863*x_56) + 0.11018894811103*std::exp(0.52183985710144*x_56) + 8.77400175658041*std::exp(0.525679886341095*x_56) + 4.89427642309615*std::exp(0.574079871177673*x_56) - 0.110492669781162*std::exp(0.655039846897125*x_56) - 0.0129297496634974*std::exp(0.658559858798981*x_56) + 0.00139669501075179*std::exp(0.754159867763519*x_56) + 0.00178074730265027*std::exp(0.859519898891449*x_56) - 0.444836551278498*std::exp(0.599999845027924*x_57) + 0.141473080321349*std::exp(0.609679877758026*x_57) - 0.0950478300963533*std::exp(0.617039859294891*x_57) - 0.026551017876763*std::exp(0.626319825649261*x_57) - 37.5621156192486*std::exp(0.628239870071411*x_57) - 0.512637534286624*std::exp(0.632079839706421*x_57) - 139.997955770925*std::exp(0.634159862995148*x_57) + 0.047910267065769*std::exp(0.637119889259338*x_57) - 11.2074007114218*std::exp(0.641199827194214*x_57) + 2.07055322863986*std::exp(0.671519815921783*x_57) + 0.145526668074597*std::exp(0.37679985165596*x_58) + 0.0589746584474079*std::exp(0.451519846916199*x_58) + 0.0287205195926455*std::exp(0.558799862861633*x_58) + 0.115783625298562*std::exp(0.595039844512939*x_58) + 0.00928644366922843*std::exp(0.603839874267578*x_58) - 0.00964192624033579*std::exp(0.653759837150574*x_58) - 22.5626331929066*std::exp(0.512399852275848*x_59) + 0.062781142504333*std::exp(0.545279860496521*x_59) - 4.061924578606*std::exp(0.696399867534637*x_59) + 0.336639064672306*std::exp(0.807599902153015*x_59) + 0.00515976913708397*std::exp(0.839199841022491*x_59) - 0.100266111222891*std::exp(0.866959869861603*x_59) + 0.00373365594302487*std::exp(0.778479874134064*x_60) + 2.52639700980576*std::exp(0.780239880084991*x_60) - 13.1782644021626*std::exp(0.821839869022369*x_60) - 0.00350647982554131*std::exp(0.842239856719971*x_60) - 0.00857358672750645*std::exp(0.845599889755249*x_60) + 0.0266826570154479*std::exp(0.847439885139465*x_60) - 0.0145655225855363*std::exp(0.850079894065857*x_60) + 0.0332412803768376*std::exp(0.897759795188904*x_60) - 0.12646688762353*std::exp(0.979119837284088*x_60) + 0.0173027858395289*std::exp(1.01919984817505*x_61) + 0.651805130077266*std::exp(1.04719984531403*x_61) - 2.54415793759709*std::exp(1.3343198299408*x_61) - 0.00941357976211721*std::exp(1.36879980564117*x_61) - 0.0582149507069334*std::exp(0.578399837017059*x_66) - 13.1730512207696*std::exp(0.930159866809845*x_66) + 0.0219288149565331*std::exp(1.03991973400116*x_66) + 0.000460338066045251*std::exp(1.46671986579895*x_66) - 3.60218987763347e-6*std::exp(1.60799980163574*x_7) - 2.73866141136002e-5*std::exp(1.8828798532486*x_7) + 0.086312832512974*std::exp(0.481679856777191*x_8) + 0.00750169671127101*std::exp(0.549919843673706*x_8) - 0.101444973592161*std::exp(0.583999812602997*x_8) + 0.300206848073915*std::exp(0.832639873027802*x_8) - 0.00710941959001962*std::exp(0.863359868526459*x_8) - 0.021183166936794*std::exp(1.34103989601135*x_8) + 2.02710909654379*std::log(9.5269603729248 - 1.42447984218597*x_5) - 0.647747875892769*std::sin(0.289279937744141*x_103 - 7.47775983810425) - 0.467827642329679*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 32.899092289034*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.120166359369824*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 39.9084988819319*std::sin(0.305919915437698*x_113 - 1.22279989719391) + 0.277492439252324*std::sin(0.32423985004425*x_113 - 7.54616022109985) + 0.291734012584664*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 55.5077960249217*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0754656720758921*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.114107896146749*std::sin(0.272479951381683*x_117 + 1.92951989173889) - 0.776686964801288*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 108.792875538362*std::sin(0.264879941940308*x_120 + 5.15752029418945) + 241.957620430771*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 0.411336630393054*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 0.793806093304908*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 57.4996425487907*std::sin(0.408319860696793*x_21 - 7.41095972061157) + 0.355457843654318*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.141989820798654*std::sin(0.197599992156029*x_3 - 7.60056018829346) + 0.321857192930245*std::sin(0.563679814338684*x_3 - 0.974079847335815) + 0.0810571647986533*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 21.0078147995153*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 313.332550078575*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 0.626391451708968*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 4.29174680766571*std::sin(0.202879995107651*x_47 + 8.19711971282959) + 0.322846597693408*std::sin(0.441279858350754*x_5 - 7.41847991943359) - 1.0933102668043*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.0161027019609334*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0251520169268399*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 30.6490566984193*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.0453797234429456*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 13.8210039856811*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 20.2105169364077*std::sin(0.515199840068817*x_72 + 2.14071989059448) + 0.809615254495036*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.0786399192222629*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 56.8154054040182*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 1.82238915122936*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 31.2540229628423*std::sin(0.357359826564789*x_91 - 7.3996000289917) + 161.336604309872*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 1.28602761495687*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 45.4003763387161*std::sin(0.388719856739044*x_91 - 4.3930401802063) + 0.416990752322365*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 44.7522801397124*std::sin(0.299439936876297*x_92 - 1.17271983623505) + 0.577099520334614*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 27.8979755737476*std::sin(0.310879945755005*x_92 + 8.21879959106445) + 0.651584702876688*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 14.9446261156321*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.106537801511359*std::sin(0.299599945545197*x_97 - 7.45336008071899) - 0.74184606395295*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 1.07652284853526*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 65.1116796590699*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.100767267664043*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 33.816264907907*std::sin(0.265759944915771*x_98 + 1.95295977592468) + 789.363237408568);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.22451828877845*x_1 + 3.45670262823099*x_100 - 14.0719095668964*x_101 - 33.6810374355941*x_102 + 4.89437256826531*x_103 - 296.400563478357*x_104 - 11.7422715503584*x_105 - 8.27300265340957*x_106 + 2.29075655743957*x_107 - 11.3487893200206*x_108 + 12.8463030367505*x_109 - 25.1627837957375*x_110 - 16.2246944251529*x_111 - 3.32116531988678*x_112 + 18.6025297818215*x_113 + 27.158202390396*x_114 + 30.2970442546359*x_115 - 6.1266502249306*x_116 - 23.9759532828442*x_117 - 20.3261665388853*x_118 - 2.16739445578228*x_119 + 4.06770405369936*x_12 + 0.627968049378443*x_120 + 32.5522659590335*x_13 + 9.21586182580435*x_14 + 0.00526440096228847*x_15 - 1.91750553892129*x_16 + 3.31572757407592*x_17 + 109.672171177695*x_18 + 0.100561657361117*x_19 + 0.241654256456891*x_2 - 0.432598738478463*x_20 + 6.50130758546619*x_21 + 0.0857858938426805*x_22 + 0.014188478856109*x_23 + 6.48219004157658*x_24 - 0.221864036936485*x_25 - 0.0681041539444782*x_26 + 50.9665938904556*x_27 - 2.38178323330591*x_28 + 2.50086833909781*x_29 + 2.51030712129275*x_3 - 0.342586674965688*x_30 - 2.20484140077586*x_31 - 14.3126298748132*x_32 + 61.1350460394087*x_33 - 92.9518203107743*x_34 + 156.579077498724*x_35 + 108.637579665712*x_36 - 482.384208663709*x_37 - 143.008826946546*x_38 - 1.79449117467932*x_39 - 10.28441571697*x_4 - 2812.50192891828*x_40 - 11.5850218882469*x_42 - 7.21166766039452*x_43 - 31.7979900375552*x_44 + 107.106102157005*x_45 - 243.336634879648*x_46 + 67.1229907627359*x_47 - 116.602459301023*x_48 + 46.3491918834586*x_5 - 0.0267863415902453*x_50 + 7.82166865240789*x_52 + 15.8027970388734*x_53 + 50.7017339296916*x_54 - 36.6061928978819*x_58 + 0.0171001186650856*x_59 + 5.53178376949887*x_6 + 0.455070710282736*x_60 + 16.9513630975046*x_61 + 14.3032858161037*x_62 + 13.537260130668*x_63 + 35.749865015703*x_64 - 0.505940860188972*x_65 + 6.04980178599182*x_66 + 14.3371529601838*x_67 + 8.38469535762458*x_68 + 25.1014252460856*x_69 + 29.3312255433068*x_7 + 0.533575892545262*x_70 - 9.1012516365078*x_71 + 0.799861469367241*x_72 + 30.182049262156*x_73 - 11.7465801452644*x_74 - 0.604754098720092*x_75 + 0.782397729970104*x_76 + 6.31961278916644*x_77 + 5.91418197638615*x_78 - 9.20218942734408*x_79 + 5.88570648762268*x_8 - 3.78116292819695*x_80 - 1.16827402231275*x_81 - 7.50777934869045*x_82 + 10.0500611904514*x_83 + 8.3946382468073*x_84 - 5.81774807313683*x_85 + 564.150521950398*x_86 + 81.6520322651242*x_87 + 54.5256563155721*x_88 + 3.89906809991432*x_89 + 10.4029649747252*x_9 - 3.38953903054254*x_90 + 1.08532845593311*x_91 - 27.514155976863*x_92 - 11.0538742738635*x_93 + 18.7900939064301*x_94 - 9.03140278141401*x_95 - 31.7498862053221*x_96 - 2.44526998386418*x_97 - 29.0739409908005*x_98 - 37.2223253138634*x_99 + 0.00296781117346165*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.0104543380504217*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) + 0.000227265901167198*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) + 0.0905373592523795*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.00475052284119505*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) + 0.0029389831991296*std::exp(1.10983991622925*x_1) - 0.161455723328464*std::exp(1.242959856987*x_1) - 2.31142921651907*std::exp(1.24823987483978*x_1) - 0.00351787702461221*std::exp(1.43383979797363*x_1) - 0.0113773955073395*std::exp(1.77823996543884*x_1) + 0.00828625817876289*std::exp(0.619279801845551*x_10) - 0.017095537004082*std::exp(0.783999860286713*x_10) - 0.521489980093268*std::exp(0.794399857521057*x_10) + 0.00268118213508822*std::exp(0.803679883480072*x_10) + 0.0288017266571219*std::exp(0.826399862766266*x_10) + 1.69600175177153*std::exp(0.846799850463867*x_10) + 0.243382980978368*std::exp(0.947519838809967*x_10) - 0.027235772253167*std::exp(0.968719840049744*x_10) + 0.0514448966920294*std::exp(0.975119829177856*x_10) + 0.0561960949174006*std::exp(1.1814398765564*x_10) - 0.413703441024531*std::exp(0.822239875793457*x_11) + 0.002738896251415*std::exp(0.89359986782074*x_11) - 0.00112652647182404*std::exp(0.906559824943542*x_11) - 0.603681301766352*std::exp(0.921199858188629*x_11) - 0.0636244126249207*std::exp(0.932559847831726*x_11) + 0.328097272968307*std::exp(0.940079808235168*x_11) - 1.94527309011867*std::exp(0.943679809570313*x_11) + 0.0102720393588922*std::exp(0.948239862918854*x_11) - 0.653604255163849*std::exp(0.976479828357697*x_11) + 0.0209393416649873*std::exp(1.0525598526001*x_11) - 0.00677486580935794*std::exp(0.547999858856201*x_12) - 0.0595167785529746*std::exp(0.748719871044159*x_12) - 0.094039730011737*std::exp(0.869919836521149*x_12) - 0.00108203743981609*std::exp(0.872399866580963*x_12) + 0.153835117017691*std::exp(1.18807995319366*x_12) - 0.000378978887478899*std::exp(1.12631988525391*x_13) + 1.20719972170729e-5*std::exp(1.31047987937927*x_13) - 0.00037612565564575*std::exp(1.34023988246918*x_13) + 87.6645052119618*std::exp(0.269759833812714*x_14) - 0.0299641911325263*std::exp(0.473199844360352*x_14) + 0.0677751256309578*std::exp(0.679999828338623*x_14) - 0.000400259168542751*std::exp(0.895599842071533*x_14) - 0.141884920242196*std::exp(0.71207982301712*x_15) - 0.289724051044401*std::exp(0.832959890365601*x_15) + 0.379680441115283*std::exp(0.923279821872711*x_15) - 0.00138622034109952*std::exp(0.930639863014221*x_15) - 2.87077369878772*std::exp(0.947279810905457*x_15) + 0.000375938231613789*std::exp(0.964959800243378*x_15) - 0.086206903981737*std::exp(1.01871979236603*x_15) + 0.00108432715360622*std::exp(1.03775978088379*x_15) + 6.09742565000353*std::exp(0.382159829139709*x_16) - 0.0150372341525424*std::exp(0.548479855060577*x_16) - 1.64945674956585*std::exp(0.570239841938019*x_16) - 0.018133522953018*std::exp(0.715919852256775*x_16) - 0.191804450154148*std::exp(0.887839913368225*x_16) + 0.0278708576818216*std::exp(0.618079841136932*x_17) + 17.967370195379*std::exp(0.642879843711853*x_17) - 0.823210801964182*std::exp(0.658879816532135*x_17) + 7.26700329167714*std::exp(0.666479825973511*x_17) - 0.0106910263564179*std::exp(0.713679850101471*x_17) - 0.484010675096217*std::exp(0.826239883899689*x_17) + 4.77736998019491*std::exp(0.442959845066071*x_18) + 0.0189178608409747*std::exp(0.693519830703735*x_19) - 0.00957970554804612*std::exp(0.705919861793518*x_19) + 3.74248111575824*std::exp(0.7219198346138*x_19) - 31.8317211706967*std::exp(0.723199844360352*x_19) + 0.00967455805202667*std::exp(0.725599884986877*x_19) - 2.19021910750258*std::exp(0.73967981338501*x_19) + 1.34419302623751*std::exp(0.765519857406616*x_19) - 4.44462476149201*std::exp(0.819519877433777*x_19) + 0.0554751559809991*std::exp(1.02399981021881*x_19) + 0.0111804758274723*std::exp(0.747839868068695*x_2) - 7.63774259726488*std::exp(0.754719853401184*x_2) + 0.596866781272547*std::exp(0.769999861717224*x_2) + 14.7655218416406*std::exp(0.827439904212952*x_2) - 0.00834575073117539*std::exp(1.00447976589203*x_2) - 0.359282758738092*std::exp(1.09567987918854*x_2) + 0.395368468518199*std::exp(0.44583985209465*x_20) - 1.18850354720325*std::exp(0.488959848880768*x_20) + 0.65399554236369*std::exp(0.627359867095947*x_20) + 3.20645456559988*std::exp(0.851519882678986*x_20) + 0.368727506150712*std::exp(0.915279805660248*x_20) - 0.0431779461686707*std::exp(1.0039998292923*x_20) - 0.0357363937754646*std::exp(0.855839908123016*x_21) - 0.0165437791246704*std::exp(0.53279983997345*x_22) - 0.277233464154145*std::exp(0.742159843444824*x_22) + 0.000216683701677681*std::exp(1.19607996940613*x_22) + 0.0201527138591597*std::exp(1.36079978942871*x_22) - 0.0193887514050638*std::exp(1.40143978595734*x_22) + 0.489143852943365*std::exp(0.62527984380722*x_23) + 0.011074242863083*std::exp(0.664479851722717*x_23) + 0.0431349095534691*std::exp(0.685359835624695*x_23) - 0.605528139199201*std::exp(0.735519826412201*x_23) + 3.51592063291848*std::exp(0.743439853191376*x_23) - 4.63896950684334*std::exp(0.744559824466705*x_23) + 0.445323790156972*std::exp(0.782239854335785*x_23) + 1.34549962184881*std::exp(0.818959891796112*x_23) - 0.0984147216976571*std::exp(0.834479868412018*x_23) + 2.87884917088695*std::exp(0.368799835443497*x_24) - 1.29833061042641*std::exp(0.424879848957062*x_24) + 4.13083297321753*std::exp(0.609519839286804*x_24) + 0.0179230806897111*std::exp(0.61167985200882*x_24) - 0.0132448011103505*std::exp(0.653759837150574*x_24) - 1.08577459177219*std::exp(0.761439859867096*x_24) - 0.00304151546058299*std::exp(0.780959844589233*x_24) + 0.0558642454581817*std::exp(0.418559849262238*x_25) + 1.73270467986052*std::exp(0.545919835567474*x_25) - 22.7090040064332*std::exp(0.627679824829102*x_25) - 0.179528684655628*std::exp(0.643359839916229*x_25) - 0.499089514402052*std::exp(0.765359818935394*x_25) + 0.270471852145165*std::exp(0.878879845142365*x_25) - 0.408533188615373*std::exp(0.964159786701202*x_25) - 0.000581986286028773*std::exp(1.00615978240967*x_25) - 0.0801195307088426*std::exp(0.429119855165482*x_26) + 1.81752602863982*std::exp(0.569839835166931*x_26) + 4.42811368084094*std::exp(0.698879837989807*x_26) + 0.0915486309801492*std::exp(0.736239850521088*x_26) - 0.590169052105195*std::exp(0.79943984746933*x_26) + 0.000801282723070832*std::exp(0.822479903697968*x_26) - 0.00044526321683013*std::exp(0.984079837799072*x_26) - 0.116248325516988*std::exp(1.10487985610962*x_26) + 0.000105685954110062*std::exp(1.14151990413666*x_27) + 0.0269512246117766*std::exp(1.18543982505798*x_27) + 0.0990385473249883*std::exp(1.24655985832214*x_27) - 0.00704684449520478*std::exp(1.2630398273468*x_27) - 0.0122209460671976*std::exp(1.27247989177704*x_27) - 0.913766717984727*std::exp(0.549759864807129*x_28) - 17.1335710115298*std::exp(0.565279841423035*x_28) - 0.00241096732581727*std::exp(0.650239825248718*x_28) - 0.0174755094294764*std::exp(0.667519807815552*x_28) + 1.22378903773804*std::exp(0.768079876899719*x_28) - 0.297568810706677*std::exp(0.905439794063568*x_28) - 0.000217223606598975*std::exp(1.13103985786438*x_29) - 0.176730547069883*std::exp(1.1431999206543*x_29) - 0.031465124194868*std::exp(1.1509598493576*x_29) + 0.159961192878661*std::exp(1.16863989830017*x_29) + 0.0512490316101816*std::exp(1.17591977119446*x_29) + 2.44495781000923*std::exp(0.575039863586426*x_3) + 1.29789231165546*std::exp(0.670239865779877*x_3) - 0.00878013711173284*std::exp(0.670399844646454*x_3) + 0.00816085294096195*std::exp(0.915599822998047*x_3) - 0.135344690189682*std::exp(0.947999835014343*x_3) + 0.254223151487637*std::exp(0.739759802818298*x_30) - 7.83135723118458*std::exp(0.847439885139465*x_30) - 0.343674456156835*std::exp(0.853279888629913*x_30) + 0.401778186341412*std::exp(0.882479906082153*x_30) + 0.774676261498394*std::exp(0.916479825973511*x_30) - 1.89714936145283*std::exp(0.9440798163414*x_30) + 0.000703340828797438*std::exp(1.00999975204468*x_30) - 0.00238698536143296*std::exp(1.03159987926483*x_30) + 0.000523991592495142*std::exp(1.09999978542328*x_30) + 7.2850580402938*std::exp(0.787999868392944*x_32) + 0.00209439386777837*std::exp(0.823919892311096*x_32) + 1.1544661951428*std::exp(0.357519835233688*x_33) - 6.46026264650183*std::exp(0.36575984954834*x_33) + 0.0385602022020325*std::exp(0.395519852638245*x_33) - 2.21305690660121*std::exp(0.41407984495163*x_33) - 19.2295659326445*std::exp(0.379279851913452*x_34) - 2.55897296797457*std::exp(0.408159852027893*x_34) - 1.0822877295623*std::exp(0.431119859218597*x_36) - 3.0497659721921*std::exp(0.250399857759476*x_37) - 17.1271446290898*std::exp(0.375039845705032*x_38) - 0.0196443911682753*std::exp(0.385999858379364*x_4) + 0.0127095548638947*std::exp(0.527999818325043*x_4) - 1.28929721456224*std::exp(0.554479837417603*x_4) + 0.0899250065159702*std::exp(0.638399839401245*x_4) + 5.17499946778003*std::exp(0.723759829998016*x_4) - 0.0420190466276674*std::exp(1.10615980625153*x_4) + 0.00138264986065121*std::exp(1.13591980934143*x_4) + 7.72854618699938*std::exp(0.685679852962494*x_41) - 0.615388296949168*std::exp(0.7497598528862*x_41) + 0.00679870671337082*std::exp(0.769599854946136*x_41) + 0.310691234625985*std::exp(0.797759890556335*x_41) + 0.0029656081030512*std::exp(0.798159837722778*x_41) + 0.0336906900308091*std::exp(0.798719823360443*x_41) - 0.174586099961519*std::exp(0.803759872913361*x_41) + 0.246297759223212*std::exp(0.805199861526489*x_41) - 0.795332752946611*std::exp(0.812879860401154*x_41) - 0.0358656432787131*std::exp(0.866879880428314*x_41) + 0.168268562498695*std::exp(0.19999985396862*x_42) - 0.236105885783895*std::exp(0.596879839897156*x_42) - 0.456917744600369*std::exp(0.690479874610901*x_42) + 1.41298547892506*std::exp(0.718159854412079*x_42) + 0.025382365887318*std::exp(0.841359853744507*x_42) - 0.164383963930869*std::exp(0.705839812755585*x_43) - 0.025576524695046*std::exp(0.787679851055145*x_43) - 0.000428089379143282*std::exp(0.83271986246109*x_43) + 0.04129925276543*std::exp(0.886719882488251*x_44) + 0.000153344597794824*std::exp(0.908799827098846*x_44) - 0.0206085899157546*std::exp(0.942639827728271*x_44) - 0.723818087333555*std::exp(0.515199840068817*x_45) - 1.18882565710387*std::exp(0.504559814929962*x_46) + 0.000577025648870467*std::exp(0.663999855518341*x_46) + 1.31459322231578*std::exp(0.700479865074158*x_46) - 0.146208989500644*std::exp(0.75791984796524*x_46) - 0.00406793706773645*std::exp(0.759199857711792*x_46) - 0.07805628329725*std::exp(0.801999866962433*x_46) - 0.13494898233279*std::exp(0.802399873733521*x_46) - 0.0185524912549825*std::exp(0.424159854650497*x_47) + 0.384822928743167*std::exp(0.552239894866943*x_47) - 0.00474009498337207*std::exp(0.608879864215851*x_48) - 1.29214123039584*std::exp(0.608959853649139*x_48) + 0.00815226982173492*std::exp(0.639919817447662*x_49) + 0.00667858423053895*std::exp(0.685839831829071*x_49) + 40.407645999417*std::exp(0.703679859638214*x_49) + 0.0112352978470951*std::exp(0.705999851226807*x_49) - 1.4995569612451*std::exp(0.708399832248688*x_49) + 0.794175799603681*std::exp(0.708639860153198*x_49) + 3.27317908747361*std::exp(0.715839862823486*x_49) - 3.49195947893707*std::exp(0.719119846820831*x_49) + 4.72786277608766*std::exp(0.719919860363007*x_49) + 2.09942401660316*std::exp(0.720319867134094*x_49) + 0.000268412775088421*std::exp(1.93999981880188*x_5) + 2.20790357484905*std::exp(0.52215987443924*x_50) + 0.712900931565468*std::exp(0.537359833717346*x_50) - 0.588531569111313*std::exp(0.541919827461243*x_50) + 1.46965565824157*std::exp(0.543199837207794*x_50) + 34.4650946678091*std::exp(0.546079874038696*x_50) + 0.797799999285747*std::exp(0.599439859390259*x_50) + 0.516195540929775*std::exp(0.610719859600067*x_50) - 0.00464506744107285*std::exp(0.658079862594604*x_50) - 0.00777600154531837*std::exp(0.463519841432571*x_51) + 0.0527542553164645*std::exp(0.48039984703064*x_51) - 5.81770422343531*std::exp(0.491039842367172*x_51) + 8.73518938911129*std::exp(0.493919849395752*x_51) + 23.8601497055389*std::exp(0.49415984749794*x_51) + 19.8320458205102*std::exp(0.496719866991043*x_51) - 103.763352156091*std::exp(0.497119843959808*x_51) - 0.253973637203489*std::exp(0.499279826879501*x_51) - 31.9275422240725*std::exp(0.501199841499329*x_51) + 8.36137140457654*std::exp(0.510319828987122*x_51) - 0.983512205288462*std::exp(0.504639863967896*x_52) - 0.151322421669125*std::exp(0.546399831771851*x_52) - 0.00792857298682589*std::exp(0.600159823894501*x_52) - 0.0182351057907334*std::exp(0.641199827194214*x_52) - 0.262510083098822*std::exp(0.673519849777222*x_52) - 0.266998992898321*std::exp(0.712159812450409*x_52) - 0.00127393549045118*std::exp(0.714239835739136*x_52) + 0.0764174094249718*std::exp(0.88375985622406*x_52) + 13.1081784077838*std::exp(0.474319845438004*x_54) - 0.0968307156005033*std::exp(0.502159833908081*x_54) + 0.0155027688000258*std::exp(0.506399810314178*x_54) - 4.61816328344055*std::exp(0.519279837608337*x_54) + 1.89191673426545*std::exp(0.532479882240295*x_54) - 0.0185715092834042*std::exp(0.532879829406738*x_54) + 5.22047270252462*std::exp(0.542559862136841*x_54) - 1.12753885264094*std::exp(0.612959861755371*x_55) - 0.0167423411646579*std::exp(0.631199836730957*x_55) + 0.24664063909672*std::exp(0.650959849357605*x_55) - 3.31846516097519*std::exp(0.652479827404022*x_55) + 13.8667154083564*std::exp(0.653439819812775*x_55) - 0.187057860041188*std::exp(0.655679821968079*x_55) + 262.20634220748*std::exp(0.655759811401367*x_55) - 8.09738819749658*std::exp(0.656879842281342*x_55) - 4.13058422258161*std::exp(0.657759845256805*x_55) + 39.8090524812026*std::exp(0.659119844436646*x_55) + 30.3262993061141*std::exp(0.347199827432632*x_56) + 54.4999915790939*std::exp(0.442879855632782*x_56) - 3.77907642331654*std::exp(0.466319859027863*x_56) - 0.637255438769525*std::exp(0.52183985710144*x_56) + 2.19296151913415*std::exp(0.525679886341095*x_56) + 2.75548244120815*std::exp(0.574079871177673*x_56) - 0.742097330290981*std::exp(0.655039846897125*x_56) + 0.0135581009665855*std::exp(0.658559858798981*x_56) + 0.00115567057461386*std::exp(0.754159867763519*x_56) - 0.00153856411550107*std::exp(0.859519898891449*x_56) + 2.57262199635542*std::exp(0.599999845027924*x_57) - 1.59302684092167*std::exp(0.609679877758026*x_57) + 0.0821212422587126*std::exp(0.617039859294891*x_57) + 0.0278413264376687*std::exp(0.626319825649261*x_57) - 26.8428809496534*std::exp(0.628239870071411*x_57) - 3.44300618633359*std::exp(0.632079839706421*x_57) - 113.791512852991*std::exp(0.634159862995148*x_57) + 0.0396425027966542*std::exp(0.637119889259338*x_57) - 2.80116179270557*std::exp(0.641199827194214*x_57) + 1.16572350474123*std::exp(0.671519815921783*x_57) - 0.841623976871971*std::exp(0.37679985165596*x_58) - 0.0509540534336747*std::exp(0.451519846916199*x_58) - 0.323401162202564*std::exp(0.558799862861633*x_58) + 0.777632755147015*std::exp(0.595039844512939*x_58) + 0.00768390350700816*std::exp(0.603839874267578*x_58) + 0.0101104981056131*std::exp(0.653759837150574*x_58) - 18.3390975306024*std::exp(0.512399852275848*x_59) - 0.363082007759415*std::exp(0.545279860496521*x_59) - 2.90275869962228*std::exp(0.696399867534637*x_59) + 0.0841390889977893*std::exp(0.807599902153015*x_59) - 0.0581004577666895*std::exp(0.839199841022491*x_59) - 0.0564499192606134*std::exp(0.866959869861603*x_59) - 0.00391510165064793*std::exp(0.778479874134064*x_60) + 1.80543010018915*std::exp(0.780239880084991*x_60) - 10.7114038547285*std::exp(0.821839869022369*x_60) - 0.00290137469072365*std::exp(0.842239856719971*x_60) + 0.00740757145073061*std::exp(0.845599889755249*x_60) - 0.300454254026029*std::exp(0.847439885139465*x_60) + 0.0842367464729815*std::exp(0.850079894065857*x_60) + 0.223257031185529*std::exp(0.897759795188904*x_60) - 0.0316089540095047*std::exp(0.979119837284088*x_60) - 0.0149495918658862*std::exp(1.01919984817505*x_61) + 0.162911247101318*std::exp(1.04719984531403*x_61) - 1.81812252878104*std::exp(1.3343198299408*x_61) + 0.105999566816153*std::exp(1.36879980564117*x_61) + 0.050297666608872*std::exp(0.578399837017059*x_66) - 10.7071665371604*std::exp(0.930159866809845*x_66) - 0.126820854871401*std::exp(1.03991973400116*x_66) - 0.000482709266663094*std::exp(1.46671986579895*x_66) + 3.77724668557553e-6*std::exp(1.60799980163574*x_7) - 0.000183935579253032*std::exp(1.8828798532486*x_7) - 0.499172765485271*std::exp(0.481679856777191*x_8) - 0.00786625913719378*std::exp(0.549919843673706*x_8) - 0.681330664045702*std::exp(0.583999812602997*x_8) + 0.0750332726013984*std::exp(0.832639873027802*x_8) + 0.0800540725101221*std::exp(0.863359868526459*x_8) - 0.0151380511679595*std::exp(1.34103989601135*x_8) + 13.6145886576286*std::log(9.5269603729248 - 1.42447984218597*x_5) + 7.29382402718113*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 5.26787138205698*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 8.22275233193171*std::sin(0.302159935235977*x_112 - 7.45056009292603) - 0.126006123515494*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 22.4685241326384*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 3.12464323868313*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 3.28500737667913*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 39.6673386445537*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0624427351284255*std::sin(0.248479977250099*x_117 + 1.95407974720001) - 0.119653235159682*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 8.74571458479599*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 77.7462653022187*std::sin(0.264879941940308*x_120 + 5.15752029418945) + 196.665183598668*std::sin(0.270639955997467*x_120 + 5.14951992034912) - 0.355394489702154*std::sin(0.270879954099655*x_120 - 7.44527959823608) - 0.832382949478354*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 41.0907648341797*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 4.00255571216269*std::sin(0.436799854040146*x_22 - 7.42592000961304) + 0.148890146887408*std::sin(0.197599992156029*x_3 - 7.60056018829346) - 1.86139581344601*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.912726568757549*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 141.093914273629*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 176.406533951817*std::sin(0.121680058538914*x_33 + 7.96871995925903) + 0.541201667649144*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 28.8244808869354*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 3.63534387218844*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 12.3109823898536*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.0133238958289189*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0208115913859338*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 21.902626266164*std::sin(0.550959885120392*x_65 - 7.2239203453064) + 0.0475850568098903*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 3.45440207755451*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 14.442969761185*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 9.11649642674525*std::sin(0.234399989247322*x_9 + 5.00383996963501) - 0.0824616092784557*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 40.6017908795538*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 12.2396365890792*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 17.5960456758894*std::sin(0.357359826564789*x_91 - 7.3996000289917) + 131.135745389201*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 8.63729387325093*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 32.4443093004354*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 4.69543364261791*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 25.1955777460964*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 6.4983035902508*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 6.97278033356775*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 7.33702778266218*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 8.41383920567253*std::sin(0.319199919700623*x_94 + 1.95127987861633) - 0.111715254141922*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 8.35339620106376*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 7.23020570936972*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 46.530527812569*std::sin(0.232959985733032*x_98 - 4.22215986251831) + 0.10566428776058*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 19.0385904117028*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 945.544862289861);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.01948189439069*x_1 - 5.52461442659858*x_100 - 7.90262301009715*x_101 - 8.18475957685796*x_102 + 2.08212670045221*x_103 - 44.6831632130955*x_104 - 16.8559516699113*x_105 - 5.93334328186903*x_106 - 3.02172117001466*x_107 - 9.01683639360058*x_108 + 12.1012790853564*x_109 - 9.93402040180714*x_110 - 15.580516693145*x_111 - 3.42769425987736*x_112 + 10.1302956036532*x_113 + 30.1800149987527*x_114 + 5.40004022706386*x_115 + 6.99510882527757*x_116 - 16.9585204486626*x_117 - 16.1211386978706*x_118 - 9.80859743648524*x_119 - 0.213622253248446*x_12 - 0.91953521486627*x_120 + 5.2644223194628*x_13 - 1.12490480905135*x_14 + 0.00530098129224664*x_15 - 1.76593995157148*x_16 - 0.291149649513888*x_17 + 53.982292476473*x_18 + 0.011459928400229*x_19 - 0.0282251233929707*x_2 - 0.0211889154568488*x_20 + 7.89620482446327*x_21 + 0.00586832977334113*x_22 + 0.043680505335262*x_23 + 4.65516808505025*x_24 - 1.10696545651181e-5*x_25 - 0.0173450294974105*x_26 + 32.6104978841406*x_27 - 1.73352624369116*x_28 + 0.644208151190904*x_29 - 1.03808720494817*x_3 - 0.03904091150647*x_30 + 2.82967824929366*x_31 + 2.73829794920097*x_32 + 38.687546147819*x_33 - 44.9320110747265*x_34 - 45.2991462988786*x_35 + 60.22234833262*x_36 - 255.762775231318*x_37 + 28.357392279853*x_38 - 53.0470282867217*x_39 - 8.82603773664609*x_4 - 2103.05194842412*x_40 - 8.79128858688514*x_42 + 19.2946396767783*x_43 - 23.2751332244141*x_44 + 6.50423807057375*x_45 - 155.59154929711*x_46 + 67.3552675965551*x_47 - 97.4172603443899*x_48 + 31.06416056297*x_5 - 0.131039024882812*x_50 + 5.08252001558272*x_52 + 5.66500809994879*x_53 + 30.7951448228598*x_54 + 10.009876941831*x_58 + 0.0105163797734963*x_59 + 8.67741459993565*x_6 - 0.0352110614139594*x_60 + 9.78695977996339*x_61 + 10.8004611798999*x_62 + 5.43375618144002*x_63 + 16.8295024313082*x_64 - 0.0229129889713815*x_65 - 1.90764306841064*x_66 + 5.83269349784087*x_67 + 9.5599388744391*x_68 + 20.3209050786545*x_69 + 29.5832733693883*x_7 - 6.05590460411304*x_70 - 7.27527305432028*x_71 + 0.0048967560377815*x_72 + 16.7294161257655*x_73 - 7.99002273211078*x_74 - 4.25605920444622*x_75 + 4.12889809979382*x_76 - 1.46531784644261*x_77 - 4.26895261738825*x_78 - 18.654084220854*x_79 + 2.5280263845143*x_8 - 4.22722192181622*x_80 + 4.32987018943682*x_81 - 7.40904819857019*x_82 + 13.4001683803691*x_83 + 12.4301422881726*x_84 - 1.03247115375283*x_85 + 200.650636687627*x_86 + 53.3448138320314*x_87 + 24.7597367503839*x_88 + 1.89371442637383*x_89 + 6.34347915653372*x_9 - 4.06683690837481*x_90 - 0.0635546179912557*x_91 - 9.77620469880816*x_92 - 12.8858662988766*x_93 + 3.61341020854121*x_94 - 3.55179504785385*x_95 - 19.3604414686019*x_96 - 4.89431326435*x_97 - 17.7231943673208*x_98 - 30.3423251653395*x_99 + 0.00193434099292736*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) + 0.000808903607325078*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.000418505570005077*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) + 0.0588867919058333*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) - 0.000367571341618119*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) + 0.00904792350270528*std::exp(1.10983991622925*x_1) + 0.00850301693692532*std::exp(1.242959856987*x_1) + 0.775207674747463*std::exp(1.24823987483978*x_1) + 0.00647809953817038*std::exp(1.43383979797363*x_1) + 4.59767112194438e-5*std::exp(1.77823996543884*x_1) + 0.00118282241477167*std::exp(0.619279801845551*x_10) + 0.0314810863472769*std::exp(0.783999860286713*x_10) + 0.0274641124003325*std::exp(0.794399857521057*x_10) + 0.00825425979375546*std::exp(0.803679883480072*x_10) + 0.00328222240916654*std::exp(0.826399862766266*x_10) - 0.568805466748577*std::exp(0.846799850463867*x_10) - 0.0188317395444268*std::exp(0.947519838809967*x_10) + 0.000110061325978744*std::exp(0.968719840049744*x_10) + 0.0335304258701321*std::exp(0.975119829177856*x_10) + 0.0365507429711614*std::exp(1.1814398765564*x_10) + 0.0320102721179981*std::exp(0.822239875793457*x_11) + 0.0084319378797362*std::exp(0.89359986782074*x_11) - 0.00016080608797855*std::exp(0.906559824943542*x_11) + 0.0317926935484453*std::exp(0.921199858188629*x_11) - 0.00725058866691019*std::exp(0.932559847831726*x_11) + 0.213845142994734*std::exp(0.940079808235168*x_11) - 1.26523340865859*std::exp(0.943679809570313*x_11) - 0.018915753154914*std::exp(0.948239862918854*x_11) + 0.219205948955536*std::exp(0.976479828357697*x_11) - 8.4617086945368e-5*std::exp(1.0525598526001*x_11) - 0.000967078621435758*std::exp(0.547999858856201*x_12) - 0.00678248587709833*std::exp(0.748719871044159*x_12) - 0.0612926140153825*std::exp(0.869919836521149*x_12) - 0.00333114935308868*std::exp(0.872399866580963*x_12) + 0.100056557850093*std::exp(1.18807995319366*x_12) + 0.000697881972217039*std::exp(1.12631988525391*x_13) + 3.71647266909503e-5*std::exp(1.31047987937927*x_13) - 4.28629877062482e-5*std::exp(1.34023988246918*x_13) + 57.0182465953574*std::exp(0.269759833812714*x_14) + 0.0551784531918551*std::exp(0.473199844360352*x_14) + 0.00772360069860605*std::exp(0.679999828338623*x_14) - 0.00123223376687004*std::exp(0.895599842071533*x_14) - 0.0161690953561837*std::exp(0.71207982301712*x_15) + 0.0152582297008659*std::exp(0.832959890365601*x_15) - 0.127337315718161*std::exp(0.923279821872711*x_15) - 0.00426760370997596*std::exp(0.930639863014221*x_15) - 1.86719222655933*std::exp(0.947279810905457*x_15) + 5.36633251498328e-5*std::exp(0.964959800243378*x_15) - 0.0561873847421113*std::exp(1.01871979236603*x_15) - 0.00199676656797756*std::exp(1.03775978088379*x_15) - 2.04495604983445*std::exp(0.382159829139709*x_16) - 0.0462934746768082*std::exp(0.548479855060577*x_16) + 0.0868681418604851*std::exp(0.570239841938019*x_16) + 0.0333925165221764*std::exp(0.715919852256775*x_16) - 0.125013078283653*std::exp(0.887839913368225*x_16) + 0.00397842723142035*std::exp(0.618079841136932*x_17) + 11.6862342631509*std::exp(0.642879843711853*x_17) - 0.0938124638790249*std::exp(0.658879816532135*x_17) - 2.43720927461795*std::exp(0.666479825973511*x_17) - 0.0329132839775752*std::exp(0.713679850101471*x_17) - 0.315465383453297*std::exp(0.826239883899689*x_17) - 0.369648636945533*std::exp(0.442959845066071*x_18) - 0.034836858912258*std::exp(0.693519830703735*x_19) - 0.00136745563614978*std::exp(0.705919861793518*x_19) - 0.289574190186122*std::exp(0.7219198346138*x_19) - 20.7038062084196*std::exp(0.723199844360352*x_19) + 0.0297839950916163*std::exp(0.725599884986877*x_19) + 0.115347228222963*std::exp(0.73967981338501*x_19) - 0.00543196151972077*std::exp(0.765519857406616*x_19) + 1.49063929877551*std::exp(0.819519877433777*x_19) + 0.0361572425033774*std::exp(1.02399981021881*x_19) + 0.0344200980940532*std::exp(0.747839868068695*x_2) + 2.56154791019814*std::exp(0.754719853401184*x_2) - 0.00241197307602992*std::exp(0.769999861717224*x_2) + 9.60370635116439*std::exp(0.827439904212952*x_2) + 0.0153685315259911*std::exp(1.00447976589203*x_2) - 0.234171019535756*std::exp(1.09567987918854*x_2) - 0.0015977067766176*std::exp(0.44583985209465*x_20) + 0.0919603710932783*std::exp(0.488959848880768*x_20) - 0.0344424778431608*std::exp(0.627359867095947*x_20) + 2.08552385798713*std::exp(0.851519882678986*x_20) - 0.123663917811418*std::exp(0.915279805660248*x_20) - 0.0281422457100099*std::exp(1.0039998292923*x_20) - 0.00407249169013364*std::exp(0.855839908123016*x_21) - 0.0509315085605119*std::exp(0.53279983997345*x_22) + 0.0146004167123235*std::exp(0.742159843444824*x_22) - 0.000399018663229698*std::exp(1.19607996940613*x_22) - 0.00675882191804131*std::exp(1.36079978942871*x_22) - 0.0126107209082743*std::exp(1.40143978595734*x_22) + 0.0557424537268075*std::exp(0.62527984380722*x_23) + 0.00158079345375108*std::exp(0.664479851722717*x_23) - 0.0794320653343907*std::exp(0.685359835624695*x_23) + 0.00244697412279016*std::exp(0.735519826412201*x_23) - 1.17917028951722*std::exp(0.743439853191376*x_23) - 3.0172520411767*std::exp(0.744559824466705*x_23) + 0.290250292919299*std::exp(0.782239854335785*x_23) - 0.104107930365245*std::exp(0.818959891796112*x_23) + 0.00518298161369943*std::exp(0.834479868412018*x_23) - 0.151613722661944*std::exp(0.368799835443497*x_24) - 0.147956748384552*std::exp(0.424879848957062*x_24) - 1.38539973495731*std::exp(0.609519839286804*x_24) + 0.0551778121975475*std::exp(0.61167985200882*x_24) + 0.0243900339198406*std::exp(0.653759837150574*x_24) + 0.0840117260213347*std::exp(0.761439859867096*x_24) - 0.00043416130466131*std::exp(0.780959844589233*x_24) - 0.10287288048188*std::exp(0.418559849262238*x_25) + 1.12933117876969*std::exp(0.545919835567474*x_25) - 14.7702606344841*std::exp(0.627679824829102*x_25) - 0.0204589495234026*std::exp(0.643359839916229*x_25) + 0.0386170130170658*std::exp(0.765359818935394*x_25) - 0.0142443184567274*std::exp(0.878879845142365*x_25) + 0.137013956966688*std::exp(0.964159786701202*x_25) - 0.00179169700499526*std::exp(1.00615978240967*x_25) + 0.147538498717304*std::exp(0.429119855165482*x_26) - 0.140630937500119*std::exp(0.569839835166931*x_26) + 2.88010839958535*std::exp(0.698879837989807*x_26) - 0.000369953296111967*std::exp(0.736239850521088*x_26) - 0.384656611732011*std::exp(0.79943984746933*x_26) + 0.00246682076458667*std::exp(0.822479903697968*x_26) - 6.35591242727422e-5*std::exp(0.984079837799072*x_26) + 0.0389873907767865*std::exp(1.10487985610962*x_26) + 1.50861477823968e-5*std::exp(1.14151990413666*x_27) - 0.00141937810949322*std::exp(1.18543982505798*x_27) - 0.0332155713155654*std::exp(1.24655985832214*x_27) + 2.84767048974742e-5*std::exp(1.2630398273468*x_27) + 0.000945594767550358*std::exp(1.27247989177704*x_27) + 0.00369258399144346*std::exp(0.549759864807129*x_28) - 11.1439193620313*std::exp(0.565279841423035*x_28) - 0.00742237925619206*std::exp(0.650239825248718*x_28) + 0.0321807978995124*std::exp(0.667519807815552*x_28) - 0.410434655556979*std::exp(0.768079876899719*x_28) + 0.0230243639766704*std::exp(0.905439794063568*x_28) - 0.000668742365070798*std::exp(1.13103985786438*x_29) - 0.114948072648085*std::exp(1.1431999206543*x_29) + 0.000127152381022365*std::exp(1.1509598493576*x_29) - 0.0536478225225695*std::exp(1.16863989830017*x_29) - 0.00269901478125905*std::exp(1.17591977119446*x_29) - 0.128762965102713*std::exp(0.575039863586426*x_3) + 0.845931953248928*std::exp(0.670239865779877*x_3) - 0.00125332119232576*std::exp(0.670399844646454*x_3) - 0.0150280459771756*std::exp(0.915599822998047*x_3) + 0.000546935696480082*std::exp(0.947999835014343*x_3) + 0.165695940385633*std::exp(0.739759802818298*x_30) - 5.09362662464544*std::exp(0.847439885139465*x_30) + 0.00138880829219912*std::exp(0.853279888629913*x_30) - 0.0211595269149922*std::exp(0.882479906082153*x_30) - 0.0599405165026091*std::exp(0.916479825973511*x_30) + 0.636266399433713*std::exp(0.9440798163414*x_30) + 0.000100398428286711*std::exp(1.00999975204468*x_30) + 0.00439558536564333*std::exp(1.03159987926483*x_30) + 0.00161315513690614*std::exp(1.09999978542328*x_30) + 4.73830582627054*std::exp(0.787999868392944*x_32) + 0.000298964376769931*std::exp(0.823919892311096*x_32) + 0.131562071310262*std::exp(0.357519835233688*x_33) + 2.16664440713201*std::exp(0.36575984954834*x_33) + 0.00550427834840905*std::exp(0.395519852638245*x_33) + 0.00894309055542292*std::exp(0.41407984495163*x_33) + 6.44921634913729*std::exp(0.379279851913452*x_34) + 0.0103409573035438*std::exp(0.408159852027893*x_34) + 0.00437358711546355*std::exp(0.431119859218597*x_36) + 0.0123242801307125*std::exp(0.250399857759476*x_37) - 11.1397395510828*std::exp(0.375039845705032*x_38) - 0.0604770209643981*std::exp(0.385999858379364*x_4) + 0.00181422616221565*std::exp(0.527999818325043*x_4) + 0.0679004486564437*std::exp(0.554479837417603*x_4) + 0.0102477839278494*std::exp(0.638399839401245*x_4) - 1.73559253970086*std::exp(0.723759829998016*x_4) + 0.000169801390069489*std::exp(1.10615980625153*x_4) - 0.00254612181184*std::exp(1.13591980934143*x_4) + 5.02675685271318*std::exp(0.685679852962494*x_41) + 0.0476156224245818*std::exp(0.7497598528862*x_41) + 0.0209304286863994*std::exp(0.769599854946136*x_41) + 0.202500346603679*std::exp(0.797759890556335*x_41) + 0.000423325904412159*std::exp(0.798159837722778*x_41) - 0.0620407256996951*std::exp(0.798719823360443*x_41) + 0.000705512495867932*std::exp(0.803759872913361*x_41) + 0.0280679014238903*std::exp(0.805199861526489*x_41) + 0.26673888590486*std::exp(0.812879860401154*x_41) + 0.00188885327794915*std::exp(0.866879880428314*x_41) - 0.309863161612806*std::exp(0.19999985396862*x_42) - 0.0269064434393689*std::exp(0.596879839897156*x_42) + 0.0353539755530642*std::exp(0.690479874610901*x_42) - 0.473887402539193*std::exp(0.718159854412079*x_42) - 0.000102571603994486*std::exp(0.841359853744507*x_42) - 0.107141129076783*std::exp(0.705839812755585*x_43) - 0.00291468089750527*std::exp(0.787679851055145*x_43) - 6.11076437944104e-5*std::exp(0.83271986246109*x_43) - 0.0138509531143293*std::exp(0.886719882488251*x_44) + 2.18891836994323e-5*std::exp(0.908799827098846*x_44) - 0.0134321349811404*std::exp(0.942639827728271*x_44) + 0.0381196610994656*std::exp(0.515199840068817*x_45) + 0.0919852943222107*std::exp(0.504559814929962*x_46) + 8.23675604425898e-5*std::exp(0.663999855518341*x_46) - 0.440888584356*std::exp(0.700479865074158*x_46) - 0.0166618629318164*std::exp(0.75791984796524*x_46) - 0.0125235092917847*std::exp(0.759199857711792*x_46) + 0.00411081060012785*std::exp(0.801999866962433*x_46) - 0.0879561849535297*std::exp(0.802399873733521*x_46) - 0.0571155091017205*std::exp(0.424159854650497*x_47) + 0.0438541221961635*std::exp(0.552239894866943*x_47) - 0.000676625139299762*std::exp(0.608879864215851*x_48) + 0.0999793289062902*std::exp(0.608959853649139*x_48) - 0.0150122403363554*std::exp(0.639919817447662*x_49) + 0.0205606208440342*std::exp(0.685839831829071*x_49) + 26.2817102356529*std::exp(0.703679859638214*x_49) + 0.00160378325698803*std::exp(0.705999851226807*x_49) - 0.170888347098569*std::exp(0.708399832248688*x_49) - 0.00320931019514039*std::exp(0.708639860153198*x_49) + 2.13337173965411*std::exp(0.715839862823486*x_49) + 0.270190097691671*std::exp(0.719119846820831*x_49) - 1.58563173078493*std::exp(0.719919860363007*x_49) - 0.110565532165421*std::exp(0.720319867134094*x_49) - 1.4135877785025e-5*std::exp(1.93999981880188*x_5) - 0.740487220674197*std::exp(0.52215987443924*x_50) - 0.00288087376742012*std::exp(0.537359833717346*x_50) - 0.0670686007000709*std::exp(0.541919827461243*x_50) - 0.113714494188311*std::exp(0.543199837207794*x_50) + 22.4165899522277*std::exp(0.546079874038696*x_50) + 0.5199849830661*std::exp(0.599439859390259*x_50) - 0.0271852823598072*std::exp(0.610719859600067*x_50) + 0.00855379793956879*std::exp(0.658079862594604*x_50) - 0.0239391185222819*std::exp(0.463519841432571*x_51) + 0.0075304093013691*std::exp(0.48039984703064*x_51) + 0.023509678192032*std::exp(0.491039842367172*x_51) + 0.995455401079758*std::exp(0.493919849395752*x_51) - 1.25658758253511*std::exp(0.49415984749794*x_51) + 12.9260040353178*std::exp(0.496719866991043*x_51) - 67.4891666415245*std::exp(0.497119843959808*x_51) + 0.46768732686349*std::exp(0.499279826879501*x_51) + 10.7078666268647*std::exp(0.501199841499329*x_51) - 0.646960473128558*std::exp(0.510319828987122*x_51) + 0.00397442952687857*std::exp(0.504639863967896*x_52) - 0.0172445856918421*std::exp(0.546399831771851*x_52) - 0.00113176462085218*std::exp(0.600159823894501*x_52) + 0.0335795792675441*std::exp(0.641199827194214*x_52) + 0.0203116976085614*std::exp(0.673519849777222*x_52) + 0.0140614213727052*std::exp(0.712159812450409*x_52) - 0.00392192472158306*std::exp(0.714239835739136*x_52) - 0.0256288887616336*std::exp(0.88375985622406*x_52) - 4.3962239600726*std::exp(0.474319845438004*x_54) + 0.178311808407082*std::exp(0.502159833908081*x_54) + 0.0022129436510547*std::exp(0.506399810314178*x_54) + 0.0186622640928684*std::exp(0.519279837608337*x_54) - 0.0996372237730115*std::exp(0.532479882240295*x_54) - 0.0571740578087641*std::exp(0.532879829406738*x_54) + 3.40256632269942*std::exp(0.542559862136841*x_54) + 0.0593814933493725*std::exp(0.612959861755371*x_55) - 0.00238988648170124*std::exp(0.631199836730957*x_55) - 0.454183758854571*std::exp(0.650959849357605*x_55) + 0.0134101090446858*std::exp(0.652479827404022*x_55) - 1.07293604448894*std::exp(0.653439819812775*x_55) - 0.575874407425554*std::exp(0.655679821968079*x_55) + 170.542750942405*std::exp(0.655759811401367*x_55) - 5.27766391141199*std::exp(0.656879842281342*x_55) - 0.470718171160572*std::exp(0.657759845256805*x_55) - 13.3511693922115*std::exp(0.659119844436646*x_55) - 10.1708414001067*std::exp(0.347199827432632*x_56) + 35.4475731288068*std::exp(0.442879855632782*x_56) + 0.0152714657127765*std::exp(0.466319859027863*x_56) - 0.0726211350587687*std::exp(0.52183985710144*x_56) - 0.115491656503798*std::exp(0.525679886341095*x_56) - 0.213205243207558*std::exp(0.574079871177673*x_56) - 0.483679453585138*std::exp(0.655039846897125*x_56) + 0.0417398304365777*std::exp(0.658559858798981*x_56) + 0.000164966264658364*std::exp(0.754159867763519*x_56) + 0.00283323476526918*std::exp(0.859519898891449*x_56) + 0.293174005408615*std::exp(0.599999845027924*x_57) + 0.00643751331160369*std::exp(0.609679877758026*x_57) - 0.151224610135082*std::exp(0.617039859294891*x_57) + 0.0857120217279489*std::exp(0.626319825649261*x_57) + 9.00257173171889*std::exp(0.628239870071411*x_57) - 2.24406056041611*std::exp(0.632079839706421*x_57) - 74.011625624567*std::exp(0.634159862995148*x_57) + 0.00565877141092552*std::exp(0.637119889259338*x_57) + 0.147522340338396*std::exp(0.641199827194214*x_57) - 0.0901977670495143*std::exp(0.671519815921783*x_57) - 0.095910814996155*std::exp(0.37679985165596*x_58) + 0.0938308609730278*std::exp(0.451519846916199*x_58) + 0.00130688274245436*std::exp(0.558799862861633*x_58) + 0.50684050561391*std::exp(0.595039844512939*x_58) + 0.00109683926145647*std::exp(0.603839874267578*x_58) + 0.0311260756648512*std::exp(0.653759837150574*x_58) - 11.9280110326057*std::exp(0.512399852275848*x_59) - 0.0413765437197653*std::exp(0.545279860496521*x_59) + 0.973527895989796*std::exp(0.696399867534637*x_59) - 0.00443115972637399*std::exp(0.807599902153015*x_59) + 0.000234787299670943*std::exp(0.839199841022491*x_59) + 0.00436780818669601*std::exp(0.866959869861603*x_59) - 0.0120529917458761*std::exp(0.778479874134064*x_60) - 0.605505572000352*std::exp(0.780239880084991*x_60) - 6.96685009394241*std::exp(0.821839869022369*x_60) - 0.000414156902162988*std::exp(0.842239856719971*x_60) - 0.0136408933166821*std::exp(0.845599889755249*x_60) + 0.00121415296348772*std::exp(0.847439885139465*x_60) + 0.00959955422952163*std::exp(0.850079894065857*x_60) + 0.145513040466693*std::exp(0.897759795188904*x_60) + 0.00166467602238247*std::exp(0.979119837284088*x_60) + 0.027529371687718*std::exp(1.01919984817505*x_61) - 0.00857967165710209*std::exp(1.04719984531403*x_61) + 0.609762361689305*std::exp(1.3343198299408*x_61) - 0.000428350361007358*std::exp(1.36879980564117*x_61) - 0.0926221378832591*std::exp(0.578399837017059*x_66) - 6.96409408206031*std::exp(0.930159866809845*x_66) - 0.0144524061617549*std::exp(1.03991973400116*x_66) - 0.00148606379243954*std::exp(1.46671986579895*x_66) + 1.16285928657421e-5*std::exp(1.60799980163574*x_7) - 0.000119884355914726*std::exp(1.8828798532486*x_7) - 0.0568853408139771*std::exp(0.481679856777191*x_8) - 0.0242169846179673*std::exp(0.549919843673706*x_8) - 0.444073344351216*std::exp(0.583999812602997*x_8) - 0.00395160465426591*std::exp(0.832639873027802*x_8) - 0.000323503122605163*std::exp(0.863359868526459*x_8) + 0.00507700316421311*std::exp(1.34103989601135*x_8) + 8.87362955493473*std::log(9.5269603729248 - 1.42447984218597*x_5) - 0.0294747634260245*std::sin(0.289279937744141*x_103 - 7.47775983810425) - 0.0212877719789*std::sin(0.233039990067482*x_108 - 1.19815993309021) - 0.433048769688496*std::sin(0.302159935235977*x_112 - 7.45056009292603) - 0.387921158167311*std::sin(0.28263995051384*x_113 - 7.4191198348999) + 1.73850033684616*std::sin(0.305919915437698*x_113 - 1.22279989719391) + 0.012626863481721*std::sin(0.32423985004425*x_113 - 7.54616022109985) + 0.0132749042093058*std::sin(0.291599929332733*x_114 + 8.11127948760986) + 13.3036413723167*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.00891339192626738*std::sin(0.248479977250099*x_117 + 1.95407974720001) - 0.368363221299336*std::sin(0.272479951381683*x_117 + 1.92951989173889) - 0.0353419368794422*std::sin(0.262239962816238*x_120 + 8.34039974212646) - 26.0745607585578*std::sin(0.264879941940308*x_120 + 5.15752029418945) + 127.913845039532*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 0.654451779724055*std::sin(0.270879954099655*x_120 - 7.44527959823608) - 2.56256560230314*std::sin(0.121840052306652*x_18 - 4.63351964950562) - 13.7810303828685*std::sin(0.408319860696793*x_21 - 7.41095972061157) + 0.0161745584039093*std::sin(0.436799854040146*x_22 - 7.42592000961304) + 0.458371677572973*std::sin(0.197599992156029*x_3 - 7.60056018829346) - 0.212123221776031*std::sin(0.563679814338684*x_3 - 0.974079847335815) + 0.00368838068844566*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 91.9612894083559*std::sin(0.0759200975298882*x_32 - 4.65767955780029) - 13.6494420766872*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 0.996611947696333*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 18.7870358727763*std::sin(0.202879995107651*x_47 + 8.19711971282959) + 0.0146906341866343*std::sin(0.441279858350754*x_5 - 7.41847991943359) - 0.0497493896385003*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.00190192029967391*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.00297075184568129*std::sin(0.603359878063202*x_64 - 7.20143985748291) + 7.34570795303245*std::sin(0.550959885120392*x_65 - 7.2239203453064) + 0.146494867345714*std::sin(0.592319846153259*x_65 - 7.19871997833252) - 0.181925042772502*std::sin(0.613759815692902*x_65 - 0.975039839744568) - 4.84388659838669*std::sin(0.515199840068817*x_72 + 2.14071989059448) + 0.0368402876805299*std::sin(0.234399989247322*x_9 + 5.00383996963501) - 0.253865463702686*std::sin(0.296639919281006*x_9 - 1.20775985717773) + 13.6170381828614*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 7.97747208599334*std::sin(0.363919854164124*x_9 + 2.01831984519958) - 1.36149268879914*std::sin(0.357359826564789*x_91 - 7.3996000289917) + 85.2925622518342*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 5.62956018104819*std::sin(0.383279830217361*x_91 - 1.19735991954803) + 10.8811800905825*std::sin(0.388719856739044*x_91 - 4.3930401802063) + 0.0189745180693983*std::sin(0.394399851560593*x_91 - 4.39671945571899) + 1.94950590168019*std::sin(0.299439936876297*x_92 - 1.17271983623505) + 0.0262600194739208*std::sin(0.306479930877686*x_92 + 8.20936012268066) + 0.367219371673608*std::sin(0.310879945755005*x_92 + 8.21879959106445) + 0.029649352292876*std::sin(0.235599994659424*x_93 + 1.97719979286194) + 0.651020165226734*std::sin(0.319199919700623*x_94 + 1.95127987861633) - 0.343925434436218*std::sin(0.299599945545197*x_97 - 7.45336008071899) - 0.0337565556713001*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 4.71245725334284*std::sin(0.334719836711884*x_97 + 1.83487987518311) + 15.6054193710829*std::sin(0.232959985733032*x_98 - 4.22215986251831) + 0.325296991459053*std::sin(0.259039968252182*x_98 + 1.97311985492706) - 1.47310947743744*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 114.053727384106);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.04357927608585*x_1 + 11.2338886678337*x_100 + 5.21337348069125*x_101 + 5.95221569177915*x_102 - 1.96496092468547*x_103 + 6.35220346206032*x_104 + 25.7461164146969*x_105 + 7.40322300367333*x_106 + 3.68209814820732*x_107 + 12.3232097466411*x_108 - 9.51083980116833*x_109 + 6.69364674918822*x_110 + 17.7479481475554*x_111 + 7.67753578600011*x_112 - 11.5613257720504*x_113 - 40.1493530797359*x_114 - 2.86329597855619*x_115 - 10.2448504136124*x_116 + 15.1091797766107*x_117 + 26.5576902446441*x_118 + 18.9822877366346*x_119 - 2.01664926594698*x_12 - 1.85868367795963*x_120 + 1.59642505566468*x_13 + 5.78127000603043*x_14 - 0.0340061176810608*x_15 + 2.03749017926302*x_16 - 0.312446196334067*x_17 - 60.9787246531907*x_18 - 0.0201471232871307*x_19 - 0.285437157962692*x_2 + 0.0586605652991974*x_20 - 9.39317780804005*x_21 + 0.0825986351448972*x_22 - 0.0464329520947908*x_23 - 6.15694904188632*x_24 + 0.0959411816687953*x_25 - 0.0272235669973045*x_26 - 40.3226978018802*x_27 - 1.95654425792143*x_28 + 1.02340237224812*x_29 + 2.79019850373205*x_3 + 0.0686358614026846*x_30 - 2.1539900314495*x_31 - 4.13435410072735*x_32 - 40.296922940314*x_33 + 35.0164482530608*x_34 + 158.596751417319*x_35 - 83.8107968831316*x_36 + 268.631146098345*x_37 - 90.7653790027408*x_38 + 87.6839717908787*x_39 + 9.94298269024679*x_4 + 2941.08980737596*x_40 + 0.866187469782547*x_42 - 28.439848932718*x_43 + 25.391102805586*x_44 + 1.73691213608355*x_45 + 192.873691219211*x_46 - 106.758556913677*x_47 + 129.158999634241*x_48 - 37.8363954500647*x_5 + 0.143987427944275*x_50 - 11.2242701572441*x_52 + 1.03734247708098*x_53 - 38.0304148458789*x_54 - 23.3130041911999*x_58 - 0.0311886308589981*x_59 - 12.2940896237775*x_6 - 0.00572844689168578*x_60 - 12.8464656392237*x_61 - 12.7855960810442*x_62 - 8.94502754984339*x_63 - 18.4174070135391*x_64 - 0.514812701766791*x_65 + 3.71570791692568*x_66 - 5.10021495115827*x_67 - 14.2105262983909*x_68 - 31.2596282267125*x_69 - 39.5321759715209*x_7 + 10.2304441917662*x_70 + 7.94076099835059*x_71 + 0.833721879159268*x_72 - 20.7161269210118*x_73 + 10.1942729605256*x_74 + 7.62299158795201*x_75 - 7.69338336883828*x_76 + 0.301866548067594*x_77 + 9.82920728409807*x_78 + 25.558258281108*x_79 - 3.25581059371014*x_8 + 5.97109117106275*x_80 - 5.69712083792948*x_81 + 8.88689594439087*x_82 - 23.9329720973096*x_83 - 17.6746937937025*x_84 - 2.16858408267004*x_85 - 229.3752645901*x_86 - 83.8862113083404*x_87 - 35.5127320820554*x_88 - 3.37598065114643*x_89 - 7.92915629426522*x_9 + 0.827280945543615*x_90 - 1.12334252287238*x_91 + 7.39574921188754*x_92 + 20.0403179409525*x_93 - 2.65664031138966*x_94 + 0.780455677134516*x_95 + 19.7273159123515*x_96 + 5.33965554435845*x_97 + 23.7909801892179*x_98 + 44.2920210994416*x_99 + 0.00180259732410901*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) + 0.000131599593110184*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) + 0.000216610487481749*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.072366288109379*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) - 5.97997568039888e-5*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.00961806177226834*std::exp(1.10983991622925*x_1) + 0.147064587587938*std::exp(1.242959856987*x_1) - 1.96510376587855*std::exp(1.24823987483978*x_1) - 0.00335294055680395*std::exp(1.43383979797363*x_1) + 0.00510399368865874*std::exp(1.77823996543884*x_1) + 0.00109209134240547*std::exp(0.619279801845551*x_10) - 0.0162940088468977*std::exp(0.783999860286713*x_10) + 0.475007681812777*std::exp(0.794399857521057*x_10) - 0.0087743868034421*std::exp(0.803679883480072*x_10) - 0.00577031000751625*std::exp(0.826399862766266*x_10) + 1.44188686615372*std::exp(0.846799850463867*x_10) - 0.0030637139446055*std::exp(0.947519838809967*x_10) + 0.0122181926079862*std::exp(0.968719840049744*x_10) + 0.0312467430358622*std::exp(0.975119829177856*x_10) - 0.044917400164924*std::exp(1.1814398765564*x_10) + 0.0052077141799442*std::exp(0.822239875793457*x_11) - 0.00896326094744102*std::exp(0.89359986782074*x_11) - 0.000148471092781385*std::exp(0.906559824943542*x_11) + 0.549872992103259*std::exp(0.921199858188629*x_11) + 0.0127468949782961*std::exp(0.932559847831726*x_11) + 0.199280625259691*std::exp(0.940079808235168*x_11) + 1.55485198655438*std::exp(0.943679809570313*x_11) + 0.00979043244734029*std::exp(0.948239862918854*x_11) - 0.555673595383112*std::exp(0.976479828357697*x_11) - 0.00939356178958706*std::exp(1.0525598526001*x_11) - 0.000892896665387667*std::exp(0.547999858856201*x_12) + 0.0119239470253926*std::exp(0.748719871044159*x_12) - 0.0571181102069134*std::exp(0.869919836521149*x_12) + 0.00354105560696652*std::exp(0.872399866580963*x_12) - 0.122960029885671*std::exp(1.18807995319366*x_12) - 0.000361210375777851*std::exp(1.12631988525391*x_13) - 3.95065936351201e-5*std::exp(1.31047987937927*x_13) + 7.53552611860376e-5*std::exp(1.34023988246918*x_13) - 70.0700229553939*std::exp(0.269759833812714*x_14) - 0.0285593131872334*std::exp(0.473199844360352*x_14) - 0.0135784736222501*std::exp(0.679999828338623*x_14) + 0.00130988071286051*std::exp(0.895599842071533*x_14) + 0.0284260726773734*std::exp(0.71207982301712*x_15) + 0.263899892817489*std::exp(0.832959890365601*x_15) + 0.322792261746041*std::exp(0.923279821872711*x_15) + 0.00453651891396272*std::exp(0.930639863014221*x_15) + 2.29460234204743*std::exp(0.947279810905457*x_15) + 4.95469582491259e-5*std::exp(0.964959800243378*x_15) - 0.0523605867606287*std::exp(1.01871979236603*x_15) + 0.00103348822734099*std::exp(1.03775978088379*x_15) + 5.18383778372022*std::exp(0.382159829139709*x_16) + 0.0492105728967925*std::exp(0.548479855060577*x_16) + 1.50243467136527*std::exp(0.570239841938019*x_16) - 0.0172833285875341*std::exp(0.715919852256775*x_16) - 0.116498715178294*std::exp(0.887839913368225*x_16) + 0.00367325295967024*std::exp(0.618079841136932*x_17) - 14.3612747142555*std::exp(0.642879843711853*x_17) + 0.164926970713223*std::exp(0.658879816532135*x_17) + 6.17817557771997*std::exp(0.666479825973511*x_17) + 0.0349872540732554*std::exp(0.713679850101471*x_17) - 0.293979736841203*std::exp(0.826239883899689*x_17) - 0.0601377095802922*std::exp(0.442959845066071*x_18) + 0.0180308926144653*std::exp(0.693519830703735*x_19) - 0.00126256185435159*std::exp(0.705919861793518*x_19) - 0.0471104903706902*std::exp(0.7219198346138*x_19) + 25.4430162783383*std::exp(0.723199844360352*x_19) - 0.031660778799738*std::exp(0.725599884986877*x_19) + 1.99499691390193*std::exp(0.73967981338501*x_19) - 0.60301610485717*std::exp(0.765519857406616*x_19) - 3.77867892051581*std::exp(0.819519877433777*x_19) + 0.0336946530224294*std::exp(1.02399981021881*x_19) - 0.0365890173117794*std::exp(0.747839868068695*x_2) - 6.49336636979053*std::exp(0.754719853401184*x_2) - 0.267759372750987*std::exp(0.769999861717224*x_2) - 11.8020452164824*std::exp(0.827439904212952*x_2) - 0.00795445830191261*std::exp(1.00447976589203*x_2) - 0.218222151493682*std::exp(1.09567987918854*x_2) - 0.177365563736426*std::exp(0.44583985209465*x_20) + 0.0149609265041558*std::exp(0.488959848880768*x_20) - 0.59570254147262*std::exp(0.627359867095947*x_20) - 2.56291123156142*std::exp(0.851519882678986*x_20) + 0.313480424034344*std::exp(0.915279805660248*x_20) - 0.0262255398591903*std::exp(1.0039998292923*x_20) + 0.00715964265233087*std::exp(0.855839908123016*x_21) + 0.0541408639610349*std::exp(0.53279983997345*x_22) + 0.252522637357738*std::exp(0.742159843444824*x_22) + 0.000206524436832352*std::exp(1.19607996940613*x_22) + 0.0171331977697102*std::exp(1.36079978942871*x_22) + 0.0154973812119785*std::exp(1.40143978595734*x_22) - 0.0979980021113154*std::exp(0.62527984380722*x_23) + 0.00145953511145294*std::exp(0.664479851722717*x_23) + 0.0411125194667201*std::exp(0.685359835624695*x_23) + 0.271644929525764*std::exp(0.735519826412201*x_23) + 2.98912414314945*std::exp(0.743439853191376*x_23) + 3.70791689347871*std::exp(0.744559824466705*x_23) + 0.270481990120257*std::exp(0.782239854335785*x_23) - 0.0169371988844446*std::exp(0.818959891796112*x_23) + 0.0896426596758252*std::exp(0.834479868412018*x_23) - 2.62224687559112*std::exp(0.368799835443497*x_24) + 0.260115311960149*std::exp(0.424879848957062*x_24) + 3.51190310041582*std::exp(0.609519839286804*x_24) - 0.0586547406171102*std::exp(0.61167985200882*x_24) - 0.0126238155850805*std::exp(0.653759837150574*x_24) + 0.0136677706228213*std::exp(0.761439859867096*x_24) - 0.000400857978430862*std::exp(0.780959844589233*x_24) + 0.0532450375500652*std::exp(0.418559849262238*x_25) + 1.05241494045076*std::exp(0.545919835567474*x_25) + 18.1512509330605*std::exp(0.627679824829102*x_25) + 0.0359678493597688*std::exp(0.643359839916229*x_25) + 0.00628255722209213*std::exp(0.765359818935394*x_25) - 0.246363712415156*std::exp(0.878879845142365*x_25) - 0.347321952018692*std::exp(0.964159786701202*x_25) + 0.00190459749865039*std::exp(1.00615978240967*x_25) - 0.076363108211661*std::exp(0.429119855165482*x_26) - 0.0228790847093873*std::exp(0.569839835166931*x_26) - 3.53938035143649*std::exp(0.698879837989807*x_26) - 0.0410694727476599*std::exp(0.736239850521088*x_26) - 0.358458504236953*std::exp(0.79943984746933*x_26) - 0.0026222629410842*std::exp(0.822479903697968*x_26) - 5.86836776867595e-5*std::exp(0.984079837799072*x_26) - 0.0988306371737097*std::exp(1.10487985610962*x_26) + 1.39289306472819e-5*std::exp(1.14151990413666*x_27) - 0.0245489639562506*std::exp(1.18543982505798*x_27) + 0.0841994299131372*std::exp(1.24655985832214*x_27) + 0.00316127270123311*std::exp(1.2630398273468*x_27) + 0.000153837720007518*std::exp(1.27247989177704*x_27) + 0.409923304370653*std::exp(0.549759864807129*x_28) + 13.6948210816109*std::exp(0.565279841423035*x_28) + 0.00789008684278923*std::exp(0.650239825248718*x_28) - 0.016656166178339*std::exp(0.667519807815552*x_28) + 1.04042660251633*std::exp(0.768079876899719*x_28) + 0.00374580716850843*std::exp(0.905439794063568*x_28) + 0.000710881936066394*std::exp(1.13103985786438*x_29) + 0.141260290697635*std::exp(1.1431999206543*x_29) + 0.014115514855739*std::exp(1.1509598493576*x_29) + 0.135993929761633*std::exp(1.16863989830017*x_29) - 0.046681019059941*std::exp(1.17591977119446*x_29) - 2.22702982951814*std::exp(0.575039863586426*x_3) + 0.78831740674489*std::exp(0.670239865779877*x_3) - 0.00115718235155063*std::exp(0.670399844646454*x_3) + 0.00777822948682536*std::exp(0.915599822998047*x_3) + 0.0607167469985532*std::exp(0.947999835014343*x_3) + 0.154410757899957*std::exp(0.739759802818298*x_30) + 6.25958453349164*std::exp(0.847439885139465*x_30) + 0.154175202404288*std::exp(0.853279888629913*x_30) - 0.365966235559968*std::exp(0.882479906082153*x_30) - 0.00975165336280617*std::exp(0.916479825973511*x_30) - 1.61289618041577*std::exp(0.9440798163414*x_30) + 9.2697139446921e-5*std::exp(1.00999975204468*x_30) - 0.00227507100755695*std::exp(1.03159987926483*x_30) - 0.00171480514290116*std::exp(1.09999978542328*x_30) - 5.82292893663775*std::exp(0.787999868392944*x_32) + 0.00027603163710853*std::exp(0.823919892311096*x_32) - 0.231292655418785*std::exp(0.357519835233688*x_33) - 5.49231028338544*std::exp(0.36575984954834*x_33) + 0.00508206021074415*std::exp(0.395519852638245*x_33) + 0.992795625031102*std::exp(0.41407984495163*x_33) - 16.3483666990059*std::exp(0.379279851913452*x_34) + 1.14797643006828*std::exp(0.408159852027893*x_34) + 0.485523223433274*std::exp(0.431119859218597*x_36) + 1.36815022945393*std::exp(0.250399857759476*x_37) + 13.6896844899653*std::exp(0.375039845705032*x_38) + 0.0642878692845304*std::exp(0.385999858379364*x_4) + 0.00167506183529983*std::exp(0.527999818325043*x_4) + 1.17437746540661*std::exp(0.554479837417603*x_4) - 0.018016113103301*std::exp(0.638399839401245*x_4) + 4.39962031710786*std::exp(0.723759829998016*x_4) + 0.0188500917149905*std::exp(1.10615980625153*x_4) + 0.00131782400612705*std::exp(1.13591980934143*x_4) - 6.17740791926555*std::exp(0.685679852962494*x_41) + 0.00774653058784654*std::exp(0.7497598528862*x_41) - 0.0222493211802305*std::exp(0.769599854946136*x_41) + 0.188708497753812*std::exp(0.797759890556335*x_41) + 0.000390853732099531*std::exp(0.798159837722778*x_41) + 0.0321110943335101*std::exp(0.798719823360443*x_41) + 0.0783207678555518*std::exp(0.803759872913361*x_41) - 0.0493447647008725*std::exp(0.805199861526489*x_41) - 0.6761666663951*std::exp(0.812879860401154*x_41) + 0.0326688080708637*std::exp(0.866879880428314*x_41) + 0.160379252512151*std::exp(0.19999985396862*x_42) + 0.0473028638800518*std::exp(0.596879839897156*x_42) + 0.00575169742782577*std::exp(0.690479874610901*x_42) + 1.201275412599*std::exp(0.718159854412079*x_42) - 0.0113867391889932*std::exp(0.841359853744507*x_42) - 0.0998439847379483*std::exp(0.705839812755585*x_43) + 0.00512415377599652*std::exp(0.787679851055145*x_43) - 5.64202435710145e-5*std::exp(0.83271986246109*x_43) + 0.035111314055092*std::exp(0.886719882488251*x_44) + 2.02101242857218e-5*std::exp(0.908799827098846*x_44) - 0.0125173021006147*std::exp(0.942639827728271*x_44) + 0.659301549105466*std::exp(0.515199840068817*x_45) + 0.0149649812354696*std::exp(0.504559814929962*x_46) + 7.60493701599121e-5*std::exp(0.663999855518341*x_46) + 1.1176254385421*std::exp(0.700479865074158*x_46) + 0.0292923825487312*std::exp(0.75791984796524*x_46) + 0.0133126552117673*std::exp(0.759199857711792*x_46) + 0.0710988429218081*std::exp(0.801999866962433*x_46) - 0.0819656845487864*std::exp(0.802399873733521*x_46) + 0.0607145379302392*std::exp(0.424159854650497*x_47) - 0.077097724844192*std::exp(0.552239894866943*x_47) - 0.00062472307546337*std::exp(0.608879864215851*x_48) + 0.0162655214840815*std::exp(0.608959853649139*x_48) + 0.00777004878910374*std::exp(0.639919817447662*x_49) - 0.0218562105763805*std::exp(0.685839831829071*x_49) - 32.297731857457*std::exp(0.703679859638214*x_49) + 0.00148076142976169*std::exp(0.705999851226807*x_49) + 0.300430201401612*std::exp(0.708399832248688*x_49) - 0.356273829651769*std::exp(0.708639860153198*x_49) + 1.98807252872746*std::exp(0.715839862823486*x_49) + 0.0439569147629421*std::exp(0.719119846820831*x_49) + 4.01947889186864*std::exp(0.719919860363007*x_49) - 1.91229471962315*std::exp(0.720319867134094*x_49) - 0.000244488168384141*std::exp(1.93999981880188*x_5) + 1.87708955075276*std::exp(0.52215987443924*x_50) - 0.319813251899506*std::exp(0.537359833717346*x_50) + 0.11790993100556*std::exp(0.541919827461243*x_50) - 0.0185000796515154*std::exp(0.543199837207794*x_50) - 27.5478652242902*std::exp(0.546079874038696*x_50) + 0.48456996076649*std::exp(0.599439859390259*x_50) - 0.470185155264712*std::exp(0.610719859600067*x_50) - 0.00442728239313016*std::exp(0.658079862594604*x_50) + 0.0254475980761903*std::exp(0.463519841432571*x_51) + 0.00695277219985924*std::exp(0.48039984703064*x_51) + 2.60987021324361*std::exp(0.491039842367172*x_51) - 1.75006003458042*std::exp(0.493919849395752*x_51) - 21.7334077968417*std::exp(0.49415984749794*x_51) + 12.0456426093852*std::exp(0.496719866991043*x_51) + 82.9377916401427*std::exp(0.497119843959808*x_51) - 0.242066025213733*std::exp(0.499279826879501*x_51) - 27.1437831673067*std::exp(0.501199841499329*x_51) - 0.105253251748542*std::exp(0.510319828987122*x_51) + 0.441211706604807*std::exp(0.504639863967896*x_52) + 0.0303168381018933*std::exp(0.546399831771851*x_52) - 0.00104495005221225*std::exp(0.600159823894501*x_52) - 0.0173801486907009*std::exp(0.641199827194214*x_52) + 0.00330448661182638*std::exp(0.673519849777222*x_52) + 0.243200401741746*std::exp(0.712159812450409*x_52) + 0.0041690575994695*std::exp(0.714239835739136*x_52) + 0.0649676563601816*std::exp(0.88375985622406*x_52) + 11.1441572897204*std::exp(0.474319845438004*x_54) - 0.0922907853827172*std::exp(0.502159833908081*x_54) + 0.00204319479607978*std::exp(0.506399810314178*x_54) + 2.07174623020448*std::exp(0.519279837608337*x_54) - 1.72328331594311*std::exp(0.532479882240295*x_54) + 0.0607767759764453*std::exp(0.532879829406738*x_54) + 3.17082508762805*std::exp(0.542559862136841*x_54) + 1.02703721450415*std::exp(0.612959861755371*x_55) - 0.00220656482613379*std::exp(0.631199836730957*x_55) + 0.235076836398111*std::exp(0.650959849357605*x_55) + 1.48869090704678*std::exp(0.652479827404022*x_55) - 0.174554725197624*std::exp(0.653439819812775*x_55) + 0.612162074760173*std::exp(0.655679821968079*x_55) - 209.580883084948*std::exp(0.655759811401367*x_55) - 4.91821394420256*std::exp(0.656879842281342*x_55) + 0.827545923207966*std::exp(0.657759845256805*x_55) + 33.8443930654636*std::exp(0.659119844436646*x_55) + 25.7824572544565*std::exp(0.347199827432632*x_56) - 43.5617089468819*std::exp(0.442879855632782*x_56) + 1.69532492749538*std::exp(0.466319859027863*x_56) + 0.127671562175828*std::exp(0.52183985710144*x_56) - 1.99749488441223*std::exp(0.525679886341095*x_56) - 0.0346861146383747*std::exp(0.574079871177673*x_56) - 0.450737120263171*std::exp(0.655039846897125*x_56) - 0.0443699891343*std::exp(0.658559858798981*x_56) + 0.000152312153686356*std::exp(0.754159867763519*x_56) - 0.0014664281855263*std::exp(0.859519898891449*x_56) - 0.515414462051197*std::exp(0.599999845027924*x_57) + 0.714645011389732*std::exp(0.609679877758026*x_57) + 0.0782709690583096*std::exp(0.617039859294891*x_57) - 0.0911130072396093*std::exp(0.626319825649261*x_57) - 22.8209655152804*std::exp(0.628239870071411*x_57) - 2.09122257974945*std::exp(0.632079839706421*x_57) + 90.9532757694743*std::exp(0.634159862995148*x_57) + 0.00522470253298026*std::exp(0.637119889259338*x_57) + 2.5514840559307*std::exp(0.641199827194214*x_57) - 0.0146741704891335*std::exp(0.671519815921783*x_57) + 0.168615976192146*std::exp(0.37679985165596*x_58) - 0.0485650610001516*std::exp(0.451519846916199*x_58) + 0.145080435124363*std::exp(0.558799862861633*x_58) + 0.472320724479422*std::exp(0.595039844512939*x_58) + 0.0010127037216134*std::exp(0.603839874267578*x_58) - 0.0330874281135695*std::exp(0.653759837150574*x_58) + 14.6583954571294*std::exp(0.512399852275848*x_59) + 0.0727420188332767*std::exp(0.545279860496521*x_59) - 2.46783332636714*std::exp(0.696399867534637*x_59) - 0.0766394660306432*std::exp(0.807599902153015*x_59) + 0.0260643457070704*std::exp(0.839199841022491*x_59) + 0.000710593666473202*std::exp(0.866959869861603*x_59) + 0.0128124888675081*std::exp(0.778479874134064*x_60) + 1.53491937523188*std::exp(0.780239880084991*x_60) + 8.56159870144238*std::exp(0.821839869022369*x_60) - 0.000382388058935271*std::exp(0.842239856719971*x_60) + 0.00706026577131862*std::exp(0.845599889755249*x_60) + 0.134786262399883*std::exp(0.847439885139465*x_60) - 0.0168764930991893*std::exp(0.850079894065857*x_60) + 0.135602470467873*std::exp(0.897759795188904*x_60) + 0.0287915329953151*std::exp(0.979119837284088*x_60) - 0.014248676836656*std::exp(1.01919984817505*x_61) - 0.148390375234028*std::exp(1.04719984531403*x_61) - 1.5457100752221*std::exp(1.3343198299408*x_61) - 0.0475522820386433*std::exp(1.36879980564117*x_61) + 0.0479394490215534*std::exp(0.578399837017059*x_66) + 8.55821182395359*std::exp(0.930159866809845*x_66) + 0.0254080478138715*std::exp(1.03991973400116*x_66) + 0.00157970537095515*std::exp(1.46671986579895*x_66) - 1.23613472719819e-5*std::exp(1.60799980163574*x_7) - 0.000111719298698921*std::exp(1.8828798532486*x_7) + 0.100007254372265*std::exp(0.481679856777191*x_8) + 0.0257429733931813*std::exp(0.549919843673706*x_8) - 0.413828495163212*std::exp(0.583999812602997*x_8) - 0.0683452841622038*std::exp(0.832639873027802*x_8) - 0.0359129187852798*std::exp(0.863359868526459*x_8) - 0.0128698906917074*std::exp(1.34103989601135*x_8) + 8.26926635445641*std::log(9.5269603729248 - 1.42447984218597*x_5) - 3.27206976121244*std::sin(0.289279937744141*x_103 - 7.47775983810425) - 2.36321065478825*std::sin(0.233039990067482*x_108 - 1.19815993309021) - 7.48982851523422*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.412365296955429*std::sin(0.28263995051384*x_113 - 7.4191198348999) + 0.282834610797982*std::sin(0.305919915437698*x_113 - 1.22279989719391) + 1.40174079025914*std::sin(0.32423985004425*x_113 - 7.54616022109985) + 1.47368146839508*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 33.7239124588823*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.00822967001011942*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.39157495264294*std::sin(0.272479951381683*x_117 + 1.92951989173889) - 3.92339986904854*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 66.0974074553159*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 157.193996543599*std::sin(0.270639955997467*x_120 + 5.14951992034912) - 0.338731737877721*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 2.72404096377166*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 34.9340642323797*std::sin(0.408319860696793*x_21 - 7.41095972061157) + 1.79557958411524*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.487255126354346*std::sin(0.197599992156029*x_3 - 7.60056018829346) + 0.372923159022498*std::sin(0.563679814338684*x_3 - 0.974079847335815) + 0.409456684827775*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 85.6980102346113*std::sin(0.0759200975298882*x_32 - 4.65767955780029) - 2.22061195821964*std::sin(0.121680058538914*x_33 + 7.96871995925903) + 0.515827303846922*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 17.507492585863*std::sin(0.202879995107651*x_47 + 8.19711971282959) + 1.63084531673214*std::sin(0.441279858350754*x_5 - 7.41847991943359) - 5.522808482703*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.00175602919532097*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.00274287359673506*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 18.6209177640695*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.155725972155937*std::sin(0.592319846153259*x_65 - 7.19871997833252) - 3.14649865873729*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 12.2789545383167*std::sin(0.515199840068817*x_72 + 2.14071989059448) + 4.08973566883307*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.269862329296653*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 34.5183540939144*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 7.434144180341*std::sin(0.363919854164124*x_9 + 2.01831984519958) - 0.221499672205631*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 104.81647808856*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 5.24614334048248*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 27.5831221358484*std::sin(0.388719856739044*x_91 - 4.3930401802063) + 2.10641035217398*std::sin(0.394399851560593*x_91 - 4.39671945571899) + 0.317162862303707*std::sin(0.299439936876297*x_92 - 1.17271983623505) + 2.91519271613897*std::sin(0.306479930877686*x_92 + 8.20936012268066) + 6.35127106650327*std::sin(0.310879945755005*x_92 + 8.21879959106445) + 3.29145132311378*std::sin(0.235599994659424*x_93 + 1.97719979286194) + 0.105913718364632*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.365597263556961*std::sin(0.299599945545197*x_97 - 7.45336008071899) - 3.74740259856406*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 4.39150225627924*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 39.5587780838459*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.345794983484414*std::sin(0.259039968252182*x_98 + 1.97311985492706) - 0.239658478565314*std::sin(0.265759944915771*x_98 + 1.95295977592468) + 1257.67667678933);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.67578938429494*x_1 + 3.0003120468541*x_100 + 6.17607705410641*x_101 + 10.9096794494996*x_102 - 1.22983875734075*x_103 + 78.5749426672321*x_104 + 11.2415283506869*x_105 + 4.90142983016755*x_106 + 0.269177456489547*x_107 + 7.26754438010966*x_108 - 7.12938811439545*x_109 + 9.65432988367552*x_110 + 10.9968504693225*x_111 + 2.33419379837219*x_112 - 8.90727554155632*x_113 - 20.5109549842594*x_114 - 9.25959273805242*x_115 - 2.5886370826016*x_116 + 12.7755006622891*x_117 + 13.4009833484819*x_118 + 5.74054523382312*x_119 - 2.08721221226445*x_12 - 0.482756132225954*x_120 - 8.58292484540861*x_13 - 1.76421659197102*x_14 + 0.0363102117393406*x_15 + 1.15558311026966*x_16 - 0.870625706357903*x_17 - 51.8405566301668*x_18 - 0.0130675593508761*x_19 - 0.176012544791669*x_2 + 0.0675329764467289*x_20 - 5.07142971224472*x_21 - 0.0664483555949537*x_22 + 0.0148962561270943*x_23 - 4.05966155075635*x_24 - 0.0352394404167707*x_25 - 0.015990906420765*x_26 - 26.9685103396985*x_27 + 0.520303857196455*x_28 - 0.915160861764246*x_29 + 0.26823966297761*x_3 + 0.0445176802512047*x_30 - 0.163199308896267*x_31 + 2.68105528435066*x_32 - 31.2261836689634*x_33 + 41.239506843978*x_34 + 13.9535475420472*x_35 - 55.6177177114362*x_36 + 224.850453312*x_37 + 10.817962134546*x_38 + 25.3515074568918*x_39 + 6.02128759562602*x_4 + 1695.74312521106*x_40 + 4.75585089044763*x_42 - 5.70713148669344*x_43 + 16.8887551161058*x_44 - 27.5827550845865*x_45 + 127.249978361597*x_46 - 49.582810227083*x_47 + 73.7622616698308*x_48 - 25.1148160748365*x_5 - 0.0467495653723718*x_50 - 5.01434544704279*x_52 - 4.46674219614562*x_53 - 24.6867797694639*x_54 + 2.45201284103597*x_58 + 0.0338683870601104*x_59 - 5.25869526458741*x_6 - 0.146867238840411*x_60 - 8.83385625877661*x_61 - 8.1011286469655*x_62 - 6.65148491038514*x_63 - 15.6398256851007*x_64 - 0.0739091668479135*x_65 - 0.378800264944144*x_66 - 5.97657884998011*x_67 - 6.77136439832645*x_68 - 16.8351993863625*x_69 - 20.3094995730512*x_7 + 3.26699768345968*x_70 + 5.47005155938763*x_71 - 0.00771623262301135*x_72 - 14.7838453801192*x_73 + 6.42915898010501*x_74 + 3.06093963175152*x_75 - 2.81410143745934*x_76 - 1.40144834688048*x_77 + 1.70841260445617*x_78 + 11.9329879993836*x_79 - 2.84222665724176*x_8 + 2.57218188558604*x_80 - 1.73910996932897*x_81 + 5.17447559774555*x_82 - 10.4356306703421*x_83 - 7.81699979008582*x_84 + 1.15495134098759*x_85 - 214.798972172138*x_86 - 51.1519773903314*x_87 - 26.1329471853342*x_88 - 2.27545642274577*x_89 - 5.71078622630118*x_9 + 1.55225569864532*x_90 - 0.628985206812358*x_91 + 10.0605667600987*x_92 + 9.5503977070343*x_93 - 5.90667026162041*x_94 + 2.78593106716819*x_95 + 15.1629513950674*x_96 + 2.22178617753751*x_97 + 14.7808581124772*x_98 + 22.2030960268141*x_99 - 0.000887045158952495*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) + 0.0033739806335058*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) + 0.000467253764701544*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.0483986644205348*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) - 0.00153315991772167*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) + 0.00308559126961038*std::exp(1.10983991622925*x_1) + 0.0907092141713422*std::exp(1.242959856987*x_1) - 0.0161422116321153*std::exp(1.24823987483978*x_1) - 0.00723267887996024*std::exp(1.43383979797363*x_1) - 0.00188368514204906*std::exp(1.77823996543884*x_1) - 0.000629134582326284*std::exp(0.619279801845551*x_10) - 0.0351480533759229*std::exp(0.783999860286713*x_10) + 0.292984016405876*std::exp(0.794399857521057*x_10) + 0.00281493007197647*std::exp(0.803679883480072*x_10) - 0.00374266178955376*std::exp(0.826399862766266*x_10) + 0.0118442818883995*std::exp(0.846799850463867*x_10) - 0.0785482027064161*std::exp(0.947519838809967*x_10) - 0.00450925868687846*std::exp(0.968719840049744*x_10) - 0.0153762971753518*std::exp(0.975119829177856*x_10) - 0.0300408136719573*std::exp(1.1814398765564*x_10) + 0.133516573818385*std::exp(0.822239875793457*x_11) + 0.0028755231959943*std::exp(0.89359986782074*x_11) + 8.55315808463419e-5*std::exp(0.906559824943542*x_11) + 0.339160826041185*std::exp(0.921199858188629*x_11) + 0.00826772161436407*std::exp(0.932559847831726*x_11) - 0.0980645602572442*std::exp(0.940079808235168*x_11) + 1.03988696238096*std::exp(0.943679809570313*x_11) + 0.0211190901800696*std::exp(0.948239862918854*x_11) - 0.00456454306932868*std::exp(0.976479828357697*x_11) + 0.00346679754194893*std::exp(1.0525598526001*x_11) + 0.000514382038229393*std::exp(0.547999858856201*x_12) + 0.00773395205014455*std::exp(0.748719871044159*x_12) + 0.0281074106068591*std::exp(0.869919836521149*x_12) - 0.00113601373382362*std::exp(0.872399866580963*x_12) - 0.0822358224948698*std::exp(1.18807995319366*x_12) - 0.000779172374771008*std::exp(1.12631988525391*x_13) + 1.26741960385457e-5*std::exp(1.31047987937927*x_13) + 4.88759280377419e-5*std::exp(1.34023988246918*x_13) - 46.862919400142*std::exp(0.269759833812714*x_14) - 0.0616057272164608*std::exp(0.473199844360352*x_14) - 0.00880708910271074*std::exp(0.679999828338623*x_14) - 0.000420225674104835*std::exp(0.895599842071533*x_14) + 0.0184373414769924*std::exp(0.71207982301712*x_15) + 0.162773052915011*std::exp(0.832959890365601*x_15) + 0.00265155514573259*std::exp(0.923279821872711*x_15) - 0.00145537047762633*std::exp(0.930639863014221*x_15) + 1.5346329296795*std::exp(0.947279810905457*x_15) - 2.85431297485995e-5*std::exp(0.964959800243378*x_15) + 0.0257662675877349*std::exp(1.01871979236603*x_15) + 0.00222935311495705*std::exp(1.03775978088379*x_15) + 0.0425822839609473*std::exp(0.382159829139709*x_16) - 0.015787350684384*std::exp(0.548479855060577*x_16) + 0.926699422468584*std::exp(0.570239841938019*x_16) - 0.0372821299789538*std::exp(0.715919852256775*x_16) + 0.057328178590396*std::exp(0.887839913368225*x_16) - 0.00211609631614761*std::exp(0.618079841136932*x_17) - 9.60483857477665*std::exp(0.642879843711853*x_17) + 0.106972739861671*std::exp(0.658879816532135*x_17) + 0.0507502043442146*std::exp(0.666479825973511*x_17) - 0.0112243369061474*std::exp(0.713679850101471*x_17) + 0.144665310941817*std::exp(0.826239883899689*x_17) - 1.5418244287231*std::exp(0.442959845066071*x_18) + 0.0388947116687876*std::exp(0.693519830703735*x_19) + 0.000727339640976355*std::exp(0.705919861793518*x_19) - 1.20782958662028*std::exp(0.7219198346138*x_19) + 17.0163212577695*std::exp(0.723199844360352*x_19) + 0.0101571631547649*std::exp(0.725599884986877*x_19) + 1.2305110652562*std::exp(0.73967981338501*x_19) + 0.222549741716912*std::exp(0.765519857406616*x_19) - 0.0310397017622677*std::exp(0.819519877433777*x_19) - 0.0165808960472652*std::exp(1.02399981021881*x_19) + 0.0117382020467335*std::exp(0.747839868068695*x_2) - 0.0533393177327498*std::exp(0.754719853401184*x_2) + 0.0988195485461022*std::exp(0.769999861717224*x_2) - 7.89322267082645*std::exp(0.827439904212952*x_2) - 0.0171586825316723*std::exp(1.00447976589203*x_2) + 0.10738554887978*std::exp(1.09567987918854*x_2) + 0.0654587167425082*std::exp(0.44583985209465*x_20) + 0.383571674435662*std::exp(0.488959848880768*x_20) - 0.367428422457866*std::exp(0.627359867095947*x_20) - 1.71407825213415*std::exp(0.851519882678986*x_20) + 0.00257506368628087*std::exp(0.915279805660248*x_20) + 0.0129053992602086*std::exp(1.0039998292923*x_20) + 0.00464379226537815*std::exp(0.855839908123016*x_21) - 0.0173690480600785*std::exp(0.53279983997345*x_22) + 0.155755579034268*std::exp(0.742159843444824*x_22) + 0.000445496992018511*std::exp(1.19607996940613*x_22) + 0.000140739491285796*std::exp(1.36079978942871*x_22) + 0.010364668028046*std::exp(1.40143978595734*x_22) - 0.0635621617342707*std::exp(0.62527984380722*x_23) - 0.000840812464195476*std::exp(0.664479851722717*x_23) + 0.0886844386923281*std::exp(0.685359835624695*x_23) - 0.100253556111883*std::exp(0.735519826412201*x_23) + 0.0245539575829025*std::exp(0.743439853191376*x_23) + 2.47985947759906*std::exp(0.744559824466705*x_23) - 0.133102239036443*std::exp(0.782239854335785*x_23) - 0.434239800225719*std::exp(0.818959891796112*x_23) + 0.0552914562831853*std::exp(0.834479868412018*x_23) - 1.61739788856985*std::exp(0.368799835443497*x_24) + 0.168712536706523*std::exp(0.424879848957062*x_24) + 0.02884828987799*std::exp(0.609519839286804*x_24) + 0.0188171546258153*std::exp(0.61167985200882*x_24) - 0.0272310238788593*std::exp(0.653759837150574*x_24) + 0.350417446549308*std::exp(0.761439859867096*x_24) + 0.000230927219216636*std::exp(0.780959844589233*x_24) + 0.11485567728589*std::exp(0.418559849262238*x_25) - 0.51788581157334*std::exp(0.545919835567474*x_25) + 12.1395794322668*std::exp(0.627679824829102*x_25) + 0.023328988438383*std::exp(0.643359839916229*x_25) + 0.161073646925968*std::exp(0.765359818935394*x_25) - 0.151956763487678*std::exp(0.878879845142365*x_25) - 0.00285305262313137*std::exp(0.964159786701202*x_25) - 0.000611018056767109*std::exp(1.00615978240967*x_25) - 0.164724017802768*std::exp(0.429119855165482*x_26) - 0.586579235523774*std::exp(0.569839835166931*x_26) - 2.36714202650402*std::exp(0.698879837989807*x_26) + 0.015157141706201*std::exp(0.736239850521088*x_26) + 0.176394847931945*std::exp(0.79943984746933*x_26) + 0.000841253864781947*std::exp(0.822479903697968*x_26) + 3.38066328495094e-5*std::exp(0.984079837799072*x_26) - 0.000811837567407839*std::exp(1.10487985610962*x_26) - 8.02421155150579e-6*std::exp(1.14151990413666*x_27) - 0.0151417636680248*std::exp(1.18543982505798*x_27) + 0.000691650507500642*std::exp(1.24655985832214*x_27) - 0.00116670254324765*std::exp(1.2630398273468*x_27) + 0.0039441268452363*std::exp(1.27247989177704*x_27) - 0.151286714859863*std::exp(0.549759864807129*x_28) + 9.15911354782129*std::exp(0.565279841423035*x_28) - 0.00253123588255313*std::exp(0.650239825248718*x_28) - 0.0359292684431041*std::exp(0.667519807815552*x_28) + 0.00854651377556783*std::exp(0.768079876899719*x_28) + 0.0960358656490146*std::exp(0.905439794063568*x_28) - 0.000228059576616014*std::exp(1.13103985786438*x_29) + 0.094475059921388*std::exp(1.1431999206543*x_29) - 0.00520948638028502*std::exp(1.1509598493576*x_29) + 0.00111711291434723*std::exp(1.16863989830017*x_29) - 0.0287927816280905*std::exp(1.17591977119446*x_29) - 1.37362861505278*std::exp(0.575039863586426*x_3) - 0.387925317550704*std::exp(0.670239865779877*x_3) + 0.000666632365947141*std::exp(0.670399844646454*x_3) + 0.0167785366843696*std::exp(0.915599822998047*x_3) - 0.0224081848786106*std::exp(0.947999835014343*x_3) - 0.0759844217304848*std::exp(0.739759802818298*x_30) + 4.18641800157728*std::exp(0.847439885139465*x_30) - 0.0569000582204251*std::exp(0.853279888629913*x_30) - 0.225727418036915*std::exp(0.882479906082153*x_30) - 0.250015131606235*std::exp(0.916479825973511*x_30) - 0.0132490263043498*std::exp(0.9440798163414*x_30) - 5.34011889338165e-5*std::exp(1.00999975204468*x_30) - 0.00490759014303906*std::exp(1.03159987926483*x_30) + 0.000550130359245021*std::exp(1.09999978542328*x_30) - 3.89438218971503*std::exp(0.787999868392944*x_32) - 0.000159016963121972*std::exp(0.823919892311096*x_32) - 0.150017968274276*std::exp(0.357519835233688*x_33) - 0.0451162103920829*std::exp(0.36575984954834*x_33) - 0.00292768535368212*std::exp(0.395519852638245*x_33) - 0.366402170934863*std::exp(0.41407984495163*x_33) - 0.134292549674493*std::exp(0.379279851913452*x_34) - 0.423673357893669*std::exp(0.408159852027893*x_34) - 0.179187698474871*std::exp(0.431119859218597*x_36) - 0.504930925960965*std::exp(0.250399857759476*x_37) + 9.15567818887425*std::exp(0.375039845705032*x_38) - 0.0206243308582346*std::exp(0.385999858379364*x_4) - 0.000964973612739059*std::exp(0.527999818325043*x_4) + 0.724354236290012*std::exp(0.554479837417603*x_4) - 0.0116853718466033*std::exp(0.638399839401245*x_4) + 0.0361403827588506*std::exp(0.723759829998016*x_4) - 0.00695683416864114*std::exp(1.10615980625153*x_4) + 0.00284269813172743*std::exp(1.13591980934143*x_4) - 4.13145817872256*std::exp(0.685679852962494*x_41) + 0.19860733276258*std::exp(0.7497598528862*x_41) + 0.00713785301175972*std::exp(0.769599854946136*x_41) - 0.0928620924634156*std::exp(0.797759890556335*x_41) - 0.000225163949156012*std::exp(0.798159837722778*x_41) + 0.069267328144872*std::exp(0.798719823360443*x_41) - 0.0289051428592472*std::exp(0.803759872913361*x_41) - 0.0320053454874897*std::exp(0.805199861526489*x_41) - 0.00555432523058235*std::exp(0.812879860401154*x_41) + 0.0201500711804634*std::exp(0.866879880428314*x_41) + 0.345956515714116*std::exp(0.19999985396862*x_42) + 0.0306809549139867*std::exp(0.596879839897156*x_42) + 0.147463341433139*std::exp(0.690479874610901*x_42) + 0.00986779541891539*std::exp(0.718159854412079*x_42) + 0.0042024016358709*std::exp(0.841359853744507*x_42) + 0.0491325057059542*std::exp(0.705839812755585*x_43) + 0.0033235605220931*std::exp(0.787679851055145*x_43) + 3.25027083317161e-5*std::exp(0.83271986246109*x_43) + 0.000288419508425078*std::exp(0.886719882488251*x_44) - 1.16426965470248e-5*std::exp(0.908799827098846*x_44) + 0.00615967420066174*std::exp(0.942639827728271*x_44) + 0.406656193732191*std::exp(0.515199840068817*x_45) + 0.383675630569595*std::exp(0.504559814929962*x_46) - 4.38107023413882e-5*std::exp(0.663999855518341*x_46) + 0.0091806583792875*std::exp(0.700479865074158*x_46) + 0.0189992358724791*std::exp(0.75791984796524*x_46) - 0.00427086180868587*std::exp(0.759199857711792*x_46) + 0.0438536582851565*std::exp(0.801999866962433*x_46) + 0.0403347229615832*std::exp(0.802399873733521*x_46) - 0.0194779626718691*std::exp(0.424159854650497*x_47) - 0.0500061016583214*std::exp(0.552239894866943*x_47) + 0.00035989195765029*std::exp(0.608879864215851*x_48) + 0.41701918056247*std::exp(0.608959853649139*x_48) + 0.0167608899773576*std::exp(0.639919817447662*x_49) + 0.00701173834583727*std::exp(0.685839831829071*x_49) - 21.6007636504833*std::exp(0.703679859638214*x_49) - 0.000853040572216265*std::exp(0.705999851226807*x_49) + 0.194861044510456*std::exp(0.708399832248688*x_49) + 0.131486784732352*std::exp(0.708639860153198*x_49) - 0.978316171153647*std::exp(0.715839862823486*x_49) + 1.12697748992777*std::exp(0.719119846820831*x_49) + 0.033017736798421*std::exp(0.719919860363007*x_49) - 1.17950047748442*std::exp(0.720319867134094*x_49) - 0.000150799930779088*std::exp(1.93999981880188*x_5) + 0.015419224830164*std::exp(0.52215987443924*x_50) + 0.118030606537016*std::exp(0.537359833717346*x_50) + 0.0764771724237708*std::exp(0.541919827461243*x_50) - 0.474309296764059*std::exp(0.543199837207794*x_50) - 18.4240468777028*std::exp(0.546079874038696*x_50) - 0.238453387300002*std::exp(0.599439859390259*x_50) - 0.290009489358474*std::exp(0.610719859600067*x_50) - 0.00955015793388686*std::exp(0.658079862594604*x_50) - 0.00816389916343075*std::exp(0.463519841432571*x_51) - 0.00400536957314708*std::exp(0.48039984703064*x_51) - 0.963201375873039*std::exp(0.491039842367172*x_51) - 1.13510068130093*std::exp(0.493919849395752*x_51) - 13.4051329069142*std::exp(0.49415984749794*x_51) - 5.92757396242579*std::exp(0.496719866991043*x_51) + 55.4688992656963*std::exp(0.497119843959808*x_51) - 0.522164290854041*std::exp(0.499279826879501*x_51) - 0.222970766221611*std::exp(0.501199841499329*x_51) - 2.69850707452993*std::exp(0.510319828987122*x_51) - 0.162834044657291*std::exp(0.504639863967896*x_52) + 0.0196637046183387*std::exp(0.546399831771851*x_52) + 0.000601977315562581*std::exp(0.600159823894501*x_52) - 0.0374909820905456*std::exp(0.641199827194214*x_52) + 0.0847211877216556*std::exp(0.673519849777222*x_52) + 0.150005638270717*std::exp(0.712159812450409*x_52) - 0.00133748441588476*std::exp(0.714239835739136*x_52) + 0.000533672407746741*std::exp(0.88375985622406*x_52) + 0.0915429243767303*std::exp(0.474319845438004*x_54) - 0.199081851569953*std::exp(0.502159833908081*x_54) - 0.00117704852582343*std::exp(0.506399810314178*x_54) - 0.764600787145148*std::exp(0.519279837608337*x_54) - 1.06291853088231*std::exp(0.532479882240295*x_54) - 0.0194979293945372*std::exp(0.532879829406738*x_54) - 1.56034018593466*std::exp(0.542559862136841*x_54) + 0.633474993405116*std::exp(0.612959861755371*x_55) + 0.00127116312194894*std::exp(0.631199836730957*x_55) + 0.507087805757333*std::exp(0.650959849357605*x_55) - 0.549417791980945*std::exp(0.652479827404022*x_55) - 4.47527418880851*std::exp(0.653439819812775*x_55) - 0.196389043675386*std::exp(0.655679821968079*x_55) - 140.167957959324*std::exp(0.655759811401367*x_55) + 2.42021765568409*std::exp(0.656879842281342*x_55) + 0.536751838611285*std::exp(0.657759845256805*x_55) + 0.278012471865047*std::exp(0.659119844436646*x_55) + 0.211788246821326*std::exp(0.347199827432632*x_56) - 29.1341256818158*std::exp(0.442879855632782*x_56) - 0.625678355356205*std::exp(0.466319859027863*x_56) + 0.0828086319011802*std::exp(0.52183985710144*x_56) - 1.23205180967148*std::exp(0.525679886341095*x_56) - 0.889290584230397*std::exp(0.574079871177673*x_56) + 0.221804490188766*std::exp(0.655039846897125*x_56) + 0.0142344325028404*std::exp(0.658559858798981*x_56) - 8.77443483634029e-5*std::exp(0.754159867763519*x_56) - 0.00316325445880985*std::exp(0.859519898891449*x_56) - 0.334301278508387*std::exp(0.599999845027924*x_57) - 0.263747620375306*std::exp(0.609679877758026*x_57) + 0.168839493343621*std::exp(0.617039859294891*x_57) + 0.0292301615796528*std::exp(0.626319825649261*x_57) - 0.187461273747123*std::exp(0.628239870071411*x_57) + 1.02907556826414*std::exp(0.632079839706421*x_57) + 60.8296651233742*std::exp(0.634159862995148*x_57) - 0.0030098590825063*std::exp(0.637119889259338*x_57) + 1.57375148892176*std::exp(0.641199827194214*x_57) - 0.376219757774214*std::exp(0.671519815921783*x_57) + 0.109365453568462*std::exp(0.37679985165596*x_58) - 0.104760428957499*std::exp(0.451519846916199*x_58) - 0.0535435340864598*std::exp(0.558799862861633*x_58) - 0.232425626355289*std::exp(0.595039844512939*x_58) - 0.000583400772607689*std::exp(0.603839874267578*x_58) + 0.0106148496171504*std::exp(0.653759837150574*x_58) + 9.80355330096238*std::exp(0.512399852275848*x_59) + 0.047180961512931*std::exp(0.545279860496521*x_59) - 0.0202718495169112*std::exp(0.696399867534637*x_59) - 0.0472711062001515*std::exp(0.807599902153015*x_59) - 0.00961933414117148*std::exp(0.839199841022491*x_59) + 0.0182183638437627*std::exp(0.866959869861603*x_59) - 0.00411040235835785*std::exp(0.778479874134064*x_60) + 0.0126084911257346*std::exp(0.780239880084991*x_60) + 5.72600796973435*std::exp(0.821839869022369*x_60) + 0.000220287023990966*std::exp(0.842239856719971*x_60) + 0.0152298062748233*std::exp(0.845599889755249*x_60) - 0.0497443561498029*std::exp(0.847439885139465*x_60) - 0.0109462066651062*std::exp(0.850079894065857*x_60) - 0.0667289989626385*std::exp(0.897759795188904*x_60) + 0.0177585738050749*std::exp(0.979119837284088*x_60) - 0.0307360367050749*std::exp(1.01919984817505*x_61) - 0.0915269579770217*std::exp(1.04719984531403*x_61) - 0.0126971305990923*std::exp(1.3343198299408*x_61) + 0.0175496939476541*std::exp(1.36879980564117*x_61) + 0.103410911878982*std::exp(0.578399837017059*x_66) + 5.72374282181401*std::exp(0.930159866809845*x_66) + 0.0164798302996313*std::exp(1.03991973400116*x_66) - 0.000506788708222891*std::exp(1.46671986579895*x_66) + 3.96567064406094e-6*std::exp(1.60799980163574*x_7) + 5.49762621673859e-5*std::exp(1.8828798532486*x_7) + 0.0648653762327697*std::exp(0.481679856777191*x_8) - 0.00825865915987758*std::exp(0.549919843673706*x_8) + 0.203642021632627*std::exp(0.583999812602997*x_8) - 0.0421552674260452*std::exp(0.832639873027802*x_8) + 0.0132540586156609*std::exp(0.863359868526459*x_8) - 0.000105718844386241*std::exp(1.34103989601135*x_8) - 4.0692464088922*std::log(9.5269603729248 - 1.42447984218597*x_5) + 1.20759341976451*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 0.872168946417031*std::sin(0.233039990067482*x_108 - 1.19815993309021) - 4.61971484800008*std::sin(0.302159935235977*x_112 - 7.45056009292603) - 0.132291805802769*std::sin(0.28263995051384*x_113 - 7.4191198348999) + 7.25137879809822*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 0.517327892760213*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 0.543878393168299*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 0.277022792092015*std::sin(0.239199981093407*x_117 - 7.43759965896606) + 0.00474096790575718*std::sin(0.248479977250099*x_117 + 1.95407974720001) - 0.12562201032612*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 1.44797397694002*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 0.542952671509871*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 105.131542412914*std::sin(0.270639955997467*x_120 + 5.14951992034912) - 0.730683364352787*std::sin(0.270879954099655*x_120 - 7.44527959823608) - 0.8739054931119*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 0.286963501775628*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 0.662678441683839*std::sin(0.436799854040146*x_22 - 7.42592000961304) + 0.156317374492937*std::sin(0.197599992156029*x_3 - 7.60056018829346) + 0.241880463249834*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.151114503773109*std::sin(0.2743199467659*x_31 - 4.31576013565063) - 42.1713735473603*std::sin(0.0759200975298882*x_32 - 4.65767955780029) - 56.9325600823961*std::sin(0.121680058538914*x_33 + 7.96871995925903) + 1.11269889311629*std::sin(0.19080001115799*x_35 - 4.59863996505737) - 8.61531099374209*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 0.601881444119872*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 2.03825335920116*std::sin(0.217119991779327*x_53 + 1.98423981666565) - 0.0010116174823963*std::sin(0.551839888095856*x_6 - 4.35479974746704) - 0.00158012115621644*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 0.152960266297919*std::sin(0.550959885120392*x_65 - 7.2239203453064) + 0.0499587870730242*std::sin(0.592319846153259*x_65 - 7.19871997833252) - 1.94075559185569*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 0.100864639425296*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 1.50936203769355*std::sin(0.234399989247322*x_9 + 5.00383996963501) - 0.0865751194981244*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 0.2835486790323*std::sin(0.296639919281006*x_9 + 1.96359980106354) - 3.65828880245666*std::sin(0.363919854164124*x_9 + 2.01831984519958) - 5.67885953662456*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 70.1013922544007*std::sin(0.364159852266312*x_91 - 7.4061598777771) - 2.5815893494938*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 0.226579686387344*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 0.777393963528029*std::sin(0.394399851560593*x_91 - 4.39671945571899) + 8.13149440503217*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 1.07588401173037*std::sin(0.306479930877686*x_92 + 8.20936012268066) + 3.91745434356996*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 1.21474639886486*std::sin(0.235599994659424*x_93 + 1.97719979286194) + 2.71544026952771*std::sin(0.319199919700623*x_94 + 1.95127987861633) - 0.117288051515472*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 1.38302024390751*std::sin(0.304399937391281*x_97 + 1.95511984825134) - 2.16102662800018*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 0.324952900108987*std::sin(0.232959985733032*x_98 - 4.22215986251831) + 0.110935239071867*std::sin(0.259039968252182*x_98 + 1.97311985492706) - 6.14441919024641*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 645.475796768946);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.86222076360434*x_1 - 5.06206061339476*x_100 + 18.9298843664911*x_101 + 22.7971594819102*x_102 - 19.2861381397299*x_103 + 301.629376751227*x_104 + 17.1589307392703*x_105 + 15.5307155279919*x_106 - 2.4490595020034*x_107 + 8.25508659740012*x_108 - 23.5005226035686*x_109 + 28.9924442440072*x_110 + 12.8153625976981*x_111 - 2.26471135650098*x_112 - 19.8717485782435*x_113 - 35.558415162859*x_114 - 27.3941652053899*x_115 - 0.496530901002844*x_116 + 28.0436491572134*x_117 + 20.4800620375799*x_118 + 0.154835414151396*x_119 + 5.30889978315781*x_12 + 2.3377223337218*x_120 - 39.4818853851751*x_13 - 4.40217571656406*x_14 + 0.0121348816685921*x_15 + 3.79913553370326*x_16 + 3.16379885579353*x_17 - 103.66618389921*x_18 - 0.0203670954967678*x_19 + 0.483074228129416*x_2 + 0.0720788655931848*x_20 - 18.4369193904505*x_21 + 0.242956748200626*x_22 - 0.0310822950296542*x_23 - 8.8924845369862*x_24 - 0.23318485901451*x_25 + 0.104397117215504*x_26 - 54.6368298677619*x_27 + 1.25098573048288*x_28 + 1.77318929586941*x_29 - 4.14962085606282*x_3 + 0.0693852478971196*x_30 - 3.42838195165543*x_31 - 3.32418640052484*x_32 - 57.1607173928982*x_33 + 43.5741404937114*x_34 - 179.620028166617*x_35 - 102.06034776944*x_36 + 413.249643155556*x_37 + 81.4483563381772*x_38 + 23.8079252571544*x_39 + 16.722625064497*x_4 + 2487.12415338888*x_40 + 11.5668196763365*x_42 - 16.1764447659867*x_43 + 44.1556995607772*x_44 - 77.7206649651333*x_45 + 258.279300863263*x_46 - 47.4708434196375*x_47 + 120.340287034855*x_48 - 53.4781239832555*x_5 + 0.108958881866786*x_50 - 11.5736517197859*x_52 - 23.101012371376*x_53 - 53.0740923496498*x_54 + 26.5179883279867*x_58 - 0.0476123516458676*x_59 - 6.90248537480818*x_6 + 0.439734224268607*x_60 - 15.1884538247902*x_61 - 22.0930573573085*x_62 - 11.3341967083974*x_63 - 36.3725413726986*x_64 - 1.0524465929993*x_65 - 4.41165947282997*x_66 - 14.2109981828347*x_67 - 6.6952824694838*x_68 - 16.1247866594575*x_69 - 39.7553754369039*x_7 + 0.860608789241293*x_70 + 13.3692621497333*x_71 + 2.89818589209348*x_72 - 28.4975814705322*x_73 + 11.8973005406016*x_74 + 1.65872231292961*x_75 + 1.73162932437998*x_76 - 1.1033496801559*x_77 - 5.91529827096168*x_78 + 15.5168683755827*x_79 - 2.31523467240566*x_8 + 5.77156940405134*x_80 + 2.45702419005573*x_81 + 11.9188300457689*x_82 - 8.34768797031488*x_83 - 7.17356148594357*x_84 + 6.22807283827941*x_85 - 587.142648217828*x_86 - 52.9417269051831*x_87 - 41.0495553651138*x_88 - 0.783321381426833*x_89 - 9.08127180946522*x_9 + 5.48027340524822*x_90 + 1.65537096419093*x_91 + 28.6039879086716*x_92 + 8.91453285178804*x_93 - 19.5871941087574*x_94 + 10.7501139119203*x_95 + 41.2784492945616*x_96 + 11.6391657919456*x_97 + 28.7711402520877*x_98 + 46.4180483689968*x_99 - 0.000565394180175477*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.0101020130036226*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.000696277918182628*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.0976369691119972*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.00459042392586709*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.00643834647878488*std::exp(1.10983991622925*x_1) - 0.221627252575502*std::exp(1.242959856987*x_1) + 2.41333491553716*std::exp(1.24823987483978*x_1) + 0.0107777721098489*std::exp(1.43383979797363*x_1) - 0.0120241091896935*std::exp(1.77823996543884*x_1) + 0.00702806199040646*std::exp(0.619279801845551*x_10) + 0.0523758507294027*std::exp(0.783999860286713*x_10) - 0.715839545053456*std::exp(0.794399857521057*x_10) - 0.00587358905744631*std::exp(0.803679883480072*x_10) - 0.00583331194702664*std::exp(0.826399862766266*x_10) - 1.77077464242074*std::exp(0.846799850463867*x_10) + 0.235180651978699*std::exp(0.947519838809967*x_10) - 0.0287839074616369*std::exp(0.968719840049744*x_10) - 0.00980070613976274*std::exp(0.975119829177856*x_10) - 0.0606027879427121*std::exp(1.1814398765564*x_10) - 0.399761086805935*std::exp(0.822239875793457*x_11) - 0.0060000217222328*std::exp(0.89359986782074*x_11) - 0.000955473231344*std::exp(0.906559824943542*x_11) - 0.828662035532142*std::exp(0.921199858188629*x_11) + 0.0128860693216714*std::exp(0.932559847831726*x_11) - 0.0625054216139209*std::exp(0.940079808235168*x_11) + 2.09781431867115*std::exp(0.943679809570313*x_11) - 0.0314705996085075*std::exp(0.948239862918854*x_11) + 0.682420192086188*std::exp(0.976479828357697*x_11) + 0.0221295752949509*std::exp(1.0525598526001*x_11) - 0.0057461613985049*std::exp(0.547999858856201*x_12) + 0.0120541361813028*std::exp(0.748719871044159*x_12) + 0.0179153972224899*std::exp(0.869919836521149*x_12) + 0.00237038848762951*std::exp(0.872399866580963*x_12) - 0.165898306429807*std::exp(1.18807995319366*x_12) + 0.00116108324853734*std::exp(1.12631988525391*x_13) - 2.64457792060398e-5*std::exp(1.31047987937927*x_13) + 7.6178012060921e-5*std::exp(1.34023988246918*x_13) - 94.5388363243417*std::exp(0.269759833812714*x_14) + 0.0918017375885735*std::exp(0.473199844360352*x_14) - 0.0137267273855103*std::exp(0.679999828338623*x_14) + 0.000876836318476329*std::exp(0.895599842071533*x_14) + 0.0287364368881359*std::exp(0.71207982301712*x_15) - 0.397698787718943*std::exp(0.832959890365601*x_15) - 0.396419695113991*std::exp(0.923279821872711*x_15) + 0.00303675327391503*std::exp(0.930639863014221*x_15) + 3.09588931321414*std::exp(0.947279810905457*x_15) + 0.000318855282969224*std::exp(0.964959800243378*x_15) + 0.0164231748428149*std::exp(1.01871979236603*x_15) - 0.00332206921172213*std::exp(1.03775978088379*x_15) - 6.36624738965868*std::exp(0.382159829139709*x_16) + 0.0329416389945194*std::exp(0.548479855060577*x_16) - 2.26417843921641*std::exp(0.570239841938019*x_16) + 0.0555559437038268*std::exp(0.715919852256775*x_16) + 0.0365404378885812*std::exp(0.887839913368225*x_16) + 0.0236389105055477*std::exp(0.618079841136932*x_17) - 19.3763059059394*std::exp(0.642879843711853*x_17) + 0.166727691821616*std::exp(0.658879816532135*x_17) - 7.58738907070622*std::exp(0.666479825973511*x_17) + 0.0234205258188698*std::exp(0.713679850101471*x_17) + 0.0922082985903081*std::exp(0.826239883899689*x_17) + 4.61636628070377*std::exp(0.442959845066071*x_18) - 0.0579589313450587*std::exp(0.693519830703735*x_19) - 0.00812511063365883*std::exp(0.705919861793518*x_19) + 3.61635454247403*std::exp(0.7219198346138*x_19) + 34.3278487730283*std::exp(0.723199844360352*x_19) - 0.0211937777618167*std::exp(0.725599884986877*x_19) - 3.00647281698802*std::exp(0.73967981338501*x_19) + 1.42059961869813*std::exp(0.765519857406616*x_19) + 4.64057823908758*std::exp(0.819519877433777*x_19) - 0.0105685060479772*std::exp(1.02399981021881*x_19) - 0.0244927487834107*std::exp(0.747839868068695*x_2) + 7.97447343580061*std::exp(0.754719853401184*x_2) + 0.630793870626391*std::exp(0.769999861717224*x_2) - 15.9233802695311*std::exp(0.827439904212952*x_2) + 0.025569000518467*std::exp(1.00447976589203*x_2) + 0.068446531451989*std::exp(1.09567987918854*x_2) + 0.4178419949063*std::exp(0.44583985209465*x_20) - 1.14844940261086*std::exp(0.488959848880768*x_20) + 0.897727452843643*std::exp(0.627359867095947*x_20) - 3.4578930506223*std::exp(0.851519882678986*x_20) - 0.384983869959278*std::exp(0.915279805660248*x_20) + 0.00822577921870336*std::exp(1.0039998292923*x_20) + 0.00723781373373043*std::exp(0.855839908123016*x_21) + 0.0362419839979559*std::exp(0.53279983997345*x_22) - 0.380553192638914*std::exp(0.742159843444824*x_22) - 0.000663857076373485*std::exp(1.19607996940613*x_22) - 0.021041201543858*std::exp(1.36079978942871*x_22) + 0.0209091466515979*std::exp(1.40143978595734*x_22) - 0.0990679730822189*std::exp(0.62527984380722*x_23) + 0.00939271546450695*std::exp(0.664479851722717*x_23) - 0.132153063308823*std::exp(0.685359835624695*x_23) - 0.639947557282878*std::exp(0.735519826412201*x_23) - 3.67092964086432*std::exp(0.743439853191376*x_23) + 5.00274059450498*std::exp(0.744559824466705*x_23) - 0.0848381061099508*std::exp(0.782239854335785*x_23) + 1.30015450148349*std::exp(0.818959891796112*x_23) - 0.135092048353477*std::exp(0.834479868412018*x_23) + 3.9517424292537*std::exp(0.368799835443497*x_24) + 0.262955327336878*std::exp(0.424879848957062*x_24) - 4.31295207885755*std::exp(0.609519839286804*x_24) - 0.0392635805069433*std::exp(0.61167985200882*x_24) + 0.040578293956528*std::exp(0.653759837150574*x_24) - 1.04918254911828*std::exp(0.761439859867096*x_24) - 0.00257968780849021*std::exp(0.780959844589233*x_24) - 0.171152118855921*std::exp(0.418559849262238*x_25) - 0.330095509686109*std::exp(0.545919835567474*x_25) + 24.4897613653566*std::exp(0.627679824829102*x_25) + 0.0363605569035111*std::exp(0.643359839916229*x_25) - 0.482269536353651*std::exp(0.765359818935394*x_25) + 0.371271654260227*std::exp(0.878879845142365*x_25) + 0.426544495152647*std::exp(0.964159786701202*x_25) + 0.00127494071979185*std::exp(1.00615978240967*x_25) + 0.245463396669794*std::exp(0.429119855165482*x_26) + 1.75627299281769*std::exp(0.569839835166931*x_26) - 4.7753502228343*std::exp(0.698879837989807*x_26) + 0.0967524363868826*std::exp(0.736239850521088*x_26) + 0.112432404852345*std::exp(0.79943984746933*x_26) - 0.00175534715547952*std::exp(0.822479903697968*x_26) - 0.000377653872522368*std::exp(0.984079837799072*x_26) + 0.121373451904951*std::exp(1.10487985610962*x_26) + 8.96384617733041e-5*std::exp(1.14151990413666*x_27) + 0.0369954421008764*std::exp(1.18543982505798*x_27) - 0.10340493342185*std::exp(1.24655985832214*x_27) - 0.00744740108564148*std::exp(1.2630398273468*x_27) - 0.0118090839890547*std::exp(1.27247989177704*x_27) - 0.965707027049239*std::exp(0.549759864807129*x_28) + 18.4771232278566*std::exp(0.565279841423035*x_28) + 0.00528163719930012*std::exp(0.650239825248718*x_28) + 0.0535399778948141*std::exp(0.667519807815552*x_28) - 1.27774313525056*std::exp(0.768079876899719*x_28) - 0.287540347435972*std::exp(0.905439794063568*x_28) + 0.000475865545291192*std::exp(1.13103985786438*x_29) + 0.190589112692228*std::exp(1.1431999206543*x_29) - 0.0332536641397667*std::exp(1.1509598493576*x_29) - 0.167013520961895*std::exp(1.16863989830017*x_29) + 0.0703485874564671*std::exp(1.17591977119446*x_29) + 3.35614787091188*std::exp(0.575039863586426*x_3) - 0.247259922082093*std::exp(0.670239865779877*x_3) - 0.00744694970567999*std::exp(0.670399844646454*x_3) - 0.02500252641133*std::exp(0.915599822998047*x_3) - 0.14303795029681*std::exp(0.947999835014343*x_3) - 0.0484317505110423*std::exp(0.739759802818298*x_30) + 8.44546373342657*std::exp(0.847439885139465*x_30) - 0.363209592553281*std::exp(0.853279888629913*x_30) + 0.551513404095704*std::exp(0.882479906082153*x_30) + 0.748568644854452*std::exp(0.916479825973511*x_30) + 1.98079039637567*std::exp(0.9440798163414*x_30) + 0.000596544645186308*std::exp(1.00999975204468*x_30) + 0.00731304251828007*std::exp(1.03159987926483*x_30) - 0.00114789340253905*std::exp(1.09999978542328*x_30) - 7.85632575030708*std::exp(0.787999868392944*x_32) + 0.00177637838666416*std::exp(0.823919892311096*x_32) - 0.23381797656564*std::exp(0.357519835233688*x_33) + 6.74508105068537*std::exp(0.36575984954834*x_33) + 0.032705171090741*std::exp(0.395519852638245*x_33) - 2.33885144195016*std::exp(0.41407984495163*x_33) + 20.0773541081057*std::exp(0.379279851913452*x_34) - 2.70443005699775*std::exp(0.408159852027893*x_34) - 1.14380710651462*std::exp(0.431119859218597*x_36) - 3.22312070710677*std::exp(0.250399857759476*x_37) + 18.4701929119189*std::exp(0.375039845705032*x_38) + 0.0430344061659132*std::exp(0.385999858379364*x_4) + 0.0107797195702705*std::exp(0.527999818325043*x_4) - 1.76979417964244*std::exp(0.554479837417603*x_4) - 0.0182128183178333*std::exp(0.638399839401245*x_4) - 5.40315351827547*std::exp(0.723759829998016*x_4) - 0.0444074924152866*std::exp(1.10615980625153*x_4) - 0.00423604492185332*std::exp(1.13591980934143*x_4) - 8.3345906217258*std::exp(0.685679852962494*x_41) - 0.594648895805209*std::exp(0.7497598528862*x_41) - 0.0148937324450462*std::exp(0.769599854946136*x_41) - 0.0591894179319274*std::exp(0.797759890556335*x_41) + 0.00251530632257071*std::exp(0.798159837722778*x_41) - 0.103218667632546*std::exp(0.798719823360443*x_41) - 0.184509919479009*std::exp(0.803759872913361*x_41) - 0.04988352533536*std::exp(0.805199861526489*x_41) + 0.830397179562736*std::exp(0.812879860401154*x_41) - 0.0492320979265829*std::exp(0.866879880428314*x_41) - 0.515526895105923*std::exp(0.19999985396862*x_42) + 0.047819330441633*std::exp(0.596879839897156*x_42) - 0.441519011081973*std::exp(0.690479874610901*x_42) - 1.475280820657*std::exp(0.718159854412079*x_42) + 0.0268251498091087*std::exp(0.841359853744507*x_42) + 0.0313165936403837*std::exp(0.705839812755585*x_43) + 0.00518010079198297*std::exp(0.787679851055145*x_43) - 0.000363087732622734*std::exp(0.83271986246109*x_43) - 0.0431200436388462*std::exp(0.886719882488251*x_44) + 0.000130060555192219*std::exp(0.908799827098846*x_44) + 0.00392611797683875*std::exp(0.942639827728271*x_44) - 0.993571554808486*std::exp(0.515199840068817*x_45) - 1.14876065698096*std::exp(0.504559814929962*x_46) + 0.000489409325998288*std::exp(0.663999855518341*x_46) - 1.37255067145033*std::exp(0.700479865074158*x_46) + 0.0296122053851207*std::exp(0.75791984796524*x_46) + 0.00891151344578494*std::exp(0.759199857711792*x_46) - 0.107146400615547*std::exp(0.801999866962433*x_46) + 0.0257089702720429*std::exp(0.802399873733521*x_46) + 0.0406424122395728*std::exp(0.424159854650497*x_47) - 0.0779395004490894*std::exp(0.552239894866943*x_47) - 0.00402035281364202*std::exp(0.608879864215851*x_48) - 1.24859435853512*std::exp(0.608959853649139*x_48) - 0.0249762301814239*std::exp(0.639919817447662*x_49) - 0.0146305835558002*std::exp(0.685839831829071*x_49) - 43.5762663823211*std::exp(0.703679859638214*x_49) + 0.00952931565087363*std::exp(0.705999851226807*x_49) + 0.303710386582502*std::exp(0.708399832248688*x_49) + 0.839318324135484*std::exp(0.708639860153198*x_49) - 0.623569458622625*std::exp(0.715839862823486*x_49) - 3.37427581681486*std::exp(0.719119846820831*x_49) - 4.93630357869392*std::exp(0.719919860363007*x_49) + 2.88184009336234*std::exp(0.720319867134094*x_49) + 0.000368445197684272*std::exp(1.93999981880188*x_5) - 2.30524506190456*std::exp(0.52215987443924*x_50) + 0.753423631713219*std::exp(0.537359833717346*x_50) + 0.119197306264638*std::exp(0.541919827461243*x_50) + 1.42012631491335*std::exp(0.543199837207794*x_50) - 37.1677218256672*std::exp(0.546079874038696*x_50) - 0.151987929883703*std::exp(0.599439859390259*x_50) + 0.708571967407131*std::exp(0.610719859600067*x_50) + 0.0142311621368518*std::exp(0.658079862594604*x_50) + 0.0170346642958535*std::exp(0.463519841432571*x_51) + 0.0447439807719333*std::exp(0.48039984703064*x_51) - 6.14839404772392*std::exp(0.491039842367172*x_51) - 1.76916770406345*std::exp(0.493919849395752*x_51) + 32.7523813728225*std::exp(0.49415984749794*x_51) - 3.77817948397677*std::exp(0.496719866991043*x_51) + 111.900096193221*std::exp(0.497119843959808*x_51) + 0.778102805907598*std::exp(0.499279826879501*x_51) + 33.3351555245452*std::exp(0.501199841499329*x_51) + 8.0795821074241*std::exp(0.510319828987122*x_51) - 1.03941698591351*std::exp(0.504639863967896*x_52) + 0.030647846244914*std::exp(0.546399831771851*x_52) - 0.00672468818189703*std::exp(0.600159823894501*x_52) + 0.05586716455308*std::exp(0.641199827194214*x_52) - 0.253663145409706*std::exp(0.673519849777222*x_52) - 0.366504525306281*std::exp(0.712159812450409*x_52) + 0.00279077406144225*std::exp(0.714239835739136*x_52) - 0.0797864805905298*std::exp(0.88375985622406*x_52) - 13.6860884185911*std::exp(0.474319845438004*x_54) + 0.296661702121567*std::exp(0.502159833908081*x_54) + 0.0131488082798051*std::exp(0.506399810314178*x_54) - 4.88066882619145*std::exp(0.519279837608337*x_54) + 2.59699872678931*std::exp(0.532479882240295*x_54) + 0.0406840744907754*std::exp(0.532879829406738*x_54) - 0.994546051368084*std::exp(0.542559862136841*x_54) - 1.54775150072919*std::exp(0.612959861755371*x_55) - 0.0142001623689834*std::exp(0.631199836730957*x_55) - 0.755636590652271*std::exp(0.650959849357605*x_55) - 3.50709328967417*std::exp(0.652479827404022*x_55) + 13.3993887223782*std::exp(0.653439819812775*x_55) + 0.409782306643294*std::exp(0.655679821968079*x_55) - 282.767608272257*std::exp(0.655759811401367*x_55) + 1.54262380384064*std::exp(0.656879842281342*x_55) + 0.836581312663317*std::exp(0.657759845256805*x_55) - 41.5641437863362*std::exp(0.659119844436646*x_55) - 31.6633174191218*std::exp(0.347199827432632*x_56) - 58.7736823599949*std::exp(0.442879855632782*x_56) - 3.99388660795357*std::exp(0.466319859027863*x_56) + 0.129065517791198*std::exp(0.52183985710144*x_56) + 3.0102372741581*std::exp(0.525679886341095*x_56) + 2.66261903126575*std::exp(0.574079871177673*x_56) + 0.141376080601814*std::exp(0.655039846897125*x_56) - 0.0297013442074381*std::exp(0.658559858798981*x_56) + 0.000980192055769069*std::exp(0.754159867763519*x_56) + 0.00471372174105195*std::exp(0.859519898891449*x_56) - 0.521041908534772*std::exp(0.599999845027924*x_57) - 1.68357763997902*std::exp(0.609679877758026*x_57) - 0.251596070087089*std::exp(0.617039859294891*x_57) - 0.0609911979380323*std::exp(0.626319825649261*x_57) + 28.0263230067513*std::exp(0.628239870071411*x_57) + 0.655923017430586*std::exp(0.632079839706421*x_57) + 122.714628716575*std::exp(0.634159862995148*x_57) + 0.0336231337594338*std::exp(0.637119889259338*x_57) - 3.84510241779305*std::exp(0.641199827194214*x_57) + 1.12643707776882*std::exp(0.671519815921783*x_57) + 0.170456974945888*std::exp(0.37679985165596*x_58) + 0.156108690593511*std::exp(0.451519846916199*x_58) - 0.341783924439374*std::exp(0.558799862861633*x_58) - 0.148145892166419*std::exp(0.595039844512939*x_58) + 0.006517169633208*std::exp(0.603839874267578*x_58) - 0.022148779175163*std::exp(0.653759837150574*x_58) + 19.7771827444842*std::exp(0.512399852275848*x_59) + 0.0735362375605944*std::exp(0.545279860496521*x_59) + 3.03073478136935*std::exp(0.696399867534637*x_59) + 0.115496154266699*std::exp(0.807599902153015*x_59) - 0.0614030027968336*std::exp(0.839199841022491*x_59) - 0.0545474821718778*std::exp(0.866959869861603*x_59) + 0.00857670126661462*std::exp(0.778479874134064*x_60) - 1.88502743982351*std::exp(0.780239880084991*x_60) + 11.5513531203724*std::exp(0.821839869022369*x_60) - 0.00246082619487563*std::exp(0.842239856719971*x_60) - 0.0226946867172532*std::exp(0.845599889755249*x_60) - 0.317532668578352*std::exp(0.847439885139465*x_60) - 0.017060755607789*std::exp(0.850079894065857*x_60) - 0.0425324317275618*std::exp(0.897759795188904*x_60) - 0.0433890201566915*std::exp(0.979119837284088*x_60) + 0.0458012867244934*std::exp(1.01919984817505*x_61) + 0.223625222843671*std::exp(1.04719984531403*x_61) + 1.89827944895486*std::exp(1.3343198299408*x_61) + 0.112024792021638*std::exp(1.36879980564117*x_61) - 0.154097708525594*std::exp(0.578399837017059*x_66) + 11.5467835277983*std::exp(0.930159866809845*x_66) + 0.0256854603427238*std::exp(1.03991973400116*x_66) + 0.00105745739146028*std::exp(1.46671986579895*x_66) - 8.27470633543579e-6*std::exp(1.60799980163574*x_7) + 3.50413486433399e-5*std::exp(1.8828798532486*x_7) + 0.101099162949508*std::exp(0.481679856777191*x_8) + 0.0172323890222169*std::exp(0.549919843673706*x_8) + 0.129799495220989*std::exp(0.583999812602997*x_8) + 0.102996770356452*std::exp(0.832639873027802*x_8) + 0.0846045044597766*std::exp(0.863359868526459*x_8) + 0.0158054536888835*std::exp(1.34103989601135*x_8) - 2.59369910772584*std::log(9.5269603729248 - 1.42447984218597*x_5) + 7.70841942311487*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 5.56730761923968*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 11.2872183801585*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.276038012698261*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 21.7113050931967*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 3.30225414564577*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 3.47173369868856*std::sin(0.291599929332733*x_114 + 8.11127948760986) + 41.4161821063699*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0529613492442043*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.262120921784686*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 9.24283831406264*std::sin(0.262239962816238*x_120 + 8.34039974212646) - 81.1739227251872*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 212.086950790138*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 1.08882737864553*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 1.82347753242063*std::sin(0.121840052306652*x_18 - 4.63351964950562) - 42.9023639451058*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 4.23006890195818*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.326169388522603*std::sin(0.197599992156029*x_3 - 7.60056018829346) + 0.376994843607235*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.964607753680998*std::sin(0.2743199467659*x_31 - 4.31576013565063) - 26.8796339544202*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 170.461399976765*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 1.65808759049376*std::sin(0.19080001115799*x_35 - 4.59863996505737) - 5.49131760328387*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 3.84198401409871*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 13.0107629986583*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.0113007782064233*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0176515323592281*std::sin(0.603359878063202*x_64 - 7.20143985748291) + 22.8682636406654*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.10424322365826*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 4.74179314276771*std::sin(0.613759815692902*x_65 - 0.975039839744568) - 15.0797277111547*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 9.63469612987624*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.180646290148958*std::sin(0.296639919281006*x_9 - 1.20775985717773) + 42.3918322320629*std::sin(0.296639919281006*x_9 + 1.96359980106354) - 2.33175862292359*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 17.0030356176402*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 141.418932778379*std::sin(0.364159852266312*x_91 - 7.4061598777771) - 1.64548059258949*std::sin(0.383279830217361*x_91 - 1.19735991954803) + 33.8747056953545*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 4.96233138554223*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 24.3464533858825*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 6.86768002980537*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 9.57140518950357*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 7.75407896557991*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 8.13028167409076*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.244731413688999*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 8.82821977679923*std::sin(0.304399937391281*x_97 + 1.95511984825134) - 1.37741789845107*std::sin(0.334719836711884*x_97 + 1.83487987518311) + 48.5819537998034*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.23147573461397*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 18.3969646841397*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 864.524071367173);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.939049848428348*x_1 - 2.54366951141973*x_100 + 1.82209603851438*x_101 - 2.0951529114051*x_102 - 8.74360581227021*x_103 + 38.7363470420507*x_104 + 1.38879111263827*x_105 + 2.18620311512578*x_106 - 0.519730537752023*x_107 - 1.80535132452773*x_108 - 3.90978976474312*x_109 + 2.09930475968919*x_110 - 5.42253461365022*x_111 - 1.87891897247655*x_112 - 0.748942751313079*x_113 - 1.01027420370939*x_114 - 2.16326969161332*x_115 - 0.995766886322114*x_116 - 1.18198423318172*x_117 + 0.664687866487711*x_118 - 1.6777383226893*x_119 + 4.41490139344735*x_12 + 0.685558916608144*x_120 - 5.82254837611784*x_13 + 2.7944806014429*x_14 - 0.0938303453482975*x_15 + 0.829559345783738*x_16 + 3.06426071551872*x_17 + 0.750369553390511*x_18 + 0.030437720415934*x_19 + 0.201981245183804*x_2 - 0.193807096972595*x_20 - 4.86455429024269*x_21 + 0.225695162076005*x_22 - 0.0864891501024779*x_23 - 0.327460510825413*x_24 + 0.0453267440282432*x_25 + 0.00197291320930777*x_26 - 0.409210638589045*x_27 - 1.39223803339306*x_28 + 2.76814109674567*x_29 - 1.65217736657882*x_3 - 0.103693173963757*x_30 - 1.97012968242442*x_31 - 7.04546267342394*x_32 + 4.18917534665206*x_33 - 32.3778920431985*x_34 - 53.2887710232296*x_35 + 0.528544053051335*x_36 - 38.24163050957*x_37 - 12.5895740494045*x_38 - 0.713894573088336*x_39 + 3.10642958399154*x_4 - 176.306343947737*x_40 - 2.410141273605*x_42 - 10.3320364944606*x_43 + 3.52817578298373*x_44 + 5.15208704820033*x_45 + 4.21353395207583*x_46 + 6.55002289367385*x_47 - 4.02086916578702*x_48 - 2.49702749260358*x_5 + 0.2563580519461*x_50 - 2.45978684043853*x_52 - 4.82307536473285*x_53 - 1.01969208340478*x_54 + 2.57365864956533*x_58 - 0.0748377970563542*x_59 - 0.51321604275006*x_6 + 0.49235083847586*x_60 + 1.34620928365322*x_61 - 3.77515334518286*x_62 + 0.847104240749971*x_63 - 1.15358452771531*x_64 - 0.459960320580061*x_65 - 0.86875857671494*x_66 - 0.520030711465327*x_67 + 1.53762538070825*x_68 + 6.2968009847129*x_69 - 3.66621431775934*x_7 - 1.0983458297013*x_70 + 0.900283623846559*x_71 + 0.817808675772332*x_72 + 0.601463408601454*x_73 - 0.765985230766992*x_74 - 0.801512493962918*x_75 + 2.10421113888083*x_76 + 1.28479889037855*x_77 - 2.03062831460025*x_78 - 3.78795152146891*x_79 + 2.01101960296768*x_8 + 0.849305694889373*x_80 + 2.5127899475541*x_81 + 0.489479375618654*x_82 + 1.40408949531946*x_83 + 1.9410232500428*x_84 + 0.142478971332476*x_85 - 70.1110256467428*x_86 + 22.7678987580638*x_87 + 4.60251870131795*x_88 + 2.23991389806751*x_89 + 0.901387580873417*x_9 - 0.162084098137166*x_90 + 0.717928834785083*x_91 + 1.83669071985286*x_92 - 2.04654897118849*x_93 - 2.09286920325945*x_94 + 1.29039286561866*x_95 + 3.96009124847989*x_96 + 4.85208063277851*x_97 + 0.846438942924638*x_98 + 6.43274370098975*x_99 + 0.00191635371369044*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.0113107743226042*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) + 2.69386053023894e-6*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.00141329993702323*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.0051396933514089*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.0179152509325364*std::exp(1.10983991622925*x_1) - 0.112269909826*std::exp(1.242959856987*x_1) + 0.586228831159538*std::exp(1.24823987483978*x_1) - 4.16986007058987e-5*std::exp(1.43383979797363*x_1) + 0.00223764237809197*std::exp(1.77823996543884*x_1) - 0.00389680802423651*std::exp(0.619279801845551*x_10) - 0.00020263925270802*std::exp(0.783999860286713*x_10) - 0.362623460062329*std::exp(0.794399857521057*x_10) - 0.0163437650001418*std::exp(0.803679883480072*x_10) + 0.00871762584756879*std::exp(0.826399862766266*x_10) - 0.430143011726246*std::exp(0.846799850463867*x_10) + 0.26332130820066*std::exp(0.947519838809967*x_10) + 0.00535657903027394*std::exp(0.968719840049744*x_10) + 0.0332186291728259*std::exp(0.975119829177856*x_10) - 0.000877228340472346*std::exp(1.1814398765564*x_10) - 0.447594695651199*std::exp(0.822239875793457*x_11) - 0.0166955747269378*std::exp(0.89359986782074*x_11) + 0.00052977559957879*std::exp(0.906559824943542*x_11) - 0.419776047053279*std::exp(0.921199858188629*x_11) - 0.0192576587729764*std::exp(0.932559847831726*x_11) + 0.211856614439237*std::exp(0.940079808235168*x_11) + 0.0303659655909993*std::exp(0.943679809570313*x_11) + 0.0001217579991185*std::exp(0.948239862918854*x_11) + 0.165768285616218*std::exp(0.976479828357697*x_11) - 0.00411823235367854*std::exp(1.0525598526001*x_11) + 0.00318604017392239*std::exp(0.547999858856201*x_12) - 0.0180143716123055*std::exp(0.748719871044159*x_12) - 0.0607226589932399*std::exp(0.869919836521149*x_12) + 0.00659580914189832*std::exp(0.872399866580963*x_12) - 0.00240138615692339*std::exp(1.18807995319366*x_12) - 4.49216649541362e-6*std::exp(1.12631988525391*x_13) - 7.35876474097547e-5*std::exp(1.31047987937927*x_13) - 0.000113844658572939*std::exp(1.34023988246918*x_13) - 1.36845431232281*std::exp(0.269759833812714*x_14) - 0.000355175815632207*std::exp(0.473199844360352*x_14) + 0.0205139849445992*std::exp(0.679999828338623*x_14) + 0.00243987221315707*std::exp(0.895599842071533*x_14) - 0.0429453297300061*std::exp(0.71207982301712*x_15) - 0.201462620306157*std::exp(0.832959890365601*x_15) - 0.0962952357002508*std::exp(0.923279821872711*x_15) + 0.00845002627641393*std::exp(0.930639863014221*x_15) + 0.0448131502973784*std::exp(0.947279810905457*x_15) - 0.000176793805595448*std::exp(0.964959800243378*x_15) - 0.0556649028308849*std::exp(1.01871979236603*x_15) + 1.28529009673877e-5*std::exp(1.03775978088379*x_15) - 1.5464400494456*std::exp(0.382159829139709*x_16) + 0.0916629340562025*std::exp(0.548479855060577*x_16) - 1.14696683844962*std::exp(0.570239841938019*x_16) - 0.000214942855511699*std::exp(0.715919852256775*x_16) - 0.123850591857745*std::exp(0.887839913368225*x_16) - 0.0131069270971099*std::exp(0.618079841136932*x_17) - 0.280472982372023*std::exp(0.642879843711853*x_17) - 0.24916713677047*std::exp(0.658879816532135*x_17) - 1.84307043246948*std::exp(0.666479825973511*x_17) + 0.0651696205539082*std::exp(0.713679850101471*x_17) - 0.31253189656422*std::exp(0.826239883899689*x_17) + 5.16873985143315*std::exp(0.442959845066071*x_18) + 0.000224239881013043*std::exp(0.693519830703735*x_19) + 0.00450508210631477*std::exp(0.705919861793518*x_19) + 4.04907121835818*std::exp(0.7219198346138*x_19) + 0.496897301814159*std::exp(0.723199844360352*x_19) - 0.0589735032220596*std::exp(0.725599884986877*x_19) - 1.52299154609867*std::exp(0.73967981338501*x_19) - 0.264368350199693*std::exp(0.765519857406616*x_19) + 1.12725371828435*std::exp(0.819519877433777*x_19) + 0.0358210192522945*std::exp(1.02399981021881*x_19) - 0.068153172857077*std::exp(0.747839868068695*x_2) + 1.93709800131146*std::exp(0.754719853401184*x_2) - 0.117388413102913*std::exp(0.769999861717224*x_2) - 0.230491713710518*std::exp(0.827439904212952*x_2) - 9.89250405558469e-5*std::exp(1.00447976589203*x_2) - 0.231993482310942*std::exp(1.09567987918854*x_2) - 0.0777588543482495*std::exp(0.44583985209465*x_20) - 1.28586767896684*std::exp(0.488959848880768*x_20) + 0.454762575485814*std::exp(0.627359867095947*x_20) - 0.050053172226923*std::exp(0.851519882678986*x_20) - 0.0935173326538765*std::exp(0.915279805660248*x_20) - 0.0278805532608551*std::exp(1.0039998292923*x_20) - 0.0108165914420569*std::exp(0.855839908123016*x_21) + 0.100846426913466*std::exp(0.53279983997345*x_22) - 0.192777161315087*std::exp(0.742159843444824*x_22) + 2.56842609690988e-6*std::exp(1.19607996940613*x_22) - 0.00511116750014063*std::exp(1.36079978942871*x_22) + 0.000302660927665786*std::exp(1.40143978595734*x_22) + 0.148052689561376*std::exp(0.62527984380722*x_23) - 0.00520792347042804*std::exp(0.664479851722717*x_23) + 0.000511292850026057*std::exp(0.685359835624695*x_23) + 0.119091880433024*std::exp(0.735519826412201*x_23) - 0.891714108463806*std::exp(0.743439853191376*x_23) + 0.0724149165163778*std::exp(0.744559824466705*x_23) + 0.28755127910197*std::exp(0.782239854335785*x_23) + 1.45572512582633*std::exp(0.818959891796112*x_23) - 0.068433696265253*std::exp(0.834479868412018*x_23) + 2.00183759457446*std::exp(0.368799835443497*x_24) - 0.392975067879977*std::exp(0.424879848957062*x_24) - 1.04766928110888*std::exp(0.609519839286804*x_24) - 0.109254278192324*std::exp(0.61167985200882*x_24) - 0.000156995161873354*std::exp(0.653759837150574*x_24) - 1.17472300144891*std::exp(0.761439859867096*x_24) + 0.00143034426359241*std::exp(0.780959844589233*x_24) + 0.000662178026349236*std::exp(0.418559849262238*x_25) + 1.11882962018319*std::exp(0.545919835567474*x_25) + 0.354490502011287*std::exp(0.627679824829102*x_25) - 0.054339238767372*std::exp(0.643359839916229*x_25) - 0.539975734183572*std::exp(0.765359818935394*x_25) + 0.188075404357347*std::exp(0.878879845142365*x_25) + 0.103612921364963*std::exp(0.964159786701202*x_25) + 0.00354763183286936*std::exp(1.00615978240967*x_25) - 0.000949684226139286*std::exp(0.429119855165482*x_26) + 1.96642069887675*std::exp(0.569839835166931*x_26) - 0.0691234296862896*std::exp(0.698879837989807*x_26) - 0.0180052716111816*std::exp(0.736239850521088*x_26) - 0.381079721250525*std::exp(0.79943984746933*x_26) - 0.00488440391764452*std::exp(0.822479903697968*x_26) + 0.000209395512281764*std::exp(0.984079837799072*x_26) + 0.0294831091971339*std::exp(1.10487985610962*x_26) - 4.97013084966013e-5*std::exp(1.14151990413666*x_27) + 0.0187408132365103*std::exp(1.18543982505798*x_27) - 0.0251183343288797*std::exp(1.24655985832214*x_27) + 0.00138593387775983*std::exp(1.2630398273468*x_27) - 0.0132221057237778*std::exp(1.27247989177704*x_27) + 0.179714516431605*std::exp(0.549759864807129*x_28) + 0.267457268817365*std::exp(0.565279841423035*x_28) + 0.0146966082163908*std::exp(0.650239825248718*x_28) - 0.000207143195948481*std::exp(0.667519807815552*x_28) - 0.310379574702892*std::exp(0.768079876899719*x_28) - 0.321946128689915*std::exp(0.905439794063568*x_28) + 0.00132413666802986*std::exp(1.13103985786438*x_29) + 0.00275878679372219*std::exp(1.1431999206543*x_29) + 0.00618838426465387*std::exp(1.1509598493576*x_29) - 0.0405696451623826*std::exp(1.16863989830017*x_29) + 0.0356365450473352*std::exp(1.17591977119446*x_29) + 1.70012674186643*std::exp(0.575039863586426*x_3) + 0.838065700962412*std::exp(0.670239865779877*x_3) + 0.00412906622178231*std::exp(0.670399844646454*x_3) + 9.67333837493208e-5*std::exp(0.915599822998047*x_3) + 0.0266188350596401*std::exp(0.947999835014343*x_3) + 0.164155147340851*std::exp(0.739759802818298*x_30) + 0.122248503524236*std::exp(0.847439885139465*x_30) + 0.0675919657419092*std::exp(0.853279888629913*x_30) + 0.279380624115985*std::exp(0.882479906082153*x_30) + 0.838138993078914*std::exp(0.916479825973511*x_30) + 0.48115842992347*std::exp(0.9440798163414*x_30) - 0.000330762586236506*std::exp(1.00999975204468*x_30) - 2.82937546653413e-5*std::exp(1.03159987926483*x_30) - 0.00319411178290165*std::exp(1.09999978542328*x_30) - 0.113720702200481*std::exp(0.787999868392944*x_32) - 0.000984938032800826*std::exp(0.823919892311096*x_32) + 0.349430590142508*std::exp(0.357519835233688*x_33) + 1.63846342045713*std::exp(0.36575984954834*x_33) - 0.0181338430586405*std::exp(0.395519852638245*x_33) + 0.435251628208358*std::exp(0.41407984495163*x_33) + 4.87703706426973*std::exp(0.379279851913452*x_34) + 0.503284460300058*std::exp(0.408159852027893*x_34) + 0.212858284428563*std::exp(0.431119859218597*x_36) + 0.599810877475216*std::exp(0.250399857759476*x_37) + 0.267356952152812*std::exp(0.375039845705032*x_38) + 0.119746923800307*std::exp(0.385999858379364*x_4) - 0.00597696744533408*std::exp(0.527999818325043*x_4) - 0.896526174692106*std::exp(0.554479837417603*x_4) + 0.0272182487695601*std::exp(0.638399839401245*x_4) - 1.31249266365881*std::exp(0.723759829998016*x_4) + 0.00826407057401114*std::exp(1.10615980625153*x_4) + 1.63890221437507e-5*std::exp(1.13591980934143*x_4) - 0.120643609771292*std::exp(0.685679852962494*x_41) - 0.665801900990086*std::exp(0.7497598528862*x_41) - 0.04144308712715*std::exp(0.769599854946136*x_41) + 0.200617312385177*std::exp(0.797759890556335*x_41) - 0.00139464704133031*std::exp(0.798159837722778*x_41) + 0.000399347282827709*std::exp(0.798719823360443*x_41) + 0.0343366155854986*std::exp(0.803759872913361*x_41) + 0.074548714997669*std::exp(0.805199861526489*x_41) + 0.201713721887162*std::exp(0.812879860401154*x_41) - 0.024939546605981*std::exp(0.866879880428314*x_41) + 0.00199454487746402*std::exp(0.19999985396862*x_42) - 0.0714638673290738*std::exp(0.596879839897156*x_42) - 0.494349184830463*std::exp(0.690479874610901*x_42) - 0.358363916072271*std::exp(0.718159854412079*x_42) - 0.00499206145457977*std::exp(0.841359853744507*x_42) - 0.106144832449917*std::exp(0.705839812755585*x_43) - 0.00774143076305397*std::exp(0.787679851055145*x_43) + 0.000201319110718925*std::exp(0.83271986246109*x_43) - 0.010474390694473*std::exp(0.886719882488251*x_44) - 7.21139079025659e-5*std::exp(0.908799827098846*x_44) - 0.0133072306527221*std::exp(0.942639827728271*x_44) - 0.503314405461151*std::exp(0.515199840068817*x_45) - 1.2862161766312*std::exp(0.504559814929962*x_46) - 0.000271359898545234*std::exp(0.663999855518341*x_46) - 0.333409495155991*std::exp(0.700479865074158*x_46) - 0.0442541268859155*std::exp(0.75791984796524*x_46) + 0.0247970500028201*std::exp(0.759199857711792*x_46) - 0.0542772452191542*std::exp(0.801999866962433*x_46) - 0.0871382875584181*std::exp(0.802399873733521*x_46) + 0.113090995673311*std::exp(0.424159854650497*x_47) + 0.116477124801788*std::exp(0.552239894866943*x_47) + 0.00222914128046215*std::exp(0.608879864215851*x_48) - 1.39799552869345*std::exp(0.608959853649139*x_48) + 9.66316450987213e-5*std::exp(0.639919817447662*x_49) - 0.0407108527873248*std::exp(0.685839831829071*x_49) - 0.630768602241201*std::exp(0.703679859638214*x_49) - 0.00528366336900499*std::exp(0.705999851226807*x_49) - 0.453881695388549*std::exp(0.708399832248688*x_49) - 0.156194044911411*std::exp(0.708639860153198*x_49) + 2.11353368972516*std::exp(0.715839862823486*x_49) - 3.77802644408867*std::exp(0.719119846820831*x_49) - 1.19908905247918*std::exp(0.719919860363007*x_49) + 1.45985623904496*std::exp(0.720319867134094*x_49) + 0.000186643603794817*std::exp(1.93999981880188*x_5) - 0.559972471900285*std::exp(0.52215987443924*x_50) - 0.140209359411217*std::exp(0.537359833717346*x_50) - 0.178135084749384*std::exp(0.541919827461243*x_50) + 1.59005222541451*std::exp(0.543199837207794*x_50) - 0.538004604129582*std::exp(0.546079874038696*x_50) + 0.515149685089367*std::exp(0.599439859390259*x_50) + 0.358941916941956*std::exp(0.610719859600067*x_50) - 5.50595746019915e-5*std::exp(0.658079862594604*x_50) + 0.0474004135094842*std::exp(0.463519841432571*x_51) - 0.0248089307616181*std::exp(0.48039984703064*x_51) + 1.14419345843833*std::exp(0.491039842367172*x_51) + 2.64394262567919*std::exp(0.493919849395752*x_51) + 16.5914022782954*std::exp(0.49415984749794*x_51) + 12.805806177313*std::exp(0.496719866991043*x_51) + 1.61975940405692*std::exp(0.497119843959808*x_51) - 0.0030104364687792*std::exp(0.499279826879501*x_51) + 8.09752062751967*std::exp(0.501199841499329*x_51) + 9.04634846591995*std::exp(0.510319828987122*x_51) + 0.19343166795111*std::exp(0.504639863967896*x_52) - 0.0458018461935954*std::exp(0.546399831771851*x_52) + 0.00372859814035152*std::exp(0.600159823894501*x_52) - 0.000216146951663677*std::exp(0.641199827194214*x_52) - 0.28401533344515*std::exp(0.673519849777222*x_52) - 0.185660515702776*std::exp(0.712159812450409*x_52) + 0.00776556803388872*std::exp(0.714239835739136*x_52) - 0.0193811206881365*std::exp(0.88375985622406*x_52) - 3.32451976106722*std::exp(0.474319845438004*x_54) - 0.00114776762167715*std::exp(0.502159833908081*x_54) - 0.00729054207032239*std::exp(0.506399810314178*x_54) + 0.908274469786044*std::exp(0.519279837608337*x_54) + 1.31556390058819*std::exp(0.532479882240295*x_54) + 0.113206924458313*std::exp(0.532879829406738*x_54) + 3.37092613578703*std::exp(0.542559862136841*x_54) - 0.784045821985382*std::exp(0.612959861755371*x_55) + 0.00787348016287424*std::exp(0.631199836730957*x_55) + 0.00292351593179284*std::exp(0.650959849357605*x_55) + 0.652657127866362*std::exp(0.652479827404022*x_55) + 15.0026991496961*std::exp(0.653439819812775*x_55) + 1.14025439224478*std::exp(0.655679821968079*x_55) - 4.09307505751204*std::exp(0.655759811401367*x_55) - 5.22858734484991*std::exp(0.656879842281342*x_55) - 1.25023364789948*std::exp(0.657759845256805*x_55) - 10.0964434207373*std::exp(0.659119844436646*x_55) - 7.69141052149146*std::exp(0.347199827432632*x_56) - 0.850751947069579*std::exp(0.442879855632782*x_56) + 0.743247569217948*std::exp(0.466319859027863*x_56) - 0.192882688967097*std::exp(0.52183985710144*x_56) + 1.52489851043685*std::exp(0.525679886341095*x_56) + 2.98121601693822*std::exp(0.574079871177673*x_56) - 0.479181757768007*std::exp(0.655039846897125*x_56) - 0.0826465360730813*std::exp(0.658559858798981*x_56) - 0.000543481300168908*std::exp(0.754159867763519*x_56) - 1.82371271831981e-5*std::exp(0.859519898891449*x_56) + 0.77867401070923*std::exp(0.599999845027924*x_57) + 0.313307590158465*std::exp(0.609679877758026*x_57) + 0.000973411198418999*std::exp(0.617039859294891*x_57) - 0.169713236051575*std::exp(0.626319825649261*x_57) + 6.80793969878423*std::exp(0.628239870071411*x_57) - 2.22319322416447*std::exp(0.632079839706421*x_57) + 1.77630029500427*std::exp(0.634159862995148*x_57) - 0.0186428203980827*std::exp(0.637119889259338*x_57) - 1.94781687134932*std::exp(0.641199827194214*x_57) + 1.26122145860314*std::exp(0.671519815921783*x_57) - 0.25474038491017*std::exp(0.37679985165596*x_58) - 0.000603975839295305*std::exp(0.451519846916199*x_58) + 0.0636047279187776*std::exp(0.558799862861633*x_58) + 0.502127437061679*std::exp(0.595039844512939*x_58) - 0.00361353655626004*std::exp(0.603839874267578*x_58) - 0.0616308765115218*std::exp(0.653759837150574*x_58) + 0.286275694355222*std::exp(0.512399852275848*x_59) - 0.109896643812776*std::exp(0.545279860496521*x_59) + 0.736202877188*std::exp(0.696399867534637*x_59) + 0.0585069871781884*std::exp(0.807599902153015*x_59) + 0.0114268723805391*std::exp(0.839199841022491*x_59) - 0.0610743878958715*std::exp(0.866959869861603*x_59) + 0.0238654064162455*std::exp(0.778479874134064*x_60) - 0.457896426077037*std::exp(0.780239880084991*x_60) + 0.167206405381437*std::exp(0.821839869022369*x_60) + 0.00136443976668569*std::exp(0.842239856719971*x_60) + 8.78044803622664e-5*std::exp(0.845599889755249*x_60) + 0.0590916586360162*std::exp(0.847439885139465*x_60) + 0.0254965421729804*std::exp(0.850079894065857*x_60) + 0.144159926563272*std::exp(0.897759795188904*x_60) - 0.0219796136252275*std::exp(0.979119837284088*x_60) - 0.000177202630328005*std::exp(1.01919984817505*x_61) + 0.113282023360034*std::exp(1.04719984531403*x_61) + 0.461115502622764*std::exp(1.3343198299408*x_61) - 0.0208474006739244*std::exp(1.36879980564117*x_61) + 0.000596195461549134*std::exp(0.578399837017059*x_66) + 0.167140260303851*std::exp(0.930159866809845*x_66) - 0.0383857806720874*std::exp(1.03991973400116*x_66) + 0.00294246583045833*std::exp(1.46671986579895*x_66) - 2.3025079635099e-5*std::exp(1.60799980163574*x_7) - 0.000118769561060117*std::exp(1.8828798532486*x_7) - 0.151088212682581*std::exp(0.481679856777191*x_8) + 0.0479505995083335*std::exp(0.549919843673706*x_8) - 0.439943942515799*std::exp(0.583999812602997*x_8) + 0.0521751634147462*std::exp(0.832639873027802*x_8) - 0.0157445862782865*std::exp(0.863359868526459*x_8) + 0.00383933973785734*std::exp(1.34103989601135*x_8) + 8.79111439693872*std::log(9.5269603729248 - 1.42447984218597*x_5) - 1.43450842778888*std::sin(0.289279937744141*x_103 - 7.47775983810425) - 1.03605541700862*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 5.71777601806917*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.768099430607431*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 24.3091819492107*std::sin(0.305919915437698*x_113 - 1.22279989719391) + 0.61453731856166*std::sin(0.32423985004425*x_113 - 7.54616022109985) + 0.646076838381865*std::sin(0.291599929332733*x_114 + 8.11127948760986) + 10.0605017028495*std::sin(0.239199981093407*x_117 - 7.43759965896606) + 0.0293651665268353*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.729373932253284*std::sin(0.272479951381683*x_117 + 1.92951989173889) - 1.72005812481531*std::sin(0.262239962816238*x_120 + 8.34039974212646) - 19.7181475034639*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 3.06996905906944*std::sin(0.270639955997467*x_120 + 5.14951992034912) - 0.00421261255452794*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 5.07398253119851*std::sin(0.121840052306652*x_18 - 4.63351964950562) - 10.42151361073*std::sin(0.408319860696793*x_21 - 7.41095972061157) + 0.787200223146998*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.907594280790747*std::sin(0.197599992156029*x_3 - 7.60056018829346) - 0.563402064363416*std::sin(0.563679814338684*x_3 - 0.974079847335815) + 0.179509945711639*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 91.1061488733504*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 190.858042368481*std::sin(0.121680058538914*x_33 + 7.96871995925903) + 0.00641504864518561*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 18.6123367574118*std::sin(0.202879995107651*x_47 + 8.19711971282959) + 0.714979056682894*std::sin(0.441279858350754*x_5 - 7.41847991943359) - 2.42125501339121*std::sin(0.217119991779327*x_53 + 1.98423981666565) - 0.00626587574996055*std::sin(0.551839888095856*x_6 - 4.35479974746704) - 0.00978714089764771*std::sin(0.603359878063202*x_64 - 7.20143985748291) + 5.55498342911578*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.290065704914767*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 2.40205427069812*std::sin(0.613759815692902*x_65 - 0.975039839744568) - 3.6630519425219*std::sin(0.515199840068817*x_72 + 2.14071989059448) + 1.792981419258*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.502663786224374*std::sin(0.296639919281006*x_9 - 1.20775985717773) + 10.2974991577504*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 7.9032902232607*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 19.0375421810845*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 2.04704601758286*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 5.57721135975568*std::sin(0.383279830217361*x_91 - 1.19735991954803) + 8.22858402197401*std::sin(0.388719856739044*x_91 - 4.3930401802063) + 0.923471570928754*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 27.2596402028753*std::sin(0.299439936876297*x_92 - 1.17271983623505) + 1.27804992714476*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 4.8485950398523*std::sin(0.310879945755005*x_92 + 8.21879959106445) + 1.44300550025989*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 9.10311451409419*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.680986135455742*std::sin(0.299599945545197*x_97 - 7.45336008071899) - 1.64289914404704*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 4.66863649742761*std::sin(0.334719836711884*x_97 + 1.83487987518311) + 11.801156071687*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.644101072234488*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 20.5982625134816*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 533.689213475712);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.05663570187306*x_1 + 10.6438451801754*x_100 - 1.79393874404152*x_101 - 15.9066869634594*x_102 + 0.276972620847021*x_103 - 193.941107586918*x_104 + 7.09028887785022*x_105 - 5.12229086994864*x_106 + 3.23430643311203*x_107 + 1.34665288312897*x_108 + 4.21534403123844*x_109 - 9.93434008450192*x_110 - 7.42118200908485*x_111 - 0.213788489096115*x_112 + 6.40642975399886*x_113 - 3.08103451148599*x_114 + 11.6160948413414*x_115 - 15.6292554081837*x_116 - 11.3666883282022*x_117 + 5.23296548226393*x_118 + 5.36410878450914*x_119 - 1.8619451012104*x_12 - 2.86156916062403*x_120 + 23.6495080018293*x_13 + 7.7435398925311*x_14 - 0.0670871243797881*x_15 + 0.481588378011933*x_16 + 3.52369814787359*x_17 + 23.8633582228516*x_18 + 0.0341776754588335*x_19 - 0.855171196874938*x_2 - 0.113389811948407*x_20 - 1.31757365609801*x_21 + 0.295645129434656*x_22 + 0.0528399721973503*x_23 + 1.39487723828985*x_24 - 0.10668788633312*x_25 - 0.184267716248935*x_26 + 13.3178529602597*x_27 - 3.11035599368303*x_28 + 3.41154568673923*x_29 + 2.0167309278893*x_3 - 0.116434200676027*x_30 - 2.53861295941525*x_31 - 15.0985529761453*x_32 + 15.012147090691*x_33 - 57.0725108395961*x_34 + 215.426803889679*x_35 + 13.4179873437877*x_36 - 149.21299970974*x_37 - 154.463454774259*x_38 + 7.82611110357186*x_39 + 0.464980813378129*x_4 - 107.716415308577*x_40 - 10.2466101682859*x_42 - 19.9678137479305*x_43 - 15.9374198841964*x_44 + 81.8511730172889*x_45 - 64.0301740269607*x_46 - 28.9183807432952*x_47 - 14.7585511533182*x_48 + 10.9171469722788*x_5 - 0.146938055514072*x_50 + 0.663563542741396*x_52 + 6.67608148541382*x_53 + 11.4985520700952*x_54 - 29.1940541797842*x_58 + 0.000680158180695756*x_59 - 5.47546406592643*x_6 + 0.649879216952387*x_60 + 6.36514935787136*x_61 + 1.28065551256767*x_62 + 3.83160530295987*x_63 + 16.182239615452*x_64 - 0.711535452048712*x_65 + 2.9981643559664*x_66 + 3.18554744226444*x_67 - 0.108259891260565*x_68 + 1.94854939816391*x_69 - 2.1799008032155*x_7 + 3.90972157388707*x_70 - 1.78856800353005*x_71 - 5.00516451530458*x_72 + 9.17734012805037*x_73 - 6.46565190569139*x_74 + 5.37566006250625*x_75 - 4.53476788589121*x_76 + 3.35301252511016*x_77 + 9.88583593952438*x_78 - 5.90456910914308*x_79 + 3.99258320314892*x_8 - 1.90695491519183*x_80 - 1.25535316778063*x_81 - 4.40821918465656*x_82 - 8.54720670526233*x_83 - 1.17426223552967*x_84 - 6.97255922328988*x_85 + 229.575738913734*x_86 + 32.3357384052039*x_87 + 16.4497076935632*x_88 + 2.32472225367292*x_89 + 3.83713971243704*x_9 - 7.02905754245945*x_90 - 3.08917310163698*x_91 - 13.2910405684218*x_92 + 6.52991014102615*x_93 + 7.83090670960095*x_94 - 7.03925184198593*x_95 - 13.6230593009357*x_96 + 3.6988157926027*x_97 - 6.85203357486571*x_98 + 2.04876038191196*x_99 + 0.00200835589100131*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.0149296732847132*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.000897129912504061*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) + 0.0243604958278124*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.00678414583578043*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) + 0.0109452036476499*std::exp(1.10983991622925*x_1) + 0.397398693090444*std::exp(1.242959856987*x_1) - 2.19264963516268*std::exp(1.24823987483978*x_1) + 0.0138867849997812*std::exp(1.43383979797363*x_1) - 0.00534331337850618*std::exp(1.77823996543884*x_1) + 0.00722974610015025*std::exp(0.619279801845551*x_10) + 0.0674844644001337*std::exp(0.783999860286713*x_10) + 1.28356822710596*std::exp(0.794399857521057*x_10) + 0.00998511474773735*std::exp(0.803679883480072*x_10) + 0.00978878125294067*std::exp(0.826399862766266*x_10) + 1.60884771884011*std::exp(0.846799850463867*x_10) + 0.347571349954578*std::exp(0.947519838809967*x_10) - 0.0127910879216965*std::exp(0.968719840049744*x_10) + 0.0348134215064899*std::exp(0.975119829177856*x_10) + 0.0151204403030863*std::exp(1.1814398765564*x_10) - 0.590803280080339*std::exp(0.822239875793457*x_11) + 0.0102000505652431*std::exp(0.89359986782074*x_11) - 0.000982892421486416*std::exp(0.906559824943542*x_11) + 1.4858696577577*std::exp(0.921199858188629*x_11) - 0.0216238930723337*std::exp(0.932559847831726*x_11) + 0.222027633321018*std::exp(0.940079808235168*x_11) - 0.523406220228873*std::exp(0.943679809570313*x_11) - 0.0405487744705775*std::exp(0.948239862918854*x_11) - 0.620016880198486*std::exp(0.976479828357697*x_11) + 0.0098340138024965*std::exp(1.0525598526001*x_11) - 0.00591105884074197*std::exp(0.547999858856201*x_12) - 0.0202278402635531*std::exp(0.748719871044159*x_12) - 0.0636378916037816*std::exp(0.869919836521149*x_12) - 0.00402966581662537*std::exp(0.872399866580963*x_12) + 0.0413917498502918*std::exp(1.18807995319366*x_12) + 0.00149601543574591*std::exp(1.12631988525391*x_13) + 4.49578847588705e-5*std::exp(1.31047987937927*x_13) - 0.000127833022324192*std::exp(1.34023988246918*x_13) + 23.5875094115593*std::exp(0.269759833812714*x_14) + 0.118283350167879*std::exp(0.473199844360352*x_14) + 0.0230345870263292*std::exp(0.679999828338623*x_14) - 0.00149062373437074*std::exp(0.895599842071533*x_14) - 0.0482221244537212*std::exp(0.71207982301712*x_15) + 0.713111662246143*std::exp(0.832959890365601*x_15) + 0.360169446133225*std::exp(0.923279821872711*x_15) - 0.00516248746789106*std::exp(0.930639863014221*x_15) - 0.772426667724725*std::exp(0.947279810905457*x_15) + 0.000328005464622507*std::exp(0.964959800243378*x_15) - 0.0583373177528549*std::exp(1.01871979236603*x_15) - 0.00428037078789419*std::exp(1.03775978088379*x_15) + 5.78409151851328*std::exp(0.382159829139709*x_16) - 0.0560008611637233*std::exp(0.548479855060577*x_16) + 4.0598867793194*std::exp(0.570239841938019*x_16) + 0.0715819037377856*std::exp(0.715919852256775*x_16) - 0.129796531811705*std::exp(0.887839913368225*x_16) + 0.0243172756974217*std::exp(0.618079841136932*x_17) + 4.83440261893641*std::exp(0.642879843711853*x_17) - 0.279782895012395*std::exp(0.658879816532135*x_17) + 6.8935669768066*std::exp(0.666479825973511*x_17) - 0.0398149471245841*std::exp(0.713679850101471*x_17) - 0.327536232537055*std::exp(0.826239883899689*x_17) + 6.82248580641885*std::exp(0.442959845066071*x_18) - 0.0746780698462177*std::exp(0.693519830703735*x_19) - 0.00835827671940995*std::exp(0.705919861793518*x_19) + 5.34457753929484*std::exp(0.7219198346138*x_19) - 8.56482359518856*std::exp(0.723199844360352*x_19) + 0.0360294703664188*std::exp(0.725599884986877*x_19) + 5.39089103167023*std::exp(0.73967981338501*x_19) + 0.631290753297293*std::exp(0.765519857406616*x_19) - 4.21622465964881*std::exp(0.819519877433777*x_19) + 0.037540749665924*std::exp(1.02399981021881*x_19) + 0.0416377286013588*std::exp(0.747839868068695*x_2) - 7.24525475393076*std::exp(0.754719853401184*x_2) + 0.28031426485105*std::exp(0.769999861717224*x_2) + 3.97289512516133*std::exp(0.827439904212952*x_2) + 0.0329447690339247*std::exp(1.00447976589203*x_2) - 0.243131251576634*std::exp(1.09567987918854*x_2) + 0.185682006563802*std::exp(0.44583985209465*x_20) - 1.6972829433951*std::exp(0.488959848880768*x_20) - 1.60971050430696*std::exp(0.627359867095947*x_20) + 0.862746867286312*std::exp(0.851519882678986*x_20) + 0.349779359911942*std::exp(0.915279805660248*x_20) - 0.0292190700421284*std::exp(1.0039998292923*x_20) - 0.0121456517382257*std::exp(0.855839908123016*x_21) - 0.0616114551709185*std::exp(0.53279983997345*x_22) + 0.682367983398524*std::exp(0.742159843444824*x_22) - 0.000855356783964437*std::exp(1.19607996940613*x_22) + 0.0191171074480791*std::exp(1.36079978942871*x_22) - 0.00521684751587378*std::exp(1.40143978595734*x_22) + 0.166244275375734*std::exp(0.62527984380722*x_23) + 0.00966225797268654*std::exp(0.664479851722717*x_23) - 0.170274631763191*std::exp(0.685359835624695*x_23) - 0.284382010378194*std::exp(0.735519826412201*x_23) + 3.33524472128952*std::exp(0.743439853191376*x_23) - 1.24818746923896*std::exp(0.744559824466705*x_23) + 0.301356321238455*std::exp(0.782239854335785*x_23) + 1.9214865314306*std::exp(0.818959891796112*x_23) + 0.242232860980369*std::exp(0.834479868412018*x_23) - 7.08584913888459*std::exp(0.368799835443497*x_24) - 0.44126084837759*std::exp(0.424879848957062*x_24) + 3.91855798434683*std::exp(0.609519839286804*x_24) + 0.0667481761039828*std::exp(0.61167985200882*x_24) + 0.05228372228406*std::exp(0.653759837150574*x_24) - 1.55057736203085*std::exp(0.761439859867096*x_24) - 0.00265371704155367*std::exp(0.780959844589233*x_24) - 0.22052356021123*std::exp(0.418559849262238*x_25) + 1.17254348331888*std::exp(0.545919835567474*x_25) - 6.11021352865392*std::exp(0.627679824829102*x_25) - 0.0610160301721897*std::exp(0.643359839916229*x_25) - 0.712741768432503*std::exp(0.765359818935394*x_25) - 0.665725304401715*std::exp(0.878879845142365*x_25) - 0.387539510432571*std::exp(0.964159786701202*x_25) - 0.00216740212145848*std::exp(1.00615978240967*x_25) + 0.316271060487031*std::exp(0.429119855165482*x_26) + 2.59557990789863*std::exp(0.569839835166931*x_26) + 1.1914534037436*std::exp(0.698879837989807*x_26) + 0.0429951674251451*std::exp(0.736239850521088*x_26) - 0.399374968017129*std::exp(0.79943984746933*x_26) + 0.00298409415404316*std::exp(0.822479903697968*x_26) - 0.000388491395750668*std::exp(0.984079837799072*x_26) - 0.110274563768366*std::exp(1.10487985610962*x_26) + 9.22108143487694e-5*std::exp(1.14151990413666*x_27) - 0.0663363380195447*std::exp(1.18543982505798*x_27) + 0.0939491605917342*std::exp(1.24655985832214*x_27) - 0.00330950070630753*std::exp(1.2630398273468*x_27) - 0.0174525379926853*std::exp(1.27247989177704*x_27) - 0.429144080109701*std::exp(0.549759864807129*x_28) - 4.61005587735792*std::exp(0.565279841423035*x_28) - 0.00897879524344165*std::exp(0.650239825248718*x_28) + 0.0689844018170419*std::exp(0.667519807815552*x_28) + 1.16090104249587*std::exp(0.768079876899719*x_28) - 0.42495326840824*std::exp(0.905439794063568*x_28) - 0.000808972508589668*std::exp(1.13103985786438*x_29) - 0.0475521242290897*std::exp(1.1431999206543*x_29) - 0.0147773731657951*std::exp(1.1509598493576*x_29) + 0.151741117010618*std::exp(1.16863989830017*x_29) - 0.126141692373482*std::exp(1.17591977119446*x_29) - 6.01789158246365*std::exp(0.575039863586426*x_3) + 0.878300376151687*std::exp(0.670239865779877*x_3) - 0.00766065462515097*std::exp(0.670399844646454*x_3) - 0.0322148868232434*std::exp(0.915599822998047*x_3) - 0.0635636770589346*std::exp(0.947999835014343*x_3) + 0.17203606768674*std::exp(0.739759802818298*x_30) - 2.10714943236392*std::exp(0.847439885139465*x_30) - 0.161404279059212*std::exp(0.853279888629913*x_30) - 0.988915864193325*std::exp(0.882479906082153*x_30) + 1.10630280270375*std::exp(0.916479825973511*x_30) - 1.79965876761873*std::exp(0.9440798163414*x_30) + 0.000613663671149804*std::exp(1.00999975204468*x_30) + 0.00942260126773436*std::exp(1.03159987926483*x_30) + 0.00195142139336292*std::exp(1.09999978542328*x_30) + 1.9601590709228*std::exp(0.787999868392944*x_32) + 0.00182735507041731*std::exp(0.823919892311096*x_32) + 0.39236595717685*std::exp(0.357519835233688*x_33) - 6.12828306991784*std::exp(0.36575984954834*x_33) + 0.0336437105237252*std::exp(0.395519852638245*x_33) - 1.03934653311555*std::exp(0.41407984495163*x_33) - 18.241398190011*std::exp(0.379279851913452*x_34) - 1.20180356621983*std::exp(0.408159852027893*x_34) - 0.508288782000475*std::exp(0.431119859218597*x_36) - 1.43230103146318*std::exp(0.250399857759476*x_37) - 4.60832675841842*std::exp(0.375039845705032*x_38) - 0.07315858829494*std::exp(0.385999858379364*x_4) + 0.0110890648987245*std::exp(0.527999818325043*x_4) + 3.17340889198355*std::exp(0.554479837417603*x_4) + 0.0305626196801793*std::exp(0.638399839401245*x_4) + 4.90906691578599*std::exp(0.723759829998016*x_4) - 0.0197339482355916*std::exp(1.10615980625153*x_4) - 0.00545799674363471*std::exp(1.13591980934143*x_4) + 2.07948650919488*std::exp(0.685679852962494*x_41) - 0.87882620328281*std::exp(0.7497598528862*x_41) + 0.025319379008538*std::exp(0.769599854946136*x_41) + 0.210248743896923*std::exp(0.797759890556335*x_41) + 0.00258748800182924*std::exp(0.798159837722778*x_41) - 0.132993667964755*std::exp(0.798719823360443*x_41) - 0.0819931277790081*std::exp(0.803759872913361*x_41) + 0.0837086927748239*std::exp(0.805199861526489*x_41) - 0.754462242719048*std::exp(0.812879860401154*x_41) + 0.088277822996789*std::exp(0.866879880428314*x_41) - 0.664238497620368*std::exp(0.19999985396862*x_42) - 0.0802448025420325*std::exp(0.596879839897156*x_42) - 0.652516937176749*std::exp(0.690479874610901*x_42) + 1.34037506868626*std::exp(0.718159854412079*x_42) + 0.0119206487228429*std::exp(0.841359853744507*x_42) - 0.111240737045151*std::exp(0.705839812755585*x_43) - 0.00869263875845905*std::exp(0.787679851055145*x_43) - 0.000373507251718164*std::exp(0.83271986246109*x_43) + 0.0391769693233277*std::exp(0.886719882488251*x_44) + 0.000133792899517374*std::exp(0.908799827098846*x_44) - 0.0139460971549142*std::exp(0.942639827728271*x_44) + 1.78156807334974*std::exp(0.515199840068817*x_45) - 1.69774294340226*std::exp(0.504559814929962*x_46) + 0.000503453892530145*std::exp(0.663999855518341*x_46) + 1.24703898726299*std::exp(0.700479865074158*x_46) - 0.0496917366265402*std::exp(0.75791984796524*x_46) - 0.0151495931128104*std::exp(0.759199857711792*x_46) + 0.192123662948256*std::exp(0.801999866962433*x_46) - 0.0913217074173103*std::exp(0.802399873733521*x_46) - 0.0690921931833992*std::exp(0.424159854650497*x_47) + 0.130788945934649*std::exp(0.552239894866943*x_47) - 0.00413572477239567*std::exp(0.608879864215851*x_48) - 1.84528626436936*std::exp(0.608959853649139*x_48) - 0.0321810050444037*std::exp(0.639919817447662*x_49) + 0.0248720252987089*std::exp(0.685839831829071*x_49) + 10.8723106119825*std::exp(0.703679859638214*x_49) + 0.00980277817100187*std::exp(0.705999851226807*x_49) - 0.509651217953042*std::exp(0.708399832248688*x_49) + 0.372979050624609*std::exp(0.708639860153198*x_49) + 2.21500227555325*std::exp(0.715839862823486*x_49) - 4.98681158888722*std::exp(0.719119846820831*x_49) + 4.48490765670058*std::exp(0.719919860363007*x_49) - 5.16741273236552*std::exp(0.720319867134094*x_49) - 0.000660657199571155*std::exp(1.93999981880188*x_5) + 2.09444396275208*std::exp(0.52215987443924*x_50) + 0.334808883344694*std::exp(0.537359833717346*x_50) - 0.200022965951454*std::exp(0.541919827461243*x_50) + 2.09879178507066*std::exp(0.543199837207794*x_50) + 9.27337401701669*std::exp(0.546079874038696*x_50) + 0.539881493382709*std::exp(0.599439859390259*x_50) - 1.27053677079804*std::exp(0.610719859600067*x_50) + 0.0183363580967624*std::exp(0.658079862594604*x_50) - 0.0289589680210338*std::exp(0.463519841432571*x_51) + 0.0460279976091068*std::exp(0.48039984703064*x_51) - 2.73224366589176*std::exp(0.491039842367172*x_51) + 2.96881013943917*std::exp(0.493919849395752*x_51) - 58.7281275290158*std::exp(0.49415984749794*x_51) + 13.4205998044586*std::exp(0.496719866991043*x_51) - 27.9191565575935*std::exp(0.497119843959808*x_51) + 1.00255843816657*std::exp(0.499279826879501*x_51) - 30.2868516625743*std::exp(0.501199841499329*x_51) + 11.9407410283079*std::exp(0.510319828987122*x_51) - 0.461899555223498*std::exp(0.504639863967896*x_52) - 0.0514296278837173*std::exp(0.546399831771851*x_52) - 0.00691766638145216*std::exp(0.600159823894501*x_52) + 0.0719829009918544*std::exp(0.641199827194214*x_52) - 0.374886459162302*std::exp(0.673519849777222*x_52) + 0.657177389855662*std::exp(0.712159812450409*x_52) - 0.00474432224760127*std::exp(0.714239835739136*x_52) + 0.07249047632446*std::exp(0.88375985622406*x_52) + 12.434576147981*std::exp(0.474319845438004*x_54) + 0.382238298698738*std::exp(0.502159833908081*x_54) + 0.0135261392845294*std::exp(0.506399810314178*x_54) - 2.16888774242007*std::exp(0.519279837608337*x_54) - 4.65666513477188*std::exp(0.532479882240295*x_54) - 0.0691630191051376*std::exp(0.532879829406738*x_54) + 3.53276084397838*std::exp(0.542559862136841*x_54) + 2.77526530005156*std::exp(0.612959861755371*x_55) - 0.0146076640543008*std::exp(0.631199836730957*x_55) - 0.973611500169577*std::exp(0.650959849357605*x_55) - 1.5584937061656*std::exp(0.652479827404022*x_55) + 19.8028349169853*std::exp(0.653439819812775*x_55) - 0.696630852687669*std::exp(0.655679821968079*x_55) + 70.5507268835364*std::exp(0.655759811401367*x_55) - 5.47960646337153*std::exp(0.656879842281342*x_55) - 1.40385282740337*std::exp(0.657759845256805*x_55) + 37.7633473589696*std::exp(0.659119844436646*x_55) + 28.7678933164668*std::exp(0.347199827432632*x_56) + 14.6640771107252*std::exp(0.442879855632782*x_56) - 1.77481652967748*std::exp(0.466319859027863*x_56) - 0.216582643347153*std::exp(0.52183985710144*x_56) - 5.39764106056876*std::exp(0.525679886341095*x_56) + 3.93506048786533*std::exp(0.574079871177673*x_56) - 0.502186782741921*std::exp(0.655039846897125*x_56) + 0.0504923526608201*std::exp(0.658559858798981*x_56) + 0.00100832060136465*std::exp(0.754159867763519*x_56) + 0.00607346673316335*std::exp(0.859519898891449*x_56) + 0.874351536927725*std::exp(0.599999845027924*x_57) - 0.748153795473233*std::exp(0.609679877758026*x_57) - 0.324172797168031*std::exp(0.617039859294891*x_57) + 0.103685175121529*std::exp(0.626319825649261*x_57) - 25.4634806466663*std::exp(0.628239870071411*x_57) - 2.32992645182733*std::exp(0.632079839706421*x_57) - 30.6173904008901*std::exp(0.634159862995148*x_57) + 0.0345880159429325*std::exp(0.637119889259338*x_57) + 6.89463347974009*std::exp(0.641199827194214*x_57) + 1.66475112839834*std::exp(0.671519815921783*x_57) - 0.286040941395872*std::exp(0.37679985165596*x_58) + 0.201140625425587*std::exp(0.451519846916199*x_58) - 0.151883069856072*std::exp(0.558799862861633*x_58) + 0.526234060576517*std::exp(0.595039844512939*x_58) + 0.00670419267843968*std::exp(0.603839874267578*x_58) + 0.0376529749397299*std::exp(0.653759837150574*x_58) - 4.93442168591129*std::exp(0.512399852275848*x_59) - 0.123399905607971*std::exp(0.545279860496521*x_59) - 2.75359191542846*std::exp(0.696399867534637*x_59) - 0.207095563515693*std::exp(0.807599902153015*x_59) - 0.0272864693050194*std::exp(0.839199841022491*x_59) - 0.0806152285725444*std::exp(0.866959869861603*x_59) - 0.0145804116472263*std::exp(0.778479874134064*x_60) + 1.71265277006971*std::exp(0.780239880084991*x_60) - 2.88207112586254*std::exp(0.821839869022369*x_60) - 0.00253144445934529*std::exp(0.842239856719971*x_60) - 0.0292413155397758*std::exp(0.845599889755249*x_60) - 0.141106216631981*std::exp(0.847439885139465*x_60) + 0.0286293629024336*std::exp(0.850079894065857*x_60) + 0.151080896857036*std::exp(0.897759795188904*x_60) + 0.0778006301317572*std::exp(0.979119837284088*x_60) + 0.0590133670459741*std::exp(1.01919984817505*x_61) - 0.40098124335977*std::exp(1.04719984531403*x_61) - 1.72469296092758*std::exp(1.3343198299408*x_61) + 0.0497819472935815*std::exp(1.36879980564117*x_61) - 0.198549544882137*std::exp(0.578399837017059*x_66) - 2.88093100914396*std::exp(0.930159866809845*x_66) - 0.0431023327672652*std::exp(1.03991973400116*x_66) - 0.00179767996897702*std::exp(1.46671986579895*x_66) + 1.40670195778181e-5*std::exp(1.60799980163574*x_7) - 0.000124471565934125*std::exp(1.8828798532486*x_7) - 0.169652780436777*std::exp(0.481679856777191*x_8) - 0.0292951005052601*std::exp(0.549919843673706*x_8) - 0.461065200202738*std::exp(0.583999812602997*x_8) - 0.184682982153771*std::exp(0.832639873027802*x_8) + 0.0375968292893832*std::exp(0.863359868526459*x_8) - 0.0143601379325328*std::exp(1.34103989601135*x_8) + 9.21316678723031*std::log(9.5269603729248 - 1.42447984218597*x_5) + 3.42549289771681*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 2.47401855845099*std::sin(0.233039990067482*x_108 - 1.19815993309021) - 20.2390535494878*std::sin(0.302159935235977*x_112 - 7.45056009292603) - 0.469265248993752*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 32.0869406434061*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 1.46746661039813*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 1.54278049426847*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 37.6289159041775*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0544811796878924*std::sin(0.248479977250099*x_117 + 1.95407974720001) - 0.445606162808523*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 4.10736303536173*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 73.7510450382263*std::sin(0.264879941940308*x_120 + 5.15752029418945) + 52.9158506951416*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 1.4029162571835*std::sin(0.270879954099655*x_120 - 7.44527959823608) - 3.09991594969655*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 38.97919515697*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 1.87977199801295*std::sin(0.436799854040146*x_22 - 7.42592000961304) + 0.55448870183872*std::sin(0.197599992156029*x_3 - 7.60056018829346) - 0.632628614939552*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.428655581377488*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 95.4800616864574*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 251.923355116974*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 2.13638826701032*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 19.5058959653449*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 1.70731355301871*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 5.78176585878758*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.0116250763408287*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0181580779182093*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 20.7770954647413*std::sin(0.550959885120392*x_65 - 7.2239203453064) + 0.177213717153431*std::sin(0.592319846153259*x_65 - 7.19871997833252) - 8.50248503260747*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 13.7007753260207*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 4.28149810654886*std::sin(0.234399989247322*x_9 + 5.00383996963501) - 0.307099103844123*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 38.5153485656264*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 8.28271908509611*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 25.1286319398598*std::sin(0.357359826564789*x_91 - 7.3996000289917) + 35.2841280639268*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 5.84496755985313*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 30.7770631444372*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 2.2051772204195*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 35.9814023761778*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 3.05188234767636*std::sin(0.306479930877686*x_92 + 8.20936012268066) + 17.1624376927744*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 3.44578323609124*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 12.015669457497*std::sin(0.319199919700623*x_94 + 1.95127987861633) - 0.416043959521247*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 3.92311347955803*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 4.89277294977863*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 44.1394199324875*std::sin(0.232959985733032*x_98 - 4.22215986251831) + 0.39350927496487*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 27.1887070493889*std::sin(0.265759944915771*x_98 + 1.95295977592468) - 302.095207417577);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.71992296785814*x_1 + 0.00652449705832803*x_100 + 11.9447073188096*x_101 + 19.809955646282*x_102 - 5.44410395037369*x_103 + 189.699362273933*x_104 + 16.6814936926314*x_105 + 11.7680918271734*x_106 + 0.414119633937526*x_107 + 9.86976085705367*x_108 - 16.9254028957694*x_109 + 19.930352457929*x_110 + 21.4360790419623*x_111 + 3.19328609899586*x_112 - 16.7574441423139*x_113 - 34.9070895377134*x_114 - 16.1862073211713*x_115 + 0.82095847980147*x_116 + 26.9868490222458*x_117 + 18.4073458763947*x_118 + 7.43772225172643*x_119 + 1.02826964099023*x_12 + 1.93584506128753*x_120 - 23.5921660542117*x_13 - 3.79641310810359*x_14 + 0.0696005893187342*x_15 + 2.23435993713105*x_16 - 1.2880014038757*x_17 - 84.760441562636*x_18 - 0.051132569664247*x_19 + 0.465641320721903*x_2 + 0.230910479885743*x_20 - 10.4764836958136*x_21 - 0.0785360264336215*x_22 + 0.00284861506207768*x_23 - 7.36632455315221*x_24 - 0.0815849826198581*x_25 + 0.13472388527694*x_26 - 49.7064825836042*x_27 + 2.70081841567303*x_28 - 1.74590373610089*x_29 - 0.496196462946135*x_3 + 0.174194991246226*x_30 - 1.53937717756785*x_31 + 4.57520500179031*x_32 - 55.4141772333618*x_33 + 79.7764291774391*x_34 - 70.3923373726069*x_35 - 88.8433982099333*x_36 + 402.299377475646*x_37 + 59.9240048601446*x_38 + 53.1831269471224*x_39 + 11.1468993241029*x_4 + 2630.14533643182*x_40 + 13.8146746022665*x_42 - 9.96400830650598*x_43 + 38.6267667986679*x_44 - 64.3913157666978*x_45 + 234.949609582419*x_46 - 61.7089256027481*x_47 + 125.865866119632*x_48 - 46.0008778601616*x_5 + 0.00555655517045054*x_50 - 8.48414041961017*x_52 - 11.5291128367543*x_53 - 47.1896207893494*x_54 + 9.12691874943859*x_58 + 0.00832858846060479*x_59 - 6.89084514863956*x_6 - 0.263848045405679*x_60 - 16.0481113286524*x_61 - 15.0831015773555*x_62 - 10.3663690223965*x_63 - 31.0913061359614*x_64 - 0.138476990577477*x_65 - 0.437164485260282*x_66 - 9.84391114800191*x_67 - 10.5347172154711*x_68 - 25.5752996366524*x_69 - 35.2050896917618*x_7 + 4.56042578936363*x_70 + 10.6678771965007*x_71 + 3.29470276170061*x_72 - 26.6466202516783*x_73 + 13.4249739612365*x_74 + 2.52888789433475*x_75 - 1.98853198376039*x_76 - 1.19652777799989*x_77 - 0.928283135158108*x_78 + 25.0818707225081*x_79 - 4.99508766276228*x_8 + 5.98776744302849*x_80 - 3.15818048891937*x_81 + 11.7562645259028*x_82 - 11.3560397799466*x_83 - 12.730849570712*x_84 + 5.0581233956469*x_85 - 414.224350592981*x_86 - 84.7491322457845*x_87 - 41.8022151632809*x_88 - 3.79322015755058*x_89 - 9.72321214427802*x_9 + 7.18026697782005*x_90 + 1.60052346234212*x_91 + 21.0543428672754*x_92 + 11.7909175441107*x_93 - 11.5720530985845*x_94 + 8.01674630257862*x_95 + 32.7814800769644*x_96 + 4.46334173935286*x_97 + 26.4007797391874*x_98 + 37.835630844513*x_99 - 0.00221419469247556*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) + 0.00606138034878187*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 0.00012169407893407*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.0886627793381578*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) - 0.00275433276188133*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) + 0.000590058447641774*std::exp(1.10983991622925*x_1) - 0.198874221441154*std::exp(1.242959856987*x_1) + 0.662229478941752*std::exp(1.24823987483978*x_1) + 0.00188371771618548*std::exp(1.43383979797363*x_1) - 0.0040226481164883*std::exp(1.77823996543884*x_1) + 0.00713979162148395*std::exp(0.619279801845551*x_10) + 0.00915414771380296*std::exp(0.783999860286713*x_10) - 0.6423489464627*std::exp(0.794399857521057*x_10) + 0.000538299834086683*std::exp(0.803679883480072*x_10) - 0.014644809298015*std::exp(0.826399862766266*x_10) - 0.485908176782228*std::exp(0.846799850463867*x_10) - 0.141112408171144*std::exp(0.947519838809967*x_10) - 0.00962961407860257*std::exp(0.968719840049744*x_10) - 0.0383814907865522*std::exp(0.975119829177856*x_10) - 0.0550325523570725*std::exp(1.1814398765564*x_10) + 0.239863480170165*std::exp(0.822239875793457*x_11) + 0.000549887073475081*std::exp(0.89359986782074*x_11) - 0.000970663005109258*std::exp(0.906559824943542*x_11) - 0.743588684330032*std::exp(0.921199858188629*x_11) + 0.0323510948035396*std::exp(0.932559847831726*x_11) - 0.244783511470771*std::exp(0.940079808235168*x_11) + 1.9049961271884*std::exp(0.943679809570313*x_11) - 0.005500369224485*std::exp(0.948239862918854*x_11) + 0.187259035335334*std::exp(0.976479828357697*x_11) + 0.00740341699950824*std::exp(1.0525598526001*x_11) - 0.00583751182968252*std::exp(0.547999858856201*x_12) + 0.0302624867709095*std::exp(0.748719871044159*x_12) + 0.0701602153586317*std::exp(0.869919836521149*x_12) - 0.000217240211586527*std::exp(0.872399866580963*x_12) - 0.150649954308677*std::exp(1.18807995319366*x_12) + 0.000202931836277865*std::exp(1.12631988525391*x_13) + 2.4236899142368e-6*std::exp(1.31047987937927*x_13) + 0.000191248551331585*std::exp(1.34023988246918*x_13) - 85.8494078641097*std::exp(0.269759833812714*x_14) + 0.0160449263270451*std::exp(0.473199844360352*x_14) - 0.0344616071748239*std::exp(0.679999828338623*x_14) - 8.03598685813065e-5*std::exp(0.895599842071533*x_14) + 0.0721442024621544*std::exp(0.71207982301712*x_15) - 0.356869635194126*std::exp(0.832959890365601*x_15) - 0.1087792690718*std::exp(0.923279821872711*x_15) - 0.000278310887520853*std::exp(0.930639863014221*x_15) + 2.81133420598098*std::exp(0.947279810905457*x_15) + 0.000323924330906179*std::exp(0.964959800243378*x_15) + 0.0643163793431209*std::exp(1.01871979236603*x_15) - 0.000580624693557663*std::exp(1.03775978088379*x_15) - 1.74692566063902*std::exp(0.382159829139709*x_16) - 0.00301901931372142*std::exp(0.548479855060577*x_16) - 2.03172993876108*std::exp(0.570239841938019*x_16) + 0.00970995808110193*std::exp(0.715919852256775*x_16) + 0.143099533865946*std::exp(0.887839913368225*x_16) + 0.0240147135012332*std::exp(0.618079841136932*x_17) - 17.5953550233244*std::exp(0.642879843711853*x_17) + 0.418577863416059*std::exp(0.658879816532135*x_17) - 2.08201218922147*std::exp(0.666479825973511*x_17) - 0.0021464329627449*std::exp(0.713679850101471*x_17) + 0.361105813430015*std::exp(0.826239883899689*x_17) - 2.76989861788961*std::exp(0.442959845066071*x_18) - 0.0101299475135587*std::exp(0.693519830703735*x_19) - 0.00825428075407064*std::exp(0.705919861793518*x_19) - 2.16987449433292*std::exp(0.7219198346138*x_19) + 31.1726440158688*std::exp(0.723199844360352*x_19) + 0.00194235703949914*std::exp(0.725599884986877*x_19) - 2.6978177720215*std::exp(0.73967981338501*x_19) + 0.475259521540132*std::exp(0.765519857406616*x_19) + 1.27339462478849*std::exp(0.819519877433777*x_19) - 0.0413883460766509*std::exp(1.02399981021881*x_19) + 0.00224469953166404*std::exp(0.747839868068695*x_2) + 2.18822980359096*std::exp(0.754719853401184*x_2) + 0.21103116543075*std::exp(0.769999861717224*x_2) - 14.4598010773517*std::exp(0.827439904212952*x_2) + 0.00446889939505945*std::exp(1.00447976589203*x_2) + 0.26805006484559*std::exp(1.09567987918854*x_2) + 0.139788427340652*std::exp(0.44583985209465*x_20) + 0.68908925756277*std::exp(0.488959848880768*x_20) + 0.805563603644858*std::exp(0.627359867095947*x_20) - 3.14006478601969*std::exp(0.851519882678986*x_20) - 0.105641229471611*std::exp(0.915279805660248*x_20) + 0.0322137675380316*std::exp(1.0039998292923*x_20) + 0.0181708783668023*std::exp(0.855839908123016*x_21) - 0.00332148772790617*std::exp(0.53279983997345*x_22) - 0.341484267045304*std::exp(0.742159843444824*x_22) - 0.00011602762825511*std::exp(1.19607996940613*x_22) - 0.00577379618758636*std::exp(1.36079978942871*x_22) + 0.0189873064739779*std::exp(1.40143978595734*x_22) - 0.248714895843946*std::exp(0.62527984380722*x_23) + 0.00954203751589149*std::exp(0.664479851722717*x_23) - 0.0230974513160775*std::exp(0.685359835624695*x_23) - 0.214093517893351*std::exp(0.735519826412201*x_23) - 1.00731887963438*std::exp(0.743439853191376*x_23) + 4.54291944384146*std::exp(0.744559824466705*x_23) - 0.332242691656343*std::exp(0.782239854335785*x_23) - 0.780114908072904*std::exp(0.818959891796112*x_23) - 0.121223024817473*std::exp(0.834479868412018*x_23) + 3.54604269024214*std::exp(0.368799835443497*x_24) + 0.66016195562944*std::exp(0.424879848957062*x_24) - 1.18349259752323*std::exp(0.609519839286804*x_24) + 0.00359840953560444*std::exp(0.61167985200882*x_24) + 0.00709219404895787*std::exp(0.653759837150574*x_24) + 0.629527449947838*std::exp(0.761439859867096*x_24) - 0.0026206987682016*std::exp(0.780959844589233*x_24) - 0.0299136291958675*std::exp(0.418559849262238*x_25) - 1.29271886974527*std::exp(0.545919835567474*x_25) + 22.2388131025459*std::exp(0.627679824829102*x_25) + 0.0912849212689484*std::exp(0.643359839916229*x_25) + 0.289369959177631*std::exp(0.765359818935394*x_25) + 0.333155603952715*std::exp(0.878879845142365*x_25) + 0.117045643748762*std::exp(0.964159786701202*x_25) - 0.000116845147187177*std::exp(1.00615978240967*x_25) + 0.0429016075186285*std::exp(0.429119855165482*x_26) - 1.05379379356807*std::exp(0.569839835166931*x_26) - 4.3364293967781*std::exp(0.698879837989807*x_26) + 0.0323683858701942*std::exp(0.736239850521088*x_26) + 0.440307386979228*std::exp(0.79943984746933*x_26) + 0.000160873202622381*std::exp(0.822479903697968*x_26) - 0.000383657679533391*std::exp(0.984079837799072*x_26) + 0.0333053971477006*std::exp(1.10487985610962*x_26) + 9.10635021724861e-5*std::exp(1.14151990413666*x_27) + 0.0331973602487205*std::exp(1.18543982505798*x_27) - 0.0283747584055139*std::exp(1.24655985832214*x_27) - 0.00249151712424297*std::exp(1.2630398273468*x_27) + 0.00708565209752774*std::exp(1.27247989177704*x_27) - 0.323075871330985*std::exp(0.549759864807129*x_28) + 16.7788196874098*std::exp(0.565279841423035*x_28) - 0.000484048918009497*std::exp(0.650239825248718*x_28) + 0.00935761155985834*std::exp(0.667519807815552*x_28) - 0.350618211020265*std::exp(0.768079876899719*x_28) + 0.172529119771011*std::exp(0.905439794063568*x_28) - 4.36118941200134e-5*std::exp(1.13103985786438*x_29) + 0.173071333497692*std::exp(1.1431999206543*x_29) - 0.0111249646279682*std::exp(1.1509598493576*x_29) - 0.0458292283639405*std::exp(1.16863989830017*x_29) + 0.0631263547118318*std::exp(1.17591977119446*x_29) + 3.01159395838112*std::exp(0.575039863586426*x_3) - 0.968318433992678*std::exp(0.670239865779877*x_3) - 0.00756533866474211*std::exp(0.670399844646454*x_3) - 0.0043698921697722*std::exp(0.915599822998047*x_3) - 0.0478531367497068*std::exp(0.947999835014343*x_3) - 0.189668250379882*std::exp(0.739759802818298*x_30) + 7.66920864315529*std::exp(0.847439885139465*x_30) - 0.121511237159031*std::exp(0.853279888629913*x_30) + 0.494893103529895*std::exp(0.882479906082153*x_30) - 0.449153972778291*std::exp(0.916479825973511*x_30) + 0.543537402802927*std::exp(0.9440798163414*x_30) + 0.000606028299886409*std::exp(1.00999975204468*x_30) + 0.00127815912328611*std::exp(1.03159987926483*x_30) + 0.000105201576428403*std::exp(1.09999978542328*x_30) - 7.13422060048946*std::exp(0.787999868392944*x_32) + 0.00180461861876042*std::exp(0.823919892311096*x_32) - 0.587011239643534*std::exp(0.357519835233688*x_33) + 1.85087924633164*std::exp(0.36575984954834*x_33) + 0.033225106274193*std::exp(0.395519852638245*x_33) - 0.782459323953175*std::exp(0.41407984495163*x_33) + 5.50931230636115*std::exp(0.379279851913452*x_34) - 0.904763114117534*std::exp(0.408159852027893*x_34) - 0.382658992035007*std::exp(0.431119859218597*x_36) - 1.07829031133307*std::exp(0.250399857759476*x_37) + 16.7725263634945*std::exp(0.375039845705032*x_38) - 0.00394399633215092*std::exp(0.385999858379364*x_4) + 0.0109510917198544*std::exp(0.527999818325043*x_4) - 1.5881009013888*std::exp(0.554479837417603*x_4) - 0.0457241535282573*std::exp(0.638399839401245*x_4) - 1.48264856071725*std::exp(0.723759829998016*x_4) - 0.0148564615394078*std::exp(1.10615980625153*x_4) - 0.000740367562472478*std::exp(1.13591980934143*x_4) - 7.56852630605832*std::exp(0.685679852962494*x_41) + 0.356799494335039*std::exp(0.7497598528862*x_41) + 0.00136497354950901*std::exp(0.769599854946136*x_41) - 0.231797389557346*std::exp(0.797759890556335*x_41) + 0.00255529376830629*std::exp(0.798159837722778*x_41) - 0.0180403548042003*std::exp(0.798719823360443*x_41) - 0.0617275232914415*std::exp(0.803759872913361*x_41) - 0.12523498182219*std::exp(0.805199861526489*x_41) + 0.227864557047662*std::exp(0.812879860401154*x_41) - 0.0441777580657792*std::exp(0.866879880428314*x_41) - 0.0901027722226297*std::exp(0.19999985396862*x_42) + 0.120052721581852*std::exp(0.596879839897156*x_42) + 0.264918947978604*std::exp(0.690479874610901*x_42) - 0.404823401371539*std::exp(0.718159854412079*x_42) + 0.00897431457513886*std::exp(0.841359853744507*x_42) + 0.122641933462122*std::exp(0.705839812755585*x_43) + 0.0130048913776599*std::exp(0.787679851055145*x_43) - 0.000368859972319833*std::exp(0.83271986246109*x_43) - 0.0118323254045918*std::exp(0.886719882488251*x_44) + 0.000132128211662694*std::exp(0.908799827098846*x_44) + 0.015375449361101*std::exp(0.942639827728271*x_44) - 0.891568013916971*std::exp(0.515199840068817*x_45) + 0.689276015501183*std::exp(0.504559814929962*x_46) + 0.000497189781480086*std::exp(0.663999855518341*x_46) - 0.37663380665646*std::exp(0.700479865074158*x_46) + 0.0743428612590817*std::exp(0.75791984796524*x_46) - 0.000816718051332811*std::exp(0.759199857711792*x_46) - 0.0961463752991289*std::exp(0.801999866962433*x_46) + 0.100681378622791*std::exp(0.802399873733521*x_46) - 0.00372477603582239*std::exp(0.424159854650497*x_47) - 0.195670852377656*std::exp(0.552239894866943*x_47) - 0.00408426695345506*std::exp(0.608879864215851*x_48) + 0.749177941635071*std::exp(0.608959853649139*x_48) - 0.00436529616666153*std::exp(0.639919817447662*x_49) + 0.00134085660805537*std::exp(0.685839831829071*x_49) - 39.5710039524545*std::exp(0.703679859638214*x_49) + 0.00968080932346024*std::exp(0.705999851226807*x_49) + 0.762479485705249*std::exp(0.708399832248688*x_49) + 0.28079271590545*std::exp(0.708639860153198*x_49) - 2.44202051256268*std::exp(0.715839862823486*x_49) + 2.02462312413151*std::exp(0.719119846820831*x_49) - 1.35454292969079*std::exp(0.719919860363007*x_49) + 2.5859802809679*std::exp(0.720319867134094*x_49) + 0.000330619321322992*std::exp(1.93999981880188*x_5) - 0.632569158283741*std::exp(0.52215987443924*x_50) + 0.252056772374187*std::exp(0.537359833717346*x_50) + 0.299250551819451*std::exp(0.541919827461243*x_50) - 0.852100045299585*std::exp(0.543199837207794*x_50) - 33.7514934015525*std::exp(0.546079874038696*x_50) - 0.595214594469999*std::exp(0.599439859390259*x_50) + 0.635827483829473*std::exp(0.610719859600067*x_50) + 0.00248729440239312*std::exp(0.658079862594604*x_50) - 0.00156118463081022*std::exp(0.463519841432571*x_51) + 0.0454553046719516*std::exp(0.48039984703064*x_51) - 2.05693622249408*std::exp(0.491039842367172*x_51) - 4.4415803367798*std::exp(0.493919849395752*x_51) + 29.3899070180679*std::exp(0.49415984749794*x_51) - 14.7960931576003*std::exp(0.496719866991043*x_51) + 101.614927490402*std::exp(0.497119843959808*x_51) + 0.135995271152781*std::exp(0.499279826879501*x_51) + 9.14731002785343*std::exp(0.501199841499329*x_51) - 4.84788726709698*std::exp(0.510319828987122*x_51) - 0.347735430098626*std::exp(0.504639863967896*x_52) + 0.0769428872872862*std::exp(0.546399831771851*x_52) - 0.00683159488401493*std::exp(0.600159823894501*x_52) + 0.00976435264626896*std::exp(0.641199827194214*x_52) + 0.152202219918468*std::exp(0.673519849777222*x_52) - 0.328877885178474*std::exp(0.712159812450409*x_52) - 0.000255767504255896*std::exp(0.714239835739136*x_52) - 0.0218937533816364*std::exp(0.88375985622406*x_52) - 3.75552151665491*std::exp(0.474319845438004*x_54) + 0.0518499461952321*std::exp(0.502159833908081*x_54) + 0.0133578433594923*std::exp(0.506399810314178*x_54) - 1.63282060659519*std::exp(0.519279837608337*x_54) + 2.33038172820351*std::exp(0.532479882240295*x_54) - 0.00372859427756363*std::exp(0.532879829406738*x_54) - 3.89483773546853*std::exp(0.542559862136841*x_54) - 1.38885390273488*std::exp(0.612959861755371*x_55) - 0.0144259115022284*std::exp(0.631199836730957*x_55) - 0.132068670435976*std::exp(0.650959849357605*x_55) - 1.17329292286776*std::exp(0.652479827404022*x_55) - 8.03986210059197*std::exp(0.653439819812775*x_55) - 0.037555529595332*std::exp(0.655679821968079*x_55) - 256.777348623588*std::exp(0.655759811401367*x_55) + 6.04121789490354*std::exp(0.656879842281342*x_55) + 2.10027749201416*std::exp(0.657759845256805*x_55) - 11.405379794192*std::exp(0.659119844436646*x_55) - 8.68855046228227*std::exp(0.347199827432632*x_56) - 53.3715669112766*std::exp(0.442879855632782*x_56) - 1.33614891444293*std::exp(0.466319859027863*x_56) + 0.324025169949139*std::exp(0.52183985710144*x_56) + 2.70119575681421*std::exp(0.525679886341095*x_56) - 1.59761689740642*std::exp(0.574079871177673*x_56) + 0.55365650777371*std::exp(0.655039846897125*x_56) + 0.00272205435256764*std::exp(0.658559858798981*x_56) + 0.000995774800617599*std::exp(0.754159867763519*x_56) + 0.000823854973206774*std::exp(0.859519898891449*x_56) - 1.30810069066424*std::exp(0.599999845027924*x_57) - 0.563238433349262*std::exp(0.609679877758026*x_57) - 0.0439734640624481*std::exp(0.617039859294891*x_57) + 0.0055896916535501*std::exp(0.626319825649261*x_57) + 7.69054355527903*std::exp(0.628239870071411*x_57) + 2.56872340535342*std::exp(0.632079839706421*x_57) + 111.435454689106*std::exp(0.634159862995148*x_57) + 0.034157662387061*std::exp(0.637119889259338*x_57) - 3.45035071641105*std::exp(0.641199827194214*x_57) - 0.675881486677826*std::exp(0.671519815921783*x_57) + 0.427940407485232*std::exp(0.37679985165596*x_58) + 0.027284368524808*std::exp(0.451519846916199*x_58) - 0.114343311275858*std::exp(0.558799862861633*x_58) - 0.580168419924549*std::exp(0.595039844512939*x_58) + 0.0066207772792108*std::exp(0.603839874267578*x_58) + 0.00202988054468974*std::exp(0.653759837150574*x_58) + 17.9593857280968*std::exp(0.512399852275848*x_59) + 0.184616249799115*std::exp(0.545279860496521*x_59) + 0.831646657144621*std::exp(0.696399867534637*x_59) + 0.103638913952661*std::exp(0.807599902153015*x_59) - 0.0205422846425187*std::exp(0.839199841022491*x_59) + 0.0327294209969423*std::exp(0.866959869861603*x_59) - 0.000786033347528228*std::exp(0.778479874134064*x_60) - 0.51725963571342*std::exp(0.780239880084991*x_60) + 10.4896237775869*std::exp(0.821839869022369*x_60) - 0.00249994753490857*std::exp(0.842239856719971*x_60) - 0.00396653250753961*std::exp(0.845599889755249*x_60) - 0.10623008915081*std::exp(0.847439885139465*x_60) - 0.0428318448636137*std::exp(0.850079894065857*x_60) - 0.16656535898551*std::exp(0.897759795188904*x_60) - 0.0389345511550614*std::exp(0.979119837284088*x_60) + 0.00800505840610405*std::exp(1.01919984817505*x_61) + 0.200667073073467*std::exp(1.04719984531403*x_61) + 0.520896044006976*std::exp(1.3343198299408*x_61) + 0.0374777300768443*std::exp(1.36879980564117*x_61) - 0.0269328930519871*std::exp(0.578399837017059*x_66) + 10.4854741938611*std::exp(0.930159866809845*x_66) + 0.0644845795779279*std::exp(1.03991973400116*x_66) - 9.69133408567553e-5*std::exp(1.46671986579895*x_66) + 7.58356262911201e-7*std::exp(1.60799980163574*x_7) + 0.000137228805855745*std::exp(1.8828798532486*x_7) + 0.253814295383118*std::exp(0.481679856777191*x_8) - 0.00157930561039448*std::exp(0.549919843673706*x_8) + 0.508320324972433*std::exp(0.583999812602997*x_8) + 0.0924227606377725*std::exp(0.832639873027802*x_8) + 0.0283043130382802*std::exp(0.863359868526459*x_8) + 0.00433708446077723*std::exp(1.34103989601135*x_8) - 10.1574352895227*std::log(9.5269603729248 - 1.42447984218597*x_5) + 2.57884042670484*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 1.86253460902049*std::sin(0.233039990067482*x_108 - 1.19815993309021) + 10.1284329499397*std::sin(0.302159935235977*x_112 - 7.45056009292603) - 0.0252981975728645*std::sin(0.28263995051384*x_113 - 7.4191198348999) + 13.027153894092*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 1.10476428728158*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 1.16146342349828*std::sin(0.291599929332733*x_114 + 8.11127948760986) + 11.3647784729263*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0538033099469554*std::sin(0.248479977250099*x_117 + 1.95407974720001) - 0.0240227307915702*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 3.09217801905354*std::sin(0.262239962816238*x_120 + 8.34039974212646) - 22.2744734698349*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 192.593222520445*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 0.190303098090942*std::sin(0.270879954099655*x_120 - 7.44527959823608) - 0.167117182282001*std::sin(0.121840052306652*x_18 - 4.63351964950562) - 11.7725931605366*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 1.41516335494218*std::sin(0.436799854040146*x_22 - 7.42592000961304) + 0.0298926135295901*std::sin(0.197599992156029*x_3 - 7.60056018829346) + 0.946463628398466*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.322708111035856*std::sin(0.2743199467659*x_31 - 4.31576013565063) - 105.265927603095*std::sin(0.0759200975298882*x_32 - 4.65767955780029) - 102.279751538083*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 0.289797273255224*std::sin(0.19080001115799*x_35 - 4.59863996505737) - 21.5050786127921*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 1.28533012417582*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 4.35273170302626*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.0114804339609707*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0179321501456308*std::sin(0.603359878063202*x_64 - 7.20143985748291) + 6.27514988390649*std::sin(0.550959885120392*x_65 - 7.2239203453064) + 0.00955363227680408*std::sin(0.592319846153259*x_65 - 7.19871997833252) + 4.2549840263064*std::sin(0.613759815692902*x_65 - 0.975039839744568) - 4.1379421316327*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 3.22327347734038*std::sin(0.234399989247322*x_9 + 5.00383996963501) - 0.0165557833659268*std::sin(0.296639919281006*x_9 - 1.20775985717773) + 11.6325010630266*std::sin(0.296639919281006*x_9 + 1.96359980106354) - 9.13162488763*std::sin(0.363919854164124*x_9 + 2.01831984519958) - 10.2021117895458*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 128.420574145275*std::sin(0.364159852266312*x_91 - 7.4061598777771) - 6.44402528790164*std::sin(0.383279830217361*x_91 - 1.19735991954803) + 9.29536491496323*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 1.66014069620662*std::sin(0.394399851560593*x_91 - 4.39671945571899) + 14.6082878791388*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 2.29757229418881*std::sin(0.306479930877686*x_92 + 8.20936012268066) - 8.58877115986393*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 2.59411575975439*std::sin(0.235599994659424*x_93 + 1.97719979286194) + 4.87830787306678*std::sin(0.319199919700623*x_94 + 1.95127987861633) - 0.0224290256087245*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 2.9534679947456*std::sin(0.304399937391281*x_97 + 1.95511984825134) - 5.39423911141893*std::sin(0.334719836711884*x_97 + 1.83487987518311) + 13.3310970407334*std::sin(0.232959985733032*x_98 - 4.22215986251831) + 0.0212141755780183*std::sin(0.259039968252182*x_98 + 1.97311985492706) - 11.038493038337*std::sin(0.265759944915771*x_98 + 1.95295977592468) + 560.850502796105);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.054993647590452*x_1 + 9.9365650862152*x_100 + 2.67247220773658*x_101 - 4.21824222730609*x_102 - 0.507165441744054*x_103 - 95.2176859770652*x_104 + 12.378118953067*x_105 - 1.63578397896461*x_106 + 3.06963468155589*x_107 + 5.83205458555897*x_108 - 2.18826622717303*x_109 - 1.25550962253222*x_110 + 1.24588209803116*x_111 + 1.30279610508366*x_112 - 0.860063669179662*x_113 - 15.1738381713088*x_114 + 2.48010572446643*x_115 - 14.0333980388523*x_116 - 0.235484033646568*x_117 + 12.2335161545994*x_118 + 7.32151334009846*x_119 - 2.49451413590246*x_12 - 2.13153084542664*x_120 + 12.4670907567849*x_13 + 4.80030576416999*x_14 - 0.0559494208298036*x_15 + 0.967675361833494*x_16 + 2.30393908676543*x_17 - 16.4475533237801*x_18 + 0.0609583363935617*x_19 - 0.811821003512157*x_2 - 0.307240959017645*x_20 - 4.00309147664115*x_21 + 0.0955680318573287*x_22 - 0.0623534981340568*x_23 - 1.21044974762244*x_24 - 0.0463862469348276*x_25 - 0.206130974003458*x_26 - 6.23792353312898*x_27 - 1.69264404224351*x_28 + 1.52824469973044*x_29 + 1.5472303241945*x_3 - 0.207668750938715*x_30 - 2.37380149961064*x_31 - 9.26503954438497*x_32 - 9.39264062714705*x_33 - 16.138636903333*x_34 + 157.832786068446*x_35 - 24.18052418404*x_36 + 28.8263872225708*x_37 - 110.882678995226*x_38 + 19.0302834987933*x_39 + 4.47389931609597*x_4 + 1011.68228364344*x_40 - 3.586664860881*x_42 - 19.9113683901083*x_43 - 2.02153338863284*x_44 + 47.4078643956299*x_45 + 31.7334567645465*x_46 - 54.9826003699694*x_47 + 36.7107251109054*x_48 - 7.83070480295075*x_5 + 0.212515462299803*x_50 - 1.96648447055482*x_52 + 1.20237088909518*x_53 - 3.96179260392266*x_54 - 19.9682142481992*x_58 - 0.0434562063783801*x_59 - 8.03758929390761*x_6 + 0.437110614257806*x_60 - 0.510708629715721*x_61 - 4.39349968634379*x_62 - 0.763111029820861*x_63 + 2.29852897491198*x_64 - 0.304973713086958*x_65 + 1.8718103936063*x_66 - 1.6216408013499*x_67 - 4.55347517655957*x_68 - 8.39038656156138*x_69 - 14.7760757667679*x_7 + 4.88940204035065*x_70 + 1.98152691709529*x_71 - 4.29128945669678*x_72 - 2.24590513962296*x_73 - 1.14152181657503*x_74 + 5.85606258643612*x_75 - 4.95404524322793*x_76 + 1.88206580391702*x_77 + 8.06295080307512*x_78 + 1.84936010179222*x_79 + 1.33334996791724*x_8 + 0.212704441331848*x_80 - 1.93766344902744*x_81 - 0.534040313433343*x_82 - 13.1699881162206*x_83 - 6.17952491572774*x_84 - 4.55377073791443*x_85 + 29.3440172457196*x_86 - 4.32696708281958*x_87 - 3.73717205883426*x_88 + 0.841923408058271*x_89 - 0.925576642929305*x_9 - 3.92540491886782*x_90 - 2.9567251874991*x_91 - 3.40313800042106*x_92 + 11.0927939969752*x_93 + 2.39491100070785*x_94 - 2.99165743713368*x_95 - 0.520463829381356*x_96 + 4.43732490198218*x_97 + 4.0555840010414*x_98 + 15.3564378442054*x_99 + 0.000379262638941266*std::pow(-4.89872026443481*x_1 - 7.54640007019043, 2) - 0.0100417408187827*std::pow(-9.59712028503418*x_2 - 7.16400003433228, 2) - 3.48655450534672e-5*std::pow(-5.17639970779419*x_20 - 9.55575942993164, 2) - 0.0120760445808928*std::pow(-5.41527986526489*x_3 - 8.63191986083984, 2) + 0.0045630358321026*std::pow(-6.25864028930664*x_66 - 9.08967971801758, 2) - 0.0129158231323754*std::exp(1.10983991622925*x_1) + 0.364861347681906*std::exp(1.242959856987*x_1) - 1.60960289275775*std::exp(1.24823987483978*x_1) + 0.0005396880889929*std::exp(1.43383979797363*x_1) - 0.00201149657566653*std::exp(1.77823996543884*x_1) + 0.0110616186527028*std::exp(0.619279801845551*x_10) + 0.00262267772053728*std::exp(0.783999860286713*x_10) + 1.17847502099603*std::exp(0.794399857521057*x_10) - 0.0117828758778682*std::exp(0.803679883480072*x_10) + 0.0174589936995122*std::exp(0.826399862766266*x_10) + 1.18103955174745*std::exp(0.846799850463867*x_10) + 0.233777480974886*std::exp(0.947519838809967*x_10) - 0.00481522002004213*std::exp(0.968719840049744*x_10) + 0.00657424820485535*std::exp(0.975119829177856*x_10) - 0.0074955416537265*std::exp(1.1814398765564*x_10) - 0.397375970680355*std::exp(0.822239875793457*x_11) - 0.0120365096240355*std::exp(0.89359986782074*x_11) - 0.00150383996789159*std::exp(0.906559824943542*x_11) + 1.36421285533957*std::exp(0.921199858188629*x_11) - 0.0385677647863859*std::exp(0.932559847831726*x_11) + 0.041928219250638*std::exp(0.940079808235168*x_11) + 0.259464211815596*std::exp(0.943679809570313*x_11) - 0.00157586443553168*std::exp(0.948239862918854*x_11) - 0.455148395768243*std::exp(0.976479828357697*x_11) + 0.00370202600662535*std::exp(1.0525598526001*x_11) - 0.0090440076074893*std::exp(0.547999858856201*x_12) - 0.036077804436586*std::exp(0.748719871044159*x_12) - 0.0120175287728886*std::exp(0.869919836521149*x_12) + 0.00475518342514235*std::exp(0.872399866580963*x_12) - 0.0205188194857105*std::exp(1.18807995319366*x_12) + 5.81402903288493e-5*std::exp(1.12631988525391*x_13) - 5.30522872524135e-5*std::exp(1.31047987937927*x_13) - 0.000227999367201836*std::exp(1.34023988246918*x_13) - 11.6928578637965*std::exp(0.269759833812714*x_14) + 0.00459689663322263*std::exp(0.473199844360352*x_14) + 0.0410838386691636*std::exp(0.679999828338623*x_14) + 0.0017590017627664*std::exp(0.895599842071533*x_14) - 0.0860076188505789*std::exp(0.71207982301712*x_15) + 0.65472505737606*std::exp(0.832959890365601*x_15) + 0.26439690732258*std::exp(0.923279821872711*x_15) + 0.00609196294604369*std::exp(0.930639863014221*x_15) + 0.382909237186569*std::exp(0.947279810905457*x_15) + 0.000501853220762671*std::exp(0.964959800243378*x_15) - 0.0110165559694064*std::exp(1.01871979236603*x_15) - 0.000166349888094044*std::exp(1.03775978088379*x_15) + 4.24604564763663*std::exp(0.382159829139709*x_16) + 0.0660834865513593*std::exp(0.548479855060577*x_16) + 3.72748020437325*std::exp(0.570239841938019*x_16) + 0.00278191826512241*std::exp(0.715919852256775*x_16) - 0.0245110816269662*std::exp(0.887839913368225*x_16) + 0.0372057921137681*std::exp(0.618079841136932*x_17) - 2.39652189187413*std::exp(0.642879843711853*x_17) - 0.499012867386864*std::exp(0.658879816532135*x_17) + 5.06050085218651*std::exp(0.666479825973511*x_17) + 0.0469833939724294*std::exp(0.713679850101471*x_17) - 0.061852710696086*std::exp(0.826239883899689*x_17) + 4.58882340566892*std::exp(0.442959845066071*x_18) - 0.0029022458982132*std::exp(0.693519830703735*x_19) - 0.0127882872210346*std::exp(0.705919861793518*x_19) + 3.59477809138925*std::exp(0.7219198346138*x_19) + 4.2457753033456*std::exp(0.723199844360352*x_19) - 0.042516364408235*std::exp(0.725599884986877*x_19) + 4.94950738696528*std::exp(0.73967981338501*x_19) + 0.237650143002178*std::exp(0.765519857406616*x_19) - 3.09508974888447*std::exp(0.819519877433777*x_19) + 0.00708928325399203*std::exp(1.02399981021881*x_19) - 0.0491343565237791*std::exp(0.747839868068695*x_2) - 5.31867144831305*std::exp(0.754719853401184*x_2) + 0.105524633109953*std::exp(0.769999861717224*x_2) - 1.96945328969391*std::exp(0.827439904212952*x_2) + 0.00128034670677996*std::exp(1.00447976589203*x_2) - 0.0459134760403812*std::exp(1.09567987918854*x_2) + 0.0699002087110218*std::exp(0.44583985209465*x_20) - 1.14159734702069*std::exp(0.488959848880768*x_20) - 1.4779141305467*std::exp(0.627359867095947*x_20) - 0.427682987448893*std::exp(0.851519882678986*x_20) + 0.256769645506745*std::exp(0.915279805660248*x_20) - 0.00551779774752088*std::exp(1.0039998292923*x_20) - 0.0216626413130286*std::exp(0.855839908123016*x_21) + 0.072704234981203*std::exp(0.53279983997345*x_22) + 0.626498542563418*std::exp(0.742159843444824*x_22) - 3.32420980199631e-5*std::exp(1.19607996940613*x_22) + 0.014033683702187*std::exp(1.36079978942871*x_22) + 0.00258610841169685*std::exp(1.40143978595734*x_22) + 0.296508592986791*std::exp(0.62527984380722*x_23) + 0.0147833978589752*std::exp(0.664479851722717*x_23) - 0.00661745613701761*std::exp(0.685359835624695*x_23) - 0.107055940674926*std::exp(0.735519826412201*x_23) + 2.44837089581087*std::exp(0.743439853191376*x_23) + 0.618754545489684*std::exp(0.744559824466705*x_23) + 0.0569088348168935*std::exp(0.782239854335785*x_23) + 1.29239731958264*std::exp(0.818959891796112*x_23) + 0.222399845915011*std::exp(0.834479868412018*x_23) - 6.50568940269692*std::exp(0.368799835443497*x_24) - 0.787020383089201*std::exp(0.424879848957062*x_24) + 2.87657552118475*std::exp(0.609519839286804*x_24) - 0.0787657922795064*std::exp(0.61167985200882*x_24) + 0.00203192475186765*std::exp(0.653759837150574*x_24) - 1.04292275470814*std::exp(0.761439859867096*x_24) - 0.00406022639235357*std::exp(0.780959844589233*x_24) - 0.00857030182221332*std::exp(0.418559849262238*x_25) + 0.221425862691691*std::exp(0.545919835567474*x_25) + 3.02896999684859*std::exp(0.627679824829102*x_25) - 0.10882646764892*std::exp(0.643359839916229*x_25) - 0.47939214561704*std::exp(0.765359818935394*x_25) - 0.611218496621165*std::exp(0.878879845142365*x_25) - 0.284489006837569*std::exp(0.964159786701202*x_25) + 0.00255763011440209*std::exp(1.00615978240967*x_25) + 0.0122913780432759*std::exp(0.429119855165482*x_26) + 1.74579444657008*std::exp(0.569839835166931*x_26) - 0.590630195762982*std::exp(0.698879837989807*x_26) + 0.0161855811028749*std::exp(0.736239850521088*x_26) - 0.0754189060693535*std::exp(0.79943984746933*x_26) - 0.00352136273976522*std::exp(0.822479903697968*x_26) - 0.000594397591578053*std::exp(0.984079837799072*x_26) - 0.0809514908322282*std::exp(1.10487985610962*x_26) + 0.00014108391219438*std::exp(1.14151990413666*x_27) - 0.0609049956905245*std::exp(1.18543982505798*x_27) + 0.0689671702380295*std::exp(1.24655985832214*x_27) - 0.00124586541464739*std::exp(1.2630398273468*x_27) - 0.0117386268145567*std::exp(1.27247989177704*x_27) - 0.161551791268802*std::exp(0.549759864807129*x_28) + 2.2853081763558*std::exp(0.565279841423035*x_28) + 0.0105953744708081*std::exp(0.650239825248718*x_28) + 0.0026809704325043*std::exp(0.667519807815552*x_28) + 0.852206228592558*std::exp(0.768079876899719*x_28) - 0.285824779958146*std::exp(0.905439794063568*x_28) + 0.000954623246515988*std::exp(1.13103985786438*x_29) + 0.0235726553418928*std::exp(1.1431999206543*x_29) - 0.00556295942512233*std::exp(1.1509598493576*x_29) + 0.111391686557557*std::exp(1.16863989830017*x_29) - 0.115813737383858*std::exp(1.17591977119446*x_29) - 5.52517175108467*std::exp(0.575039863586426*x_3) + 0.165860303910737*std::exp(0.670239865779877*x_3) - 0.0117209150805064*std::exp(0.670399844646454*x_3) - 0.00125198098098536*std::exp(0.915599822998047*x_3) - 0.0239286206298768*std::exp(0.947999835014343*x_3) + 0.0324876946941019*std::exp(0.739759802818298*x_30) + 1.04456127098932*std::exp(0.847439885139465*x_30) - 0.0607608297749316*std::exp(0.853279888629913*x_30) - 0.907947563057222*std::exp(0.882479906082153*x_30) + 0.744102419389108*std::exp(0.916479825973511*x_30) - 1.32111209738305*std::exp(0.9440798163414*x_30) + 0.000938914509201873*std::exp(1.00999975204468*x_30) + 0.000366194599513549*std::exp(1.03159987926483*x_30) - 0.0023027633276445*std::exp(1.09999978542328*x_30) - 0.971694849457043*std::exp(0.787999868392944*x_32) + 0.00279588033272966*std::exp(0.823919892311096*x_32) + 0.699812836474999*std::exp(0.357519835233688*x_33) - 4.49871333695602*std::exp(0.36575984954834*x_33) + 0.0514753755830564*std::exp(0.395519852638245*x_33) - 0.39126321894249*std::exp(0.41407984495163*x_33) - 13.3908340045441*std::exp(0.379279851913452*x_34) - 0.452420359209934*std::exp(0.408159852027893*x_34) - 0.191345906934154*std::exp(0.431119859218597*x_36) - 0.539191399797193*std::exp(0.250399857759476*x_37) + 2.28445101328545*std::exp(0.375039845705032*x_38) + 0.0863303614487428*std::exp(0.385999858379364*x_4) + 0.0169664335960862*std::exp(0.527999818325043*x_4) + 2.91358342442094*std::exp(0.554479837417603*x_4) + 0.0545106250358327*std::exp(0.638399839401245*x_4) + 3.60369854885833*std::exp(0.723759829998016*x_4) - 0.00742886791179938*std::exp(1.10615980625153*x_4) - 0.00021211647133214*std::exp(1.13591980934143*x_4) - 1.03084813904864*std::exp(0.685679852962494*x_41) - 0.591101010037298*std::exp(0.7497598528862*x_41) - 0.0298779841493467*std::exp(0.769599854946136*x_41) + 0.0397038661333464*std::exp(0.797759890556335*x_41) + 0.00395889498029317*std::exp(0.798159837722778*x_41) - 0.00516859003096728*std::exp(0.798719823360443*x_41) - 0.0308664089250501*std::exp(0.803759872913361*x_41) + 0.149300459575702*std::exp(0.805199861526489*x_41) - 0.553843436216375*std::exp(0.812879860401154*x_41) + 0.0810500035079449*std::exp(0.866879880428314*x_41) - 0.0258145859838616*std::exp(0.19999985396862*x_42) - 0.14312236281499*std::exp(0.596879839897156*x_42) - 0.43888475240138*std::exp(0.690479874610901*x_42) + 0.983956375582871*std::exp(0.718159854412079*x_42) + 0.00448754216478793*std::exp(0.841359853744507*x_42) - 0.0210069618032095*std::exp(0.705839812755585*x_43) - 0.0155039449135182*std::exp(0.787679851055145*x_43) - 0.000571471629195876*std::exp(0.83271986246109*x_43) + 0.0287594343122819*std::exp(0.886719882488251*x_44) + 0.000204705118602963*std::exp(0.908799827098846*x_44) - 0.00263361371040019*std::exp(0.942639827728271*x_44) + 1.63570071953282*std::exp(0.515199840068817*x_45) - 1.14190674433706*std::exp(0.504559814929962*x_46) + 0.000770291914991528*std::exp(0.663999855518341*x_46) + 0.915439260833515*std::exp(0.700479865074158*x_46) - 0.0886287776039492*std::exp(0.75791984796524*x_46) + 0.0178771881704114*std::exp(0.759199857711792*x_46) + 0.176393379756111*std::exp(0.801999866962433*x_46) - 0.0172454055095003*std::exp(0.802399873733521*x_46) + 0.0815318358353528*std::exp(0.424159854650497*x_47) + 0.233271469045536*std::exp(0.552239894866943*x_47) - 0.00632772017869703*std::exp(0.608879864215851*x_48) - 1.24114480269505*std::exp(0.608959853649139*x_48) - 0.0012506642188641*std::exp(0.639919817447662*x_49) - 0.0293500870375369*std::exp(0.685839831829071*x_49) - 5.3896484117419*std::exp(0.703679859638214*x_49) + 0.014998395844414*std::exp(0.705999851226807*x_49) - 0.908999514165037*std::exp(0.708399832248688*x_49) + 0.140408400178186*std::exp(0.708639860153198*x_49) + 0.41828622708319*std::exp(0.715839862823486*x_49) - 3.3541436930828*std::exp(0.719119846820831*x_49) + 3.29232733867262*std::exp(0.719919860363007*x_49) - 4.74432655753709*std::exp(0.720319867134094*x_49) - 0.000606565347049154*std::exp(1.93999981880188*x_5) + 1.53751105835686*std::exp(0.52215987443924*x_50) + 0.126039196027627*std::exp(0.537359833717346*x_50) - 0.356755311214569*std::exp(0.541919827461243*x_50) + 1.41165333871368*std::exp(0.543199837207794*x_50) - 4.59701965166621*std::exp(0.546079874038696*x_50) + 0.10195248800938*std::exp(0.599439859390259*x_50) - 1.16651052590977*std::exp(0.610719859600067*x_50) + 0.000712613759087299*std::exp(0.658079862594604*x_50) + 0.0341728597380732*std::exp(0.463519841432571*x_51) + 0.0704235183153766*std::exp(0.48039984703064*x_51) - 1.02855632610571*std::exp(0.491039842367172*x_51) + 5.29508589273515*std::exp(0.493919849395752*x_51) - 53.9197137022161*std::exp(0.49415984749794*x_51) + 2.53437755769269*std::exp(0.496719866991043*x_51) + 13.8401525828344*std::exp(0.497119843959808*x_51) + 0.0389628591215568*std::exp(0.499279826879501*x_51) - 22.2332849110148*std::exp(0.501199841499329*x_51) + 8.03137646108084*std::exp(0.510319828987122*x_51) - 0.173882628215549*std::exp(0.504639863967896*x_52) - 0.091728431353018*std::exp(0.546399831771851*x_52) - 0.0105841320591681*std::exp(0.600159823894501*x_52) + 0.0027975023936117*std::exp(0.641199827194214*x_52) - 0.252149701308841*std::exp(0.673519849777222*x_52) + 0.603370449621089*std::exp(0.712159812450409*x_52) + 0.00559850953948845*std::exp(0.714239835739136*x_52) + 0.0532145576375138*std::exp(0.88375985622406*x_52) + 9.12810209941349*std::exp(0.474319845438004*x_54) + 0.0148550911508941*std::exp(0.502159833908081*x_54) + 0.02069519351526*std::exp(0.506399810314178*x_54) - 0.816480329308844*std::exp(0.519279837608337*x_54) - 4.27539684029492*std::exp(0.532479882240295*x_54) + 0.0816154135473635*std::exp(0.532879829406738*x_54) + 0.667134847184683*std::exp(0.542559862136841*x_54) + 2.54803816710385*std::exp(0.612959861755371*x_55) - 0.022349942437413*std::exp(0.631199836730957*x_55) - 0.0378378818391952*std::exp(0.650959849357605*x_55) - 0.586696779896961*std::exp(0.652479827404022*x_55) + 13.3194432270074*std::exp(0.653439819812775*x_55) + 0.822055136799734*std::exp(0.655679821968079*x_55) - 34.9735789075064*std::exp(0.655759811401367*x_55) - 1.03478174210537*std::exp(0.656879842281342*x_55) - 2.50387224265684*std::exp(0.657759845256805*x_55) + 27.7217080989336*std::exp(0.659119844436646*x_55) + 21.1182322784989*std::exp(0.347199827432632*x_56) - 7.26931217568201*std::exp(0.442879855632782*x_56) - 0.668131760013048*std::exp(0.466319859027863*x_56) - 0.386290683989458*std::exp(0.52183985710144*x_56) - 4.95570475168648*std::exp(0.525679886341095*x_56) + 2.64673290378273*std::exp(0.574079871177673*x_56) - 0.0948341304036345*std::exp(0.655039846897125*x_56) - 0.0595832035199001*std::exp(0.658559858798981*x_56) + 0.00154274545986171*std::exp(0.754159867763519*x_56) + 0.000236035745842866*std::exp(0.859519898891449*x_56) + 1.55946869992565*std::exp(0.599999845027924*x_57) - 0.281643372017055*std::exp(0.609679877758026*x_57) - 0.0125984666292345*std::exp(0.617039859294891*x_57) - 0.12235308053008*std::exp(0.626319825649261*x_57) - 18.6924948935192*std::exp(0.628239870071411*x_57) - 0.439988778193356*std::exp(0.632079839706421*x_57) + 15.1777276638852*std::exp(0.634159862995148*x_57) + 0.0529201768657369*std::exp(0.637119889259338*x_57) + 6.33012968318503*std::exp(0.641199827194214*x_57) + 1.11971635549916*std::exp(0.671519815921783*x_57) - 0.510174542120125*std::exp(0.37679985165596*x_58) + 0.00781701450382375*std::exp(0.451519846916199*x_58) - 0.0571765594258706*std::exp(0.558799862861633*x_58) + 0.0993752747753901*std::exp(0.595039844512939*x_58) + 0.0102575141306277*std::exp(0.603839874267578*x_58) - 0.0444321714227524*std::exp(0.653759837150574*x_58) + 2.44610358841534*std::exp(0.512399852275848*x_59) - 0.220092585466935*std::exp(0.545279860496521*x_59) - 2.02138519600701*std::exp(0.696399867534637*x_59) - 0.19013944362943*std::exp(0.807599902153015*x_59) - 0.0102720233085825*std::exp(0.839199841022491*x_59) - 0.054222032588034*std::exp(0.866959869861603*x_59) + 0.0172055289325965*std::exp(0.778479874134064*x_60) + 1.25724183598956*std::exp(0.780239880084991*x_60) + 1.4287073484557*std::exp(0.821839869022369*x_60) - 0.00387314752992405*std::exp(0.842239856719971*x_60) - 0.00113641780322434*std::exp(0.845599889755249*x_60) - 0.0531196004153959*std::exp(0.847439885139465*x_60) + 0.0510625228635566*std::exp(0.850079894065857*x_60) + 0.0285304710645905*std::exp(0.897759795188904*x_60) + 0.0714306394407643*std::exp(0.979119837284088*x_60) + 0.00229346182623121*std::exp(1.01919984817505*x_61) - 0.368150573696313*std::exp(1.04719984531403*x_61) - 1.26608042366148*std::exp(1.3343198299408*x_61) + 0.0187404723282477*std::exp(1.36879980564117*x_61) - 0.00771631622794899*std::exp(0.578399837017059*x_66) + 1.42814216700708*std::exp(0.930159866809845*x_66) - 0.0768761030380461*std::exp(1.03991973400116*x_66) + 0.00212134166484026*std::exp(1.46671986579895*x_66) - 1.65997036433189e-5*std::exp(1.60799980163574*x_7) - 2.35055025759363e-5*std::exp(1.8828798532486*x_7) - 0.302587906319861*std::exp(0.481679856777191*x_8) + 0.0345695108973457*std::exp(0.549919843673706*x_8) - 0.0870686342676502*std::exp(0.583999812602997*x_8) - 0.169561910831957*std::exp(0.832639873027802*x_8) + 0.0141533703929332*std::exp(0.863359868526459*x_8) - 0.0105416383839592*std::exp(1.34103989601135*x_8) + 1.7398360342344*std::log(9.5269603729248 - 1.42447984218597*x_5) + 1.28953081087183*std::sin(0.289279937744141*x_103 - 7.47775983810425) + 0.931347182158134*std::sin(0.233039990067482*x_108 - 1.19815993309021) - 18.5819643654232*std::sin(0.302159935235977*x_112 - 7.45056009292603) + 0.553753694612596*std::sin(0.28263995051384*x_113 - 7.4191198348999) - 21.5817677630405*std::sin(0.305919915437698*x_113 - 1.22279989719391) - 0.552429523148431*std::sin(0.32423985004425*x_113 - 7.54616022109985) - 0.580781522886032*std::sin(0.291599929332733*x_114 + 8.11127948760986) - 27.6230232680145*std::sin(0.239199981093407*x_117 - 7.43759965896606) - 0.0833570121424206*std::sin(0.248479977250099*x_117 + 1.95407974720001) + 0.525834929235613*std::sin(0.272479951381683*x_117 + 1.92951989173889) + 1.54622162231465*std::sin(0.262239962816238*x_120 + 8.34039974212646) + 54.1399289397317*std::sin(0.264879941940308*x_120 + 5.15752029418945) - 26.2315749460581*std::sin(0.270639955997467*x_120 + 5.14951992034912) + 0.0545221369718305*std::sin(0.270879954099655*x_120 - 7.44527959823608) + 3.65803756790829*std::sin(0.121840052306652*x_18 - 4.63351964950562) + 28.6142502093696*std::sin(0.408319860696793*x_21 - 7.41095972061157) - 0.707642368917911*std::sin(0.436799854040146*x_22 - 7.42592000961304) - 0.654321128450366*std::sin(0.197599992156029*x_3 - 7.60056018829346) - 1.12833852519104*std::sin(0.563679814338684*x_3 - 0.974079847335815) - 0.161367895349274*std::sin(0.2743199467659*x_31 - 4.31576013565063) + 18.0306788870107*std::sin(0.0759200975298882*x_32 - 4.65767955780029) + 169.44436693555*std::sin(0.121680058538914*x_33 + 7.96871995925903) - 0.0830273746722383*std::sin(0.19080001115799*x_35 - 4.59863996505737) + 3.68353916349067*std::sin(0.202879995107651*x_47 + 8.19711971282959) - 0.642720185437876*std::sin(0.441279858350754*x_5 - 7.41847991943359) + 2.17655252507541*std::sin(0.217119991779327*x_53 + 1.98423981666565) + 0.0177865390443147*std::sin(0.551839888095856*x_6 - 4.35479974746704) + 0.0277821282538704*std::sin(0.603359878063202*x_64 - 7.20143985748291) - 15.2522648520042*std::sin(0.550959885120392*x_65 - 7.2239203453064) - 0.209120003708287*std::sin(0.592319846153259*x_65 - 7.19871997833252) - 7.80633706547284*std::sin(0.613759815692902*x_65 - 0.975039839744568) + 10.0576066710041*std::sin(0.515199840068817*x_72 + 2.14071989059448) - 1.61177497368748*std::sin(0.234399989247322*x_9 + 5.00383996963501) + 0.36239048966561*std::sin(0.296639919281006*x_9 - 1.20775985717773) - 28.2737449123766*std::sin(0.296639919281006*x_9 + 1.96359980106354) + 1.5641281069246*std::sin(0.363919854164124*x_9 + 2.01831984519958) + 16.9015894895054*std::sin(0.357359826564789*x_91 - 7.3996000289917) - 17.4911342736891*std::sin(0.364159852266312*x_91 - 7.4061598777771) + 1.10377738886248*std::sin(0.383279830217361*x_91 - 1.19735991954803) - 22.5931444191715*std::sin(0.388719856739044*x_91 - 4.3930401802063) - 0.830141545778423*std::sin(0.394399851560593*x_91 - 4.39671945571899) - 24.201193828392*std::sin(0.299439936876297*x_92 - 1.17271983623505) - 1.14888468199938*std::sin(0.306479930877686*x_92 + 8.20936012268066) + 15.7572489667631*std::sin(0.310879945755005*x_92 + 8.21879959106445) - 1.29716913250265*std::sin(0.235599994659424*x_93 + 1.97719979286194) - 8.0817735361894*std::sin(0.319199919700623*x_94 + 1.95127987861633) + 0.490950225272726*std::sin(0.299599945545197*x_97 - 7.45336008071899) + 1.47686066136894*std::sin(0.304399937391281*x_97 + 1.95511984825134) + 0.923962724429443*std::sin(0.334719836711884*x_97 + 1.83487987518311) - 32.4023213141893*std::sin(0.232959985733032*x_98 - 4.22215986251831) - 0.46435830341876*std::sin(0.259039968252182*x_98 + 1.97311985492706) + 18.2872018818608*std::sin(0.265759944915771*x_98 + 1.95295977592468) + 222.825395841551);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
