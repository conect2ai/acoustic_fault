
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000959927113937036*x_1 + 0.00209343922168368*x_10 - 0.00102720937412112*x_100 - 0.00135553118205527*x_101 - 2.22013238702254e-5*x_102 - 0.000101286325936015*x_103 + 0.000100400109612061*x_104 + 0.000278720733155689*x_105 - 5.60710823066928e-5*x_106 + 5.65765098365587e-5*x_107 - 0.000258983211838712*x_108 + 2.59539917059261e-5*x_109 - 0.000681920791191813*x_11 - 0.000304727330064359*x_110 - 0.000119558591037166*x_111 + 1.81498869130083e-5*x_112 + 0.00086047445399658*x_113 - 0.000291920398572137*x_114 - 0.000218918173157119*x_115 - 0.000599378021838899*x_116 + 0.00026268551869115*x_117 - 3.25384017030469e-5*x_118 - 9.2512230269205e-5*x_119 - 2.27912268445005e-5*x_12 - 0.000188897757075358*x_120 + 0.000558651313461546*x_13 - 0.000881723249718624*x_15 + 0.00119882503542497*x_16 + 0.000476272457455428*x_18 + 0.000272045898758409*x_19 + 0.00331391662054647*x_2 - 0.000311594563001344*x_20 - 0.000103396682412817*x_21 + 0.000117361597272825*x_22 - 8.92274698310696e-5*x_23 + 0.000292265872302623*x_24 + 0.000687973875704538*x_25 - 0.000853144503330031*x_26 - 0.000362533498109102*x_27 - 0.000379817356030519*x_28 - 0.00229138567092302*x_29 + 0.000197944089822535*x_3 + 0.000568986670073036*x_30 - 0.00415377854795029*x_31 + 0.000758709617330224*x_32 - 0.00158468595709974*x_33 - 0.000351681569969294*x_34 - 4.94025180709468e-5*x_35 - 0.000182258704054471*x_36 + 0.000122001093385826*x_37 - 2.46033170532809e-5*x_38 - 0.000769153499683144*x_39 + 0.00400927818227208*x_4 - 0.00177507337286801*x_40 + 0.000123124431737699*x_41 - 0.000942298328552597*x_42 - 0.000367961129637505*x_43 - 0.000241000351010388*x_44 + 0.00085384815331248*x_45 - 0.000186812931333276*x_46 + 0.000969648733785205*x_47 + 4.6287778159981e-5*x_48 + 0.000131143303684342*x_49 + 0.000211787596917459*x_5 - 0.000591275544791537*x_50 + 0.000919813009534975*x_51 - 0.000852220963721164*x_52 + 1.16516911855774e-5*x_53 + 0.000264998013088424*x_54 - 6.39724452634909e-5*x_55 - 0.00014847711136506*x_56 + 9.21974782235009e-5*x_57 - 0.000150594610652105*x_58 - 0.000221653133822943*x_59 - 0.000115618873176888*x_6 + 0.000728653509092029*x_60 + 0.000754524104564998*x_61 + 0.00076214504996134*x_62 - 0.00026330210465062*x_63 + 0.00114397349009473*x_64 + 0.000142167359124265*x_65 + 0.000220318842174343*x_66 + 1.434427207104e-5*x_67 - 0.000166461178925639*x_68 - 0.000235159765082178*x_69 + 1.38173928631176e-5*x_7 + 7.92463051723215e-5*x_70 - 2.36605959758629e-5*x_71 - 0.000617377126172551*x_72 - 7.88107862369789e-6*x_73 + 9.41634455311678e-5*x_74 - 0.000143273520414077*x_75 + 5.42130501554213e-5*x_76 + 0.000167428692746301*x_77 + 6.28669739167149e-5*x_78 + 0.000410196721704348*x_79 + 0.000440410488177014*x_8 + 0.000213658445852584*x_80 - 0.000294028215690032*x_81 - 4.78013603047677e-5*x_82 + 0.000714692862439281*x_83 + 0.00010211951400295*x_84 + 0.000127020552241391*x_85 - 0.000372382043783635*x_86 - 0.000343305301322091*x_87 + 0.000697035723787323*x_88 - 0.000351097974216635*x_89 - 0.000408767715357132*x_9 + 0.000271990170543959*x_90 - 0.00707029488269573*x_91 + 0.000222816033898181*x_92 + 0.000187319011450598*x_93 + 0.000354980540921936*x_94 - 0.000456804516521541*x_95 + 3.92513963615887e-5*x_96 + 0.00177676092004503*x_97 - 0.000208220045839615*x_98 - 2.16834301254667e-5*x_99 - 9.68695134883274e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 1.54322465304067e-8*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 6.55823705108657e-5*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 0.000204223333448498*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) + 6.85630637116762e-6*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 1.0253402699507e-8*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 3.1242909038579e-5*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 1.19927632742781e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) + 1.19750271246834e-5*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) + 2.8248454900499e-5*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 2.15793228025292e-8*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 5.84125406675237e-6*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 9.3459258931095e-9*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) + 1.09618990939522e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 4.09478187363256e-5*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 6.7775182636256e-7*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 3.83835225102854e-6*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) + 1.27476224913528e-5*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 4.91194712823846e-5*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 0.00012283611971908*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 8.49568475222726e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) - 3.48174462603031e-6*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 4.01078554375379e-6*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 4.97396343796133e-5*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) - 1.98739412536834e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) + 4.93790491310087e-5*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) - 2.0222342385482e-6*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 1.10205719144402e-5*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 6.46920914379339e-6*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 2.24627143766553e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 5.20635953446184e-9*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) - 4.36697560272493e-6*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 1.4734337117134e-5*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 1.89626869521579e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) - 2.92217778350524e-6*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) + 3.36411951156024e-6*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.173573344819272*std::sin(0.295599937438965*x_1 + 1.98367977142334) - 0.00552903684646625*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 1.30281011839743e-5*std::sin(0.192640006542206*x_10 - 1.22311997413635) - 0.00425536895392981*std::sin(0.307519912719727*x_10 - 7.46888017654419) + 0.000915265093910192*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 0.00106654182191407*std::sin(0.411279857158661*x_103 + 2.01903986930847) - 0.00128612275215795*std::sin(0.39055985212326*x_105 + 1.97119987010956) - 0.000600176329011871*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 0.00236076720898598*std::sin(0.308559864759445*x_106 - 1.27239990234375) + 0.000778711993361881*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 0.00248640061950152*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 8.88297825676615e-6*std::sin(0.270079970359802*x_11 + 8.2992000579834) - 0.00149988135411225*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 0.000702800323285402*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 0.00574738792474959*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.0175846904742648*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 6.58494893806641e-6*std::sin(0.361279845237732*x_112 + 5.17248010635376) + 0.00137722446259141*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 0.000546737267699999*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 4.74957358603099e-6*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 2.39426655437922e-6*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 0.00401264988396633*std::sin(0.448079854249954*x_115 + 2.03823971748352) + 0.000249415532349671*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 2.07393474071764e-6*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.00158524156211668*std::sin(0.409199863672256*x_117 - 7.38831996917725) + 0.00163431585558424*std::sin(0.412159860134125*x_117 + 5.203200340271) + 0.00132503801865648*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 0.00519469637119217*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.00290847111071122*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 2.55108312383942e-6*std::sin(0.392399847507477*x_119 - 1.17687976360321) - 0.0103049813034157*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.00586293271419376*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 1.31507861192949e-5*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.0160023318293173*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 0.00620437569507019*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 4.23256377965179e-6*std::sin(0.42495983839035*x_120 + 5.21432018280029) - 0.00332491387748137*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 4.43333322187787e-5*std::sin(0.169520005583763*x_14 - 4.45079946517944) - 0.00209522203869739*std::sin(0.346159845590591*x_14 + 2.1276798248291) - 0.0329258572332971*std::sin(0.146160036325455*x_15 - 4.48871994018555) - 0.00593268863578229*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 3.50061465323198e-5*std::sin(0.154080033302307*x_19 - 4.46744012832642) - 0.00470026252980608*std::sin(0.23063999414444*x_19 - 4.34007978439331) - 0.00106841702197485*std::sin(0.32167986035347*x_21 + 8.33103942871094) - 0.006481669708968*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 5.99979494801852e-6*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 0.00545161533477904*std::sin(0.355359852313995*x_21 + 5.16544008255005) + 0.0257734598381125*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.0185038883090584*std::sin(0.232959985733032*x_23 + 5.04463958740234) - 0.0129016376089708*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 9.9031903397168e-7*std::sin(0.462799847126007*x_24 - 0.902719795703888) + 0.00508011008203443*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.0389394220995411*std::sin(0.227439984679222*x_27 + 5.01991987228394) + 0.0201945915890312*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 6.24107227754224e-6*std::sin(0.283199936151505*x_27 + 5.1101598739624) + 0.00834058546625422*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 1.01067876444958e-5*std::sin(0.329759836196899*x_28 - 4.26440000534058) + 0.00197695122775838*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 0.000808492642012573*std::sin(0.355279833078384*x_28 + 8.35503959655762) + 0.0122762303227251*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.0330715324262531*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 1.02309796617215e-5*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.00198052297578323*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.0130704422490888*std::sin(0.246079966425896*x_32 + 5.16936016082764) + 0.0032371241103532*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.0183313689286097*std::sin(0.333039849996567*x_34 - 7.41599988937378) + 0.000758175740090971*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.0130309326680565*std::sin(0.302479922771454*x_35 + 8.27551937103271) - 0.00243543805543242*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.0152159673647588*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.00266901978883953*std::sin(0.362639844417572*x_36 - 4.23672008514404) - 0.00110746543993365*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 2.14675018363215e-6*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 4.05680647208609e-6*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 0.00634885385327326*std::sin(0.393119841814041*x_37 - 7.40255975723267) - 0.000577481483338729*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.00187061013457673*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 0.00286133694544922*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 5.48919123210809e-6*std::sin(0.366399854421616*x_38 + 5.16160011291504) - 0.000768253151889674*std::sin(0.448799848556519*x_38 + 5.24264001846313) - 0.0017657163114288*std::sin(0.282239943742752*x_40 + 5.09631967544556) - 0.00291848469463164*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.0111161369611482*std::sin(0.367999851703644*x_41 + 5.17600011825562) - 0.00286160358110914*std::sin(0.353599846363068*x_43 + 5.16128015518188) - 0.00143996887516594*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 5.77436182593428e-6*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 0.00477877437775998*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 2.60587511094059e-6*std::sin(0.373519837856293*x_47 - 7.40975952148438) - 0.00130839906218089*std::sin(0.391199827194214*x_47 + 5.17775964736938) - 0.00195849905432225*std::sin(0.454959839582443*x_47 - 1.14519989490509) + 0.000612170746943512*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.0113131050627181*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 6.19998411740043e-6*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 4.04781955347329e-6*std::sin(0.353759855031967*x_51 + 5.1625599861145) - 0.00255391431449583*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 3.20867363618672e-6*std::sin(0.30583992600441*x_53 - 4.24975967407227) + 0.00431253875796341*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 0.00513007390572348*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 7.24026294960786e-6*std::sin(0.309359937906265*x_55 + 5.14407968521118) + 0.000622173031604563*std::sin(0.345439851284027*x_55 - 7.45807981491089) - 0.00214085906669342*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.0161574583179834*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.00344869938759738*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 3.01294848574915e-6*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 6.80732952463243e-7*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.00203081516389907*std::sin(0.416479855775833*x_59 - 7.39607954025269) + 0.000360733442411723*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 2.0086353560798e-6*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 6.9951272787009e-6*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.0142814461181688*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 2.83312013845407e-6*std::sin(0.305919915437698*x_65 + 5.13711977005005) - 0.00499990185728031*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.00234541553129843*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 0.0049927965462237*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 6.11385220330158e-6*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.0113491509016173*std::sin(0.245439976453781*x_70 + 5.05655956268311) + 0.00335842729204585*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 1.70615134843093e-6*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.00475540640941167*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 2.4077495786231e-6*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 0.00246594878292481*std::sin(0.373519837856293*x_74 - 7.43503999710083) + 0.000926271709644176*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 2.16306163277292e-6*std::sin(0.290879935026169*x_75 + 5.09583950042725) + 0.00179295127527007*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 1.05147807825259e-5*std::sin(0.185440018773079*x_77 - 7.62768030166626) + 0.00868418293175066*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.0165688187877095*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 3.83209025589715e-7*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 0.00034710753410029*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.012468674585685*std::sin(0.198319986462593*x_8 - 1.20415985584259) - 0.00586809674338027*std::sin(0.286399960517883*x_8 + 8.31287956237793) + 0.00188139491609699*std::sin(0.238159984350204*x_80 + 1.82535994052887) - 0.000118300484966226*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 2.20601727116225e-6*std::sin(0.399199843406677*x_81 + 5.2050404548645) + 0.00327434951753416*std::sin(0.166720017790794*x_84 - 4.44655990600586) + 0.00174319959196623*std::sin(0.307439923286438*x_84 - 7.48952007293701) + 0.00143176044341756*std::sin(0.254959970712662*x_87 - 7.5402398109436) - 0.00199421691211206*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 6.39261062011223e-5*std::sin(0.202799990773201*x_9 - 4.39831972122192) - 0.0205104877208566*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.0424935060254184*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 0.00510643465733399*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.0105163614352938*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 9.40391785529494e-6*std::sin(0.357679843902588*x_92 + 2.0079197883606) + 0.00413368326647118*std::sin(0.361359834671021*x_92 - 7.41015958786011) - 0.0186835401358537*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.00216142160422889*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 3.7492655033693e-6*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 0.00559924999198962*std::sin(0.379039853811264*x_93 - 7.41239976882935) + 0.000489420158429257*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 7.48061985432887e-7*std::sin(0.412159860134125*x_94 - 4.2065601348877) - 0.000224528416723144*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 4.74104547395956e-6*std::sin(0.381519854068756*x_95 - 7.40271997451782) - 0.00108018461463728*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 0.000638798842969422*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 2.44166537190604e-6*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 0.00695431658132848*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.00200383218388311*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.00122401146563261*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 0.0039077823388909*std::sin(0.300399929285049*x_99 - 1.07527995109558) + 0.00217122794850624*std::sin(0.396959841251373*x_99 - 7.4041600227356) - 0.000988284280879151*std::sin(0.402559846639633*x_99 + 1.9916797876358) - 0.0905903868126021);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00285449914892868*x_1 - 0.00281629758229795*x_10 + 0.000243915867110988*x_100 - 0.00287247028863973*x_101 + 0.000708505219213238*x_102 - 0.000969017457686243*x_103 + 0.00169056739664068*x_104 + 0.000900256513545703*x_105 + 8.11924734638071e-5*x_106 + 0.000688504472848295*x_107 - 0.00169830647860112*x_108 + 0.0015188136321862*x_109 - 0.000291822433676577*x_11 - 0.000478014986528698*x_110 - 0.000518034939453119*x_111 + 5.98935159861234e-5*x_112 + 0.000513285203283136*x_113 - 0.000233486135285106*x_114 - 0.000579455156542121*x_115 + 5.28724769407683e-5*x_116 + 0.000777898104849828*x_117 + 6.75308745317038e-5*x_118 + 0.000289422233176647*x_119 - 7.52096536963051e-5*x_12 - 0.00112732971743301*x_120 + 0.000863335318854878*x_13 - 0.00100952689624592*x_15 + 0.000832928283115103*x_16 + 0.000115510143810284*x_18 - 0.000999091760594555*x_19 + 0.00853103910285164*x_2 + 0.00236477622821752*x_20 - 0.00027800643812174*x_21 + 0.000259176837844913*x_22 + 0.000290102252182718*x_23 + 0.00277636209468899*x_24 - 0.000597768512157418*x_25 - 4.36238489927636e-6*x_26 + 3.92349115660125e-5*x_27 - 0.000179256039844202*x_28 - 0.00422036762774926*x_29 + 0.000582941658765835*x_3 - 0.00102908520416332*x_30 - 0.00282025422944869*x_31 + 0.00230500896820765*x_32 + 0.00132795621888167*x_33 - 0.00259326873331997*x_34 + 0.00015839666891162*x_35 - 0.00125791994124587*x_36 + 0.000389301819756844*x_37 - 8.11894404799959e-5*x_38 - 0.00011763444321196*x_39 + 0.00838045937448831*x_4 + 0.000392385291545428*x_40 + 0.000435469310012426*x_41 - 0.00153755795417273*x_42 + 0.00046527485896076*x_43 - 0.000737344107193929*x_44 - 0.000314118290577366*x_45 - 0.000482548207721638*x_46 + 0.00035345740143698*x_47 - 0.00102876453669602*x_48 + 0.000574748900371493*x_49 + 0.000451073698730179*x_5 - 0.00202425147625706*x_50 + 0.000841595670500589*x_51 - 0.00113207518235426*x_52 - 0.000256199196774146*x_53 + 0.000872305672677099*x_54 - 0.00017200505113534*x_55 - 0.000697294633325635*x_56 + 0.000115405581039557*x_57 + 0.000670902602497314*x_58 - 0.00130044212891388*x_59 - 9.75566739753153e-5*x_6 + 0.00148815775284176*x_60 + 7.25638762460844e-5*x_61 + 0.00154179438120982*x_62 + 0.000777480637295716*x_63 + 0.00163772420388625*x_64 + 0.000432141212284258*x_65 + 0.00119374070596393*x_66 + 0.000105307824655636*x_67 - 0.00099684929626478*x_68 - 0.00104600095144098*x_69 + 3.7151329079084e-5*x_7 + 0.000690240788070106*x_70 + 0.000107384896548242*x_71 - 0.000227584602118015*x_72 - 0.00086433568001769*x_73 + 0.000689856858826803*x_74 + 0.000231078510926342*x_75 + 0.00139658370521364*x_76 + 0.000471282451109282*x_77 + 0.00097269770897741*x_78 + 0.000112986712731155*x_79 - 0.000466807738247473*x_8 - 0.000466029124907414*x_80 + 0.00113247607503301*x_81 - 0.000133778291311206*x_82 + 0.00034721888050912*x_83 + 0.000343575807437396*x_84 + 0.000203436590287071*x_85 - 0.000341585242372598*x_86 + 0.00028646582929288*x_87 - 0.000945609884863596*x_88 - 0.000135612926104273*x_89 + 0.000394441472665471*x_9 + 0.000618484819907127*x_90 + 0.0125142010226022*x_91 + 0.000599093612047728*x_92 + 0.00100067293772908*x_93 - 0.000135952600040605*x_94 + 4.94373206949389e-5*x_95 + 0.00032717164231802*x_96 + 0.00405077460395441*x_97 - 0.000101857323343794*x_98 + 4.89645457758383e-5*x_99 + 1.04836292783443e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 1.50915715531341e-5*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) - 7.0976020718199e-6*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 0.00054910273897074*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) + 4.73211117807863e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 1.00270534298307e-5*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) - 3.38124002219711e-6*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 3.22453808315419e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) + 3.95168566043483e-5*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) + 0.000194966242699182*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 2.11029478761162e-5*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 1.57055932489054e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 9.13960965231119e-6*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) + 7.56572452094602e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) - 4.43154647865768e-6*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 0.000662790097518507*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 1.03203179508662e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) + 4.2066374029234e-5*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 0.00013206931726415*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) - 1.32938454499447e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) + 9.19439008215578e-7*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) - 2.40304352987181e-5*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) + 4.34064209073623e-7*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) - 5.3830340268932e-6*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) - 0.000137166711152987*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) + 0.000162947839988357*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) - 6.67324922048771e-6*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) + 1.19269299726839e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) + 7.00125229758458e-7*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 6.03963209328839e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 5.09142640320445e-6*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) - 3.01401555667824e-5*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) + 1.59461240627367e-6*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 5.09856693055129e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) - 9.64300783963711e-6*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) + 1.11013884940767e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) - 0.0187848429723635*std::sin(0.295599937438965*x_1 + 1.98367977142334) - 0.0381605133271136*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 0.0127404989825702*std::sin(0.192640006542206*x_10 - 1.22311997413635) - 0.0140424571067922*std::sin(0.307519912719727*x_10 - 7.46888017654419) + 0.00302031879297064*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 0.00286764996805592*std::sin(0.411279857158661*x_103 + 2.01903986930847) - 0.00887661011978879*std::sin(0.39055985212326*x_105 + 1.97119987010956) - 0.00198054515317128*std::sin(0.465279847383499*x_105 - 1.15903985500336) + 0.000255492232181624*std::sin(0.308559864759445*x_106 - 1.27239990234375) + 0.00537454356442959*std::sin(0.468879848718643*x_106 + 5.25511980056763) - 0.000269088812296353*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 0.00868688182908312*std::sin(0.270079970359802*x_11 + 8.2992000579834) - 0.0103519372346507*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 0.00188964490956591*std::sin(0.480879843235016*x_110 + 5.24336004257202) + 0.000622006678387705*std::sin(0.469759851694107*x_111 + 2.02207970619202) - 0.00190308972625159*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 0.00643958271900058*std::sin(0.361279845237732*x_112 + 5.17248010635376) + 0.00950537931262587*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 0.00147003246946391*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 0.00464472424538007*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 0.00234141185805289*std::sin(0.400079846382141*x_115 + 8.3942403793335) - 0.000434265975872414*std::sin(0.448079854249954*x_115 + 2.03823971748352) + 0.000823055991785048*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 0.00202815153804091*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.00426229691284537*std::sin(0.409199863672256*x_117 - 7.38831996917725) + 0.00539314229845994*std::sin(0.412159860134125*x_117 + 5.203200340271) + 0.00914519696177998*std::sin(0.33231982588768*x_118 + 1.94903981685638) + 0.000562192056179797*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.0078201125510056*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 0.00249476661907636*std::sin(0.392399847507477*x_119 - 1.17687976360321) - 0.0711233054299473*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.0157638814204196*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 0.0128604755832702*std::sin(0.282159954309464*x_12 - 4.30015993118286) - 0.00173184016773066*std::sin(0.285359919071198*x_12 - 4.28639984130859) - 0.0006714638315854*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 0.00413912770301858*std::sin(0.42495983839035*x_120 + 5.21432018280029) - 0.0109720123011172*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 0.0433546505397184*std::sin(0.169520005583763*x_14 - 4.45079946517944) - 0.0144608818409439*std::sin(0.346159845590591*x_14 + 2.1276798248291) - 0.108653313709955*std::sin(0.146160036325455*x_15 - 4.48871994018555) - 0.0195775093999759*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 0.0342333673941171*std::sin(0.154080033302307*x_19 - 4.46744012832642) - 0.0155105786783802*std::sin(0.23063999414444*x_19 - 4.34007978439331) - 0.00352571078223266*std::sin(0.32167986035347*x_21 + 8.33103942871094) - 0.0447354304518889*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 0.00586734631174712*std::sin(0.340719848871231*x_21 + 5.15775966644287) - 0.00058999691523017*std::sin(0.355359852313995*x_21 + 5.16544008255005) + 0.177884229197481*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.0497520806292927*std::sin(0.232959985733032*x_23 + 5.04463958740234) - 0.0425746144911921*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 0.000968457219249749*std::sin(0.462799847126007*x_24 - 0.902719795703888) + 0.0167640523529391*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.104697847046884*std::sin(0.227439984679222*x_27 + 5.01991987228394) + 0.139379787631796*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 0.00610329731703219*std::sin(0.283199936151505*x_27 + 5.1101598739624) + 0.0275234215701197*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 0.00988367497944709*std::sin(0.329759836196899*x_28 - 4.26440000534058) + 0.0136445959339453*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 0.00217382370892868*std::sin(0.355279833078384*x_28 + 8.35503959655762) + 0.0847285456483215*std::sin(0.314559936523438*x_3 - 4.25967979431152) - 0.0035791413948348*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 0.0100051253924247*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.00532510449336733*std::sin(0.286239951848984*x_30 + 8.28415966033936) + 0.00141453865214227*std::sin(0.246079966425896*x_32 + 5.16936016082764) + 0.0223421042732977*std::sin(0.265119940042496*x_32 + 1.95223987102509) + 0.00198389843297047*std::sin(0.333039849996567*x_34 - 7.41599988937378) + 0.00250193353970066*std::sin(0.415279865264893*x_34 + 8.18767929077148) - 0.00141026275784313*std::sin(0.302479922771454*x_35 + 8.27551937103271) - 0.0168089974714289*std::sin(0.355519831180573*x_35 - 1.22207987308502) + 0.00164673647279894*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.00717629103232947*std::sin(0.362639844417572*x_36 - 4.23672008514404) - 0.00365456817161796*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 0.0020993595416684*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 0.00396725033066792*std::sin(0.318879842758179*x_37 - 4.25999975204468) + 0.000687099870158067*std::sin(0.393119841814041*x_37 - 7.40255975723267) - 0.00190565355144164*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.00502957782099635*std::sin(0.348319828510284*x_38 + 1.94791972637177) + 0.000309666010453685*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 0.00536801444203033*std::sin(0.366399854421616*x_38 + 5.16160011291504) - 0.00530235834113136*std::sin(0.448799848556519*x_38 + 5.24264001846313) - 0.0121866868869295*std::sin(0.282239943742752*x_40 + 5.09631967544556) - 0.0201429068347858*std::sin(0.343279838562012*x_41 + 5.15711975097656) + 0.00120303545162351*std::sin(0.367999851703644*x_41 + 5.17600011825562) - 0.00944311667905046*std::sin(0.353599846363068*x_43 + 5.16128015518188) - 0.00993843104636179*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 0.00564688974467004*std::sin(0.342479854822159*x_45 + 5.15463972091675) - 0.00051717921539188*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 0.00254834904417865*std::sin(0.373519837856293*x_47 - 7.40975952148438) - 0.00431763682730137*std::sin(0.391199827194214*x_47 + 5.17775964736938) - 0.0135172420330985*std::sin(0.454959839582443*x_47 - 1.14519989490509) + 0.00202012599825181*std::sin(0.485199838876724*x_48 + 2.04519987106323) + 0.00122435217431735*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 0.00606311619968514*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 0.00395846180302095*std::sin(0.353759855031967*x_51 + 5.1625599861145) - 0.00842776093072042*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 0.00313784047421453*std::sin(0.30583992600441*x_53 - 4.24975967407227) + 0.0297644413153326*std::sin(0.262479960918427*x_54 - 7.52544021606445) + 0.000555198339099676*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 0.00708043032828826*std::sin(0.309359937906265*x_55 + 5.14407968521118) + 0.00205313292546385*std::sin(0.345439851284027*x_55 - 7.45807981491089) - 0.0147758611878741*std::sin(0.406399875879288*x_55 - 7.39015960693359) + 0.00174862861375318*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.00927264405902958*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 0.00294643605964945*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 0.000665705413689016*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.0054603269372327*std::sin(0.416479855775833*x_59 - 7.39607954025269) + 0.00119039828200422*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 0.00196429367174154*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 0.00684070615653992*std::sin(0.287999957799911*x_62 - 4.27383995056152) + 0.00154559862303399*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 0.00277057751791748*std::sin(0.305919915437698*x_65 + 5.13711977005005) - 0.0164993701202313*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.00630620444056781*std::sin(0.26063996553421*x_68 + 5.08111953735352) + 0.000540341601479339*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 0.00597888569299448*std::sin(0.254239976406097*x_7 + 8.28104019165039) - 0.00122825320776366*std::sin(0.245439976453781*x_70 + 5.05655956268311) + 0.0231793191101932*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 0.00166848715801607*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.012786034975702*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 0.00235459723742901*std::sin(0.353759855031967*x_74 + 5.15727996826172) + 0.00026687542786806*std::sin(0.373519837856293*x_74 - 7.43503999710083) + 0.00305663995125532*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 0.0021153109069708*std::sin(0.290879935026169*x_75 + 5.09583950042725) + 0.0123746581791253*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 0.0102826614538815*std::sin(0.185440018773079*x_77 - 7.62768030166626) + 0.0599368186005064*std::sin(0.19463999569416*x_77 + 4.99911975860596) - 0.00179314778711409*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 0.000374749484341057*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 0.000933280710256912*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.0335249809643375*std::sin(0.198319986462593*x_8 - 1.20415985584259) - 0.0405006496065719*std::sin(0.286399960517883*x_8 + 8.31287956237793) + 0.0129850818077237*std::sin(0.238159984350204*x_80 + 1.82535994052887) - 0.000390384360048688*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 0.00215731827699861*std::sin(0.399199843406677*x_81 + 5.2050404548645) + 0.0108051530079799*std::sin(0.166720017790794*x_84 - 4.44655990600586) + 0.0120312801502782*std::sin(0.307439923286438*x_84 - 7.48952007293701) + 0.00988177778507472*std::sin(0.254959970712662*x_87 - 7.5402398109436) - 0.0137637608800609*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 0.0625149037080646*std::sin(0.202799990773201*x_9 - 4.39831972122192) - 0.0676833541762657*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.114253842364742*std::sin(0.210319995880127*x_9 - 4.38711977005005) + 0.000552639999456894*std::sin(0.374799847602844*x_90 + 8.36688041687012) - 0.00113812520239386*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 0.0091963214113609*std::sin(0.357679843902588*x_92 + 2.0079197883606) + 0.013640901785703*std::sin(0.361359834671021*x_92 - 7.41015958786011) - 0.128950756189586*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.00581149324571138*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 0.00366649849095588*std::sin(0.350799858570099*x_93 + 1.98431980609894) + 0.000605974563502531*std::sin(0.379039853811264*x_93 - 7.41239976882935) + 0.00161505656885414*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 0.000731548122763333*std::sin(0.412159860134125*x_94 - 4.2065601348877) - 0.000740930033382653*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 0.00463638439587821*std::sin(0.381519854068756*x_95 - 7.40271997451782) - 0.00745525857888867*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 0.001717561790824*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 0.0023877643216965*std::sin(0.323839843273163*x_96 + 5.14455986022949) + 0.000752625612511989*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.00538777681290476*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.00329104435306825*std::sin(0.392319828271866*x_98 + 2.00223970413208) + 0.000422916765720415*std::sin(0.300399929285049*x_99 - 1.07527995109558) + 0.0149854622723538*std::sin(0.396959841251373*x_99 - 7.4041600227356) - 0.00326127764097782*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.444964648234517);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00820725768462225*x_1 + 0.00223080909292877*x_10 + 0.00101935223015152*x_100 - 0.00299736776274046*x_101 - 0.000787634494554661*x_102 - 0.000143893948191493*x_103 - 0.000687289495601362*x_104 - 0.00162413947109122*x_105 - 0.000422987746467088*x_106 + 0.000380206619364588*x_107 + 0.000788935334538571*x_108 - 0.000417899655500685*x_109 + 0.00238900579279261*x_11 + 0.00132675381525982*x_110 + 0.000108499744175089*x_111 - 0.000202956126366698*x_112 + 0.000224662447424112*x_113 + 0.00153896888996792*x_114 + 0.00101132379396261*x_115 + 0.000433147344122304*x_116 + 0.00032902963884651*x_117 - 0.000437288609147576*x_118 + 6.64960857666854e-5*x_119 + 0.000254856635618445*x_12 - 0.000547795316244644*x_120 - 0.00120721698141921*x_13 + 0.00162253943752312*x_15 - 0.00017966511027628*x_16 - 0.000643697910302779*x_18 - 0.000120734163011807*x_19 - 0.011104432408967*x_2 - 0.000999158064167528*x_20 + 0.000470661883752201*x_21 + 7.73446715903847e-5*x_22 - 0.000700387880368938*x_23 - 4.89419669376454e-5*x_24 + 0.00228278686367373*x_25 + 0.000873406089615518*x_26 - 0.000169533463354609*x_27 + 0.00057562864956838*x_28 + 0.0105053138073583*x_29 - 0.00145126757938199*x_3 + 0.000634637160907658*x_30 - 0.00570646632198685*x_31 - 0.00419245720924524*x_32 - 0.00417926050100146*x_33 - 0.00193889773122858*x_34 - 0.000495270244283204*x_35 - 0.000411941465426924*x_36 - 0.000456276251950291*x_37 + 0.000275119836770266*x_38 - 0.000222269411388195*x_39 - 0.00149635155972587*x_4 - 0.000695949114221899*x_40 - 0.000497608458158881*x_41 + 0.000513784763665462*x_42 - 0.000302575259340182*x_43 + 0.00165081690016847*x_44 - 0.00212655198831215*x_45 + 0.000729706291124466*x_46 - 0.000369231716527978*x_47 - 1.63266762858214e-5*x_48 - 0.0020696306879019*x_49 + 0.0010866262572584*x_5 - 0.00108406887601524*x_50 - 0.00103613991489369*x_51 + 0.0025602596408008*x_52 + 9.64220333731221e-5*x_53 - 0.0019395217508075*x_54 + 0.000291202685553641*x_55 - 0.000250895295105911*x_56 - 0.000481592436954953*x_57 + 0.00109902991808365*x_58 - 0.000757133743872276*x_59 - 0.00165823527924619*x_6 - 6.73494536991271e-5*x_60 - 0.000410952482681274*x_61 - 0.00311449798170096*x_62 - 0.00094034685949146*x_63 + 0.000300835110588895*x_64 - 0.000546565550823229*x_65 + 7.56935191631662e-5*x_66 - 0.000396969129822531*x_67 - 0.000679458302818142*x_68 - 0.00230437801427126*x_69 - 6.28967970900102e-5*x_7 - 0.00100601807075224*x_70 - 0.00017059488831497*x_71 + 0.00234009855203333*x_72 + 0.000928179199565932*x_73 + 0.000361946014448317*x_74 - 0.000453883065999896*x_75 + 0.00105105032103175*x_76 - 0.000991142343195514*x_77 + 0.000835890513475942*x_78 + 0.000376538620287298*x_79 + 0.000814601157713237*x_8 + 0.000918288365743681*x_80 + 0.000671258778131449*x_81 + 0.000639950680527297*x_82 + 0.00100347472730931*x_83 - 0.000630338645895927*x_84 + 0.000949144013440554*x_85 + 0.000190646571705746*x_86 - 0.000973040150251422*x_87 - 0.00206996107863068*x_88 + 0.00023701533405676*x_89 - 0.000101602648102483*x_9 - 0.000621867970827934*x_90 - 0.0346664763534229*x_91 - 0.0010142589858542*x_92 - 0.000667020190028535*x_93 + 0.000191684509106909*x_94 - 0.00021361791990493*x_95 + 0.000298698849799254*x_96 - 0.00253315761581811*x_97 + 4.11513692670286e-5*x_98 - 0.000113551498650985*x_99 - 4.52996045904973e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) - 2.98509761384406e-5*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 3.06686319076815e-5*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) - 0.000929624980067147*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) + 1.54966365453286e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) + 1.98334104317046e-5*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 1.46102873312669e-5*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) - 5.45910799297197e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) - 0.000133907452427154*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) + 6.38472108540844e-5*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) + 4.17414178028317e-5*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) - 2.65893989862878e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) + 1.80780556011176e-5*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) + 2.4776104933102e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 1.91486457483078e-5*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) + 0.00131099212008248*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) - 1.74721863295457e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) - 0.000142546787956881*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) - 0.000223591921357561*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 5.7442506443225e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 3.97288213951632e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) - 7.86944574707713e-6*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 1.87558492539784e-6*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 2.32600091477066e-5*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) - 4.49191193711338e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) - 0.000552167657205492*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) + 2.26130790582334e-5*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 5.15360852044987e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 3.02523059809093e-6*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) - 1.02250316122268e-5*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) + 1.00707900126624e-5*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) - 9.87024646423742e-6*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 6.89029624774244e-6*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) + 8.63181850097697e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) + 3.26764506212975e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) - 3.76183426361486e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.0811690242328978*std::sin(0.295599937438965*x_1 + 1.98367977142334) - 0.0124967394712302*std::sin(0.320239931344986*x_1 + 1.96527981758118) - 0.0252005783348355*std::sin(0.192640006542206*x_10 - 1.22311997413635) + 0.0475844947844668*std::sin(0.307519912719727*x_10 - 7.46888017654419) - 0.0102347005768686*std::sin(0.335919857025146*x_102 + 8.33936023712158) - 0.00485490028585633*std::sin(0.411279857158661*x_103 + 2.01903986930847) - 0.00290689706146771*std::sin(0.39055985212326*x_105 + 1.97119987010956) + 0.00671130698814062*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 0.0011039780963715*std::sin(0.308559864759445*x_106 - 1.27239990234375) + 0.00176004631084803*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 0.00116272871475253*std::sin(0.505839824676514*x_107 + 5.26151990890503) + 0.0171825645383871*std::sin(0.270079970359802*x_11 + 8.2992000579834) - 0.00339003465532631*std::sin(0.393039852380753*x_110 + 1.99663984775543) + 0.00319914833184396*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 0.00268768151138415*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.00822322211235703*std::sin(0.353599846363068*x_112 + 5.17000007629395) - 0.0127374295917167*std::sin(0.361279845237732*x_112 + 5.17248010635376) + 0.00311280531859899*std::sin(0.403839856386185*x_112 - 1.17599976062775) - 0.00248874902296976*std::sin(0.411519855260849*x_112 + 1.99287974834442) + 0.00918721765525361*std::sin(0.359839856624603*x_114 - 4.23712015151978) + 0.00463128901181162*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 0.00187645675670378*std::sin(0.448079854249954*x_115 + 2.03823971748352) - 0.00278902069990843*std::sin(0.530159831047058*x_115 - 1.03967976570129) + 0.00401166326210923*std::sin(0.356719851493835*x_117 + 2.14879989624023) - 0.0072160224333816*std::sin(0.409199863672256*x_117 - 7.38831996917725) - 0.0182752882648169*std::sin(0.412159860134125*x_117 + 5.203200340271) + 0.00299485341994205*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 0.00242922342756528*std::sin(0.396319836378098*x_118 + 2.00671982765198) + 0.0132393657113752*std::sin(0.35471984744072*x_119 - 7.4332799911499) - 0.00493462318055012*std::sin(0.392399847507477*x_119 - 1.17687976360321) - 0.0232913381083706*std::sin(0.24679996073246*x_12 + 5.06799983978271) + 0.0266880802283148*std::sin(0.258559972047806*x_12 - 4.33599996566772) - 0.0254378908395045*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.00748325534308947*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 0.00290138512723549*std::sin(0.383039832115173*x_120 - 7.41440010070801) + 0.00818715279994194*std::sin(0.42495983839035*x_120 + 5.21432018280029) + 0.0371799363990996*std::sin(0.169440016150475*x_14 - 4.44503974914551) - 0.0857550609752634*std::sin(0.169520005583763*x_14 - 4.45079946517944) - 0.00473562478946321*std::sin(0.346159845590591*x_14 + 2.1276798248291) + 0.368184356927506*std::sin(0.146160036325455*x_15 - 4.48871994018555) + 0.0663406615274901*std::sin(0.359359860420227*x_16 - 4.23943996429443) - 0.0677132550193581*std::sin(0.154080033302307*x_19 - 4.46744012832642) + 0.052559395026989*std::sin(0.23063999414444*x_19 - 4.34007978439331) + 0.0119472799562649*std::sin(0.32167986035347*x_21 + 8.33103942871094) - 0.0146498820573617*std::sin(0.327519834041595*x_21 - 4.26376008987427) + 0.0116055517565735*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 0.00254936780574148*std::sin(0.355359852313995*x_21 + 5.16544008255005) + 0.0582532223627628*std::sin(0.18104000389576*x_23 + 4.96823978424072) + 0.0842297327636712*std::sin(0.232959985733032*x_23 + 5.04463958740234) + 0.144269019716422*std::sin(0.250639975070953*x_24 + 5.05199956893921) - 0.00191559860026116*std::sin(0.462799847126007*x_24 - 0.902719795703888) - 0.0568069359719899*std::sin(0.329199850559235*x_26 - 4.25816011428833) + 0.177252319222577*std::sin(0.227439984679222*x_27 + 5.01991987228394) + 0.0456438538616926*std::sin(0.262239962816238*x_27 + 5.06120014190674) - 0.0120722604624103*std::sin(0.283199936151505*x_27 + 5.1101598739624) - 0.0932663066152829*std::sin(0.305439829826355*x_27 - 4.30359983444214) + 0.0195498093046715*std::sin(0.329759836196899*x_28 - 4.26440000534058) + 0.00446830888030978*std::sin(0.348719835281372*x_28 - 4.23776006698608) - 0.0036802599562156*std::sin(0.355279833078384*x_28 + 8.35503959655762) + 0.0277467588464276*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.0154654161888776*std::sin(0.320879846811295*x_3 - 4.25608015060425) - 0.0197900369951433*std::sin(0.332959830760956*x_3 + 8.33480072021484) + 0.00901534413720321*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.00611220026182952*std::sin(0.246079966425896*x_32 + 5.16936016082764) + 0.00731655399782271*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.00857239531990226*std::sin(0.333039849996567*x_34 - 7.41599988937378) - 0.00847809201520604*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.00609372418681015*std::sin(0.302479922771454*x_35 + 8.27551937103271) - 0.00550458166986357*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.00711552355601063*std::sin(0.352639853954315*x_36 + 5.17200040817261) - 0.0121493828648355*std::sin(0.362639844417572*x_36 - 4.23672008514404) + 0.0123839281672236*std::sin(0.363919854164124*x_36 + 5.15623998641968) + 0.00415251197423085*std::sin(0.368639826774597*x_36 - 4.23024034500122) + 0.00784718109303829*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 0.0029689482149695*std::sin(0.393119841814041*x_37 - 7.40255975723267) + 0.00645752810850419*std::sin(0.459439843893051*x_37 + 2.04919981956482) + 0.00851502068693751*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 0.00133806217829978*std::sin(0.362959831953049*x_38 - 7.44015979766846) + 0.0106178783604928*std::sin(0.366399854421616*x_38 + 5.16160011291504) - 0.00173640721769701*std::sin(0.448799848556519*x_38 + 5.24264001846313) - 0.00399087532544298*std::sin(0.282239943742752*x_40 + 5.09631967544556) - 0.0065963645915824*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.00519829811031832*std::sin(0.367999851703644*x_41 + 5.17600011825562) + 0.0319990962369429*std::sin(0.353599846363068*x_43 + 5.16128015518188) - 0.00325462035781695*std::sin(0.338319838047028*x_44 + 8.31983947753906) + 0.0111694908930504*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 0.0022347236188588*std::sin(0.303999930620193*x_46 + 5.12455987930298) + 0.0050406086763308*std::sin(0.373519837856293*x_47 - 7.40975952148438) + 0.0146308132207552*std::sin(0.391199827194214*x_47 + 5.17775964736938) - 0.00442660324323186*std::sin(0.454959839582443*x_47 - 1.14519989490509) - 0.00684543127294177*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.00529040734878509*std::sin(0.23455998301506*x_49 + 5.04671955108643) + 0.011992782618044*std::sin(0.391439825296402*x_50 - 4.21415996551514) + 0.00782979747409855*std::sin(0.353759855031967*x_51 + 5.1625599861145) + 0.0285584455058526*std::sin(0.270639955997467*x_53 + 5.08367967605591) + 0.00620661677229758*std::sin(0.30583992600441*x_53 - 4.24975967407227) + 0.00974720820540301*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 0.00239900368114582*std::sin(0.275279939174652*x_55 - 1.09767985343933) - 0.0140050196916524*std::sin(0.309359937906265*x_55 + 5.14407968521118) - 0.00695727907449304*std::sin(0.345439851284027*x_55 - 7.45807981491089) - 0.00483877368590657*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.00755579796609882*std::sin(0.218239992856979*x_56 - 4.3854398727417) - 0.0156984857964886*std::sin(0.31127992272377*x_57 + 5.13424015045166) - 0.00582802077307655*std::sin(0.352319836616516*x_57 + 5.14552021026611) + 0.00131675858602908*std::sin(0.547279834747314*x_58 - 7.24168014526367) + 0.00924427426768953*std::sin(0.416479855775833*x_59 - 7.39607954025269) - 0.00403380266079426*std::sin(0.50111985206604*x_59 - 4.32183980941772) - 0.00388535304740145*std::sin(0.463119864463806*x_60 - 4.14192008972168) + 0.0135308477006525*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.00667850842681781*std::sin(0.214239999651909*x_65 - 4.37847948074341) + 0.00548017435333826*std::sin(0.305919915437698*x_65 + 5.13711977005005) + 0.0559100295242049*std::sin(0.214239999651909*x_68 + 5.0021595954895) - 0.0106763357042271*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 0.00233480794111748*std::sin(0.386399835348129*x_68 - 1.0201598405838) - 0.0118261755263638*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.00530726365569182*std::sin(0.245439976453781*x_70 + 5.05655956268311) + 0.00759072367705233*std::sin(0.281039953231812*x_71 - 4.29439973831177) - 0.00330025075028643*std::sin(0.290399938821793*x_72 - 1.06831979751587) + 0.0216466185029506*std::sin(0.225679993629456*x_74 + 5.04471969604492) + 0.00465736955907251*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 0.00115316471389497*std::sin(0.373519837856293*x_74 - 7.43503999710083) - 0.0103577790348492*std::sin(0.254399985074997*x_75 - 7.54184007644653) - 0.0041840636137232*std::sin(0.290879935026169*x_75 + 5.09583950042725) + 0.00405243184190032*std::sin(0.353839844465256*x_75 + 5.14816045761108) + 0.0203390005221646*std::sin(0.185440018773079*x_77 - 7.62768030166626) + 0.0196280065827292*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.0077481646452708*std::sin(0.205440014600754*x_78 - 7.57904005050659) - 0.000741250695831917*std::sin(0.413199871778488*x_79 - 0.998559832572937) - 0.00158003411765146*std::sin(0.453359842300415*x_79 - 7.34407997131348) - 0.0567574290726394*std::sin(0.198319986462593*x_8 - 1.20415985584259) - 0.0132630832874384*std::sin(0.286399960517883*x_8 + 8.31287956237793) + 0.00425233232511152*std::sin(0.238159984350204*x_80 + 1.82535994052887) + 0.00132286268730627*std::sin(0.560719847679138*x_80 + 2.34431982040405) + 0.00426715376745065*std::sin(0.399199843406677*x_81 + 5.2050404548645) - 0.0366145143291834*std::sin(0.166720017790794*x_84 - 4.44655990600586) + 0.00393998299379749*std::sin(0.307439923286438*x_84 - 7.48952007293701) + 0.00323606764495297*std::sin(0.254959970712662*x_87 - 7.5402398109436) - 0.00450733281253378*std::sin(0.297679930925369*x_89 + 5.11312007904053) - 0.123653848263324*std::sin(0.202799990773201*x_9 - 4.39831972122192) + 0.229352896669196*std::sin(0.205039992928505*x_9 - 4.39551973342896) + 0.19343051562629*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 0.00238794913398956*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.00491782189870262*std::sin(0.241679981350899*x_92 + 8.43072032928467) + 0.0181902308878464*std::sin(0.357679843902588*x_92 + 2.0079197883606) - 0.0462237779998805*std::sin(0.361359834671021*x_92 - 7.41015958786011) - 0.0422285725274668*std::sin(0.366239845752716*x_92 + 2.00367975234985) - 0.00983879501827196*std::sin(0.331919848918915*x_93 - 7.40503978729248) + 0.00725229699105942*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 0.00261840698385502*std::sin(0.379039853811264*x_93 - 7.41239976882935) - 0.00547280652472749*std::sin(0.333199828863144*x_94 + 1.94319987297058) + 0.0014469947997029*std::sin(0.412159860134125*x_94 - 4.2065601348877) + 0.00251072736352516*std::sin(0.350079834461212*x_95 + 8.37312030792236) - 0.00917072151715418*std::sin(0.381519854068756*x_95 - 7.40271997451782) - 0.00244143529601918*std::sin(0.409439861774445*x_95 - 7.4031195640564) + 0.00290781347867933*std::sin(0.419039845466614*x_95 - 7.3983998298645) - 0.00472297371683467*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 0.00325208396312715*std::sin(0.335439831018448*x_96 - 7.45047998428345) - 0.00912144769427152*std::sin(0.406719863414764*x_96 + 2.01599979400635) + 0.00557170238643483*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 0.00182741699016396*std::sin(0.300399929285049*x_99 - 1.07527995109558) + 0.00490741348965284*std::sin(0.396959841251373*x_99 - 7.4041600227356) + 0.0110512175837621*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.0467578250139138);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00653375325576122*x_1 - 0.00206184747817635*x_10 - 0.00145862193768121*x_100 + 0.00197715067010045*x_101 + 0.00122885444157653*x_102 + 0.0011357973334596*x_103 - 0.00195084292582489*x_104 + 0.0018008191158277*x_105 - 0.00154086019922435*x_106 + 0.000519352858941386*x_107 + 0.00178889400016463*x_108 + 0.00633650247069609*x_109 + 0.00499645110848835*x_11 + 0.00143850905048739*x_110 + 0.000320241685972837*x_111 - 0.000296757116085932*x_112 + 0.000819429203283907*x_113 - 0.0014885826819863*x_114 - 0.00216932944714249*x_115 - 0.00583593906247069*x_116 - 0.000397362086064855*x_117 - 0.00162299161052142*x_118 - 0.000116665368085206*x_119 + 0.000372644677228637*x_12 - 0.0011659908670117*x_120 - 0.00265893027738777*x_13 - 0.00304113269764589*x_15 + 0.00132402086961614*x_16 - 0.000434203621985267*x_18 + 0.000554127036459198*x_19 + 0.0471327992093808*x_2 - 0.0027732272372011*x_20 - 0.00101083572812479*x_21 + 0.00355729441090566*x_22 - 0.000294189187677775*x_23 + 0.00029129353601368*x_24 + 0.000282038996818399*x_25 - 0.00248218205100091*x_26 - 4.70347797136121e-5*x_27 + 0.00101627580220479*x_28 + 0.0182004821465439*x_29 - 0.000233026657836193*x_3 - 2.14920986972427e-5*x_30 + 0.00523512372252467*x_31 + 0.00645859154253627*x_32 + 0.00486102947161677*x_33 + 0.0026509591043487*x_34 - 0.0010915132968278*x_35 + 0.000659985294500971*x_36 + 0.000997872901463493*x_37 + 0.000402272997615572*x_38 - 0.000217651705362086*x_39 - 0.00548463798115649*x_4 + 0.00296019962088716*x_40 + 0.00254412808005262*x_41 + 0.00153500265939799*x_42 - 0.000361007827757895*x_43 - 0.00110715998772008*x_44 + 0.00126415009891557*x_45 + 0.000775492929786765*x_46 + 0.00170678457679898*x_47 - 0.000122206727349047*x_48 + 0.00011388214412171*x_49 + 0.000168506644987113*x_5 + 0.00172600304350744*x_50 + 0.0016675409028739*x_51 - 0.00143408454135061*x_52 - 0.000165513599819226*x_53 - 0.000428903629947337*x_54 - 0.000625413038202358*x_55 - 0.00160883706865162*x_56 - 0.000706835883527392*x_57 + 0.000765798655486615*x_58 + 0.000800083820278066*x_59 + 0.000645533707104907*x_6 + 0.00112581883546822*x_60 - 0.00066492382178956*x_61 - 0.00123062644948416*x_62 + 0.000992662782209178*x_63 + 0.00166628632905612*x_64 + 0.00129442494400626*x_65 - 0.000333941933352187*x_66 - 0.000808175149358458*x_67 + 0.000652023962225814*x_68 + 0.00126391080034017*x_69 + 0.000135082809715416*x_7 + 0.000632035614643555*x_70 + 0.000113128013060854*x_71 - 0.00179566658042593*x_72 + 0.00296523772253358*x_73 - 0.000199773676442205*x_74 + 0.000724909528270345*x_75 - 0.00242203468424425*x_76 + 0.000734421888499503*x_77 - 0.000127259543217027*x_78 + 0.000138115999002892*x_79 - 0.000865219486168434*x_8 - 0.00109897458189216*x_80 - 9.85716324378475e-6*x_81 + 0.00162161273498746*x_82 + 0.000891888995137854*x_83 + 0.000525884889105093*x_84 + 0.00382761216198638*x_85 - 2.05101049167399e-5*x_86 - 0.00144145427544555*x_87 + 0.00163544312040758*x_88 + 0.000800614718999996*x_89 - 0.000240416780472353*x_9 + 0.00224293550724674*x_90 + 0.00307453157496875*x_91 + 0.00217831368093709*x_92 - 0.00171085493533079*x_93 - 1.22116230908134e-7*x_94 - 5.92654193856252e-5*x_95 + 5.67066676250686e-5*x_96 + 0.000882971328771082*x_97 - 0.000245370018303237*x_98 - 0.000178864876585912*x_99 - 1.25677661558245e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 4.79762816184561e-6*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 8.50859952573748e-6*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 0.00199654608976985*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) - 2.48276832815159e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 3.18761195584672e-6*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 4.05342775745303e-6*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 0.000117244705668433*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) - 0.00019579595903845*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) - 0.000102291766658954*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 6.70865169157215e-6*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 5.71057810554627e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 2.90549254607603e-6*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) - 3.96946320854437e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 5.31253427355389e-6*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 0.000210701743423589*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 3.75248364060365e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) - 0.000208428168484881*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 0.000480206089404269*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 1.5936650990864e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 1.10222272678661e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) + 1.26079040466623e-5*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 5.20355816808485e-7*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 6.45317676375566e-6*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) + 7.19664338625339e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) - 0.000807365042295733*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) + 3.30642501277342e-5*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 1.42979938410469e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 8.39309549563435e-7*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 2.19601961230537e-5*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 1.61857037949803e-6*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) + 1.58134542555597e-5*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 1.91162004103117e-6*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 1.85384685709326e-5*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) + 4.77786476510705e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) - 5.50045523260818e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.022519254304253*std::sin(0.295599937438965*x_1 + 1.98367977142334) + 0.0200214471531147*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 0.00405021945524623*std::sin(0.192640006542206*x_10 - 1.22311997413635) + 0.0695767981752408*std::sin(0.307519912719727*x_10 - 7.46888017654419) - 0.0149649103063138*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 0.0104268198357243*std::sin(0.411279857158661*x_103 + 2.01903986930847) + 0.00465723767625211*std::sin(0.39055985212326*x_105 + 1.97119987010956) + 0.00981309676441857*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 0.000306283877790399*std::sin(0.308559864759445*x_106 - 1.27239990234375) - 0.00281982946678246*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 0.000322583446848401*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 0.00276156984414119*std::sin(0.270079970359802*x_11 + 8.2992000579834) + 0.0054312886857488*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 0.00687077824874656*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 0.000745661094434693*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.00228142239849017*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 0.00204715084141092*std::sin(0.361279845237732*x_112 + 5.17248010635376) - 0.00498713022926841*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 0.0053450608974276*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 0.00147656324360831*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 0.000744337554848024*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 0.000520597694680917*std::sin(0.448079854249954*x_115 + 2.03823971748352) - 0.00407803279667146*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 0.000644751734512026*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.0154977777942444*std::sin(0.409199863672256*x_117 - 7.38831996917725) - 0.0267216463882807*std::sin(0.412159860134125*x_117 + 5.203200340271) - 0.00479815552022481*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 0.000673955374530917*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.0284340507288971*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 0.000793089211867234*std::sin(0.392399847507477*x_119 - 1.17687976360321) + 0.0373158371538141*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.0573177177526546*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 0.00408836015624971*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.00207612856859245*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 0.000804950289008309*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 0.00131583351432696*std::sin(0.42495983839035*x_120 + 5.21432018280029) + 0.0543635262436974*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 0.0137824938671236*std::sin(0.169520005583763*x_14 - 4.45079946517944) + 0.00758710395439521*std::sin(0.346159845590591*x_14 + 2.1276798248291) + 0.538349494079072*std::sin(0.146160036325455*x_15 - 4.48871994018555) + 0.0970015724411325*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 0.0108828273388609*std::sin(0.154080033302307*x_19 - 4.46744012832642) + 0.0768509666135894*std::sin(0.23063999414444*x_19 - 4.34007978439331) + 0.017468998883466*std::sin(0.32167986035347*x_21 + 8.33103942871094) + 0.0234710694006295*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 0.00186523622151817*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 0.000707287816690293*std::sin(0.355359852313995*x_21 + 5.16544008255005) - 0.0933294493111392*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.180899338117528*std::sin(0.232959985733032*x_23 + 5.04463958740234) + 0.210946370518701*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 0.000307873677188403*std::sin(0.462799847126007*x_24 - 0.902719795703888) - 0.0830616093956551*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.380682998450528*std::sin(0.227439984679222*x_27 + 5.01991987228394) - 0.0731275553963682*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 0.00194024532072205*std::sin(0.283199936151505*x_27 + 5.1101598739624) - 0.136371543321291*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 0.00314203177959136*std::sin(0.329759836196899*x_28 - 4.26440000534058) - 0.00715882813408035*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 0.0079040567782377*std::sin(0.355279833078384*x_28 + 8.35503959655762) - 0.0444540167611641*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.00429067176019213*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 0.00318064100723327*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.0193621626688243*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.00169574777269374*std::sin(0.246079966425896*x_32 + 5.16936016082764) - 0.0117220975557312*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.00237829580963752*std::sin(0.333039849996567*x_34 - 7.41599988937378) - 0.0123964434155486*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.00169062183412496*std::sin(0.302479922771454*x_35 + 8.27551937103271) + 0.00881907566824932*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.00197410632910827*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.0260931056845654*std::sin(0.362639844417572*x_36 - 4.23672008514404) + 0.0181074544262864*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 0.000667388841744315*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 0.00126119349760834*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 0.000823694759188178*std::sin(0.393119841814041*x_37 - 7.40255975723267) + 0.00944202795367297*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.0182876230967745*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 0.000371227358623621*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 0.00170649803896204*std::sin(0.366399854421616*x_38 + 5.16160011291504) + 0.00278195647956364*std::sin(0.448799848556519*x_38 + 5.24264001846313) + 0.00639391575754441*std::sin(0.282239943742752*x_40 + 5.09631967544556) + 0.010568257854546*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.00144219790987867*std::sin(0.367999851703644*x_41 + 5.17600011825562) + 0.0467882378651346*std::sin(0.353599846363068*x_43 + 5.16128015518188) + 0.00521433687943153*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 0.00179515282225462*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 0.000619994018018582*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 0.000810123127171924*std::sin(0.373519837856293*x_47 - 7.40975952148438) + 0.0213927907233436*std::sin(0.391199827194214*x_47 + 5.17775964736938) + 0.00709201012841856*std::sin(0.454959839582443*x_47 - 1.14519989490509) - 0.0100092097700579*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.00146775237951049*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 0.00192747169675055*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 0.00125839961444039*std::sin(0.353759855031967*x_51 + 5.1625599861145) + 0.0417574087559284*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 0.000997523138890349*std::sin(0.30583992600441*x_53 - 4.24975967407227) - 0.0156163305175851*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 0.000665571312247781*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 0.00225087704228703*std::sin(0.309359937906265*x_55 + 5.14407968521118) - 0.0101727506871176*std::sin(0.345439851284027*x_55 - 7.45807981491089) + 0.00775236227507936*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.00209625454387531*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.0337154778586338*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 0.000936675452724205*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 0.000211628525827335*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.0198538335755376*std::sin(0.416479855775833*x_59 - 7.39607954025269) - 0.00589812027804588*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 0.000624451244491185*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 0.00217466844907288*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.00185286235799853*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 0.000880769817625575*std::sin(0.305919915437698*x_65 + 5.13711977005005) + 0.0817501763504527*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.0229294573192356*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 0.000647761067408569*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 0.00190069472063757*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.00147242893519723*std::sin(0.245439976453781*x_70 + 5.05655956268311) - 0.012161354031896*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 0.000530414009488182*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.0464902218157735*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 0.000748529202298174*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 0.000319930043416328*std::sin(0.373519837856293*x_74 - 7.43503999710083) - 0.0151448723941626*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 0.000672459799339767*std::sin(0.290879935026169*x_75 + 5.09583950042725) - 0.0064925375255678*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 0.00326887004419504*std::sin(0.185440018773079*x_77 - 7.62768030166626) - 0.0314466903484557*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.00214962409228221*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 0.000119133297243547*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 0.0033934231619638*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.121897351631174*std::sin(0.198319986462593*x_8 - 1.20415985584259) + 0.0212492323888277*std::sin(0.286399960517883*x_8 + 8.31287956237793) - 0.00681280482166605*std::sin(0.238159984350204*x_80 + 1.82535994052887) + 0.0019342550682772*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 0.000685813991164053*std::sin(0.399199843406677*x_81 + 5.2050404548645) - 0.0535367809473445*std::sin(0.166720017790794*x_84 - 4.44655990600586) - 0.00631237943914033*std::sin(0.307439923286438*x_84 - 7.48952007293701) - 0.00518461295336199*std::sin(0.254959970712662*x_87 - 7.5402398109436) + 0.00722134969008528*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 0.0198735606499902*std::sin(0.202799990773201*x_9 - 4.39831972122192) + 0.335353780149172*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.415428745888413*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 0.000662504376788314*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.00136438355649252*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 0.00292352128028484*std::sin(0.357679843902588*x_92 + 2.0079197883606) - 0.0675871938403908*std::sin(0.361359834671021*x_92 - 7.41015958786011) + 0.0676558181561351*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.0211306797288936*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 0.00116558413771833*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 0.000726441808297173*std::sin(0.379039853811264*x_93 - 7.41239976882935) - 0.00800219392362669*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 0.000232559999676494*std::sin(0.412159860134125*x_94 - 4.2065601348877) + 0.00367111959129319*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 0.0014739119957449*std::sin(0.381519854068756*x_95 - 7.40271997451782) + 0.00391150570671095*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 0.00624508135551385*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 0.000759073056990034*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 0.000902246965225452*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.0195900401963409*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.0119662883974937*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 0.000506992270885718*std::sin(0.300399929285049*x_99 - 1.07527995109558) - 0.00786233241620857*std::sin(0.396959841251373*x_99 - 7.4041600227356) + 0.0161588000229664*std::sin(0.402559846639633*x_99 + 1.9916797876358) - 0.569285461486439);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000671401353674647*x_1 + 0.000366576023370665*x_10 - 0.00138388505942992*x_100 + 0.00264340373218595*x_101 + 0.000445307506790225*x_102 + 0.000771698361810188*x_103 - 0.000783120476977919*x_104 + 0.00119550880941022*x_105 - 0.000230146073982513*x_106 - 0.000149867019405678*x_107 + 0.000634849030364307*x_108 + 0.0014884474153156*x_109 + 0.000340513736954766*x_11 - 0.00015462737438079*x_110 + 0.000234876642968725*x_111 - 2.01927110737741e-5*x_112 + 0.000353878281608873*x_113 - 0.00108807644074801*x_114 - 0.000919224084651578*x_115 - 0.00189567608724092*x_116 - 0.000430279983026989*x_117 - 0.000276229278028549*x_118 - 0.000204374030218204*x_119 + 2.53564477229883e-5*x_12 + 0.000216976738379053*x_120 - 0.000389080774885713*x_13 - 0.00167005556718446*x_15 + 0.000667578401684109*x_16 + 0.000279480177213266*x_18 + 0.000687258163381012*x_19 + 0.0161696704125525*x_2 - 0.00119327566748901*x_20 - 0.000425708118508475*x_21 + 0.000965602673614828*x_22 + 0.000158103793939344*x_23 - 0.000798336468118433*x_24 - 0.00040785246033839*x_25 - 0.00143418882725002*x_26 - 0.00010471669756865*x_27 - 1.9098817261564e-5*x_28 + 0.00178079881121277*x_29 + 0.000380974909611926*x_3 + 0.00015020710137824*x_30 + 0.00323621540457743*x_31 + 0.00316365321911579*x_32 + 0.00232780158052767*x_33 + 0.00249521981264511*x_34 - 6.05777052016217e-5*x_35 + 0.000749371415464716*x_36 + 0.000382631464088386*x_37 + 2.73724941149519e-5*x_38 - 0.000231764430520993*x_39 - 0.00248747790113567*x_4 + 0.000301314775352401*x_40 + 0.000904967603101077*x_41 + 0.000341835371123012*x_42 - 0.000222815220794686*x_43 - 0.000712476248822458*x_44 + 0.00168449106546495*x_45 + 0.000143076532789487*x_46 + 0.000907518192192239*x_47 + 0.000401965282679741*x_48 + 0.000889288044356467*x_49 - 0.000559165123305725*x_5 + 0.00145163192399785*x_50 + 0.000965348200066037*x_51 - 0.00134410225590729*x_52 + 1.13382204705463e-5*x_53 + 0.000736414659825074*x_54 - 0.00026338939194176*x_55 - 0.000164268931695033*x_56 - 1.9260231454803e-5*x_57 - 0.00052444411665856*x_58 + 0.00100027316056278*x_59 + 0.00120172976033935*x_6 + 0.000101962631328125*x_60 + 0.000260992019349133*x_61 + 0.000630811580616895*x_62 + 0.000352040468561365*x_63 + 0.000138040166206891*x_64 + 0.000498440780739417*x_65 - 0.000510194571605604*x_66 - 8.82191896303527e-5*x_67 + 0.000842085268318474*x_68 + 0.00178549928275652*x_69 + 5.68894105805574e-5*x_7 + 0.000567435241170058*x_70 + 0.000142603555239824*x_71 - 0.00163316304346843*x_72 + 0.000960615378839095*x_73 - 0.000420429018127094*x_74 + 0.000253684667494224*x_75 - 0.00184210265033647*x_76 + 0.000508707000797325*x_77 - 0.000626146317489355*x_78 + 1.11767725093063e-5*x_79 - 0.000522403744374398*x_8 - 0.000500521595910829*x_80 - 0.000806922896764457*x_81 + 0.000248712517326757*x_82 - 6.50832635780464e-5*x_83 + 0.000436919732519358*x_84 + 0.00060288805099612*x_85 - 0.000209979100392141*x_86 - 0.000183715879741409*x_87 + 0.00189800189539671*x_88 - 0.000176688432292686*x_89 - 0.000337904271200888*x_9 + 0.00067891603219497*x_90 + 0.0144620707950418*x_91 + 0.00091738528114087*x_92 - 0.000526907449100587*x_93 + 0.000114467287409*x_94 - 0.000131946594325978*x_95 - 0.000208232799844082*x_96 + 0.000539187474022234*x_97 - 0.0002045378263313*x_98 + 2.05748456642466e-5*x_99 - 2.79804641515546e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 1.54763063095988e-5*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 1.89432681240251e-5*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 0.000840834821863802*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) - 2.81902586593949e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 1.02826766395012e-5*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 9.02441918890797e-6*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 4.9376987443628e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) - 1.33228523124314e-5*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) - 0.00011614580902074*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 2.16409327694203e-5*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 2.40497975414624e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 9.37260894475626e-6*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) - 4.50707354846621e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 1.18276528184915e-5*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 0.000679686839243397*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 1.58033863062862e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) - 1.41824056028109e-5*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 0.00020223625375395*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 3.54808393326962e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 2.45395268431123e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) + 1.43154748752917e-5*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 1.15850319760406e-6*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 1.43671420094198e-5*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) + 8.17133182494502e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) - 5.49368090820182e-5*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) + 2.24984276200811e-6*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 3.18325865669573e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 1.86861137233472e-6*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 9.248420404535e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 5.22122393226881e-6*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) + 1.79551736949465e-5*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 4.2559684327574e-6*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 7.80737795052087e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) + 3.25107764975837e-6*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) - 3.74276124364693e-6*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.0501361323856168*std::sin(0.295599937438965*x_1 + 1.98367977142334) + 0.022733082566826*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 0.0130652970167604*std::sin(0.192640006542206*x_10 - 1.22311997413635) + 0.00473432348151039*std::sin(0.307519912719727*x_10 - 7.46888017654419) - 0.00101828092295127*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 0.0043912000048984*std::sin(0.411279857158661*x_103 + 2.01903986930847) + 0.00528799780644736*std::sin(0.39055985212326*x_105 + 1.97119987010956) + 0.000667727973355532*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 0.000681900423389216*std::sin(0.308559864759445*x_106 - 1.27239990234375) - 0.00320173739702738*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 0.000718189251654996*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 0.00890833957145163*std::sin(0.270079970359802*x_11 + 8.2992000579834) + 0.00616688360202712*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 0.00289359190576785*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 0.00166011551005582*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.00507928432499705*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 0.00660374927252393*std::sin(0.361279845237732*x_112 + 5.17248010635376) - 0.00566256986352936*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 0.0022510441159201*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 0.00476313383878128*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 0.00240110229637603*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 0.00115904170660038*std::sin(0.448079854249954*x_115 + 2.03823971748352) - 0.000277487997924595*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 0.00207985592053775*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.00652680711839237*std::sin(0.409199863672256*x_117 - 7.38831996917725) - 0.00181826300258918*std::sin(0.412159860134125*x_117 + 5.203200340271) - 0.0054480010748261*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 0.00150047223691144*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.0119748500182405*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 0.00255836658441113*std::sin(0.392399847507477*x_119 - 1.17687976360321) + 0.042369764811727*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.0241390535601152*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 0.0131883322232582*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.00462222484626651*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 0.00179211503668393*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 0.00424464794543935*std::sin(0.42495983839035*x_120 + 5.21432018280029) + 0.00369914289796725*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 0.0444599059372948*std::sin(0.169520005583763*x_14 - 4.45079946517944) + 0.00861467501920942*std::sin(0.346159845590591*x_14 + 2.1276798248291) + 0.0366317611318993*std::sin(0.146160036325455*x_15 - 4.48871994018555) + 0.00660043051988135*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 0.0351060907033477*std::sin(0.154080033302307*x_19 - 4.46744012832642) + 0.00522929116253815*std::sin(0.23063999414444*x_19 - 4.34007978439331) + 0.00118867055946104*std::sin(0.32167986035347*x_21 + 8.33103942871094) + 0.0266499096961235*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 0.00601692464071017*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 0.00157468249761811*std::sin(0.355359852313995*x_21 + 5.16544008255005) - 0.10596966647221*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.076184799099161*std::sin(0.232959985733032*x_23 + 5.04463958740234) + 0.0143537555834448*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 0.000993146440719011*std::sin(0.462799847126007*x_24 - 0.902719795703888) - 0.00565189169503678*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.160322630581309*std::sin(0.227439984679222*x_27 + 5.01991987228394) - 0.0830316980597063*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 0.00625889082819388*std::sin(0.283199936151505*x_27 + 5.1101598739624) - 0.00927934335422679*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 0.0101356429917118*std::sin(0.329759836196899*x_28 - 4.26440000534058) - 0.0081283950060747*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 0.00332875169132558*std::sin(0.355279833078384*x_28 + 8.35503959655762) - 0.050474714726173*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.0095526114890755*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 0.0102601895829035*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.00815427236163404*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.00377535746413822*std::sin(0.246079966425896*x_32 + 5.16936016082764) - 0.0133096978231852*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.00529496012404039*std::sin(0.333039849996567*x_34 - 7.41599988937378) - 0.000843510691619198*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.00376394524190329*std::sin(0.302479922771454*x_35 + 8.27551937103271) + 0.0100135007123204*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.00439508586395616*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.0109889733988981*std::sin(0.362639844417572*x_36 - 4.23672008514404) + 0.00123211399387523*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 0.00215287925491708*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 0.00406838884261348*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 0.00183384711296581*std::sin(0.393119841814041*x_37 - 7.40255975723267) + 0.000642478754793558*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.00770173570631734*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 0.00082648846829718*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 0.00550486312752224*std::sin(0.366399854421616*x_38 + 5.16160011291504) + 0.00315873502367677*std::sin(0.448799848556519*x_38 + 5.24264001846313) + 0.00725988554823196*std::sin(0.282239943742752*x_40 + 5.09631967544556) + 0.0119995860717554*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.00321086232958792*std::sin(0.367999851703644*x_41 + 5.17600011825562) + 0.00318368563936341*std::sin(0.353599846363068*x_43 + 5.16128015518188) + 0.0059205485949562*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 0.00579084789661263*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 0.00138033443495505*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 0.00261331500517531*std::sin(0.373519837856293*x_47 - 7.40975952148438) + 0.00145566329743245*std::sin(0.391199827194214*x_47 + 5.17775964736938) + 0.00805252740129849*std::sin(0.454959839582443*x_47 - 1.14519989490509) - 0.000681072398968351*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.00326775596625969*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 0.00621768535945025*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 0.00405937626593146*std::sin(0.353759855031967*x_51 + 5.1625599861145) + 0.00284136502375829*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 0.00321783454815319*std::sin(0.30583992600441*x_53 - 4.24975967407227) - 0.017731352201076*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 0.0014818062344374*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 0.00726093423594482*std::sin(0.309359937906265*x_55 + 5.14407968521118) - 0.000692200470741267*std::sin(0.345439851284027*x_55 - 7.45807981491089) + 0.00880231535410816*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.00466703266039472*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.0141990951095876*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 0.00302155059333846*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 0.000682676476597285*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.00836133696253668*std::sin(0.416479855775833*x_59 - 7.39607954025269) - 0.000401335072344015*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 0.00201437010312988*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 0.00701509869133438*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.00412515224606688*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 0.00284120882777608*std::sin(0.305919915437698*x_65 + 5.13711977005005) + 0.00556265579423128*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.009656619628889*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 0.00144215408694554*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 0.00613130753474408*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.00327816769712125*std::sin(0.245439976453781*x_70 + 5.05655956268311) - 0.0138084456741423*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 0.0017110224896178*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.0195791109352155*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 0.00241462381527912*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 0.000712281800904386*std::sin(0.373519837856293*x_74 - 7.43503999710083) - 0.001030526366269*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 0.00216923727400124*std::sin(0.290879935026169*x_75 + 5.09583950042725) - 0.00737186430672112*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 0.0105448009690631*std::sin(0.185440018773079*x_77 - 7.62768030166626) - 0.0357057211038635*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.00478585288011148*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 0.000384303105121081*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 0.00142912220985955*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.051336424673413*std::sin(0.198319986462593*x_8 - 1.20415985584259) + 0.0241271547797056*std::sin(0.286399960517883*x_8 + 8.31287956237793) - 0.00773550749544652*std::sin(0.238159984350204*x_80 + 1.82535994052887) + 0.000131615559053333*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 0.00221231555272935*std::sin(0.399199843406677*x_81 + 5.2050404548645) - 0.00364288736778471*std::sin(0.166720017790794*x_84 - 4.44655990600586) - 0.00716730623344518*std::sin(0.307439923286438*x_84 - 7.48952007293701) - 0.00588679896335458*std::sin(0.254959970712662*x_87 - 7.5402398109436) + 0.0081993842649428*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 0.0641086181975633*std::sin(0.202799990773201*x_9 - 4.39831972122192) + 0.0228190045764204*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.174955618272981*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 0.00147497810948546*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.00303761899434426*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 0.0094307664766819*std::sin(0.357679843902588*x_92 + 2.0079197883606) - 0.00459894170527989*std::sin(0.361359834671021*x_92 - 7.41015958786011) + 0.0768188876911588*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.00889907396415448*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 0.00375996983017523*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 0.0016173263190316*std::sin(0.379039853811264*x_93 - 7.41239976882935) - 0.000544505863877293*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 0.000750197737077033*std::sin(0.412159860134125*x_94 - 4.2065601348877) + 0.000249799762856535*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 0.00475458137855458*std::sin(0.381519854068756*x_95 - 7.40271997451782) + 0.00444126648344888*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 0.00263008296978196*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 0.00244863643972401*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 0.00200873317925635*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.00825024177663428*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.00503953904426887*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 0.00112875103536667*std::sin(0.300399929285049*x_99 - 1.07527995109558) - 0.00892717947002632*std::sin(0.396959841251373*x_99 - 7.4041600227356) + 0.00109951863822592*std::sin(0.402559846639633*x_99 + 1.9916797876358) - 0.359011626284964);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0125324650219803*x_1 - 0.00223894369241087*x_10 - 0.0012133901750847*x_100 - 0.000723763161253067*x_101 + 0.000838445880773305*x_102 - 0.00084652466974939*x_103 + 0.00150676215415872*x_104 + 0.00103724292906452*x_105 + 0.000240128186575083*x_106 - 0.00054307024721996*x_107 - 0.00169909822978721*x_108 + 0.000134648674667512*x_109 - 0.00407882695020674*x_11 - 0.00168983456352956*x_110 - 0.000690797133413864*x_111 + 0.000317846137499393*x_112 + 0.00014549533734898*x_113 - 0.00178697754414577*x_114 - 0.00119580968485966*x_115 - 0.00107161253484446*x_116 + 0.000218350704488081*x_117 + 0.000477843397861604*x_118 + 2.36094520948732e-5*x_119 - 0.000399126642282548*x_12 + 0.000166516704593793*x_120 + 0.00255025986442201*x_13 - 0.00167747803477725*x_15 + 0.000948837847410982*x_16 + 0.00114490737993056*x_18 - 0.000258425414637894*x_19 + 0.0124929342493283*x_2 + 0.00150006803864173*x_20 - 0.000561157468535793*x_21 - 0.000477783603787761*x_22 + 0.000426816897066614*x_23 + 0.00149173580220584*x_24 - 0.00218337923527695*x_25 - 0.00103756106642764*x_26 - 2.56053828893898e-6*x_27 - 0.0011345176913975*x_28 - 0.0184081519502798*x_29 + 0.00207719723238314*x_3 + 6.48882877104359e-5*x_30 + 0.00164700368744925*x_31 + 0.00466027812678169*x_32 + 0.00199656352351517*x_33 - 0.000255091825464063*x_34 + 0.000126510376950534*x_35 - 0.000344329457509227*x_36 + 0.000610673222850361*x_37 - 0.000430860496957341*x_38 - 0.000267451013456617*x_39 + 0.00897923142250513*x_4 - 0.000614118717355525*x_40 + 0.000103662189429784*x_41 - 0.0016990536483178*x_42 + 2.01192608341149e-5*x_43 - 0.00267195129409821*x_44 + 0.00257412239079819*x_45 - 0.00180035398537307*x_46 + 0.000895165351229668*x_47 - 0.00058216636388015*x_48 + 0.00181675226346111*x_49 - 0.00049127242347295*x_5 - 0.000367348038958053*x_50 + 0.00185644139625728*x_51 - 0.00387315802827364*x_52 - 0.00019551312739932*x_53 + 0.00143402959448698*x_54 - 0.000347193107190596*x_55 + 8.04587065935499e-5*x_56 + 0.000772006051108751*x_57 - 0.00114685948265626*x_58 - 0.000356480312188831*x_59 - 2.69198036798403e-5*x_6 + 0.00103547092407193*x_60 + 0.000991587530835013*x_61 + 0.00491986634921245*x_62 + 0.000763671788529924*x_63 + 0.00125808473783915*x_64 + 0.000696751319062176*x_65 + 0.000811347572682923*x_66 + 0.000534741772870874*x_67 - 0.000272913609818016*x_68 + 0.00084012417647754*x_69 + 7.49901546151591e-5*x_7 + 0.000466118702522543*x_70 - 0.000214593058668846*x_71 - 0.00283966842914485*x_72 - 0.00265632581352528*x_73 + 4.58935957792648e-6*x_74 + 0.000416741735276927*x_75 + 0.000920141337076899*x_76 + 0.00132608961041038*x_77 - 0.000811922408550698*x_78 - 0.000146264670088641*x_79 + 0.000633241634548868*x_8 - 0.000643697756755155*x_80 - 0.000405205865320224*x_81 - 0.00108308342309888*x_82 - 0.000301311100959896*x_83 + 0.000310282240029305*x_84 - 0.000982551862381385*x_85 - 0.000106177164164946*x_86 + 0.000836139893662112*x_87 + 0.00225716575822203*x_88 + 0.000396351343280121*x_89 + 9.11409029035684e-5*x_9 + 0.001324711540241*x_90 + 0.00702275021925367*x_91 + 0.00120927363058208*x_92 + 0.00162117310133889*x_93 - 6.4897594155464e-5*x_94 - 3.2263651806368e-6*x_95 - 0.000169891085422052*x_96 + 0.00552993276908871*x_97 + 0.000152137652331783*x_98 - 8.88680918292753e-5*x_99 - 6.84179805759929e-8*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 4.12638974241649e-6*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 4.63201805207854e-7*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 0.00110836678836897*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) + 1.29531715127067e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 2.74163166333218e-6*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 2.20665580610827e-7*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 6.50874720803295e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) + 0.000209710183665283*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) + 5.33679595815392e-5*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 5.77004106856399e-6*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 3.17018231986025e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 2.49898371327376e-6*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) + 2.07095995106132e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 2.89210399231414e-7*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 0.000181222363101584*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 2.08316164723371e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) + 0.000223240100095219*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 0.000266582616747699*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 8.67579380790744e-7*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 6.00041822681069e-8*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) - 6.57783256216057e-6*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 2.83277821417041e-8*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 3.51306124733602e-7*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) - 3.75465382899126e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) + 0.000864740376340035*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) - 3.54139584958459e-5*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 7.78372109063349e-8*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 4.56913852050496e-8*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 1.21910293849853e-5*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 1.39211543413372e-6*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) - 8.25024158952052e-6*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 1.04067167716464e-7*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 1.02914843671915e-5*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) - 5.11740335367044e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) + 5.89134465664028e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.00122593139024963*std::sin(0.295599937438965*x_1 + 1.98367977142334) - 0.0104456479473445*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 0.00348355134055127*std::sin(0.192640006542206*x_10 - 1.22311997413635) - 0.0745212679353958*std::sin(0.307519912719727*x_10 - 7.46888017654419) + 0.0160283904953078*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 0.00578836665651725*std::sin(0.411279857158661*x_103 + 2.01903986930847) - 0.00242978765726584*std::sin(0.39055985212326*x_105 + 1.97119987010956) - 0.0105104637240613*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 1.66738656190636e-5*std::sin(0.308559864759445*x_106 - 1.27239990234375) + 0.00147116967401507*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 1.75612019884553e-5*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 0.00237519730446288*std::sin(0.270079970359802*x_11 + 8.2992000579834) - 0.00283362781310749*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 0.0038142582633975*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 4.05932332307622e-5*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.000124198931942409*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 0.00176073300143538*std::sin(0.361279845237732*x_112 + 5.17248010635376) + 0.00260190016456394*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 0.00296726832947859*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 0.00126997658361891*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 0.000640196936404239*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 2.83409497924804e-5*std::sin(0.448079854249954*x_115 + 2.03823971748352) + 0.00436783788073521*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 0.000554544215171564*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.00860346890496415*std::sin(0.409199863672256*x_117 - 7.38831996917725) + 0.0286206181141085*std::sin(0.412159860134125*x_117 + 5.203200340271) + 0.00250330772683827*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 3.66896273785078e-5*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.0157849386238517*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 0.000682127726091051*std::sin(0.392399847507477*x_119 - 1.17687976360321) - 0.0194685276637729*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.0318194781816794*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 0.00351635575808427*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.000113022889126077*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 4.38208927148814e-5*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 0.00113173462658638*std::sin(0.42495983839035*x_120 + 5.21432018280029) - 0.058226866015245*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 0.0118541786482133*std::sin(0.169520005583763*x_14 - 4.45079946517944) - 0.00395836605822915*std::sin(0.346159845590591*x_14 + 2.1276798248291) - 0.576607259076598*std::sin(0.146160036325455*x_15 - 4.48871994018555) - 0.103894981655144*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 0.00936020583185217*std::sin(0.154080033302307*x_19 - 4.46744012832642) - 0.0823123745890255*std::sin(0.23063999414444*x_19 - 4.34007978439331) - 0.0187104319327697*std::sin(0.32167986035347*x_21 + 8.33103942871094) - 0.0122453949523087*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 0.00160427014183096*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 3.85042206418887e-5*std::sin(0.355359852313995*x_21 + 5.16544008255005) + 0.0486921131708522*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.10042483839204*std::sin(0.232959985733032*x_23 + 5.04463958740234) - 0.225937257961051*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 0.000264798925772012*std::sin(0.462799847126007*x_24 - 0.902719795703888) + 0.0889643762181842*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.211333159069682*std::sin(0.227439984679222*x_27 + 5.01991987228394) + 0.0381523220114269*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 0.0016687846825793*std::sin(0.283199936151505*x_27 + 5.1101598739624) + 0.146062776459089*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 0.00270242863103938*std::sin(0.329759836196899*x_28 - 4.26440000534058) + 0.00373492474506347*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 0.00438787467580635*std::sin(0.355279833078384*x_28 + 8.35503959655762) + 0.0231926795990985*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.000233580966980943*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 0.00273563602342782*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.0107487516381834*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 9.23152426099004e-5*std::sin(0.246079966425896*x_32 + 5.16936016082764) + 0.00611568700979477*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.000129472648114425*std::sin(0.333039849996567*x_34 - 7.41599988937378) + 0.0132773957043745*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 9.20361903415146e-5*std::sin(0.302479922771454*x_35 + 8.27551937103271) - 0.00460111394281475*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.000107468874583793*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.014485381476722*std::sin(0.362639844417572*x_36 - 4.23672008514404) - 0.0193942592691689*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 0.000574014154051813*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 0.00108473932038356*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 4.48413276758543e-5*std::sin(0.393119841814041*x_37 - 7.40255975723267) - 0.010113024937091*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.0101522294839738*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 2.02093402253646e-5*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 0.0014677410932818*std::sin(0.366399854421616*x_38 + 5.16160011291504) - 0.00145141046839039*std::sin(0.448799848556519*x_38 + 5.24264001846313) - 0.00333585242352961*std::sin(0.282239943742752*x_40 + 5.09631967544556) - 0.00551370238730085*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 7.8512177392071e-5*std::sin(0.367999851703644*x_41 + 5.17600011825562) - 0.0501132403562297*std::sin(0.353599846363068*x_43 + 5.16128015518188) - 0.00272043908239288*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 0.00154399214402057*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 3.37520114203972e-5*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 0.000696778418269627*std::sin(0.373519837856293*x_47 - 7.40975952148438) - 0.0229130677350922*std::sin(0.391199827194214*x_47 + 5.17775964736938) - 0.0037000642597874*std::sin(0.454959839582443*x_47 - 1.14519989490509) + 0.0107205134852195*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 7.99033436385003e-5*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 0.00165779822236368*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 0.00108233633072766*std::sin(0.353759855031967*x_51 + 5.1625599861145) - 0.0447248957669876*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 0.000857959205941626*std::sin(0.30583992600441*x_53 - 4.24975967407227) + 0.00814739761659484*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 3.6233205287801e-5*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 0.00193595577343805*std::sin(0.309359937906265*x_55 + 5.14407968521118) + 0.0108956764248522*std::sin(0.345439851284027*x_55 - 7.45807981491089) - 0.00404458511247806*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.000114118532193352*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.0187168811699242*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 0.00080562474825219*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 0.000182019478942007*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.0110216988576844*std::sin(0.416479855775833*x_59 - 7.39607954025269) + 0.006317269737656*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 0.000537083976286397*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 0.00187040956045228*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.000100868443323781*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 0.000757540896933974*std::sin(0.305919915437698*x_65 + 5.13711977005005) - 0.0875597462854485*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.0127291070805654*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 3.52636288568311e-5*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 0.00163476762561084*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 8.01579318383208e-5*std::sin(0.245439976453781*x_70 + 5.05655956268311) + 0.00634485718283568*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 0.000456203535195204*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.0258086793530771*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 0.000643802128482208*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 1.74167526867855e-5*std::sin(0.373519837856293*x_74 - 7.43503999710083) + 0.0162211415749567*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 0.000578375631577836*std::sin(0.290879935026169*x_75 + 5.09583950042725) + 0.00338730566069267*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 0.00281152089420577*std::sin(0.185440018773079*x_77 - 7.62768030166626) + 0.016406459232295*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.000117023930560078*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 0.000102465301424468*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 0.00188383205921194*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.0676703517291211*std::sin(0.198319986462593*x_8 - 1.20415985584259) - 0.0110862116503139*std::sin(0.286399960517883*x_8 + 8.31287956237793) + 0.00355439645080921*std::sin(0.238159984350204*x_80 + 1.82535994052887) - 0.00207171275452248*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 0.000589861432124079*std::sin(0.399199843406677*x_81 + 5.2050404548645) + 0.0573413681285981*std::sin(0.166720017790794*x_84 - 4.44655990600586) + 0.00329331305709629*std::sin(0.307439923286438*x_84 - 7.48952007293701) + 0.00270493142877719*std::sin(0.254959970712662*x_87 - 7.5402398109436) - 0.00376754367406262*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 0.0170930414039975*std::sin(0.202799990773201*x_9 - 4.39831972122192) - 0.359185670497517*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.23062198625706*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 3.60662436113249e-5*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 7.42760220940672e-5*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 0.00251449003877427*std::sin(0.357679843902588*x_92 + 2.0079197883606) + 0.072390272522969*std::sin(0.361359834671021*x_92 - 7.41015958786011) - 0.0352975912602105*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.011730529912218*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 0.00100250671113996*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 3.95469496435776e-5*std::sin(0.379039853811264*x_93 - 7.41239976882935) + 0.0085708692134929*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 0.000200022420410403*std::sin(0.412159860134125*x_94 - 4.2065601348877) - 0.0039320074200108*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 0.00126769627309481*std::sin(0.381519854068756*x_95 - 7.40271997451782) - 0.00204072219374889*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 0.00346690757632935*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 0.000652870787490013*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 4.91176511212653e-5*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.0108752560472773*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.00664299046627862*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 2.76002806796033e-5*std::sin(0.300399929285049*x_99 - 1.07527995109558) + 0.00410195905603822*std::sin(0.396959841251373*x_99 - 7.4041600227356) - 0.0173071238919768*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.541353327606302);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00566099130822532*x_1 - 0.000348191088993616*x_10 + 0.000114652793627485*x_100 - 0.00270562559910034*x_101 - 0.000162987694147774*x_102 - 0.000880256686102155*x_103 + 0.000263109041135123*x_104 - 0.00140139562887184*x_105 - 0.000292542925089543*x_106 - 0.000776114627206754*x_107 - 0.000305481512173685*x_108 - 0.00111924531446975*x_109 - 0.00225786794914492*x_11 - 0.00022521970998458*x_110 - 0.000546433595203849*x_111 + 0.000158979582273411*x_112 - 0.000386844589726581*x_113 - 0.000337809559570351*x_114 - 1.74403739489845e-5*x_115 - 0.000891281182755276*x_116 + 0.00014460930488846*x_117 + 6.2091898033818e-5*x_118 + 2.64629193507762e-5*x_119 - 0.000199634286461606*x_12 + 0.000262963405681141*x_120 + 0.0013291331049574*x_13 + 0.00084404018470384*x_15 - 0.000110638858105592*x_16 + 0.00046606673485962*x_18 - 0.00017799768577707*x_19 - 0.00204620484071491*x_2 - 0.000330566618963033*x_20 - 9.44337095034659e-6*x_21 - 0.000788814924390959*x_22 - 0.000453299109643046*x_23 + 0.000443380900011687*x_24 - 0.000365077072330355*x_25 + 0.000167098684718659*x_26 + 2.52662140416112e-6*x_27 - 0.000564150733716402*x_28 - 0.00958271550764524*x_29 + 0.000737408321648033*x_3 + 0.00122946655640336*x_30 - 0.000555742089146583*x_31 - 0.000329489873898132*x_32 - 0.00229771337439382*x_33 - 0.00130915616902702*x_34 - 0.000621083075273453*x_35 - 0.000230767587269503*x_36 + 2.82285119536501e-5*x_37 - 0.000215506856126333*x_38 - 0.000101409824767211*x_39 + 0.00400476520482333*x_4 - 0.000780912389258467*x_40 - 0.000834665148354193*x_41 - 0.000286704774380696*x_42 - 0.000425314488034273*x_43 - 0.00133594362339592*x_44 + 0.000650106782720836*x_45 - 0.00139827459683487*x_46 + 9.35280834694411e-6*x_47 - 0.000383986715478585*x_48 - 0.000529474895721172*x_49 + 0.000361354910115056*x_5 - 0.000430340867247662*x_50 + 0.000335934002858036*x_51 - 0.00125359708493752*x_52 - 3.52259814081626e-5*x_53 - 0.00127022717175174*x_54 - 5.84269743599629e-6*x_55 + 0.000247776380717686*x_56 + 0.000384401060868629*x_57 - 0.000523416737769685*x_58 - 0.000697161372839656*x_59 - 0.00231293754364528*x_6 + 0.000152576295769962*x_60 + 0.000359642079909931*x_61 + 0.0018701254798715*x_62 - 0.000373400482447954*x_63 + 0.00066312406705976*x_64 + 4.68707603184394e-6*x_65 + 0.000520609220365089*x_66 + 0.00018431297255311*x_67 - 0.000681049099021637*x_68 - 0.00114889493253345*x_69 + 1.26196279540316e-6*x_7 - 0.00118266407638698*x_70 - 0.000645527691457518*x_71 - 0.000640145675327357*x_72 - 0.00233053465646571*x_73 + 3.61039656640676e-5*x_74 + 8.57495588131304e-6*x_75 + 0.00206395005810689*x_76 + 0.000314680081287034*x_77 - 0.000747452126786128*x_78 - 6.82797883218798e-5*x_79 + 0.00214759585160862*x_8 + 0.000380433432104406*x_80 - 0.000141157066284927*x_81 - 0.000649803699022344*x_82 + 0.000247968824086855*x_83 - 0.000692722862209923*x_84 - 0.000293431503468628*x_85 + 0.000606276478546259*x_86 - 2.72984170192663e-5*x_87 + 0.000738920306284366*x_88 + 0.00138268490125965*x_89 + 6.64504934542178e-5*x_9 + 0.000739127408973974*x_90 - 0.0416522134561813*x_91 + 2.03501158130457e-5*x_92 + 0.000844987214169521*x_93 - 1.65713960201425e-5*x_94 + 3.18362875425502e-6*x_95 - 6.73507267284413e-5*x_96 + 0.00146855801756053*x_97 + 0.000525104368322406*x_98 - 0.00033220992327857*x_99 + 6.75117161495034e-8*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) - 4.63320056803843e-5*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) - 4.57066235072466e-7*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 1.86520171582549e-5*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) + 8.68113974069521e-6*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) + 3.0783639386579e-5*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) - 2.17742644795203e-7*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 1.09531669368787e-6*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) + 0.000104892378620302*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) + 3.5766894180984e-5*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) + 6.47872819226716e-5*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 5.33490317874315e-7*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) + 2.80591351826071e-5*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) + 1.3879452391185e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) - 2.85379518892829e-7*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) + 0.00203480429158835*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 3.50562351699471e-7*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) + 0.000111659742474864*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 4.48615349525911e-6*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) - 8.56087426141582e-7*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) + 5.9209366996268e-8*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) - 4.40842488706297e-6*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) + 2.79525523991679e-8*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) - 3.46652724545908e-7*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) - 2.51634702245972e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) + 0.000432523940316103*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) - 1.77132759032765e-5*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) + 7.68061793747447e-8*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) + 4.50861572129376e-8*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 2.05155271388229e-7*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) + 1.56309762839469e-5*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) - 5.52926362959562e-6*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) + 1.02688694232258e-7*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 1.73189006577185e-7*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) - 2.55961155888715e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) + 2.94671981830565e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) - 0.00120969270563856*std::sin(0.295599937438965*x_1 + 1.98367977142334) - 0.00700061212221651*std::sin(0.320239931344986*x_1 + 1.96527981758118) - 0.0391140756383842*std::sin(0.192640006542206*x_10 - 1.22311997413635) - 0.0372738839617858*std::sin(0.307519912719727*x_10 - 7.46888017654419) + 0.00801704511971305*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 9.74088319215219e-5*std::sin(0.411279857158661*x_103 + 2.01903986930847) - 0.00162842946781407*std::sin(0.39055985212326*x_105 + 1.97119987010956) - 0.00525710063836876*std::sin(0.465279847383499*x_105 - 1.15903985500336) + 1.64530036302207e-5*std::sin(0.308559864759445*x_106 - 1.27239990234375) + 0.000985969305653794*std::sin(0.468879848718643*x_106 + 5.25511980056763) - 1.7328586343934e-5*std::sin(0.505839824676514*x_107 + 5.26151990890503) + 0.0266692343360571*std::sin(0.270079970359802*x_11 + 8.2992000579834) - 0.00189908077682564*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 6.41877863190016e-5*std::sin(0.480879843235016*x_110 + 5.24336004257202) + 4.0055535348955e-5*std::sin(0.469759851694107*x_111 + 2.02207970619202) - 0.000122553793151702*std::sin(0.353599846363068*x_112 + 5.17000007629395) - 0.0197698948757977*std::sin(0.361279845237732*x_112 + 5.17248010635376) + 0.00174377826293428*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 4.99343181114488e-5*std::sin(0.411519855260849*x_112 + 1.99287974834442) + 0.0142595745819511*std::sin(0.359839856624603*x_114 - 4.23712015151978) + 0.00718827109062059*std::sin(0.400079846382141*x_115 + 8.3942403793335) - 2.79655456312698e-5*std::sin(0.448079854249954*x_115 + 2.03823971748352) + 0.00218469554854538*std::sin(0.530159831047058*x_115 - 1.03967976570129) + 0.00622654362074551*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.00014478244144436*std::sin(0.409199863672256*x_117 - 7.38831996917725) + 0.0143153978462189*std::sin(0.412159860134125*x_117 + 5.203200340271) + 0.00167770218817277*std::sin(0.33231982588768*x_118 + 1.94903981685638) + 3.62036366515911e-5*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.000265634940656549*std::sin(0.35471984744072*x_119 - 7.4332799911499) - 0.00765907915947127*std::sin(0.392399847507477*x_119 - 1.17687976360321) - 0.0130476933026796*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.000535470260602781*std::sin(0.258559972047806*x_12 - 4.33599996566772) - 0.0394824108064992*std::sin(0.282159954309464*x_12 - 4.30015993118286) - 0.000111525788174957*std::sin(0.285359919071198*x_12 - 4.28639984130859) - 4.32404412623513e-5*std::sin(0.383039832115173*x_120 - 7.41440010070801) + 0.0127073636813037*std::sin(0.42495983839035*x_120 + 5.21432018280029) - 0.0291237858324178*std::sin(0.169440016150475*x_14 - 4.44503974914551) - 0.133101308104666*std::sin(0.169520005583763*x_14 - 4.45079946517944) - 0.00265287376628982*std::sin(0.346159845590591*x_14 + 2.1276798248291) - 0.288406151180583*std::sin(0.146160036325455*x_15 - 4.48871994018555) - 0.0519659635123618*std::sin(0.359359860420227*x_16 - 4.23943996429443) - 0.105098436367518*std::sin(0.154080033302307*x_19 - 4.46744012832642) - 0.041170822559141*std::sin(0.23063999414444*x_19 - 4.34007978439331) - 0.00935854270946583*std::sin(0.32167986035347*x_21 + 8.33103942871094) - 0.00820679203210695*std::sin(0.327519834041595*x_21 - 4.26376008987427) + 0.0180130956996453*std::sin(0.340719848871231*x_21 + 5.15775966644287) - 3.79941938164303e-5*std::sin(0.355359852313995*x_21 + 5.16544008255005) + 0.0326331692814578*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.00168998731147451*std::sin(0.232959985733032*x_23 + 5.04463958740234) - 0.113008800966526*std::sin(0.250639975070953*x_24 + 5.05199956893921) - 0.00297322019946758*std::sin(0.462799847126007*x_24 - 0.902719795703888) + 0.0444980061096654*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.00355639464339823*std::sin(0.227439984679222*x_27 + 5.01991987228394) + 0.0255694629294683*std::sin(0.262239962816238*x_27 + 5.06120014190674) - 0.0187374790601635*std::sin(0.283199936151505*x_27 + 5.1101598739624) + 0.0730573584119927*std::sin(0.305439829826355*x_27 - 4.30359983444214) + 0.0303434591737873*std::sin(0.329759836196899*x_28 - 4.26440000534058) + 0.00250312470587378*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 7.38408211074681e-5*std::sin(0.355279833078384*x_28 + 8.35503959655762) + 0.0155435981345139*std::sin(0.314559936523438*x_3 - 4.25967979431152) - 0.000230486953984685*std::sin(0.320879846811295*x_3 - 4.25608015060425) - 0.0307163190316326*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.000180884073836464*std::sin(0.286239951848984*x_30 + 8.28415966033936) + 9.10924351008834e-5*std::sin(0.246079966425896*x_32 + 5.16936016082764) + 0.00409869764252732*std::sin(0.265119940042496*x_32 + 1.95223987102509) + 0.00012775765369042*std::sin(0.333039849996567*x_34 - 7.41599988937378) + 0.00664105859321405*std::sin(0.415279865264893*x_34 + 8.18767929077148) - 9.08170791582563e-5*std::sin(0.302479922771454*x_35 + 8.27551937103271) - 0.00308363963692237*std::sin(0.355519831180573*x_35 - 1.22207987308502) + 0.000106045342097592*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.000243765499546657*std::sin(0.362639844417572*x_36 - 4.23672008514404) - 0.00970057796319954*std::sin(0.363919854164124*x_36 + 5.15623998641968) + 0.00644515634884622*std::sin(0.368639826774597*x_36 - 4.23024034500122) + 0.0121796901143698*std::sin(0.318879842758179*x_37 - 4.25999975204468) + 4.42473595439821e-5*std::sin(0.393119841814041*x_37 - 7.40255975723267) - 0.00505831057966653*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.000170845572527733*std::sin(0.348319828510284*x_38 + 1.94791972637177) + 1.99416473473392e-5*std::sin(0.362959831953049*x_38 - 7.44015979766846) + 0.0164801177097347*std::sin(0.366399854421616*x_38 + 5.16160011291504) - 0.000972726801682877*std::sin(0.448799848556519*x_38 + 5.24264001846313) - 0.00223566877151201*std::sin(0.282239943742752*x_40 + 5.09631967544556) - 0.00369525107158577*std::sin(0.343279838562012*x_41 + 5.15711975097656) + 7.74722052558335e-5*std::sin(0.367999851703644*x_41 + 5.17600011825562) - 0.0250655303880031*std::sin(0.353599846363068*x_43 + 5.16128015518188) - 0.00182322235192626*std::sin(0.338319838047028*x_44 + 8.31983947753906) + 0.0173362811689563*std::sin(0.342479854822159*x_45 + 5.15463972091675) - 3.33049323482694e-5*std::sin(0.303999930620193*x_46 + 5.12455987930298) + 0.0078235803325577*std::sin(0.373519837856293*x_47 - 7.40975952148438) - 0.0114606078456256*std::sin(0.391199827194214*x_47 + 5.17775964736938) - 0.00247976141265921*std::sin(0.454959839582443*x_47 - 1.14519989490509) + 0.00536216286611291*std::sin(0.485199838876724*x_48 + 2.04519987106323) + 7.88449441170951e-5*std::sin(0.23455998301506*x_49 + 5.04671955108643) + 0.0186141206842241*std::sin(0.391439825296402*x_50 - 4.21415996551514) + 0.012152708821439*std::sin(0.353759855031967*x_51 + 5.1625599861145) - 0.0223704000375689*std::sin(0.270639955997467*x_53 + 5.08367967605591) + 0.00963335343596178*std::sin(0.30583992600441*x_53 - 4.24975967407227) + 0.00546033820082473*std::sin(0.262479960918427*x_54 - 7.52544021606445) + 3.57532603269357e-5*std::sin(0.275279939174652*x_55 - 1.09767985343933) - 0.0217373344475639*std::sin(0.309359937906265*x_55 + 5.14407968521118) + 0.00544977548016474*std::sin(0.345439851284027*x_55 - 7.45807981491089) - 0.00271065727185918*std::sin(0.406399875879288*x_55 - 7.39015960693359) + 0.000112606918356472*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.000314974783071746*std::sin(0.31127992272377*x_57 + 5.13424015045166) - 0.00904573070948447*std::sin(0.352319836616516*x_57 + 5.14552021026611) + 0.00204375448242146*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.000185477333283477*std::sin(0.416479855775833*x_59 - 7.39607954025269) + 0.00315975808893676*std::sin(0.50111985206604*x_59 - 4.32183980941772) - 0.00603049624332676*std::sin(0.463119864463806*x_60 - 4.14192008972168) + 0.0210013672457344*std::sin(0.287999957799911*x_62 - 4.27383995056152) + 9.95323401361374e-5*std::sin(0.214239999651909*x_65 - 4.37847948074341) + 0.00850583472013819*std::sin(0.305919915437698*x_65 + 5.13711977005005) - 0.0437954413979722*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.000214210247155955*std::sin(0.26063996553421*x_68 + 5.08111953735352) + 3.47965269033267e-5*std::sin(0.386399835348129*x_68 - 1.0201598405838) - 0.0183555281114948*std::sin(0.254239976406097*x_7 + 8.28104019165039) - 7.90961600421573e-5*std::sin(0.245439976453781*x_70 + 5.05655956268311) + 0.00425228615130418*std::sin(0.281039953231812*x_71 - 4.29439973831177) - 0.00512235297766552*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.000434318255632576*std::sin(0.225679993629456*x_74 + 5.04471969604492) + 0.00722875097503827*std::sin(0.353759855031967*x_74 + 5.15727996826172) + 1.71860504174096e-5*std::sin(0.373519837856293*x_74 - 7.43503999710083) + 0.0081134549309708*std::sin(0.254399985074997*x_75 - 7.54184007644653) - 0.00649412797152969*std::sin(0.290879935026169*x_75 + 5.09583950042725) + 0.00227015242993386*std::sin(0.353839844465256*x_75 + 5.14816045761108) + 0.0315683709422407*std::sin(0.185440018773079*x_77 - 7.62768030166626) + 0.0109955129603477*std::sin(0.19463999569416*x_77 + 4.99911975860596) - 0.000115473831822557*std::sin(0.205440014600754*x_78 - 7.57904005050659) - 0.00115050279396549*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 3.17018411778636e-5*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.00113878237312947*std::sin(0.198319986462593*x_8 - 1.20415985584259) - 0.0074299141671126*std::sin(0.286399960517883*x_8 + 8.31287956237793) + 0.00238213569958808*std::sin(0.238159984350204*x_80 + 1.82535994052887) - 0.00103622473092067*std::sin(0.560719847679138*x_80 + 2.34431982040405) + 0.00662309304981157*std::sin(0.399199843406677*x_81 + 5.2050404548645) + 0.0286808794462315*std::sin(0.166720017790794*x_84 - 4.44655990600586) + 0.00220715913708573*std::sin(0.307439923286438*x_84 - 7.48952007293701) + 0.00181282921322999*std::sin(0.254959970712662*x_87 - 7.5402398109436) - 0.00252498572119004*std::sin(0.297679930925369*x_89 + 5.11312007904053) - 0.191924403864302*std::sin(0.202799990773201*x_9 - 4.39831972122192) - 0.179656699003931*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.00388099435121791*std::sin(0.210319995880127*x_9 - 4.38711977005005) + 3.55885102244742e-5*std::sin(0.374799847602844*x_90 + 8.36688041687012) - 7.32921620619775e-5*std::sin(0.241679981350899*x_92 + 8.43072032928467) + 0.0282332435935956*std::sin(0.357679843902588*x_92 + 2.0079197883606) + 0.0362080073613668*std::sin(0.361359834671021*x_92 - 7.41015958786011) - 0.0236562390870249*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.000197405811410217*std::sin(0.331919848918915*x_93 - 7.40503978729248) + 0.0112563644092328*std::sin(0.350799858570099*x_93 + 1.98431980609894) + 3.90231108319608e-5*std::sin(0.379039853811264*x_93 - 7.41239976882935) + 0.00428695852024864*std::sin(0.333199828863144*x_94 + 1.94319987297058) + 0.00224589544303001*std::sin(0.412159860134125*x_94 - 4.2065601348877) - 0.00196670282686844*std::sin(0.350079834461212*x_95 + 8.37312030792236) - 0.0142339707571187*std::sin(0.381519854068756*x_95 - 7.40271997451782) - 0.00136768007113112*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 5.83424370689933e-5*std::sin(0.419039845466614*x_95 - 7.3983998298645) - 0.00733057585995983*std::sin(0.323839843273163*x_96 + 5.14455986022949) + 4.84670388180494e-5*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.000183012938066045*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.000111790765890312*std::sin(0.392319828271866*x_98 + 2.00223970413208) + 2.72346874199006e-5*std::sin(0.300399929285049*x_99 - 1.07527995109558) + 0.00274910895305802*std::sin(0.396959841251373*x_99 - 7.4041600227356) - 0.00865663917877846*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.616359454295189);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00109695460198323*x_1 - 0.000603939840164559*x_10 + 0.000874398461635371*x_100 + 0.00129156204248554*x_101 - 0.000300186921623643*x_102 - 1.03301084681495e-5*x_103 + 0.000297078283622855*x_104 - 0.000439595185057886*x_105 + 0.000516037996222448*x_106 - 0.000219272453076541*x_107 - 0.000160790354179153*x_108 - 0.00173988273969823*x_109 - 0.000901398844045503*x_11 - 0.000258868401061359*x_110 + 9.97962599154728e-5*x_111 + 6.61656370826025e-5*x_112 - 0.000801950650942522*x_113 + 0.000476519881337502*x_114 + 0.000680856011950921*x_115 + 0.00197922865814948*x_116 - 0.000205675631156396*x_117 + 0.000488708247071287*x_118 + 4.24164853978606e-5*x_119 - 8.30856991720253e-5*x_12 + 0.000603336827031724*x_120 + 0.000248762335892354*x_13 + 0.00122060690468289*x_15 - 0.00117257500762777*x_16 - 0.000172917410424872*x_18 - 0.000160344971558491*x_19 - 0.0143268889228815*x_2 + 0.000787399295099464*x_20 + 0.000319324557040884*x_21 - 0.000983587058318363*x_22 + 0.000223882527888449*x_23 - 0.000649110364190792*x_24 - 0.000640830911373582*x_25 + 0.00108234620808471*x_26 + 0.000251383053437996*x_27 - 1.71735352827391e-5*x_28 - 0.0030614344743651*x_29 - 5.24935273620629e-5*x_3 - 0.000420847922984765*x_30 + 0.00221776063032008*x_31 - 0.00199490449256833*x_32 + 0.000221501941831439*x_33 + 0.000185748618874896*x_34 + 0.000424888573472733*x_35 + 0.000163659735617306*x_36 - 0.000344925536075061*x_37 - 8.96916964264309e-5*x_38 + 0.000586379724194243*x_39 - 0.00233235330774372*x_4 + 0.00042016744142216*x_40 - 0.000669128222897749*x_41 + 0.000340102279029527*x_42 + 0.000346241666632179*x_43 + 0.000500269610011671*x_44 - 0.000665698854838179*x_45 + 3.78870729908135e-5*x_46 - 0.00106486959068142*x_47 + 0.000175657168771299*x_48 + 0.000100970467334142*x_49 - 0.00039172368088619*x_5 + 0.000323141098540252*x_50 - 0.00104593682729685*x_51 + 0.000908048408207725*x_52 + 6.23530404279065e-5*x_53 + 0.00019128672113978*x_54 + 0.000197568938092488*x_55 + 0.000612145986771652*x_56 + 0.000129765379173194*x_57 - 0.0002607844166047*x_58 + 0.000243927314282998*x_59 + 0.000341639011484441*x_6 - 0.000949814698315945*x_60 - 0.000292782373561011*x_61 - 0.000193484702519483*x_62 - 5.62511967527997e-5*x_63 - 0.00146689040505236*x_64 - 0.000429892876991557*x_65 - 0.000260766088801097*x_66 + 0.000218715202271854*x_67 + 0.000201096666407051*x_68 + 0.000315041697323639*x_69 - 4.26728667933352e-5*x_7 - 6.74234312782905e-5*x_70 + 5.89427028403424e-5*x_71 + 0.00070450068021925*x_72 - 0.000534894821781456*x_73 - 0.000134955262272364*x_74 - 8.52405703725915e-5*x_75 + 0.000104253822288728*x_76 - 0.000284491352569612*x_77 - 0.000138556188792834*x_78 - 0.000340235223877433*x_79 - 0.000303215980919076*x_8 + 7.83428784839249e-5*x_80 - 1.51449702318048e-5*x_81 - 0.000389454262202576*x_82 - 0.000863948638104365*x_83 - 0.000103744883030113*x_84 - 0.00120434188582475*x_85 + 0.000193577106410383*x_86 + 0.000674354186807618*x_87 - 0.000604654836148571*x_88 - 0.000154050284740693*x_89 + 0.000273223590107064*x_9 - 0.000858768013480056*x_90 + 0.0102902944110158*x_91 - 0.000688132633134887*x_92 + 0.000200345104128979*x_93 - 0.000222879069043408*x_94 + 0.000316751182404927*x_95 - 0.000106218908533893*x_96 - 0.00172571627678545*x_97 + 0.000147098956792571*x_98 + 0.000103469830554266*x_99 + 6.71699421233083e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 5.07408591471152e-6*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) - 4.5475236458734e-5*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) - 0.000630711972270889*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) - 6.15664033077502e-6*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 3.37129439404195e-6*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) - 2.16640335675683e-5*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) - 3.70377823629312e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) + 4.36551094000616e-5*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) - 2.5365782581398e-5*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 7.09522995667442e-6*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) - 1.80398038302799e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 3.0729181808188e-6*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) - 9.84326930714725e-6*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) - 2.83934802142486e-5*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 0.000222843186767419*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) - 1.18541533802117e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) + 4.6471615358901e-5*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) - 0.000151697840233466*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) - 8.51753534735838e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) + 5.89096231162285e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) + 3.12644275585761e-6*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) + 2.78110442740488e-6*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) - 3.44897815855731e-5*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) + 1.78458635933218e-5*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) + 0.000180011933955614*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) - 7.37207991240403e-6*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) + 7.64173526842272e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) + 4.48579112379396e-6*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) - 6.93725964013351e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 1.71183861848536e-6*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) + 3.92133849681928e-6*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) + 1.021688388579e-5*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) + 5.85633065781246e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) - 1.0652835229275e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) + 1.22639392615093e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) - 0.120356870864892*std::sin(0.295599937438965*x_1 + 1.98367977142334) + 0.00496481478459637*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 0.00428360864912249*std::sin(0.192640006542206*x_10 - 1.22311997413635) - 0.0155130001199344*std::sin(0.307519912719727*x_10 - 7.46888017654419) + 0.00333661021296128*std::sin(0.335919857025146*x_102 + 8.33936023712158) - 0.00329384837985934*std::sin(0.411279857158661*x_103 + 2.01903986930847) + 0.00115487768159849*std::sin(0.39055985212326*x_105 + 1.97119987010956) - 0.00218795022587753*std::sin(0.465279847383499*x_105 - 1.15903985500336) + 0.00163697112831376*std::sin(0.308559864759445*x_106 - 1.27239990234375) - 0.000699246708774701*std::sin(0.468879848718643*x_106 + 5.25511980056763) - 0.00172408614117175*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 0.00292070210027665*std::sin(0.270079970359802*x_11 + 8.2992000579834) + 0.00134682284253472*std::sin(0.393039852380753*x_110 + 1.99663984775543) + 0.00217048938790209*std::sin(0.480879843235016*x_110 + 5.24336004257202) + 0.00398527565963413*std::sin(0.469759851694107*x_111 + 2.02207970619202) - 0.0121933371901882*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 0.00216511553194173*std::sin(0.361279845237732*x_112 + 5.17248010635376) - 0.00123668272855728*std::sin(0.403839856386185*x_112 - 1.17599976062775) - 0.00168851293631452*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 0.00156164848625773*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 0.000787229142283559*std::sin(0.400079846382141*x_115 + 8.3942403793335) - 0.00278239717286901*std::sin(0.448079854249954*x_115 + 2.03823971748352) + 0.000909247406075279*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 0.000681904804668055*std::sin(0.356719851493835*x_117 + 2.14879989624023) - 0.00489577177732504*std::sin(0.409199863672256*x_117 - 7.38831996917725) + 0.00595791865245327*std::sin(0.412159860134125*x_117 + 5.203200340271) - 0.00118982175880823*std::sin(0.33231982588768*x_118 + 1.94903981685638) + 0.00360203579058114*std::sin(0.396319836378098*x_118 + 2.00671982765198) + 0.0089823602403992*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 0.0008387900569387*std::sin(0.392399847507477*x_119 - 1.17687976360321) + 0.00925338805851631*std::sin(0.24679996073246*x_12 + 5.06799983978271) + 0.0181067549580136*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 0.00432394716374061*std::sin(0.282159954309464*x_12 - 4.30015993118286) - 0.0110961195540921*std::sin(0.285359919071198*x_12 - 4.28639984130859) - 0.004302153911399*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 0.00139165689293089*std::sin(0.42495983839035*x_120 + 5.21432018280029) - 0.0121210146378745*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 0.0145766940749879*std::sin(0.169520005583763*x_14 - 4.45079946517944) + 0.00188141074903224*std::sin(0.346159845590591*x_14 + 2.1276798248291) - 0.120031619523233*std::sin(0.146160036325455*x_15 - 4.48871994018555) - 0.0216276897525963*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 0.011509937629495*std::sin(0.154080033302307*x_19 - 4.46744012832642) - 0.0171348651498875*std::sin(0.23063999414444*x_19 - 4.34007978439331) - 0.00389492745975162*std::sin(0.32167986035347*x_21 + 8.33103942871094) + 0.00582023424577502*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 0.00197271829327728*std::sin(0.340719848871231*x_21 + 5.15775966644287) - 0.00378018504820686*std::sin(0.355359852313995*x_21 + 5.16544008255005) - 0.0231433535365648*std::sin(0.18104000389576*x_23 + 4.96823978424072) + 0.0571463783937774*std::sin(0.232959985733032*x_23 + 5.04463958740234) - 0.0470330793738772*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 0.000325614540400554*std::sin(0.462799847126007*x_24 - 0.902719795703888) + 0.0185196040966322*std::sin(0.329199850559235*x_26 - 4.25816011428833) + 0.120258343142184*std::sin(0.227439984679222*x_27 + 5.01991987228394) - 0.0181337924984508*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 0.00205204970473856*std::sin(0.283199936151505*x_27 + 5.1101598739624) + 0.0304057074108313*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 0.00332308771304764*std::sin(0.329759836196899*x_28 - 4.26440000534058) - 0.0017752091289234*std::sin(0.348719835281372*x_28 - 4.23776006698608) - 0.00249690366031973*std::sin(0.355279833078384*x_28 + 8.35503959655762) - 0.0110234768727089*std::sin(0.314559936523438*x_3 - 4.25967979431152) - 0.022932012756193*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 0.00336392175260779*std::sin(0.332959830760956*x_3 + 8.33480072021484) + 0.00611653688680518*std::sin(0.286239951848984*x_30 + 8.28415966033936) + 0.00906312850949881*std::sin(0.246079966425896*x_32 + 5.16936016082764) - 0.00290678504935752*std::sin(0.265119940042496*x_32 + 1.95223987102509) + 0.0127110888207785*std::sin(0.333039849996567*x_34 - 7.41599988937378) + 0.00276393903191422*std::sin(0.415279865264893*x_34 + 8.18767929077148) - 0.00903573231253559*std::sin(0.302479922771454*x_35 + 8.27551937103271) + 0.0021869087149071*std::sin(0.355519831180573*x_35 - 1.22207987308502) + 0.0105508493894124*std::sin(0.352639853954315*x_36 + 5.17200040817261) - 0.00824285211010685*std::sin(0.362639844417572*x_36 - 4.23672008514404) - 0.00403727895007746*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 0.000705846348923328*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 0.00133386830868494*std::sin(0.318879842758179*x_37 - 4.25999975204468) + 0.0044023359932028*std::sin(0.393119841814041*x_37 - 7.40255975723267) - 0.00210521588545701*std::sin(0.459439843893051*x_37 + 2.04919981956482) + 0.00577708818775272*std::sin(0.348319828510284*x_38 + 1.94791972637177) + 0.0019840693950039*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 0.00180483300724354*std::sin(0.366399854421616*x_38 + 5.16160011291504) + 0.000689855161528249*std::sin(0.448799848556519*x_38 + 5.24264001846313) + 0.00158553011886465*std::sin(0.282239943742752*x_40 + 5.09631967544556) + 0.00262066185538014*std::sin(0.343279838562012*x_41 + 5.15711975097656) + 0.00770800068491175*std::sin(0.367999851703644*x_41 + 5.17600011825562) - 0.0104320112257141*std::sin(0.353599846363068*x_43 + 5.16128015518188) + 0.00129302425708226*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 0.00189859641949673*std::sin(0.342479854822159*x_45 + 5.15463972091675) - 0.00331363281196994*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 0.000856805531836752*std::sin(0.373519837856293*x_47 - 7.40975952148438) - 0.00476978495361485*std::sin(0.391199827194214*x_47 + 5.17775964736938) + 0.00175863994589433*std::sin(0.454959839582443*x_47 - 1.14519989490509) + 0.00223167602470403*std::sin(0.485199838876724*x_48 + 2.04519987106323) + 0.00784457963019758*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 0.00203854001551565*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 0.00133091343124308*std::sin(0.353759855031967*x_51 + 5.1625599861145) - 0.0093103262010896*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 0.00105500425166239*std::sin(0.30583992600441*x_53 - 4.24975967407227) - 0.00387245677307539*std::sin(0.262479960918427*x_54 - 7.52544021606445) + 0.00355722615843696*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 0.00238058121862085*std::sin(0.309359937906265*x_55 + 5.14407968521118) + 0.00226813947706889*std::sin(0.345439851284027*x_55 - 7.45807981491089) + 0.00192239065161049*std::sin(0.406399875879288*x_55 - 7.39015960693359) + 0.0112036852565537*std::sin(0.218239992856979*x_56 - 4.3854398727417) - 0.010650771171892*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 0.000990650288223998*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 0.000223823373931203*std::sin(0.547279834747314*x_58 - 7.24168014526367) + 0.00627185648041252*std::sin(0.416479855775833*x_59 - 7.39607954025269) + 0.00131505822314878*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 0.000660434522478269*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 0.00229998119369955*std::sin(0.287999957799911*x_62 - 4.27383995056152) + 0.00990284636156589*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 0.000931523155808251*std::sin(0.305919915437698*x_65 + 5.13711977005005) - 0.0182272040218793*std::sin(0.214239999651909*x_68 + 5.0021595954895) - 0.00724345073876222*std::sin(0.26063996553421*x_68 + 5.08111953735352) + 0.00346203715665105*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 0.00201022004724175*std::sin(0.254239976406097*x_7 + 8.28104019165039) - 0.00786957404614387*std::sin(0.245439976453781*x_70 + 5.05655956268311) - 0.00301570959564105*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 0.000560978500983765*std::sin(0.290399938821793*x_72 - 1.06831979751587) + 0.0146863323831996*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 0.000791662328551597*std::sin(0.353759855031967*x_74 + 5.15727996826172) + 0.00170990470647983*std::sin(0.373519837856293*x_74 - 7.43503999710083) + 0.00337673496666653*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 0.000711209514562927*std::sin(0.290879935026169*x_75 + 5.09583950042725) - 0.00160998583418937*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 0.00345723488539215*std::sin(0.185440018773079*x_77 - 7.62768030166626) - 0.00779798742691528*std::sin(0.19463999569416*x_77 + 4.99911975860596) - 0.0114889252453625*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 0.00012599821518558*std::sin(0.413199871778488*x_79 - 0.998559832572937) - 0.00107198758205408*std::sin(0.453359842300415*x_79 - 7.34407997131348) - 0.0385075603592793*std::sin(0.198319986462593*x_8 - 1.20415985584259) + 0.00526927460930134*std::sin(0.286399960517883*x_8 + 8.31287956237793) - 0.00168940405978172*std::sin(0.238159984350204*x_80 + 1.82535994052887) - 0.000431265880194611*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 0.00072533322618711*std::sin(0.399199843406677*x_81 + 5.2050404548645) + 0.0119366816386874*std::sin(0.166720017790794*x_84 - 4.44655990600586) - 0.00156531116486006*std::sin(0.307439923286438*x_84 - 7.48952007293701) - 0.00128565347181995*std::sin(0.254959970712662*x_87 - 7.5402398109436) + 0.0017907129006156*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 0.0210187515095976*std::sin(0.202799990773201*x_9 - 4.39831972122192) - 0.0747712365057616*std::sin(0.205039992928505*x_9 - 4.39551973342896) + 0.131234578054497*std::sin(0.210319995880127*x_9 - 4.38711977005005) + 0.00354083455194508*std::sin(0.374799847602844*x_90 + 8.36688041687012) - 0.0072921124873988*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 0.00309198579990536*std::sin(0.357679843902588*x_92 + 2.0079197883606) + 0.015069393442211*std::sin(0.361359834671021*x_92 - 7.41015958786011) + 0.0167769394328366*std::sin(0.366239845752716*x_92 + 2.00367975234985) - 0.00667521413881874*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 0.00123274957043203*std::sin(0.350799858570099*x_93 + 1.98431980609894) + 0.00388255586667313*std::sin(0.379039853811264*x_93 - 7.41239976882935) + 0.00178418723701969*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 0.000245960999659854*std::sin(0.412159860134125*x_94 - 4.2065601348877) - 0.000818521118442194*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 0.00155884446331425*std::sin(0.381519854068756*x_95 - 7.40271997451782) + 0.000969954929541171*std::sin(0.409439861774445*x_95 - 7.4031195640564) + 0.0019728307795701*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 0.000802813760628848*std::sin(0.323839843273163*x_96 + 5.14455986022949) + 0.00482216773320828*std::sin(0.335439831018448*x_96 - 7.45047998428345) - 0.00618852374729023*std::sin(0.406719863414764*x_96 + 2.01599979400635) + 0.00378016885992124*std::sin(0.392319828271866*x_98 + 2.00223970413208) + 0.00270968134433148*std::sin(0.300399929285049*x_99 - 1.07527995109558) - 0.00194966047773081*std::sin(0.396959841251373*x_99 - 7.4041600227356) - 0.00360280256160849*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.248794410246608);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000516774485657861*x_1 - 0.00346876445024255*x_10 + 0.00195363367731573*x_100 - 0.0088329467567339*x_101 + 0.000400954291707656*x_102 - 0.00233194574265279*x_103 + 0.00313493051278086*x_104 - 0.000240940712004764*x_105 + 9.47014315106105e-5*x_106 + 0.00156689043240989*x_107 - 0.00299247846359027*x_108 + 0.00120009985544079*x_109 + 0.0005988044355297*x_11 + 2.83288112685112e-5*x_110 - 0.0010020023468639*x_111 - 2.85533788937382e-6*x_112 + 0.000876681107575674*x_113 + 0.00133993334316257*x_114 + 0.000305478176648664*x_115 + 0.00184389431301542*x_116 + 0.00190066902029509*x_117 + 8.43556028692315e-5*x_118 + 0.000681930467045839*x_119 + 3.58551289417537e-6*x_12 - 0.0024571066140751*x_120 + 0.00112001604250061*x_13 + 0.00037593634492085*x_15 + 0.000974364867130287*x_16 - 0.000346434446678956*x_18 - 0.00228004450508708*x_19 - 0.0043614601328826*x_2 + 0.00441001019710868*x_20 + 0.000126075596515341*x_21 - 0.000241064683251776*x_22 - 2.13040748399818e-5*x_23 + 0.00538190260889399*x_24 + 0.000746709423085771*x_25 + 0.00151446580899457*x_26 - 3.45792080390446e-6*x_27 + 7.16575961021572e-6*x_28 - 0.00250926080751402*x_29 - 0.000153226616715343*x_3 - 0.00149453995013808*x_30 - 0.0113552272475082*x_31 - 0.00090244685281286*x_32 - 0.00214694055015911*x_33 - 0.00754997697698952*x_34 + 6.63698017887697e-5*x_35 - 0.00300942445840006*x_36 + 0.000109111668641314*x_37 + 3.87059069421311e-6*x_38 - 0.000257623192331097*x_39 + 0.0159039076862957*x_4 - 0.000220922692923084*x_40 - 0.000213737331986102*x_41 - 0.00274820529927855*x_42 + 0.000768036967581753*x_43 + 0.000302955123491069*x_44 - 0.00302169860928608*x_45 - 0.00047500140022778*x_46 - 0.000192153270987862*x_47 - 0.00206259501715545*x_48 - 0.000872654683205718*x_49 + 0.00185854123939561*x_5 - 0.00532924599420536*x_50 + 0.000186524660502898*x_51 + 0.000559050178101022*x_52 - 0.000387277167249217*x_53 - 0.000101033840271388*x_54 + 7.80040907399543e-5*x_55 - 0.00123522673869318*x_56 - 6.81280811190603e-5*x_57 + 0.00220348049224922*x_58 - 0.00346311857063779*x_59 - 0.00197828983920766*x_6 + 0.00252609052748018*x_60 - 0.000220213326104785*x_61 + 0.000358923668891704*x_62 + 0.000480761247341681*x_63 + 0.00299936520536874*x_64 + 4.05657907264491e-5*x_65 + 0.00250232398557301*x_66 + 1.80686799105787e-5*x_67 - 0.0027636017555721*x_68 - 0.00452811444740378*x_69 - 1.68480845502295e-5*x_7 + 0.000221640705746613*x_70 + 2.82195795401681e-6*x_71 + 0.00221593631886538*x_72 - 0.00159990044115206*x_73 + 0.00173972248072724*x_74 - 9.60809979923918e-5*x_75 + 0.00437730895709366*x_76 - 0.000167470386775483*x_77 + 0.00270011729646134*x_78 + 0.000468894611920135*x_79 + 4.31907945446104e-5*x_8 + 0.000150785444284196*x_80 + 0.00293313144022334*x_81 - 3.87007104869842e-5*x_82 + 0.00131858947309655*x_83 - 7.35779517446418e-5*x_84 + 0.000429320185696366*x_85 - 0.000398424271621321*x_86 + 3.13417071003516e-5*x_87 - 0.00427212380136138*x_88 - 8.99288838517121e-5*x_89 + 0.000820508941311971*x_9 + 0.000146126462878638*x_90 - 0.00896287825296526*x_91 - 0.000271688256638043*x_92 + 0.00174084097840698*x_93 - 0.000157249936263136*x_94 - 4.35709761783719e-6*x_95 + 0.000908499370852579*x_96 + 0.00523162528692086*x_97 - 4.73606079736482e-5*x_98 + 1.78363003070847e-5*x_99 - 9.23961806846838e-8*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) - 1.22589658209061e-6*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 6.2553845242363e-7*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) - 0.000249017453810289*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) + 0.00011321015473428*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) + 8.14503014798132e-7*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 2.98001441804653e-7*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) - 1.46232427229643e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) - 1.88390973669821e-6*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) + 0.000466433641842234*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) + 1.71420395697589e-6*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) - 7.1224682811697e-6*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) + 7.42415473097886e-7*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) + 0.00018100099753806*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 3.90568913000798e-7*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) + 5.38388008386513e-5*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) - 4.68025219370519e-6*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) - 2.00545434103538e-6*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) - 5.98932818532787e-5*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 1.17163676201772e-6*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 8.10336291718333e-8*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) - 5.74899700392199e-5*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 3.82557166277961e-8*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 4.74427100935387e-7*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) - 0.000328155108991479*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) - 7.76830569803541e-6*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) + 3.18137631941788e-7*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 1.05116534313746e-7*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 6.17046783257529e-8*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) - 2.73896613344288e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) + 4.13579341533721e-7*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) - 7.21067520821888e-5*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 1.40539208417497e-7*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) + 2.31219417609731e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) + 4.59716635410484e-7*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) - 5.29242851582462e-7*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.00165557909319932*std::sin(0.295599937438965*x_1 + 1.98367977142334) - 0.0912945080097671*std::sin(0.320239931344986*x_1 + 1.96527981758118) - 0.00103491767586115*std::sin(0.192640006542206*x_10 - 1.22311997413635) + 0.000669454099943311*std::sin(0.307519912719727*x_10 - 7.46888017654419) - 0.000143989387591721*std::sin(0.335919857025146*x_102 + 8.33936023712158) - 0.00130047592696946*std::sin(0.411279857158661*x_103 + 2.01903986930847) - 0.0212362382742071*std::sin(0.39055985212326*x_105 + 1.97119987010956) + 9.44196633701693e-5*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 2.25174944872856e-5*std::sin(0.308559864759445*x_106 - 1.27239990234375) + 0.0128579588614453*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 2.37158123976388e-5*std::sin(0.505839824676514*x_107 + 5.26151990890503) + 0.000705640145282715*std::sin(0.270079970359802*x_11 + 8.2992000579834) - 0.0247657836435322*std::sin(0.393039852380753*x_110 + 1.99663984775543) + 0.000856951769841292*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 5.4819795623741e-5*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.000167726478624278*std::sin(0.353599846363068*x_112 + 5.17000007629395) - 0.000523090813804157*std::sin(0.361279845237732*x_112 + 5.17248010635376) + 0.0227404940901521*std::sin(0.403839856386185*x_112 - 1.17599976062775) - 0.000666658016039985*std::sin(0.411519855260849*x_112 + 1.99287974834442) + 0.000377293481803249*std::sin(0.359839856624603*x_114 - 4.23712015151978) + 0.000190194161287158*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 3.82734990971131e-5*std::sin(0.448079854249954*x_115 + 2.03823971748352) - 3.9238019670852e-5*std::sin(0.530159831047058*x_115 - 1.03967976570129) + 0.000164747854767308*std::sin(0.356719851493835*x_117 + 2.14879989624023) - 0.00193294669520264*std::sin(0.409199863672256*x_117 - 7.38831996917725) - 0.000257110361514677*std::sin(0.412159860134125*x_117 + 5.203200340271) + 0.0218788004794712*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 4.95481072662327e-5*std::sin(0.396319836378098*x_118 + 2.00671982765198) + 0.00354641195127069*std::sin(0.35471984744072*x_119 - 7.4332799911499) - 0.000202651252102656*std::sin(0.392399847507477*x_119 - 1.17687976360321) - 0.170154083662233*std::sin(0.24679996073246*x_12 + 5.06799983978271) + 0.00714890189919341*std::sin(0.258559972047806*x_12 - 4.33599996566772) - 0.00104466344052264*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.000152633608844958*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 5.91786411548813e-5*std::sin(0.383039832115173*x_120 - 7.41440010070801) + 0.000336223599119688*std::sin(0.42495983839035*x_120 + 5.21432018280029) + 0.00052307502624014*std::sin(0.169440016150475*x_14 - 4.44503974914551) - 0.00352172189140476*std::sin(0.169520005583763*x_14 - 4.45079946517944) - 0.0345959469082491*std::sin(0.346159845590591*x_14 + 2.1276798248291) + 0.0051798916516094*std::sin(0.146160036325455*x_15 - 4.48871994018555) + 0.000933329817910085*std::sin(0.359359860420227*x_16 - 4.23943996429443) - 0.00278079509043477*std::sin(0.154080033302307*x_19 - 4.46744012832642) + 0.000739444700437249*std::sin(0.23063999414444*x_19 - 4.34007978439331) + 0.000168083229340137*std::sin(0.32167986035347*x_21 + 8.33103942871094) - 0.107024218429697*std::sin(0.327519834041595*x_21 - 4.26376008987427) + 0.000476607738577035*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 5.19986544121885e-5*std::sin(0.355359852313995*x_21 + 5.16544008255005) + 0.42556694790953*std::sin(0.18104000389576*x_23 + 4.96823978424072) + 0.0225625107303114*std::sin(0.232959985733032*x_23 + 5.04463958740234) + 0.00202968397965399*std::sin(0.250639975070953*x_24 + 5.05199956893921) - 7.86683077239025e-5*std::sin(0.462799847126007*x_24 - 0.902719795703888) - 0.000799202268804585*std::sin(0.329199850559235*x_26 - 4.25816011428833) + 0.0474803519281363*std::sin(0.227439984679222*x_27 + 5.01991987228394) + 0.333449632327394*std::sin(0.262239962816238*x_27 + 5.06120014190674) - 0.000495774167328436*std::sin(0.283199936151505*x_27 + 5.1101598739624) - 0.00131213983952085*std::sin(0.305439829826355*x_27 - 4.30359983444214) + 0.000802856305132944*std::sin(0.329759836196899*x_28 - 4.26440000534058) + 0.0326430795650889*std::sin(0.348719835281372*x_28 - 4.23776006698608) - 0.000985826525004286*std::sin(0.355279833078384*x_28 + 8.35503959655762) + 0.202703009339515*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.000315443236529072*std::sin(0.320879846811295*x_3 - 4.25608015060425) - 0.000812721788368972*std::sin(0.332959830760956*x_3 + 8.33480072021484) + 0.0024149286974923*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.000124668628982126*std::sin(0.246079966425896*x_32 + 5.16936016082764) + 0.0534508380442666*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.000174848454868054*std::sin(0.333039849996567*x_34 - 7.41599988937378) - 0.000119276110526849*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.000124291778283038*std::sin(0.302479922771454*x_35 + 8.27551937103271) - 0.0402135354191158*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.00014513309908343*std::sin(0.352639853954315*x_36 + 5.17200040817261) - 0.00325443964097131*std::sin(0.362639844417572*x_36 - 4.23672008514404) + 0.000174226321462544*std::sin(0.363919854164124*x_36 + 5.15623998641968) + 0.000170532119709968*std::sin(0.368639826774597*x_36 - 4.23024034500122) + 0.000322261906491352*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 6.0556704234751e-5*std::sin(0.393119841814041*x_37 - 7.40255975723267) + 9.08493131495533e-5*std::sin(0.459439843893051*x_37 + 2.04919981956482) + 0.00228090769511159*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 2.72920339837718e-5*std::sin(0.362959831953049*x_38 - 7.44015979766846) + 0.000436046738666618*std::sin(0.366399854421616*x_38 + 5.16160011291504) - 0.0126852642650677*std::sin(0.448799848556519*x_38 + 5.24264001846313) - 0.0291552048599097*std::sin(0.282239943742752*x_40 + 5.09631967544556) - 0.0481895186682868*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.000106028053841904*std::sin(0.367999851703644*x_41 + 5.17600011825562) + 0.000450187109631663*std::sin(0.353599846363068*x_43 + 5.16128015518188) - 0.023776519067995*std::sin(0.338319838047028*x_44 + 8.31983947753906) + 0.000458699931485659*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 4.55809557577734e-5*std::sin(0.303999930620193*x_46 + 5.12455987930298) + 0.000207003781695864*std::sin(0.373519837856293*x_47 - 7.40975952148438) + 0.00020583717323267*std::sin(0.391199827194214*x_47 + 5.17775964736938) - 0.0323384004424243*std::sin(0.454959839582443*x_47 - 1.14519989490509) - 9.63066236661397e-5*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.00010790677704866*std::sin(0.23455998301506*x_49 + 5.04671955108643) + 0.000492510233267831*std::sin(0.391439825296402*x_50 - 4.21415996551514) + 0.000321548009600886*std::sin(0.353759855031967*x_51 + 5.1625599861145) + 0.00040178147353456*std::sin(0.270639955997467*x_53 + 5.08367967605591) + 0.000254888491827502*std::sin(0.30583992600441*x_53 - 4.24975967407227) + 0.071207900239072*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 4.89317245901234e-5*std::sin(0.275279939174652*x_55 - 1.09767985343933) - 0.000575147214365274*std::sin(0.309359937906265*x_55 + 5.14407968521118) - 9.78801818106003e-5*std::sin(0.345439851284027*x_55 - 7.45807981491089) - 0.0353494976863722*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.000154113237941835*std::sin(0.218239992856979*x_56 - 4.3854398727417) - 0.00420513330164193*std::sin(0.31127992272377*x_57 + 5.13424015045166) - 0.00023934060691795*std::sin(0.352319836616516*x_57 + 5.14552021026611) + 5.40756135600142e-5*std::sin(0.547279834747314*x_58 - 7.24168014526367) + 0.00247625191859383*std::sin(0.416479855775833*x_59 - 7.39607954025269) - 5.67505390540045e-5*std::sin(0.50111985206604*x_59 - 4.32183980941772) - 0.000159560645485599*std::sin(0.463119864463806*x_60 - 4.14192008972168) + 0.000555674289245706*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.000136219438753752*std::sin(0.214239999651909*x_65 - 4.37847948074341) + 0.000225055521731055*std::sin(0.305919915437698*x_65 + 5.13711977005005) + 0.000786583921137873*std::sin(0.214239999651909*x_68 + 5.0021595954895) - 0.00285985638305296*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 4.76223442437684e-5*std::sin(0.386399835348129*x_68 - 1.0201598405838) - 0.000485668143304152*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.000108250589846302*std::sin(0.245439976453781*x_70 + 5.05655956268311) + 0.0554537753731665*std::sin(0.281039953231812*x_71 - 4.29439973831177) - 0.000135532121162637*std::sin(0.290399938821793*x_72 - 1.06831979751587) + 0.00579845199815746*std::sin(0.225679993629456*x_74 + 5.04471969604492) + 0.000191265216839844*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 2.35207384760688e-5*std::sin(0.373519837856293*x_74 - 7.43503999710083) - 0.00014572094697221*std::sin(0.254399985074997*x_75 - 7.54184007644653) - 0.000171827857806894*std::sin(0.290879935026169*x_75 + 5.09583950042725) + 0.0296049039112267*std::sin(0.353839844465256*x_75 + 5.14816045761108) + 0.000835266193896842*std::sin(0.185440018773079*x_77 - 7.62768030166626) + 0.143391738965839*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.000158036880677165*std::sin(0.205440014600754*x_78 - 7.57904005050659) - 3.04411048495818e-5*std::sin(0.413199871778488*x_79 - 0.998559832572937) - 0.000423241717194965*std::sin(0.453359842300415*x_79 - 7.34407997131348) - 0.0152035398956963*std::sin(0.198319986462593*x_8 - 1.20415985584259) - 0.0968930068684593*std::sin(0.286399960517883*x_8 + 8.31287956237793) + 0.0310652701377689*std::sin(0.238159984350204*x_80 + 1.82535994052887) + 1.86110171746175e-5*std::sin(0.560719847679138*x_80 + 2.34431982040405) + 0.000175240139368056*std::sin(0.399199843406677*x_81 + 5.2050404548645) - 0.000515120247595997*std::sin(0.166720017790794*x_84 - 4.44655990600586) + 0.0287834126504505*std::sin(0.307439923286438*x_84 - 7.48952007293701) + 0.0236409828509632*std::sin(0.254959970712662*x_87 - 7.5402398109436) - 0.0329281675835436*std::sin(0.297679930925369*x_89 + 5.11312007904053) - 0.00507811969850978*std::sin(0.202799990773201*x_9 - 4.39831972122192) + 0.00322670730675045*std::sin(0.205039992928505*x_9 - 4.39551973342896) + 0.0518139846962707*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 4.87062484638591e-5*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.000100307268647316*std::sin(0.241679981350899*x_92 + 8.43072032928467) + 0.000747022200193114*std::sin(0.357679843902588*x_92 + 2.0079197883606) - 0.000650310523145259*std::sin(0.361359834671021*x_92 - 7.41015958786011) - 0.30849940992411*std::sin(0.366239845752716*x_92 + 2.00367975234985) - 0.00263550543127023*std::sin(0.331919848918915*x_93 - 7.40503978729248) + 0.000297831670643324*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 5.34068248439099e-5*std::sin(0.379039853811264*x_93 - 7.41239976882935) - 7.69955167701247e-5*std::sin(0.333199828863144*x_94 + 1.94319987297058) + 5.94240527020615e-5*std::sin(0.412159860134125*x_94 - 4.2065601348877) + 3.53227818213688e-5*std::sin(0.350079834461212*x_95 + 8.37312030792236) - 0.000376616031283037*std::sin(0.381519854068756*x_95 - 7.40271997451782) - 0.0178358230721609*std::sin(0.409439861774445*x_95 - 7.4031195640564) + 0.000778912275532509*std::sin(0.419039845466614*x_95 - 7.3983998298645) - 0.000193959397170785*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 6.6331735160861e-5*std::sin(0.335439831018448*x_96 - 7.45047998428345) - 0.00244335052154812*std::sin(0.406719863414764*x_96 + 2.01599979400635) + 0.00149248478839123*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 3.72732503817196e-5*std::sin(0.300399929285049*x_99 - 1.07527995109558) + 0.0358509434536725*std::sin(0.396959841251373*x_99 - 7.4041600227356) + 0.00015547675675292*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.98121482322383);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00638389683483646*x_1 + 0.00571494529040618*x_10 + 0.000253073253225928*x_100 + 0.0039812355341026*x_101 - 0.00185220658323313*x_102 + 0.000471173600486397*x_103 - 0.000124157834059825*x_104 - 0.00195003040890438*x_105 + 0.00174117952926494*x_106 - 0.00161392733384388*x_107 + 0.000207131812652903*x_108 - 0.00834189214013089*x_109 - 0.00585571062723255*x_11 - 0.00156741431180336*x_110 + 0.000438310725649916*x_111 + 0.000308095299573488*x_112 - 0.00141250275325896*x_113 + 0.000993262894534834*x_114 + 0.00246748602009165*x_115 + 0.00568034148805395*x_116 - 0.00087596637868776*x_117 + 0.00179801810589772*x_118 - 0.000377064222139358*x_119 - 0.000386882292763545*x_12 + 0.00307698184418214*x_120 + 0.00206603460776419*x_13 + 0.00331546799637185*x_15 - 0.00213028469030438*x_16 + 0.000692916853158268*x_18 + 0.00108619901391812*x_19 - 0.0536805083311247*x_2 - 0.000113973332703339*x_20 + 0.00116176845699621*x_21 - 0.00392088219790672*x_22 + 0.000320824340618621*x_23 - 0.00437772615058278*x_24 - 0.000420653712849719*x_25 + 0.00179904258595718*x_26 - 2.02277319625291e-5*x_27 - 0.0011151399884315*x_28 - 0.0173690107449866*x_29 + 0.000117061492016735*x_3 + 0.00113723062409315*x_30 + 0.000869703211910292*x_31 - 0.00744397598517041*x_32 - 0.00468825618795343*x_33 + 0.00232341221647931*x_34 + 0.00126429231963691*x_35 + 0.00140104459264434*x_36 - 0.00131919479562969*x_37 - 0.000417642620825328*x_38 + 0.000317973630444503*x_39 - 0.00546251197720824*x_4 - 0.00361961434482771*x_40 - 0.00280525525204829*x_41 + 0.000183490277675189*x_42 - 0.000178451949958835*x_43 + 0.00147522594997114*x_44 + 0.000485927110787113*x_45 - 0.000300162867003352*x_46 - 0.00179652771584077*x_47 + 0.0017399972506373*x_48 + 0.000323437838134399*x_49 - 0.00145328720848196*x_5 + 0.00173004001294289*x_50 - 0.00217748908569027*x_51 + 0.00169513348249549*x_52 + 0.00050559950895139*x_53 + 0.000539824764414965*x_54 + 0.000718796457388342*x_55 + 0.00274485633737581*x_56 + 0.000786365211492822*x_57 - 0.0023497637308693*x_58 + 0.00158432850493965*x_59 + 0.000784997240044395*x_6 - 0.00314219371328858*x_60 + 0.000963571480419027*x_61 + 0.000620763202516924*x_62 - 0.00165785477751345*x_63 - 0.00409731972283548*x_64 - 0.0016277591866572*x_65 - 0.00149411359693443*x_66 + 0.000871284568306303*x_67 + 0.00125708022960288*x_68 + 0.00167270412259143*x_69 - 0.000155252671668939*x_7 - 0.000877083073920594*x_70 - 7.23813888139859e-5*x_71 + 0.000811363097522333*x_72 - 0.00188652077047134*x_73 - 0.000997424648238906*x_74 - 0.000878299894599635*x_75 - 0.000510150575678555*x_76 - 0.000906828778758024*x_77 - 0.0016266816833554*x_78 - 0.00038959522786004*x_79 + 0.000873545617792275*x_8 + 0.00130301193693288*x_80 - 0.00210316671899538*x_81 - 0.00173112993655155*x_82 - 0.00183271643186279*x_83 - 0.000545157050140023*x_84 - 0.00469073303579265*x_85 + 0.000204477429259993*x_86 + 0.00151260825773801*x_87 + 0.000945180270548207*x_88 - 0.00110468362862734*x_89 - 0.000409621617879847*x_9 - 0.00293206935910827*x_90 + 0.00306658249703807*x_91 - 0.00250356814024641*x_92 + 0.000560558680289658*x_93 + 0.000199944794273505*x_94 - 2.54876290540458e-5*x_95 - 0.000686975480108398*x_96 - 0.0052336836676095*x_97 + 0.000227172222017643*x_98 + 0.000228201666313046*x_99 - 5.40488138172764e-7*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) - 2.33889823990319e-6*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 3.65920009897081e-6*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) - 0.00229465995858368*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) - 5.2705252221954e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) + 1.55399704635638e-6*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 1.74321322873139e-6*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) - 0.000134751074784502*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) + 0.000203276724921944*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) - 0.000217149272481788*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) + 3.27054392383454e-6*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) - 6.56325190102282e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) + 1.41646062863172e-6*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) - 8.4265437584285e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 2.28470336167212e-6*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) + 0.00010271949392768*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) - 4.31278496372007e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) + 0.000216391572528653*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) - 0.000551907962891581*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 6.85370074201234e-6*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 4.74020841942946e-7*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) + 2.67645899633434e-5*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 2.23783720294511e-7*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 2.77524696998407e-6*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) + 0.000152773378217826*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) + 0.000838211995897805*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) - 3.43275341890274e-5*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 6.14898142990318e-7*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 3.60952654727685e-7*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) - 2.52391782911582e-5*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) + 7.89071450320791e-7*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) + 3.35694670174928e-5*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 8.22109469622683e-7*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) + 2.13065361932539e-5*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) - 4.96041239227103e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) + 5.71061083566486e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.00968460876900059*std::sin(0.295599937438965*x_1 + 1.98367977142334) + 0.0425023716505618*std::sin(0.320239931344986*x_1 + 1.96527981758118) - 0.00197452800332339*std::sin(0.192640006542206*x_10 - 1.22311997413635) - 0.0722351152346339*std::sin(0.307519912719727*x_10 - 7.46888017654419) + 0.0155366738453512*std::sin(0.335919857025146*x_102 + 8.33936023712158) - 0.0119836982952699*std::sin(0.411279857158661*x_103 + 2.01903986930847) + 0.00988658037889498*std::sin(0.39055985212326*x_105 + 1.97119987010956) - 0.0101880252350939*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 0.000131720148836909*std::sin(0.308559864759445*x_106 - 1.27239990234375) - 0.0059860528098614*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 0.000138729925772562*std::sin(0.505839824676514*x_107 + 5.26151990890503) + 0.00134629667617817*std::sin(0.270079970359802*x_11 + 8.2992000579834) + 0.0115297684776635*std::sin(0.393039852380753*x_110 + 1.99663984775543) + 0.00789668709001545*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 0.000320678290510755*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.000981146314513595*std::sin(0.353599846363068*x_112 + 5.17000007629395) - 0.000998009295066001*std::sin(0.361279845237732*x_112 + 5.17248010635376) - 0.0105868901909592*std::sin(0.403839856386185*x_112 - 1.17599976062775) - 0.00614315756614078*std::sin(0.411519855260849*x_112 + 1.99287974834442) + 0.000719841358079044*std::sin(0.359839856624603*x_114 - 4.23712015151978) + 0.000362873015206365*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 0.000223887742058853*std::sin(0.448079854249954*x_115 + 2.03823971748352) + 0.00423384198071658*std::sin(0.530159831047058*x_115 - 1.03967976570129) + 0.000314323796291163*std::sin(0.356719851493835*x_117 + 2.14879989624023) - 0.0178118252985481*std::sin(0.409199863672256*x_117 - 7.38831996917725) + 0.0277425989229191*std::sin(0.412159860134125*x_117 + 5.203200340271) - 0.0101857267158665*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 0.000289840597824081*std::sin(0.396319836378098*x_118 + 2.00671982765198) + 0.0326796751661558*std::sin(0.35471984744072*x_119 - 7.4332799911499) - 0.000386640001923137*std::sin(0.392399847507477*x_119 - 1.17687976360321) + 0.0792156314693026*std::sin(0.24679996073246*x_12 + 5.06799983978271) + 0.0658761009917776*std::sin(0.258559972047806*x_12 - 4.33599996566772) - 0.00199312202842003*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.000892857848191081*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 0.000346176144299198*std::sin(0.383039832115173*x_120 - 7.41440010070801) + 0.000641483788831404*std::sin(0.42495983839035*x_120 + 5.21432018280029) - 0.0564405906245331*std::sin(0.169440016150475*x_14 - 4.44503974914551) - 0.00671912235793011*std::sin(0.169520005583763*x_14 - 4.45079946517944) + 0.0161062239684801*std::sin(0.346159845590591*x_14 + 2.1276798248291) - 0.558918184814475*std::sin(0.146160036325455*x_15 - 4.48871994018555) - 0.100707706404911*std::sin(0.359359860420227*x_16 - 4.23943996429443) - 0.00530550197917803*std::sin(0.154080033302307*x_19 - 4.46744012832642) - 0.0797872074429705*std::sin(0.23063999414444*x_19 - 4.34007978439331) - 0.0181364360027406*std::sin(0.32167986035347*x_21 + 8.33103942871094) + 0.0498253751126324*std::sin(0.327519834041595*x_21 - 4.26376008987427) + 0.000909323850941019*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 0.000304175515724446*std::sin(0.355359852313995*x_21 + 5.16544008255005) - 0.198123687575063*std::sin(0.18104000389576*x_23 + 4.96823978424072) + 0.207910285587463*std::sin(0.232959985733032*x_23 + 5.04463958740234) - 0.219005987374805*std::sin(0.250639975070953*x_24 + 5.05199956893921) - 0.000150091915712673*std::sin(0.462799847126007*x_24 - 0.902719795703888) + 0.0862351399263499*std::sin(0.329199850559235*x_26 - 4.25816011428833) + 0.437524602078531*std::sin(0.227439984679222*x_27 + 5.01991987228394) - 0.15523825593546*std::sin(0.262239962816238*x_27 + 5.06120014190674) - 0.0009458916390618*std::sin(0.283199936151505*x_27 + 5.1101598739624) + 0.141581883686677*std::sin(0.305439829826355*x_27 - 4.30359983444214) + 0.00153177619254658*std::sin(0.329759836196899*x_28 - 4.26440000534058) - 0.0151970620110669*std::sin(0.348719835281372*x_28 - 4.23776006698608) - 0.00908424939064877*std::sin(0.355279833078384*x_28 + 8.35503959655762) - 0.0943688599177694*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.00184524215554562*std::sin(0.320879846811295*x_3 - 4.25608015060425) - 0.00155059862970289*std::sin(0.332959830760956*x_3 + 8.33480072021484) + 0.0222532200059836*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.000729271650275801*std::sin(0.246079966425896*x_32 + 5.16936016082764) - 0.0248841626195999*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.00102280760020295*std::sin(0.333039849996567*x_34 - 7.41599988937378) + 0.0128700736755148*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.000727067194082809*std::sin(0.302479922771454*x_35 + 8.27551937103271) + 0.0187215054336394*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.000848982262357186*std::sin(0.352639853954315*x_36 + 5.17200040817261) - 0.0299891923939339*std::sin(0.362639844417572*x_36 - 4.23672008514404) - 0.0187992849828225*std::sin(0.363919854164124*x_36 + 5.15623998641968) + 0.000325359643271378*std::sin(0.368639826774597*x_36 - 4.23024034500122) + 0.000614846159857192*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 0.00035423737305134*std::sin(0.393119841814041*x_37 - 7.40255975723267) - 0.00980277901786102*std::sin(0.459439843893051*x_37 + 2.04919981956482) + 0.0210182357787071*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 0.000159649679516264*std::sin(0.362959831953049*x_38 - 7.44015979766846) + 0.000831937183350019*std::sin(0.366399854421616*x_38 + 5.16160011291504) + 0.00590565443675775*std::sin(0.448799848556519*x_38 + 5.24264001846313) + 0.0135732737874175*std::sin(0.282239943742752*x_40 + 5.09631967544556) + 0.0224347430831446*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.000620230241016791*std::sin(0.367999851703644*x_41 + 5.17600011825562) - 0.0485758736023032*std::sin(0.353599846363068*x_43 + 5.16128015518188) + 0.011069214041621*std::sin(0.338319838047028*x_44 + 8.31983947753906) + 0.000875157397507306*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 0.000266634028929487*std::sin(0.303999930620193*x_46 + 5.12455987930298) + 0.00039494422917477*std::sin(0.373519837856293*x_47 - 7.40975952148438) - 0.0222101439505596*std::sin(0.391199827194214*x_47 + 5.17775964736938) + 0.0150552179331704*std::sin(0.454959839582443*x_47 - 1.14519989490509) + 0.0103916311199994*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.000631220171559775*std::sin(0.23455998301506*x_49 + 5.04671955108643) + 0.000939664352240844*std::sin(0.391439825296402*x_50 - 4.21415996551514) + 0.00061348411006851*std::sin(0.353759855031967*x_51 + 5.1625599861145) - 0.0433528318705758*std::sin(0.270639955997467*x_53 + 5.08367967605591) + 0.000486303864140196*std::sin(0.30583992600441*x_53 - 4.24975967407227) - 0.0331510044404136*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 0.000286234956091451*std::sin(0.275279939174652*x_55 - 1.09767985343933) - 0.00109732813274516*std::sin(0.309359937906265*x_55 + 5.14407968521118) + 0.0105614204362545*std::sin(0.345439851284027*x_55 - 7.45807981491089) + 0.0164570412950375*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.000901513205694293*std::sin(0.218239992856979*x_56 - 4.3854398727417) - 0.0387496975016689*std::sin(0.31127992272377*x_57 + 5.13424015045166) - 0.000456639925778322*std::sin(0.352319836616516*x_57 + 5.14552021026611) + 0.000103171310879676*std::sin(0.547279834747314*x_58 - 7.24168014526367) + 0.022818304653023*std::sin(0.416479855775833*x_59 - 7.39607954025269) + 0.00612346944852641*std::sin(0.50111985206604*x_59 - 4.32183980941772) - 0.000304427076750345*std::sin(0.463119864463806*x_60 - 4.14192008972168) + 0.00106017557766563*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.000796840197174501*std::sin(0.214239999651909*x_65 - 4.37847948074341) + 0.000429385293463809*std::sin(0.305919915437698*x_65 + 5.13711977005005) - 0.0848736010279358*std::sin(0.214239999651909*x_68 + 5.0021595954895) - 0.026353164523524*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 0.000278575499387537*std::sin(0.386399835348129*x_68 - 1.0201598405838) - 0.000926610272143797*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.000633231366584289*std::sin(0.245439976453781*x_70 + 5.05655956268311) - 0.0258166347759379*std::sin(0.281039953231812*x_71 - 4.29439973831177) - 0.000258582856228412*std::sin(0.290399938821793*x_72 - 1.06831979751587) + 0.0534318997257038*std::sin(0.225679993629456*x_74 + 5.04471969604492) + 0.000364916490964119*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 0.000137588805653807*std::sin(0.373519837856293*x_74 - 7.43503999710083) + 0.0157235117352017*std::sin(0.254399985074997*x_75 - 7.54184007644653) - 0.000327831792715754*std::sin(0.290879935026169*x_75 + 5.09583950042725) - 0.0137826322321548*std::sin(0.353839844465256*x_75 + 5.14816045761108) + 0.00159361128768655*std::sin(0.185440018773079*x_77 - 7.62768030166626) - 0.0667563593255185*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.000924465262166316*std::sin(0.205440014600754*x_78 - 7.57904005050659) - 5.80788360075e-5*std::sin(0.413199871778488*x_79 - 0.998559832572937) - 0.00390011144355117*std::sin(0.453359842300415*x_79 - 7.34407997131348) - 0.140098429622375*std::sin(0.198319986462593*x_8 - 1.20415985584259) + 0.0451087658835197*std::sin(0.286399960517883*x_8 + 8.31287956237793) - 0.0144625091432586*std::sin(0.238159984350204*x_80 + 1.82535994052887) - 0.00200815704968584*std::sin(0.560719847679138*x_80 + 2.34431982040405) + 0.000334342112961402*std::sin(0.399199843406677*x_81 + 5.2050404548645) + 0.0555822579142332*std::sin(0.166720017790794*x_84 - 4.44655990600586) - 0.0134001850550533*std::sin(0.307439923286438*x_84 - 7.48952007293701) - 0.0110061148388981*std::sin(0.254959970712662*x_87 - 7.5402398109436) + 0.0153297854045944*std::sin(0.297679930925369*x_89 + 5.11312007904053) - 0.0096885866217256*std::sin(0.202799990773201*x_9 - 4.39831972122192) - 0.348166624345555*std::sin(0.205039992928505*x_9 - 4.39551973342896) + 0.477458403649806*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 0.000284915992788164*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.000586765475311149*std::sin(0.241679981350899*x_92 + 8.43072032928467) + 0.00142524984140231*std::sin(0.357679843902588*x_92 + 2.0079197883606) + 0.0701694941918657*std::sin(0.361359834671021*x_92 - 7.41015958786011) + 0.143622621561976*std::sin(0.366239845752716*x_92 + 2.00367975234985) - 0.0242858028271901*std::sin(0.331919848918915*x_93 - 7.40503978729248) + 0.000568235510590248*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 0.00031241286286619*std::sin(0.379039853811264*x_93 - 7.41239976882935) + 0.00830793332494508*std::sin(0.333199828863144*x_94 + 1.94319987297058) + 0.000113375642206084*std::sin(0.412159860134125*x_94 - 4.2065601348877) - 0.00381138186395523*std::sin(0.350079834461212*x_95 + 8.37312030792236) - 0.000718548844621962*std::sin(0.381519854068756*x_95 - 7.40271997451782) + 0.00830350913140961*std::sin(0.409439861774445*x_95 - 7.4031195640564) + 0.00717756439384128*std::sin(0.419039845466614*x_95 - 7.3983998298645) - 0.000370056739926452*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 0.0003880194589559*std::sin(0.335439831018448*x_96 - 7.45047998428345) - 0.0225151230196594*std::sin(0.406719863414764*x_96 + 2.01599979400635) + 0.0137530322887555*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 0.000218036606634352*std::sin(0.300399929285049*x_99 - 1.07527995109558) - 0.0166904905443846*std::sin(0.396959841251373*x_99 - 7.4041600227356) - 0.0167761784434592*std::sin(0.402559846639633*x_99 + 1.9916797876358) + 0.123066538576974);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00343300044890566*x_1 + 0.00176975012291025*x_10 + 5.3308646701911e-5*x_100 + 0.00248502499857786*x_101 - 0.000271222751261792*x_102 + 0.000647976511413721*x_103 + 0.000401192297209765*x_104 + 0.00109280289062247*x_105 + 0.000943529611843628*x_106 + 0.000648557178315668*x_107 - 0.000339285537674183*x_108 - 0.00117338135263331*x_109 + 0.000388182616440218*x_11 - 0.000437475782461761*x_110 + 0.000512905981003202*x_111 - 5.62656869035941e-5*x_112 + 0.000315876818655937*x_113 + 0.00078199196054522*x_114 + 0.000751185223762*x_115 + 0.0030752177981784*x_116 - 2.69789488498985e-5*x_117 + 0.000567918062166322*x_118 - 3.60832558419197e-5*x_119 + 7.06541059967907e-5*x_12 + 0.000207325027059849*x_120 - 0.000357583570536247*x_13 - 0.000119112062782085*x_15 - 0.000100645133508309*x_16 - 0.000211025402614545*x_18 + 0.000147137543814446*x_19 - 0.0144362220581653*x_2 + 0.00127908792732137*x_20 + 0.000351795166942266*x_21 - 0.000427195884049422*x_22 + 0.000654339557698395*x_23 - 0.000739499708275298*x_24 + 0.000364943010150185*x_25 + 0.00045740226305745*x_26 - 7.07223405979597e-5*x_27 + 0.000138959407306111*x_28 + 0.00313103804268246*x_29 - 0.000648392396827686*x_3 - 0.00125940524686939*x_30 - 0.00181129644069006*x_31 - 0.00170874266228343*x_32 + 0.000649593600575086*x_33 + 0.000757135898905057*x_34 + 0.00115881212219025*x_35 + 8.83917776877479e-5*x_36 - 0.000372665391906727*x_37 + 7.62716892256556e-5*x_38 + 2.30177167182038e-5*x_39 - 0.00198856495814081*x_4 - 0.000659767443844346*x_40 + 4.77636554760267e-5*x_41 - 0.000435336265342989*x_42 + 0.000529891230291237*x_43 + 0.00184452804953067*x_44 - 0.000829177025839497*x_45 + 0.00126767868525755*x_46 - 0.00040043461411521*x_47 + 0.000580486366779572*x_48 + 0.000733884183154512*x_49 - 0.000547222515875014*x_5 - 8.83832732742596e-5*x_50 - 0.000762426905183385*x_51 + 0.0016664933032388*x_52 + 0.000117577776578222*x_53 + 0.00181350298105324*x_54 + 0.000217658792680809*x_55 + 0.000352184330176296*x_56 - 0.000125996184682558*x_57 + 0.000148477250050359*x_58 + 0.000600515569694298*x_59 + 0.0025677304496273*x_6 - 0.000511838967467484*x_60 + 6.03341716290673e-5*x_61 - 0.00137969145538625*x_62 + 8.52833470532167e-6*x_63 - 0.00124481041230437*x_64 - 0.00044884460161052*x_65 - 0.000511458219407738*x_66 + 0.0001203917076965*x_67 + 0.000625925872931085*x_68 + 0.0010524305820708*x_69 - 4.70120695902018e-5*x_7 + 0.00119598575670129*x_70 + 0.000712415701281527*x_71 + 0.00110373173706189*x_72 + 0.00158147501551337*x_73 - 1.66581585821616e-5*x_74 - 0.000305220135180585*x_75 - 0.00165581501990327*x_76 - 0.000559214329656437*x_77 + 0.000808387533885225*x_78 + 9.89572337116418e-5*x_79 - 0.00209921238896657*x_8 - 9.00737618876948e-6*x_80 - 3.92926287416333e-5*x_81 + 8.81673891363928e-5*x_82 - 0.000543429557510708*x_83 + 0.000663261675461702*x_84 - 0.00117233496971869*x_85 - 0.000792508874477972*x_86 + 0.000547634243953107*x_87 - 0.00107768583942523*x_88 - 0.00202731484840766*x_89 - 0.000113715392730388*x_9 - 0.00164344505658365*x_90 + 0.0475769111387481*x_91 - 0.000758105598878554*x_92 - 0.000302971136451793*x_93 + 0.000108072123323105*x_94 - 8.91125503508652e-5*x_95 + 2.18137230387684e-5*x_96 - 0.00166464193207365*x_97 - 0.000572749622332827*x_98 + 0.000457078179425769*x_99 - 1.88971191964678e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) + 5.37274465929581e-5*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) + 1.27936832559821e-5*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) - 0.000694846101513937*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) - 3.32516963545518e-6*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) - 3.56972748490258e-5*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) + 6.09480686839178e-6*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) - 4.08039799703549e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) - 3.71232685960469e-5*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) - 1.36999281243712e-5*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) - 7.51285246189321e-5*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) - 1.98741864981793e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) - 3.25378896257532e-5*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) - 5.31629889927543e-6*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) + 7.98802206835635e-6*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) - 0.00235959650997194*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) - 1.30595463937867e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) - 3.95183583953686e-5*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) - 0.000167123278974378*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) + 2.39626350166686e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) - 1.65732191313006e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) + 1.68857558022362e-6*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) - 7.8241636364694e-7*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) + 9.70311262865525e-6*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) + 9.63845872924636e-6*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) - 0.000153077874882584*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) + 6.26904173327557e-6*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) - 2.14987206584366e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) - 1.26200093192244e-6*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) - 7.6426768922446e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) - 1.8125967809054e-5*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) + 2.11789466322836e-6*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) - 2.87434627011905e-6*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) + 6.45183333385307e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) + 9.05891816469135e-6*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) - 1.04289627836776e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) + 0.033860355732814*std::sin(0.295599937438965*x_1 + 1.98367977142334) + 0.00268147081532057*std::sin(0.320239931344986*x_1 + 1.96527981758118) + 0.0453574020600608*std::sin(0.192640006542206*x_10 - 1.22311997413635) + 0.013191887000105*std::sin(0.307519912719727*x_10 - 7.46888017654419) - 0.002837374108972*std::sin(0.335919857025146*x_102 + 8.33936023712158) - 0.00362878430463702*std::sin(0.411279857158661*x_103 + 2.01903986930847) + 0.00062374346935949*std::sin(0.39055985212326*x_105 + 1.97119987010956) + 0.00186058092686668*std::sin(0.465279847383499*x_105 - 1.15903985500336) - 0.000460533946510388*std::sin(0.308559864759445*x_106 - 1.27239990234375) - 0.000377659534874423*std::sin(0.468879848718643*x_106 + 5.25511980056763) + 0.000485042271659114*std::sin(0.505839824676514*x_107 + 5.26151990890503) - 0.0309261350210062*std::sin(0.270079970359802*x_11 + 8.2992000579834) + 0.00072741205913033*std::sin(0.393039852380753*x_110 + 1.99663984775543) + 0.00239119622881264*std::sin(0.480879843235016*x_110 + 5.24336004257202) - 0.00112118943072239*std::sin(0.469759851694107*x_111 + 2.02207970619202) + 0.00343038774490404*std::sin(0.353599846363068*x_112 + 5.17000007629395) + 0.0229255339908049*std::sin(0.361279845237732*x_112 + 5.17248010635376) - 0.000667925952590587*std::sin(0.403839856386185*x_112 - 1.17599976062775) - 0.00186020986240306*std::sin(0.411519855260849*x_112 + 1.99287974834442) - 0.016535665152835*std::sin(0.359839856624603*x_114 - 4.23712015151978) - 0.00833565146696276*std::sin(0.400079846382141*x_115 + 8.3942403793335) + 0.000782780055565588*std::sin(0.448079854249954*x_115 + 2.03823971748352) - 0.000773202407229424*std::sin(0.530159831047058*x_115 - 1.03967976570129) - 0.0072204145909436*std::sin(0.356719851493835*x_117 + 2.14879989624023) - 0.00539359974589985*std::sin(0.409199863672256*x_117 - 7.38831996917725) - 0.00506647257212253*std::sin(0.412159860134125*x_117 + 5.203200340271) - 0.000642616584928057*std::sin(0.33231982588768*x_118 + 1.94903981685638) - 0.00101337142080006*std::sin(0.396319836378098*x_118 + 2.00671982765198) + 0.00989573413829939*std::sin(0.35471984744072*x_119 - 7.4332799911499) + 0.00888160916948929*std::sin(0.392399847507477*x_119 - 1.17687976360321) + 0.00499770708440729*std::sin(0.24679996073246*x_12 + 5.06799983978271) + 0.0199479455706927*std::sin(0.258559972047806*x_12 - 4.33599996566772) + 0.0457845303007358*std::sin(0.282159954309464*x_12 - 4.30015993118286) + 0.00312170425049651*std::sin(0.285359919071198*x_12 - 4.28639984130859) + 0.00121033772987346*std::sin(0.383039832115173*x_120 - 7.41440010070801) - 0.0147356928218109*std::sin(0.42495983839035*x_120 + 5.21432018280029) + 0.0103074230769835*std::sin(0.169440016150475*x_14 - 4.44503974914551) + 0.154346726795683*std::sin(0.169520005583763*x_14 - 4.45079946517944) + 0.00101614022557551*std::sin(0.346159845590591*x_14 + 2.1276798248291) + 0.102072039511902*std::sin(0.146160036325455*x_15 - 4.48871994018555) + 0.0183916738918187*std::sin(0.359359860420227*x_16 - 4.23943996429443) + 0.121874081296893*std::sin(0.154080033302307*x_19 - 4.46744012832642) + 0.014571082516069*std::sin(0.23063999414444*x_19 - 4.34007978439331) + 0.00331215384035377*std::sin(0.32167986035347*x_21 + 8.33103942871094) + 0.00314347844692938*std::sin(0.327519834041595*x_21 - 4.26376008987427) - 0.0208883173297692*std::sin(0.340719848871231*x_21 + 5.15775966644287) + 0.00106349068024405*std::sin(0.355359852313995*x_21 + 5.16544008255005) - 0.0124996056790444*std::sin(0.18104000389576*x_23 + 4.96823978424072) + 0.0629573244021156*std::sin(0.232959985733032*x_23 + 5.04463958740234) + 0.0399958140637067*std::sin(0.250639975070953*x_24 + 5.05199956893921) + 0.0034478008696185*std::sin(0.462799847126007*x_24 - 0.902719795703888) - 0.0157486316406015*std::sin(0.329199850559235*x_26 - 4.25816011428833) + 0.132486847532018*std::sin(0.227439984679222*x_27 + 5.01991987228394) - 0.00979396764337261*std::sin(0.262239962816238*x_27 + 5.06120014190674) + 0.0217283256079247*std::sin(0.283199936151505*x_27 + 5.1101598739624) - 0.0258562917050784*std::sin(0.305439829826355*x_27 - 4.30359983444214) - 0.0351868337721343*std::sin(0.329759836196899*x_28 - 4.26440000534058) - 0.000958781279226661*std::sin(0.348719835281372*x_28 - 4.23776006698608) - 0.00275080203088944*std::sin(0.355279833078384*x_28 + 8.35503959655762) - 0.00595372290810103*std::sin(0.314559936523438*x_3 - 4.25967979431152) + 0.00645153121723957*std::sin(0.320879846811295*x_3 - 4.25608015060425) + 0.0356192089263039*std::sin(0.332959830760956*x_3 + 8.33480072021484) + 0.00673849870846812*std::sin(0.286239951848984*x_30 + 8.28415966033936) - 0.00254975684544284*std::sin(0.246079966425896*x_32 + 5.16936016082764) - 0.00156993958776571*std::sin(0.265119940042496*x_32 + 1.95223987102509) - 0.00357604834796766*std::sin(0.333039849996567*x_34 - 7.41599988937378) - 0.00235038813268224*std::sin(0.415279865264893*x_34 + 8.18767929077148) + 0.00254204939203171*std::sin(0.302479922771454*x_35 + 8.27551937103271) + 0.00118113809864316*std::sin(0.355519831180573*x_35 - 1.22207987308502) - 0.0029683017765549*std::sin(0.352639853954315*x_36 + 5.17200040817261) - 0.00908102890998194*std::sin(0.362639844417572*x_36 - 4.23672008514404) + 0.00343320616808901*std::sin(0.363919854164124*x_36 + 5.15623998641968) - 0.00747392193432512*std::sin(0.368639826774597*x_36 - 4.23024034500122) - 0.0141237928410173*std::sin(0.318879842758179*x_37 - 4.25999975204468) - 0.00123852225231538*std::sin(0.393119841814041*x_37 - 7.40255975723267) + 0.00179022560801038*std::sin(0.459439843893051*x_37 + 2.04919981956482) + 0.00636453307031583*std::sin(0.348319828510284*x_38 + 1.94791972637177) - 0.00055818413216173*std::sin(0.362959831953049*x_38 - 7.44015979766846) - 0.0191106478360445*std::sin(0.366399854421616*x_38 + 5.16160011291504) + 0.000372587208726386*std::sin(0.448799848556519*x_38 + 5.24264001846313) + 0.000856336625837081*std::sin(0.282239943742752*x_40 + 5.09631967544556) + 0.00141540592890355*std::sin(0.343279838562012*x_41 + 5.15711975097656) - 0.00216851471215856*std::sin(0.367999851703644*x_41 + 5.17600011825562) + 0.00887113467475614*std::sin(0.353599846363068*x_43 + 5.16128015518188) + 0.000698355721068356*std::sin(0.338319838047028*x_44 + 8.31983947753906) - 0.0201034707422552*std::sin(0.342479854822159*x_45 + 5.15463972091675) + 0.000932234154767776*std::sin(0.303999930620193*x_46 + 5.12455987930298) - 0.00907236775767668*std::sin(0.373519837856293*x_47 - 7.40975952148438) + 0.00405611188270616*std::sin(0.391199827194214*x_47 + 5.17775964736938) + 0.000949832349074419*std::sin(0.454959839582443*x_47 - 1.14519989490509) - 0.0018977643080727*std::sin(0.485199838876724*x_48 + 2.04519987106323) - 0.00220693887223981*std::sin(0.23455998301506*x_49 + 5.04671955108643) - 0.0215852769646003*std::sin(0.391439825296402*x_50 - 4.21415996551514) - 0.0140925048371059*std::sin(0.353759855031967*x_51 + 5.1625599861145) + 0.00791728036030015*std::sin(0.270639955997467*x_53 + 5.08367967605591) - 0.0111710139598134*std::sin(0.30583992600441*x_53 - 4.24975967407227) - 0.00209149389677309*std::sin(0.262479960918427*x_54 - 7.52544021606445) - 0.00100076499398159*std::sin(0.275279939174652*x_55 - 1.09767985343933) + 0.0252070131317283*std::sin(0.309359937906265*x_55 + 5.14407968521118) - 0.00192877196226673*std::sin(0.345439851284027*x_55 - 7.45807981491089) + 0.00103827325924258*std::sin(0.406399875879288*x_55 - 7.39015960693359) - 0.00315196602885471*std::sin(0.218239992856979*x_56 - 4.3854398727417) - 0.0117337979177088*std::sin(0.31127992272377*x_57 + 5.13424015045166) + 0.0104895958301643*std::sin(0.352319836616516*x_57 + 5.14552021026611) - 0.00236997531600292*std::sin(0.547279834747314*x_58 - 7.24168014526367) + 0.00690961201985527*std::sin(0.416479855775833*x_59 - 7.39607954025269) - 0.00111829429151135*std::sin(0.50111985206604*x_59 - 4.32183980941772) + 0.00699307444356001*std::sin(0.463119864463806*x_60 - 4.14192008972168) - 0.0243535720179713*std::sin(0.287999957799911*x_62 - 4.27383995056152) - 0.0027859971612791*std::sin(0.214239999651909*x_65 - 4.37847948074341) - 0.00986352250337035*std::sin(0.305919915437698*x_65 + 5.13711977005005) + 0.0154999815590479*std::sin(0.214239999651909*x_68 + 5.0021595954895) - 0.00798000312125909*std::sin(0.26063996553421*x_68 + 5.08111953735352) - 0.000973985189561945*std::sin(0.386399835348129*x_68 - 1.0201598405838) + 0.021285408257502*std::sin(0.254239976406097*x_7 + 8.28104019165039) + 0.0022139706254683*std::sin(0.245439976453781*x_70 + 5.05655956268311) - 0.00162876917247399*std::sin(0.281039953231812*x_71 - 4.29439973831177) + 0.00593997479704016*std::sin(0.290399938821793*x_72 - 1.06831979751587) + 0.0161797163374937*std::sin(0.225679993629456*x_74 + 5.04471969604492) - 0.00838259268602293*std::sin(0.353759855031967*x_74 + 5.15727996826172) - 0.000481052566542827*std::sin(0.373519837856293*x_74 - 7.43503999710083) - 0.00287149524690111*std::sin(0.254399985074997*x_75 - 7.54184007644653) + 0.00753071032938073*std::sin(0.290879935026169*x_75 + 5.09583950042725) - 0.000869545031337824*std::sin(0.353839844465256*x_75 + 5.14816045761108) - 0.0366072640050634*std::sin(0.185440018773079*x_77 - 7.62768030166626) - 0.00421165272235025*std::sin(0.19463999569416*x_77 + 4.99911975860596) + 0.00323221344157725*std::sin(0.205440014600754*x_78 - 7.57904005050659) + 0.0013341442165108*std::sin(0.413199871778488*x_79 - 0.998559832572937) - 0.0011809929492534*std::sin(0.453359842300415*x_79 - 7.34407997131348) - 0.0424232127671834*std::sin(0.198319986462593*x_8 - 1.20415985584259) + 0.00284590799370574*std::sin(0.286399960517883*x_8 + 8.31287956237793) - 0.000912438404679995*std::sin(0.238159984350204*x_80 + 1.82535994052887) + 0.000366738265618744*std::sin(0.560719847679138*x_80 + 2.34431982040405) - 0.00768026060794076*std::sin(0.399199843406677*x_81 + 5.2050404548645) - 0.0101506706708166*std::sin(0.166720017790794*x_84 - 4.44655990600586) - 0.000845416473236862*std::sin(0.307439923286438*x_84 - 7.48952007293701) - 0.000694374798028045*std::sin(0.254959970712662*x_87 - 7.5402398109436) + 0.000967154786220114*std::sin(0.297679930925369*x_89 + 5.11312007904053) + 0.222559071360692*std::sin(0.202799990773201*x_9 - 4.39831972122192) + 0.0635836843432127*std::sin(0.205039992928505*x_9 - 4.39551973342896) + 0.144579204064687*std::sin(0.210319995880127*x_9 - 4.38711977005005) - 0.000996153494672421*std::sin(0.374799847602844*x_90 + 8.36688041687012) + 0.00205151165108134*std::sin(0.241679981350899*x_92 + 8.43072032928467) - 0.0327397889438466*std::sin(0.357679843902588*x_92 + 2.0079197883606) - 0.0128146544132568*std::sin(0.361359834671021*x_92 - 7.41015958786011) + 0.00906113831257644*std::sin(0.366239845752716*x_92 + 2.00367975234985) - 0.00735398521836969*std::sin(0.331919848918915*x_93 - 7.40503978729248) - 0.013053087358227*std::sin(0.350799858570099*x_93 + 1.98431980609894) - 0.00109229096646799*std::sin(0.379039853811264*x_93 - 7.41239976882935) - 0.00151723046708084*std::sin(0.333199828863144*x_94 + 1.94319987297058) - 0.00260438169461439*std::sin(0.412159860134125*x_94 - 4.2065601348877) + 0.000696050926204377*std::sin(0.350079834461212*x_95 + 8.37312030792236) + 0.0165059744862847*std::sin(0.381519854068756*x_95 - 7.40271997451782) + 0.000523867646344116*std::sin(0.409439861774445*x_95 - 7.4031195640564) + 0.00217343864774811*std::sin(0.419039845466614*x_95 - 7.3983998298645) + 0.00850067069680876*std::sin(0.323839843273163*x_96 + 5.14455986022949) - 0.00135663476190754*std::sin(0.335439831018448*x_96 - 7.45047998428345) - 0.00681780557367343*std::sin(0.406719863414764*x_96 + 2.01599979400635) + 0.00416455642331223*std::sin(0.392319828271866*x_98 + 2.00223970413208) - 0.000762322695682489*std::sin(0.300399929285049*x_99 - 1.07527995109558) - 0.00105300155144541*std::sin(0.396959841251373*x_99 - 7.4041600227356) + 0.00306373776245603*std::sin(0.402559846639633*x_99 + 1.9916797876358) - 0.374670934357171);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00570934709260018*x_1 - 0.000949979258103875*x_10 - 0.000247567779712545*x_100 + 0.00194633941104658*x_101 + 0.00025310748304031*x_102 + 0.000947128944591823*x_103 - 0.00237115960357694*x_104 - 0.000394402686843451*x_105 - 0.00131172883199179*x_106 - 0.00034122396180353*x_107 + 0.00236267658506479*x_108 + 0.00297975440689715*x_109 + 0.00350239861832447*x_11 + 0.00162140494753669*x_110 + 0.00034765373657261*x_111 - 0.000217558524625653*x_112 - 0.000391643960356344*x_113 - 0.000584047540799911*x_114 - 0.000871116771539918*x_115 - 0.00407556877321941*x_116 - 0.000738277091297647*x_117 - 0.00121178949412355*x_118 - 0.000156139705422457*x_119 + 0.000273193200071363*x_12 - 6.34751873307736e-5*x_120 - 0.00230347368707319*x_13 - 0.000296519109452353*x_15 - 0.00037772071335061*x_16 - 0.000577514426320015*x_18 + 0.000655796783759754*x_19 + 0.0230827111770543*x_2 - 0.00339908406517391*x_20 - 0.000401379969832864*x_21 + 0.00191932831936221*x_22 - 0.000662541984723126*x_23 - 0.00130460432006375*x_24 + 0.000370250618252022*x_25 - 0.000943590810625948*x_26 + 0.000143067314636106*x_27 + 0.000899400575640293*x_28 + 0.0140842231201043*x_29 - 0.000548497342645283*x_3 + 0.000896411815966831*x_30 + 0.00645623966548432*x_31 + 0.00179209021004535*x_32 + 0.00176678312596845*x_33 + 0.00249964655155605*x_34 - 0.00121312910864435*x_35 + 0.00107748477131944*x_36 + 0.000331165798700117*x_37 + 0.000294914309089861*x_38 + 0.000307926762723647*x_39 - 0.00939055043188638*x_4 + 0.00247865979112554*x_40 + 0.000972631750581878*x_41 + 0.0024843240222482*x_42 - 0.000536264106173949*x_43 - 0.000522539374658541*x_44 + 0.000401484898118778*x_45 + 0.000410479586520673*x_46 + 0.00031823795597176*x_47 + 0.000264497340412741*x_48 - 0.000980798998083531*x_49 + 0.000123255761645266*x_5 + 0.0022768277304651*x_50 + 7.64353907866229e-5*x_51 + 7.25604596114252e-5*x_52 + 1.96508822187906e-5*x_53 - 0.00193417518719257*x_54 - 0.000248337350394635*x_55 - 0.000583703979895859*x_56 - 0.000531243895608471*x_57 + 0.000235184181684943*x_58 + 0.000934718976561711*x_59 - 0.000844648935488442*x_6 - 0.000430925059346417*x_60 - 0.000896371323297922*x_61 - 0.00192681585618634*x_62 + 7.27666619787503e-5*x_63 - 8.28943379807601e-5*x_64 + 0.000473671033746529*x_65 - 0.000767562210042927*x_66 - 0.00062518738155569*x_67 + 0.000652378585776901*x_68 + 0.000607461392928009*x_69 + 5.36383237948021e-5*x_7 - 0.000745559865714669*x_70 - 0.000303957697444191*x_71 - 0.000579781783031618*x_72 + 0.00163990372412482*x_73 - 0.000489289947476206*x_74 + 0.00038615284084686*x_75 - 0.0013131357764566*x_76 + 0.000101846298379461*x_77 - 0.000850301425551191*x_78 - 0.000182940095245225*x_79 + 0.000548195802635838*x_8 - 0.000287743290225949*x_80 - 0.000375017015434579*x_81 + 0.00106037177172654*x_82 + 0.000298022461111156*x_83 - 0.000337758181006581*x_84 + 0.00254103394565311*x_85 + 0.000734159208095351*x_86 - 0.00115624281347263*x_87 + 0.00116108178104092*x_88 + 0.0015598829508679*x_89 - 0.000114311457797887*x_9 + 0.00128653566863499*x_90 - 0.0268251863036102*x_91 + 0.000864959018774517*x_92 - 0.0016001757180741*x_93 - 0.000120505748572592*x_94 + 0.000180269673928762*x_95 - 0.000137152258906816*x_96 - 0.00254008047376714*x_97 + 0.00027266089810842*x_98 - 0.000318269001309493*x_99 + 3.82278085671142e-6*std::pow(-6.07055997848511*x_108 - 8.49071979522705, 2) - 3.2785212505517e-5*std::pow(-3.85383987426758*x_13 - 6.28512001037598, 2) - 2.58809011729891e-5*std::pow(-5.0818395614624*x_14 - 7.72304010391235, 2) + 0.000792783225785242*std::pow(-1.07743990421295*x_14 - 1.72439980506897, 2) - 4.05334041013793e-5*std::pow(-4.78087997436523*x_15 - 7.78128004074097, 2) + 2.17829585436981e-5*std::pow(-6.26783990859985*x_17 - 8.88696002960205, 2) - 1.23294512669404e-5*std::pow(-5.94151973724365*x_17 - 8.59568023681641, 2) + 4.65552167527352e-5*std::pow(-5.65711975097656*x_17 - 8.48408031463623, 2) - 0.00014354189897079*std::pow(-4.90263986587524*x_17 - 7.56591987609863, 2) - 0.000167000419137706*std::pow(-3.70231986045837*x_17 - 5.34439992904663, 2) + 4.58444389423206e-5*std::pow(-2.11367988586426*x_18 - 2.87975978851318, 2) + 2.26754120769404e-5*std::pow(-5.01983976364136*x_19 - 8.22336006164551, 2) + 1.98550590714503e-5*std::pow(-6.21544027328491*x_22 - 9.81591987609863, 2) - 6.48050220687616e-5*std::pow(-6.07119941711426*x_22 - 9.69167995452881, 2) - 1.61593190625632e-5*std::pow(-3.7279999256134*x_22 - 6.19999980926514, 2) + 0.00143985761305183*std::pow(-1.80927991867065*x_4 - 3.00735998153687, 2) + 1.490026251108e-5*std::pow(-5.43544006347656*x_5 - 8.05191993713379, 2) - 0.000152802822133057*std::pow(-5.15328025817871*x_6 - 8.12784004211426, 2) + 0.000190678960305653*std::pow(-3.36783981323242*x_6 - 5.34975957870483, 2) - 4.84750619741055e-5*std::pow(-1.48615992069244*x_6 - 2.54791975021362, 2) + 3.35266895289847e-6*std::pow(-6.0958399772644*x_66 - 9.95759963989258, 2) + 2.05835262114546e-5*std::pow(-5.29624032974243*x_67 - 7.5351996421814, 2) + 1.58278426771333e-6*std::pow(-4.91903972625732*x_67 - 8.66384029388428, 2) - 1.96288507373502e-5*std::pow(-5.38607978820801*x_7 - 8.77080059051514, 2) + 0.00011749161258461*std::pow(-4.51895999908447*x_7 - 7.46663999557495, 2) - 0.000591895317466706*std::pow(-3.49199986457825*x_7 - 5.62400007247925, 2) + 2.42400572243073e-5*std::pow(-5.50767993927002*x_70 - 8.96648025512695, 2) + 4.34907019013881e-6*std::pow(-5.17312002182007*x_71 - 9.14951992034912, 2) + 2.55295685736419e-6*std::pow(-5.41871976852417*x_77 - 8.64591979980469, 2) + 8.71989643039895e-6*std::pow(-5.07823991775513*x_81 - 6.69808053970337, 2) + 1.10607100127086e-5*std::pow(-5.85183954238892*x_82 - 7.25784015655518, 2) + 2.58168724125975e-5*std::pow(-5.53887987136841*x_82 - 7.58911991119385, 2) + 5.81464073054312e-6*std::pow(-6.80000019073486*x_85 - 9.99676036834717, 2) - 7.3612059296244e-6*std::pow(-6.86871957778931*x_86 - 8.89000034332275, 2) + 3.50274737424184e-5*std::pow(-4.53007984161377*x_86 - 5.5527195930481, 2) - 4.03249277038117e-5*std::pow(-5.89527988433838*x_90 - 9.14391994476318, 2) - 0.0684975939195193*std::sin(0.295599937438965*x_1 + 1.98367977142334) + 0.0326867955801494*std::sin(0.320239931344986*x_1 + 1.96527981758118) - 0.0276776984490488*std::sin(0.192640006542206*x_10 - 1.22311997413635) + 0.0510081300116117*std::sin(0.307519912719727*x_10 - 7.46888017654419) - 0.0109710724054014*std::sin(0.335919857025146*x_102 + 8.33936023712158) + 0.00414025396478574*std::sin(0.411279857158661*x_103 + 2.01903986930847) + 0.00760335527834915*std::sin(0.39055985212326*x_105 + 1.97119987010956) + 0.00719417576984896*std::sin(0.465279847383499*x_105 - 1.15903985500336) + 0.000931634254026796*std::sin(0.308559864759445*x_106 - 1.27239990234375) - 0.00460362273749334*std::sin(0.468879848718643*x_106 + 5.25511980056763) - 0.000981213216425532*std::sin(0.505839824676514*x_107 + 5.26151990890503) + 0.0188715446747267*std::sin(0.270079970359802*x_11 + 8.2992000579834) + 0.00886706248804956*std::sin(0.393039852380753*x_110 + 1.99663984775543) - 0.00272823040329826*std::sin(0.480879843235016*x_110 + 5.24336004257202) + 0.00226810311558699*std::sin(0.469759851694107*x_111 + 2.02207970619202) - 0.00693948133891635*std::sin(0.353599846363068*x_112 + 5.17000007629395) - 0.0139894700260984*std::sin(0.361279845237732*x_112 + 5.17248010635376) - 0.00814193425125721*std::sin(0.403839856386185*x_112 - 1.17599976062775) + 0.00212240260417413*std::sin(0.411519855260849*x_112 + 1.99287974834442) + 0.0100902858842881*std::sin(0.359839856624603*x_114 - 4.23712015151978) + 0.00508652694379333*std::sin(0.400079846382141*x_115 + 8.3942403793335) - 0.00158351999599546*std::sin(0.448079854249954*x_115 + 2.03823971748352) - 0.00298968668492504*std::sin(0.530159831047058*x_115 - 1.03967976570129) + 0.00440599436141915*std::sin(0.356719851493835*x_117 + 2.14879989624023) + 0.00615381650099562*std::sin(0.409199863672256*x_117 - 7.38831996917725) - 0.0195901686890613*std::sin(0.412159860134125*x_117 + 5.203200340271) - 0.00783341620872573*std::sin(0.33231982588768*x_118 + 1.94903981685638) + 0.00204999334972551*std::sin(0.396319836378098*x_118 + 2.00671982765198) - 0.0112905174463539*std::sin(0.35471984744072*x_119 - 7.4332799911499) - 0.00541967769692632*std::sin(0.392399847507477*x_119 - 1.17687976360321) + 0.0609214274882781*std::sin(0.24679996073246*x_12 + 5.06799983978271) - 0.0227595673385309*std::sin(0.258559972047806*x_12 - 4.33599996566772) - 0.027938337861968*std::sin(0.282159954309464*x_12 - 4.30015993118286) - 0.00631503200304908*std::sin(0.285359919071198*x_12 - 4.28639984130859) - 0.00244844510732656*std::sin(0.383039832115173*x_120 - 7.41440010070801) + 0.00899191849259431*std::sin(0.42495983839035*x_120 + 5.21432018280029) + 0.039854978775309*std::sin(0.169440016150475*x_14 - 4.44503974914551) - 0.0941844542858039*std::sin(0.169520005583763*x_14 - 4.45079946517944) + 0.0123866229102265*std::sin(0.346159845590591*x_14 + 2.1276798248291) + 0.394674686186444*std::sin(0.146160036325455*x_15 - 4.48871994018555) + 0.0711137756863433*std::sin(0.359359860420227*x_16 - 4.23943996429443) - 0.0743692080605407*std::sin(0.154080033302307*x_19 - 4.46744012832642) + 0.0563409670946737*std::sin(0.23063999414444*x_19 - 4.34007978439331) + 0.012806869381604*std::sin(0.32167986035347*x_21 + 8.33103942871094) + 0.0383186111213009*std::sin(0.327519834041595*x_21 - 4.26376008987427) + 0.0127463329446391*std::sin(0.340719848871231*x_21 + 5.15775966644287) - 0.00215138179076939*std::sin(0.355359852313995*x_21 + 5.16544008255005) - 0.152368637886725*std::sin(0.18104000389576*x_23 + 4.96823978424072) - 0.0718310293712082*std::sin(0.232959985733032*x_23 + 5.04463958740234) + 0.154648965964123*std::sin(0.250639975070953*x_24 + 5.05199956893921) - 0.00210389458936179*std::sin(0.462799847126007*x_24 - 0.902719795703888) - 0.0608941124361048*std::sin(0.329199850559235*x_26 - 4.25816011428833) - 0.151160595319889*std::sin(0.227439984679222*x_27 + 5.01991987228394) - 0.11938724689765*std::sin(0.262239962816238*x_27 + 5.06120014190674) - 0.01325891732473*std::sin(0.283199936151505*x_27 + 5.1101598739624) - 0.0999766817969485*std::sin(0.305439829826355*x_27 - 4.30359983444214) + 0.0214714805145221*std::sin(0.329759836196899*x_28 - 4.26440000534058) - 0.0116874244914761*std::sin(0.348719835281372*x_28 - 4.23776006698608) + 0.00313852190117149*std::sin(0.355279833078384*x_28 + 8.35503959655762) - 0.0725751414209167*std::sin(0.314559936523438*x_3 - 4.25967979431152) - 0.0130510845475058*std::sin(0.320879846811295*x_3 - 4.25608015060425) - 0.0217353216648181*std::sin(0.332959830760956*x_3 + 8.33480072021484) - 0.00768827619728956*std::sin(0.286239951848984*x_30 + 8.28415966033936) + 0.0051580145929596*std::sin(0.246079966425896*x_32 + 5.16936016082764) - 0.0191373682254107*std::sin(0.265119940042496*x_32 + 1.95223987102509) + 0.00723414454084648*std::sin(0.333039849996567*x_34 - 7.41599988937378) - 0.00908807841127282*std::sin(0.415279865264893*x_34 + 8.18767929077148) - 0.00514242284849964*std::sin(0.302479922771454*x_35 + 8.27551937103271) + 0.0143979264520393*std::sin(0.355519831180573*x_35 - 1.22207987308502) + 0.00600470743206062*std::sin(0.352639853954315*x_36 + 5.17200040817261) + 0.0103609811971581*std::sin(0.362639844417572*x_36 - 4.23672008514404) + 0.0132749337965947*std::sin(0.363919854164124*x_36 + 5.15623998641968) + 0.00456068796127396*std::sin(0.368639826774597*x_36 - 4.23024034500122) + 0.00861852887193309*std::sin(0.318879842758179*x_37 - 4.25999975204468) + 0.00250546080994575*std::sin(0.393119841814041*x_37 - 7.40255975723267) + 0.00692213786873581*std::sin(0.459439843893051*x_37 + 2.04919981956482) - 0.0072616008740759*std::sin(0.348319828510284*x_38 + 1.94791972637177) + 0.00112917508365338*std::sin(0.362959831953049*x_38 - 7.44015979766846) + 0.0116615750450522*std::sin(0.366399854421616*x_38 + 5.16160011291504) + 0.00454179171290436*std::sin(0.448799848556519*x_38 + 5.24264001846313) + 0.0104386369139674*std::sin(0.282239943742752*x_40 + 5.09631967544556) + 0.0172536221526882*std::sin(0.343279838562012*x_41 + 5.15711975097656) + 0.00438678321438874*std::sin(0.367999851703644*x_41 + 5.17600011825562) + 0.0343013846947656*std::sin(0.353599846363068*x_43 + 5.16128015518188) + 0.00851286934258886*std::sin(0.338319838047028*x_44 + 8.31983947753906) + 0.0122674089721149*std::sin(0.342479854822159*x_45 + 5.15463972091675) - 0.00188585722710842*std::sin(0.303999930620193*x_46 + 5.12455987930298) + 0.00553608116010143*std::sin(0.373519837856293*x_47 - 7.40975952148438) + 0.0156834789634775*std::sin(0.391199827194214*x_47 + 5.17775964736938) + 0.0115783381464463*std::sin(0.454959839582443*x_47 - 1.14519989490509) - 0.00733795010196785*std::sin(0.485199838876724*x_48 + 2.04519987106323) + 0.00446451312764518*std::sin(0.23455998301506*x_49 + 5.04671955108643) + 0.0131716271133498*std::sin(0.391439825296402*x_50 - 4.21415996551514) + 0.00859943650998113*std::sin(0.353759855031967*x_51 + 5.1625599861145) + 0.0306131841451762*std::sin(0.270639955997467*x_53 + 5.08367967605591) + 0.00681670337600934*std::sin(0.30583992600441*x_53 - 4.24975967407227) - 0.0254950503545866*std::sin(0.262479960918427*x_54 - 7.52544021606445) + 0.00202449125778645*std::sin(0.275279939174652*x_55 - 1.09767985343933) - 0.015381659367028*std::sin(0.309359937906265*x_55 + 5.14407968521118) - 0.00745784519024989*std::sin(0.345439851284027*x_55 - 7.45807981491089) + 0.0126564218365884*std::sin(0.406399875879288*x_55 - 7.39015960693359) + 0.00637624987747484*std::sin(0.218239992856979*x_56 - 4.3854398727417) + 0.0133876525228324*std::sin(0.31127992272377*x_57 + 5.13424015045166) - 0.00640089284336093*std::sin(0.352319836616516*x_57 + 5.14552021026611) + 0.00144619090046557*std::sin(0.547279834747314*x_58 - 7.24168014526367) - 0.00788350757684358*std::sin(0.416479855775833*x_59 - 7.39607954025269) - 0.00432402889838278*std::sin(0.50111985206604*x_59 - 4.32183980941772) - 0.00426726833746581*std::sin(0.463119864463806*x_60 - 4.14192008972168) + 0.0148608780894913*std::sin(0.287999957799911*x_62 - 4.27383995056152) + 0.00563591545582292*std::sin(0.214239999651909*x_65 - 4.37847948074341) + 0.00601885445582166*std::sin(0.305919915437698*x_65 + 5.13711977005005) + 0.059932674873216*std::sin(0.214239999651909*x_68 + 5.0021595954895) + 0.00910476809535815*std::sin(0.26063996553421*x_68 + 5.08111953735352) + 0.001970317220666*std::sin(0.386399835348129*x_68 - 1.0201598405838) - 0.0129886431841031*std::sin(0.254239976406097*x_7 + 8.28104019165039) - 0.0044787379686654*std::sin(0.245439976453781*x_70 + 5.05655956268311) - 0.0198544935427693*std::sin(0.281039953231812*x_71 - 4.29439973831177) - 0.00362465273054502*std::sin(0.290399938821793*x_72 - 1.06831979751587) - 0.0184602139702314*std::sin(0.225679993629456*x_74 + 5.04471969604492) + 0.00511517110873598*std::sin(0.353759855031967*x_74 + 5.15727996826172) + 0.000973142267523799*std::sin(0.373519837856293*x_74 - 7.43503999710083) - 0.0111030061795171*std::sin(0.254399985074997*x_75 - 7.54184007644653) - 0.00459534100581284*std::sin(0.290879935026169*x_75 + 5.09583950042725) - 0.0105996457334838*std::sin(0.353839844465256*x_75 + 5.14816045761108) + 0.0223382461992689*std::sin(0.185440018773079*x_77 - 7.62768030166626) - 0.0513395226244835*std::sin(0.19463999569416*x_77 + 4.99911975860596) - 0.00653858587692903*std::sin(0.205440014600754*x_78 - 7.57904005050659) - 0.000814112793833124*std::sin(0.413199871778488*x_79 - 0.998559832572937) + 0.00134745146860403*std::sin(0.453359842300415*x_79 - 7.34407997131348) + 0.0484026770711712*std::sin(0.198319986462593*x_8 - 1.20415985584259) + 0.0346912643235507*std::sin(0.286399960517883*x_8 + 8.31287956237793) - 0.0111225106172514*std::sin(0.238159984350204*x_80 + 1.82535994052887) + 0.00141804073463978*std::sin(0.560719847679138*x_80 + 2.34431982040405) + 0.00468659860269801*std::sin(0.399199843406677*x_81 + 5.2050404548645) - 0.0392488754094048*std::sin(0.166720017790794*x_84 - 4.44655990600586) - 0.0103055216125783*std::sin(0.307439923286438*x_84 - 7.48952007293701) - 0.00846434238607846*std::sin(0.254959970712662*x_87 - 7.5402398109436) + 0.0117894964998009*std::sin(0.297679930925369*x_89 + 5.11312007904053) - 0.13580854688425*std::sin(0.202799990773201*x_9 - 4.39831972122192) + 0.245854504178975*std::sin(0.205039992928505*x_9 - 4.39551973342896) - 0.164957344554614*std::sin(0.210319995880127*x_9 - 4.38711977005005) + 0.00201516245422832*std::sin(0.374799847602844*x_90 + 8.36688041687012) - 0.00415009260699382*std::sin(0.241679981350899*x_92 + 8.43072032928467) + 0.0199782607582634*std::sin(0.357679843902588*x_92 + 2.0079197883606) - 0.0495495116324203*std::sin(0.361359834671021*x_92 - 7.41015958786011) + 0.110454148542071*std::sin(0.366239845752716*x_92 + 2.00367975234985) + 0.00839051426077429*std::sin(0.331919848918915*x_93 - 7.40503978729248) + 0.00796516994627921*std::sin(0.350799858570099*x_93 + 1.98431980609894) + 0.00220964314886321*std::sin(0.379039853811264*x_93 - 7.41239976882935) - 0.0058665669984758*std::sin(0.333199828863144*x_94 + 1.94319987297058) + 0.00158922883401279*std::sin(0.412159860134125*x_94 - 4.2065601348877) + 0.00269137054753828*std::sin(0.350079834461212*x_95 + 8.37312030792236) - 0.0100721682391363*std::sin(0.381519854068756*x_95 - 7.40271997451782) + 0.0063858814234594*std::sin(0.409439861774445*x_95 - 7.4031195640564) - 0.00247978034050106*std::sin(0.419039845466614*x_95 - 7.3983998298645) - 0.00518722390337501*std::sin(0.323839843273163*x_96 + 5.14455986022949) + 0.00274439576924444*std::sin(0.335439831018448*x_96 - 7.45047998428345) + 0.00777876120150473*std::sin(0.406719863414764*x_96 + 2.01599979400635) - 0.00475154205808248*std::sin(0.392319828271866*x_98 + 2.00223970413208) + 0.00154213590833273*std::sin(0.300399929285049*x_99 - 1.07527995109558) - 0.012835957885882*std::sin(0.396959841251373*x_99 - 7.4041600227356) + 0.011846336623987*std::sin(0.402559846639633*x_99 + 1.9916797876358) - 0.238665564088052);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
