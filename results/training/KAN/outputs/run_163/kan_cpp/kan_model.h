
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00118009533358443*x_1 + 0.000312594392597065*x_10 - 0.000156025506516536*x_100 - 6.24968395330521e-5*x_101 + 0.000436344463844462*x_102 + 0.00287204135579841*x_103 - 0.00450716884476292*x_104 - 0.00224477957374914*x_105 - 0.00633913077785263*x_106 - 0.00380812772678724*x_107 + 0.00174479424905244*x_108 - 0.000931358386386688*x_109 + 0.00854384762026816*x_11 + 0.00355888746114053*x_110 - 0.00813841470645463*x_111 - 0.01477780068819*x_112 - 0.00478504567355073*x_113 - 0.00566398283533666*x_114 + 0.00106591346150756*x_115 - 0.00337898468729801*x_116 - 0.00673281628273549*x_117 - 0.00657498864183433*x_118 - 0.00325199163328315*x_119 + 0.000970920186107977*x_12 - 0.0130031950396986*x_120 + 0.00146340100019025*x_13 + 0.000153934006591526*x_14 + 0.00022078746283535*x_15 - 0.00124069906537806*x_16 - 0.00503500722036146*x_17 - 0.00132827106628762*x_18 + 0.000513956180170065*x_19 + 0.000194207084718707*x_2 - 0.00276374280416362*x_20 + 0.00218526091678849*x_21 + 0.000247058345785007*x_22 + 0.000299368918141617*x_23 - 0.000997395765856222*x_24 + 0.00289832208896122*x_25 - 0.000602501298432912*x_26 + 0.00012194358287233*x_27 + 0.00161602235141314*x_28 + 0.00186378629204361*x_29 + 0.00209383645909733*x_3 - 0.000757799114489537*x_30 + 0.000621159673700871*x_31 - 0.00259878379908613*x_32 - 0.00133176673112105*x_33 + 0.00110622999613815*x_34 + 0.00129940871139748*x_35 + 0.00130054881294665*x_36 - 0.00215794316968069*x_37 + 0.00169647000786102*x_38 - 0.00148693180503244*x_39 - 0.00201139569250011*x_4 - 0.000238686964905024*x_40 + 0.000237156001124545*x_41 - 0.00110696965127379*x_42 - 0.000225690665973647*x_43 - 0.00307703971189102*x_44 - 0.00290900798548328*x_45 - 0.00179848465400765*x_46 - 0.00190360946812477*x_47 + 0.00519943575175973*x_48 + 0.000691102564001928*x_49 + 0.00025926020249511*x_5 + 0.00170855362708002*x_50 - 0.00101275571018326*x_51 + 0.000436801102235678*x_52 - 0.000577221345176545*x_53 - 0.000417373643060253*x_54 + 0.00813799456294166*x_55 - 0.00411344755811244*x_56 - 0.00122496175460356*x_57 + 0.000965801400676582*x_58 + 0.00051780110308274*x_59 + 0.000278799643691395*x_6 + 0.00229890319912614*x_60 - 0.000542078899378427*x_61 - 0.00192887195928268*x_62 - 0.00025000862394981*x_63 + 0.00277748461074575*x_64 + 0.000624517226593666*x_65 + 0.00218528311301648*x_66 + 0.00151253680123154*x_67 + 0.000209219367801923*x_68 + 0.000923273798647773*x_69 + 0.000219572151374947*x_7 + 0.00141422357092473*x_70 - 0.00156602546282421*x_71 + 0.00136095560109322*x_72 + 0.00129428770942353*x_73 + 0.00343697959246359*x_74 + 0.0033959810717419*x_75 + 0.000763903810071097*x_76 + 0.00136460948765926*x_77 + 0.000104071341243178*x_78 + 0.00124074497784897*x_79 + 1.06547066467466e-6*x_8 + 0.00473579864333895*x_80 - 0.00035871995954713*x_81 - 0.003516325128707*x_82 - 0.00347403983321688*x_83 - 0.000748513515864987*x_84 + 0.00189645464076466*x_85 - 0.000418517354941094*x_86 + 0.00191745489346784*x_87 - 0.0025909721181434*x_88 - 0.000494980753516265*x_89 - 0.000619798654084052*x_9 - 0.00108643054273273*x_90 + 0.00304126914925741*x_91 - 0.00193412768266631*x_92 - 0.000586553907477459*x_93 + 0.00459472416055475*x_94 - 0.00199391817989391*x_95 + 0.000866608949646388*x_96 - 0.00123909310871981*x_97 + 0.000260339961160952*x_98 + 0.00668790772070394*x_99 + 8.72237740165415e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) + 3.26864015326362e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 9.10954229933984e-7*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) - 1.0202324988888e-5*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.00709768869550699*std::exp(0.241199851036072*x_59) + 0.000208185082640065*std::exp(0.262799859046936*x_59) + 0.00676694765709823*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.0568502278571231*std::sin(0.322319835424423*x_1 - 4.26448011398315) - 0.00238271995792108*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.0308021421854371*std::sin(0.351919859647751*x_1 - 4.22192001342773) + 0.00147248722460741*std::sin(0.177440017461777*x_10 - 7.61080026626587) - 0.0196984409018259*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.000668801458362685*std::sin(0.613919854164124*x_10 + 4.98239946365356) + 0.00467216385664671*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.0175246442521498*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.00120898674672045*std::sin(0.205119997262955*x_102 - 7.41111993789673) + 0.00128589482439439*std::sin(0.180640012025833*x_107 - 7.3918399810791) + 0.000684981690128189*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.000975851533574822*std::sin(0.278079956769943*x_108 - 4.41975975036621) + 0.0197845209535277*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.00211234847373501*std::sin(0.314319938421249*x_11 + 5.12199974060059) - 0.000964494424473844*std::sin(0.320399910211563*x_11 - 4.29864025115967) - 0.00107312100814799*std::sin(0.190880000591278*x_110 + 8.41744041442871) + 0.0281866047250576*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.0479501904562907*std::sin(0.245119974017143*x_116 - 7.42927980422974) + 0.0265231314706794*std::sin(0.250159978866577*x_116 + 5.1715202331543) + 0.00822441059015687*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.0221493116172381*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.00283222985005334*std::sin(0.293759942054749*x_12 + 1.95231974124908) - 0.0308543010731414*std::sin(0.301919937133789*x_12 + 8.31360054016113) + 0.0723861537646478*std::sin(0.261279970407486*x_120 - 4.24855995178223) + 0.0121603916814011*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.00656300656885742*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.00290396438156942*std::sin(0.329119831323624*x_14 - 4.3219199180603) - 0.000594251435335418*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.00537814674795104*std::sin(0.401919841766357*x_14 - 1.40335988998413) + 0.0101779822175684*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.0787110824349419*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.000751175417038232*std::sin(0.336879849433899*x_15 - 1.09447979927063) - 0.0103648503272099*std::sin(0.357919842004776*x_15 - 4.34151983261108) - 0.00055596705476421*std::sin(0.479599863290787*x_15 + 8.09632015228271) + 0.00663772322891876*std::sin(0.35319983959198*x_17 + 2.01239991188049) - 0.0254776624283072*std::sin(0.370559841394424*x_17 - 1.17351984977722) - 0.0188430921627992*std::sin(0.445119857788086*x_18 + 5.17095994949341) + 0.00424988713180417*std::sin(0.497599840164185*x_19 + 1.90071988105774) + 0.0010105912964304*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.0717417406304939*std::sin(0.377039849758148*x_2 - 7.3931999206543) - 0.00975979547309243*std::sin(0.428799867630005*x_2 - 7.37967967987061) - 0.0128859003652485*std::sin(0.268879950046539*x_20 + 1.9923198223114) - 0.000912346872034695*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.0222525488633829*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.00526783829869149*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.00552232812008425*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.00170292544030098*std::sin(0.494639873504639*x_23 + 8.32231998443604) - 0.00470965437250567*std::sin(0.120720058679581*x_24 + 7.95175981521606) - 0.0131132812532433*std::sin(0.243999972939491*x_24 + 8.21592044830322) - 0.00800022942367156*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.00335044119402635*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.0430832777987135*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.00114511653473039*std::sin(0.277439951896667*x_26 - 7.40551996231079) + 0.000326156682291171*std::sin(0.598719835281372*x_26 - 4.38567972183228) + 0.005691722566206*std::sin(0.356959849596024*x_27 + 5.00256013870239) + 0.000457494035360924*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.00895655776590759*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.00228167865704449*std::sin(0.201120004057884*x_29 + 8.21127986907959) - 0.000578999168663778*std::sin(0.663759827613831*x_29 + 7.96551990509033) - 0.0978371764096385*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.00201851276062431*std::sin(0.360399842262268*x_3 + 5.18527984619141) - 0.000398260753567307*std::sin(0.532079875469208*x_3 + 1.79583990573883) + 0.0737653154785621*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.00827962443709025*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.136177591097621*std::sin(0.349039852619171*x_30 - 1.13991987705231) + 0.00489794495614971*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.0324273192761824*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.00660336181525454*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.0202567955263755*std::sin(0.421839863061905*x_31 - 7.38175964355469) + 0.000236727068089592*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.00220380753677963*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.096956357136023*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.00651491325810754*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.00410208364591445*std::sin(0.235039994120598*x_36 + 5.17000007629395) - 0.00119091716382873*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.00391721572694616*std::sin(0.0996000692248344*x_4 - 7.55311965942383) - 0.00579378588704478*std::sin(0.255919963121414*x_41 - 7.42320013046265) - 0.000344471858620363*std::sin(0.244959965348244*x_44 - 4.23079967498779) + 0.000506814288780427*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.000551638784238188*std::sin(0.447439849376678*x_49 - 4.49327993392944) + 0.00893604530951892*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.00119996413467947*std::sin(0.198320001363754*x_5 + 1.98175978660583) - 0.00273130251774635*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.0172248002786948*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.00771598787873856*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.0377301607516574*std::sin(0.240319982171059*x_53 - 7.40279960632324) + 0.00035029677898273*std::sin(0.245839968323708*x_53 - 7.60552024841309) - 0.0668122981575316*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.0143994935625853*std::sin(0.105680070817471*x_54 + 1.75039982795715) - 0.0256325964931412*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.00031867279089324*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.00452725848651346*std::sin(0.14408004283905*x_6 - 7.45831966400146) - 0.100146501768696*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.00989526253446951*std::sin(0.446719855070114*x_6 + 5.15248012542725) - 0.000557608311366327*std::sin(0.576079845428467*x_60 + 8.0152006149292) + 2.54654476929171e-5*std::sin(1.24703979492188*x_67 + 2.59119987487793) + 0.00349240597314217*std::sin(0.344559848308563*x_7 + 2.00287985801697) + 0.110140031388278*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.0455005308849456*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.00117524549193595*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 0.00128753640739803*std::sin(1.01663982868195*x_71 + 8.21144008636475) - 0.0138555502156906*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.0212378281014207*std::sin(0.221199989318848*x_8 + 2.01559972763062) - 0.0126456884779844*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 0.000157822160119008*std::sin(1.24679982662201*x_88 + 8.19960021972656) + 0.0153364644851312*std::sin(0.305919945240021*x_9 - 1.20959985256195) + 0.00277656243932314*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.000947027082718269*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.00621594898892958*std::sin(0.15776002407074*x_92 + 8.38064002990723) + 0.0219895083138102*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.000912404481871946*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.00661552958403259*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 0.000910606856364091*std::sin(0.283439934253693*x_95 - 7.42248010635376) - 0.020951977387045*std::sin(0.29079994559288*x_95 - 1.20351994037628) + 0.00643833487156633*std::sin(0.305119931697845*x_96 - 1.22831988334656) + 0.00565925826027171*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.000893096867199844*std::sin(0.268399953842163*x_97 + 5.17671966552734) - 0.0277406019859961);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000560853820204005*x_1 - 0.000821762212416687*x_10 + 0.000560842690770728*x_100 - 0.00177363729732301*x_101 - 0.000394240156937214*x_102 - 0.00321662875343286*x_103 - 0.00784329259738431*x_104 - 0.00545270268198949*x_105 - 0.0103145391472362*x_106 - 0.0131505374368215*x_107 + 0.0108618425281428*x_108 - 0.00198767300073909*x_109 + 0.00345965624710654*x_11 - 0.00771512718733315*x_110 - 0.00665807522291445*x_111 - 0.00365910395673625*x_112 + 0.0163869139911151*x_113 - 0.00833178979540318*x_114 + 0.00392594846249852*x_115 + 0.000460224354223979*x_116 - 0.00337898722268635*x_117 - 0.00714813764533051*x_118 + 0.0513950150338753*x_119 + 0.0110806184231987*x_12 - 0.00457292515820353*x_120 + 0.0142083744072374*x_13 + 0.00209817756496497*x_14 + 0.00300941495257729*x_15 - 0.00825363111401927*x_16 - 0.00127362198202815*x_17 - 0.00580511700314198*x_18 - 0.00448350705856708*x_19 - 0.000237749894203853*x_2 - 0.0103139478139671*x_20 - 0.00365465790212337*x_21 - 0.0110870464361772*x_22 - 2.89698215102581e-5*x_23 - 0.00767501265958686*x_24 - 0.00039738599256183*x_25 - 0.00757063681325691*x_26 - 0.00787751973999317*x_27 + 0.000886981876854307*x_28 - 0.00372747251203972*x_29 - 0.00921288024813156*x_3 - 0.0103290828061887*x_30 - 8.51665708283901e-5*x_31 + 0.000336123439733965*x_32 + 0.00577855511588468*x_33 + 0.0142796207577628*x_34 + 0.0067680847342993*x_35 + 7.16326322295988e-5*x_36 - 0.00415741007963068*x_37 - 0.00119656885847919*x_38 - 0.000536398022569571*x_39 - 0.00853355316336877*x_4 - 0.00268814686516152*x_40 - 0.00276444549491678*x_41 - 0.00415128826459614*x_42 - 0.00540341216974265*x_43 - 0.00783004270032968*x_44 - 0.00641456616929012*x_45 - 0.00843105713975503*x_46 - 0.00575058418777295*x_47 + 0.00727752397715743*x_48 + 0.0007991974048171*x_49 + 0.00353381265393154*x_5 - 0.00259511909308838*x_50 - 0.00774310925246736*x_51 - 0.00360748952923036*x_52 - 0.00578126017395271*x_53 + 0.000912090743563081*x_54 - 0.00523573999934339*x_55 - 0.0143434541425329*x_56 - 0.00106380089148355*x_57 - 0.00666670097423917*x_58 + 0.00592340346289819*x_59 + 0.00319232308071362*x_6 - 0.00208920856558586*x_60 - 0.00505653908018803*x_61 - 0.000641916716281043*x_62 - 0.000317278606957668*x_63 + 0.0067185880981393*x_64 - 0.000385760475137774*x_65 - 0.00446076203324342*x_66 + 0.000362433244828552*x_67 - 0.00641257807598854*x_68 - 0.00216052149071824*x_69 - 0.000812176291269588*x_7 - 0.00176367553159533*x_70 - 0.00463707381494833*x_71 - 0.00125497778856665*x_72 - 0.00428874033020263*x_73 - 0.00318802425858606*x_74 - 0.00626430480654473*x_75 - 0.00329017263028486*x_76 - 0.00440455820361146*x_77 - 0.0023968017723541*x_78 - 0.00432508766082686*x_79 - 0.00294047839964308*x_8 - 0.00314199564234251*x_80 + 0.00309002893164114*x_81 + 0.00445453144321642*x_82 + 0.000110028950673632*x_83 - 0.00126612773803175*x_84 + 0.00402432017542343*x_85 + 0.000961788180386517*x_86 + 0.00311438644761914*x_87 - 0.00151246080833195*x_88 - 0.00750454440929942*x_89 - 0.00250664790825186*x_9 - 0.000664420032637243*x_90 + 0.00131746631963859*x_91 - 0.00113126804723826*x_92 + 0.0185410485764419*x_93 + 0.0123729809666117*x_94 - 0.00101019105650378*x_95 - 0.00141643735212962*x_96 + 0.0058096656648283*x_97 - 0.000397544610267906*x_98 + 0.0185082213962215*x_99 - 1.19591629048292e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 4.48159925558052e-6*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) - 3.36953217132136e-6*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) - 0.00013906147105603*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.00337325782604586*std::exp(0.241199851036072*x_59) - 0.000102889558084667*std::exp(0.262799859046936*x_59) - 0.000927809307865339*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.774889677038579*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.00117759159494571*std::sin(0.332799851894379*x_1 - 4.25767993927002) - 0.113934164449697*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.000727734945769927*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.00270083318879793*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.0091160117664974*std::sin(0.613919854164124*x_10 + 4.98239946365356) + 0.063683325087934*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.00832878785028361*std::sin(0.209440007805824*x_101 + 2.00071978569031) - 0.00447192581571404*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.000635516957062886*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.000338532725302071*std::sin(0.241119980812073*x_108 + 4.99031972885132) - 0.00360958106210444*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.00271263553709993*std::sin(0.309439927339554*x_11 - 7.45864009857178) - 0.00781337404823016*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.000476673947291465*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00053035954785778*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.00386463669385672*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.022788877077613*std::sin(0.245119974017143*x_116 - 7.42927980422974) + 0.361520112654946*std::sin(0.250159978866577*x_116 + 5.1715202331543) + 0.112101764693997*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.0105267139712219*std::sin(0.222479999065399*x_119 - 4.20864009857178) + 0.0104761460924584*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.00423040182574957*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.0099247918894368*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.00600992785058962*std::sin(0.267119973897934*x_120 + 5.15655994415283) - 0.0242759307193305*std::sin(0.188800007104874*x_13 - 1.17847990989685) + 0.0107414852322258*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.000293691876466243*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.00255602582551038*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.00139549278570854*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.0374083432242224*std::sin(0.280479967594147*x_15 + 1.99391984939575) - 0.00277852569409496*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.00142111408208235*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.000274770909850555*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.00328050598559241*std::sin(0.35319983959198*x_17 + 2.01239991188049) - 0.347269982107826*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.00258355719351114*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.000582697700362573*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.00049945601565366*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.0340960837278141*std::sin(0.377039849758148*x_2 - 7.3931999206543) - 0.133029629733658*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00176677268761817*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.000450901502130552*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.010575778654591*std::sin(0.299359947443008*x_21 + 8.36335945129395) - 0.0194852277287807*std::sin(0.399359852075577*x_22 + 1.99407982826233) - 0.0204265611265288*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.0232115049348966*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.00232761277116295*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.00179794864981008*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.00395388593428023*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.0456677553043534*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.0204758211075412*std::sin(0.323279827833176*x_25 - 1.15535986423492) - 0.00423567603826342*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 0.000161193667104954*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.000780386289699426*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.000226103419744244*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.00425670663710639*std::sin(0.576079845428467*x_28 + 1.81583988666534) + 0.00843971012691369*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.000286153877308312*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0134143557077625*std::sin(0.354879856109619*x_3 - 7.40855979919434) + 0.00746628476124336*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.000196829054307664*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.0101138873487284*std::sin(0.327359855175018*x_30 - 1.15199983119965) - 0.0306255352799184*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.0647199594979294*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.0024206700387489*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.44199638081133*std::sin(0.358559846878052*x_31 + 5.17304039001465) - 0.0244252008983894*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.00962727402840484*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 0.000116995622902184*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.0300387135601671*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.0460796189470839*std::sin(0.302479922771454*x_32 - 1.16159987449646) - 0.0240980381837101*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.0559129205173382*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.000588576948683844*std::sin(0.230319991707802*x_38 + 1.96823978424072) + 0.0144894046047819*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.000794380087769748*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 0.000170245422278072*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.000250478552748994*std::sin(0.316959917545319*x_49 + 5.04191970825195) - 0.00204045886100543*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.00122521207992221*std::sin(0.182640001177788*x_5 - 0.996399819850922) + 0.00443855204067421*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.00134986861442098*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.00818628356847566*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.00366711159283532*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.0179316909339887*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 0.000173124223556061*std::sin(0.245839968323708*x_53 - 7.60552024841309) + 0.00916056621856801*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.196270434381958*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.00351445922389342*std::sin(0.178720012307167*x_56 + 4.99911975860596) + 0.00117874003517976*std::sin(0.446799844503403*x_59 + 1.90111982822418) - 0.0167458941590295*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.0137309849579941*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.00470283682719243*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.000275582054262796*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 1.25855735018365e-5*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.00172602235795207*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.015101187635674*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.0216246483160136*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.0160190316558808*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 0.000611916420809457*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.00189972039198925*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.0100935209932051*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00173383748017205*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 0.0021511745386756*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.00210276704063538*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.00137223704385371*std::sin(0.344239860773087*x_91 - 7.38695955276489) - 0.00350296218786214*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.0847256886397232*std::sin(0.15776002407074*x_92 + 8.38064002990723) - 0.00301495911048381*std::sin(0.299599945545197*x_92 + 1.99519979953766) + 0.00337489651389852*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.0901721202541825*std::sin(0.222959995269775*x_95 - 4.21456003189087) + 0.00336824726986225*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.00287270430080737*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.000882753543206033*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.000775935141745352*std::sin(0.243519976735115*x_97 - 1.02255988121033) - 0.00330347950231734*std::sin(0.268399953842163*x_97 + 5.17671966552734) + 1.103246412525);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000402838230306002*x_1 + 0.000957423372747992*x_10 + 0.00106981918213886*x_100 + 0.00145244366942495*x_101 + 0.000476517489217044*x_102 + 0.00128627463902872*x_103 + 0.00068308037306524*x_104 - 0.000247949595934018*x_105 - 0.00141627896313717*x_106 + 0.0013452671207772*x_107 + 0.000949688208843719*x_108 - 0.00062272351271815*x_109 + 0.00293212708163513*x_11 + 0.000145301165999609*x_110 - 0.000279952538953765*x_111 + 0.00418864936079767*x_112 - 0.00233987946179763*x_113 + 0.00422501610380326*x_114 + 0.00249241226404458*x_115 + 0.00256546702622312*x_116 + 0.00735408077357415*x_117 - 0.000216438000769555*x_118 + 0.00592129558392479*x_119 + 1.17673903788218e-5*x_12 - 0.00307027029691894*x_120 + 0.000105692153559582*x_13 + 0.000631745302167954*x_16 + 0.000943762496853873*x_17 - 4.84301068155585e-5*x_18 + 0.000825405198595874*x_19 + 0.000134933606208777*x_2 - 4.34657474502483e-5*x_20 - 0.00116196600837681*x_21 - 0.00080610469909337*x_22 + 1.28072303214252e-5*x_23 + 0.000158899383502455*x_24 - 0.00219568580603037*x_25 - 0.00107814254125604*x_26 + 0.000448535090088784*x_27 - 0.000654683222018327*x_28 - 0.00116152881360909*x_29 + 0.000979640066841102*x_3 - 0.000470572778649416*x_31 + 0.00200228988065271*x_32 - 0.000815387965805692*x_33 - 0.00188241637053754*x_34 + 0.00212153116028184*x_35 - 0.000381304885187974*x_36 - 0.00114225573103911*x_37 - 0.000552103590570855*x_38 - 0.00120593858313977*x_39 - 0.00103908884182551*x_4 + 0.00090637903169114*x_40 + 0.000295022986151096*x_41 - 0.00214614959332835*x_42 - 0.000778679961535661*x_43 - 0.000645389213501128*x_44 - 0.00119502163938038*x_45 - 0.000606831586609171*x_46 + 0.00153768391538044*x_47 + 0.000134370734190948*x_48 + 0.00108068925184906*x_49 - 0.000988123441492327*x_50 - 0.000649569544934142*x_51 - 0.00102250347166712*x_52 - 0.000481726835420331*x_53 + 0.0025933292585039*x_54 + 0.00410336988166207*x_55 - 0.00110069687934844*x_56 + 0.00173040701136432*x_57 - 0.000226868534266292*x_58 - 6.24226239049302e-5*x_59 - 7.08641424572628e-6*x_6 - 0.000913957456126872*x_60 + 0.000363370013393135*x_61 + 0.000606723019295835*x_62 - 0.000566788880326204*x_63 - 0.000416225705456083*x_64 - 0.000316502571001412*x_65 - 0.000151866848885257*x_66 - 0.00305753014790713*x_67 - 0.000320326429797037*x_68 + 0.00114130748252456*x_69 + 0.000878504735625138*x_7 + 0.000826435368207576*x_70 + 0.000876444933830981*x_71 - 0.000398527842577215*x_72 - 0.000717829329019447*x_73 + 0.000917531278287866*x_74 + 0.00161368210351165*x_75 - 0.000231671639722902*x_76 - 0.000420222897999564*x_77 - 0.000749790428098452*x_78 + 0.000578205569924209*x_79 + 0.000527975714927592*x_8 + 0.000632979839935989*x_80 + 0.000679442674327504*x_81 + 0.000536625722960876*x_82 - 0.000351788438928199*x_83 + 0.000228975803348288*x_84 - 9.5074971243034e-5*x_85 + 9.07561714963906e-5*x_86 + 0.000163529914608376*x_87 - 0.0011109278856315*x_88 - 0.000914024257335151*x_89 + 0.000528938411025229*x_9 + 0.000121277858317858*x_90 + 0.00209386468142587*x_91 - 0.000504841569829153*x_92 - 0.000611866711877259*x_93 + 0.000797513605370557*x_94 - 0.000713298790049675*x_95 - 3.38922242808341e-6*x_96 - 0.000647446888085648*x_97 - 0.000729594466555802*x_98 - 0.00116824317560662*x_99 - 6.60782330873245e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 2.47622816555703e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 3.64471359379351e-6*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) + 0.00242287234936887*std::exp(0.241199851036072*x_59) - 3.42828962827845e-5*std::exp(0.262799859046936*x_59) - 0.00512644573818444*std::sin(0.308639913797379*x_1 + 8.31319999694824) + 0.000392374612784139*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.123238888027732*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.000242481959604277*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.0149229746596483*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.00598222573750496*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.0048371370214808*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.000211754840146257*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.000112799418385186*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.00390436668832654*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.0149881864414664*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.00845147313011424*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.000158828201810831*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00017671629376453*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.0213533644692951*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.0163683130646546*std::sin(0.245119974017143*x_116 - 7.42927980422974) - 0.00756090566622515*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.0113317072318609*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.0233743348192075*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.0548376769371183*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.00200251353980192*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.0262584863999196*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.0116187159679419*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 9.7858405920095e-5*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.00183588821734424*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.00771054782843479*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.0268688742775147*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.00300544106809973*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.00785211375635644*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 9.15539222763626e-5*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.00109306764022226*std::sin(0.35319983959198*x_17 + 2.01239991188049) + 0.0142749869523331*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.0032195927733753*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.000166419208141384*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.0244898145193731*std::sin(0.377039849758148*x_2 - 7.3931999206543) + 0.00976198906176032*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.000150240799154497*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.00759614681018622*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.0210765384541201*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.0220947482401151*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.000775562736449887*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.00993424631026777*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.00131743846433227*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.0147069401007626*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.00458159330454181*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 5.37098795414531e-5*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.00431188600400184*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 7.53378693870583e-5*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.00305741729279837*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.00912896053910549*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 9.53467376019321e-5*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0741186427702125*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.0080760379129325*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 6.55836236434743e-5*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.0558824903520923*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.033126647580916*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.0464856848797761*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.000806569504409598*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.0264199471081433*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.00691487495059385*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 3.89830501769166e-5*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.03309709496686*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.026066065817523*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.000196114385772379*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.0156727187170063*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.00438920625275389*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 5.67259327693405e-5*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 8.34596863356089e-5*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.0022070981282148*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.00676969199623607*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.00480103769214387*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.000449777475625846*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.00587987077329403*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.00263393542341401*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.0128795960409339*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 5.76851520280219e-5*std::sin(0.245839968323708*x_53 - 7.60552024841309) + 0.0506150835655878*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.0194185209801391*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.00127500484083035*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.0181134902349687*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.0758681215226608*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.0033778542583431*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 9.18241963476374e-5*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 4.19352477602993e-6*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.0005751122522146*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.083438933345623*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.0155320954316473*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.000439514396040668*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.0104965680174755*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.00724976096798312*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00958001141568901*std::sin(0.240479975938797*x_8 + 1.98351979255676) - 0.0116184662543011*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.000457230657081054*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.00378904051230327*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.0166586217143053*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.00365051602906307*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.00364332375758582*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.0158726179992963*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.00487749810340617*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.00428729197561072*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.00357326656542729*std::sin(0.268399953842163*x_97 + 5.17671966552734) + 0.0415713898837566*std::sin(0.00426118528664622*x_101 + 0.00432507631980588*x_102 + 0.0270113097277094*x_103 + 0.0357120672738077*x_104 + 0.0267748338605697*x_105 + 0.0437883757143681*x_106 + 0.0793269031327189*x_107 - 0.0612890805233168*x_108 + 0.00861653048120013*x_109 + 0.00379871164344316*x_11 + 0.0480086958464476*x_110 + 0.0237579309754986*x_111 + 0.013094964274025*x_112 - 0.119449419736151*x_113 + 0.0320510897588844*x_114 - 0.0148983665967514*x_115 + 0.0144916646404265*x_118 - 0.310546540572488*x_119 - 0.0676396478398637*x_12 - 0.0206372504435527*x_120 - 0.0859222188036375*x_13 - 0.0128014575344174*x_14 - 0.0183611236542328*x_15 + 0.0495339734661889*x_16 + 0.0299080388614997*x_18 + 0.0247634968653033*x_19 + 0.0519459413165294*x_20 + 0.017264558182368*x_21 + 0.0666311118110493*x_22 + 0.0432000292914659*x_24 + 0.0423627318364693*x_26 + 0.0479801048160464*x_27 - 0.00890461708999001*x_28 + 0.0225050674061515*x_29 + 0.0645313945701077*x_3 + 0.0630200785294894*x_30 - 0.0395596643784588*x_33 - 0.0905814941589324*x_34 - 0.0282265440577075*x_35 + 0.0148822424643762*x_37 + 0.00967065118831724*x_38 + 9.86030489322161e-5*x_39 + 0.0458940507373998*x_4 + 0.0212355920933718*x_40 + 0.0163837564133621*x_41 + 0.0214496868790973*x_42 + 0.0304080466475025*x_43 + 0.0402554115257*x_44 + 0.0278434977431649*x_45 + 0.0460721671460423*x_46 + 0.0423001205786282*x_47 - 0.0187394448157224*x_48 - 0.0215605930495433*x_5 + 0.0124778182839872*x_50 + 0.0420640761272289*x_51 + 0.0351259376227191*x_52 + 0.0379899968245099*x_53 + 0.0612973021507603*x_55 + 0.0780491143735794*x_56 + 0.0143875021406607*x_57 + 0.0378697889813696*x_58 - 0.0362089578597627*x_59 - 0.0196068466647294*x_6 + 0.0192091770150514*x_60 + 0.0272547189923192*x_61 + 0.00314185826849109*x_62 + 0.00162779436283192*x_63 - 0.0380709586661867*x_64 + 0.00676050835997787*x_65 + 0.0360894800103669*x_66 - 0.00836398010122489*x_67 + 0.0391183628092164*x_68 + 0.0184476356757805*x_69 + 0.0174941839059338*x_70 + 0.0295060922411815*x_71 + 0.00674012009500147*x_72 + 0.025888382005244*x_73 + 0.0236677247803636*x_74 + 0.0478933228441415*x_75 + 0.0178507604519491*x_76 + 0.028140061831525*x_77 + 0.013123219520012*x_78 + 0.0315542384433276*x_79 + 0.0147848161109801*x_8 + 0.0323621251075328*x_80 - 0.0195982845069476*x_81 - 0.0362434636077408*x_82 - 0.00761289559596187*x_83 + 0.00584829335205741*x_84 - 0.022621110975774*x_85 - 0.00723962914711797*x_86 - 0.0208726939216569*x_87 + 0.0397603059152646*x_89 + 0.00884165798866656*x_9 + 0.00118845268901062*x_90 + 0.00446308328101345*x_91 - 0.119069153323997*x_93 - 0.0662857505687033*x_94 + 0.0135269251211818*x_96 - 0.0411236310054632*x_97 - 0.000140150459169548*x_98 - 0.104309973857633*x_99 + 0.000848445596846853*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 4.72777779159668*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.0556188567929969*std::sin(0.613919854164124*x_10 + 4.98239946365356) - 0.388546420177406*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 2.20571625932305*std::sin(0.250159978866577*x_116 + 5.1715202331543) - 0.683958309451953*std::sin(0.178880020976067*x_117 - 0.982079803943634) + 2.11877297858985*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.811643963928823*std::sin(0.428799867630005*x_2 - 7.37967967987061) - 0.141618659781523*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.278629340043775*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 2.69672023655295*std::sin(0.358559846878052*x_31 + 5.17304039001465) - 0.183273009134204*std::sin(0.270479947328568*x_32 - 4.34687995910645) - 0.341137418290863*std::sin(0.235039994120598*x_36 + 5.17000007629395) - 1.19749046646785*std::sin(0.105680070817471*x_54 + 1.75039982795715) - 0.0977357478744514*std::sin(0.393759846687317*x_7 + 1.80199980735779) - 0.0131248040994258*std::sin(1.24679982662201*x_88 + 8.19960021972656) + 0.516930656063799*std::sin(0.15776002407074*x_92 + 8.38064002990723) + 0.550160571486984*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 4.18552426556314) + 0.213387510271396);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.92887649591211e-5*x_1 + 0.0016547052833005*x_10 + 0.0007110949750857*x_100 + 0.00241014396250563*x_101 + 0.000238365947748943*x_102 + 0.000902297143727094*x_103 + 0.00293041844345218*x_104 + 0.0010722241745296*x_105 + 0.00166766142499322*x_106 + 0.0033441474975518*x_107 - 0.00104062966537636*x_108 - 0.00012033675576363*x_109 + 0.000450028285199111*x_11 + 0.0013489421336672*x_110 + 0.00194377313371375*x_111 + 0.0052474999566759*x_112 - 0.00354718907424377*x_113 + 0.00724087537796519*x_114 + 0.00108545746258766*x_115 + 0.00224177483365268*x_116 + 0.010088423858196*x_117 + 0.00330838394416313*x_118 - 0.00190922325941287*x_119 - 0.00169974956311429*x_12 + 0.00175500303308706*x_120 - 0.00212598245492236*x_13 - 0.000307580349383872*x_14 - 0.000441162329638304*x_15 + 0.00193742276144297*x_16 + 0.00177955388607026*x_17 + 0.00122269744713058*x_18 + 0.0016868954087237*x_19 + 0.000331259457769174*x_2 + 0.00248398381616876*x_20 + 2.4110723186562e-5*x_21 + 0.00088059090419511*x_22 - 0.000160123062336305*x_23 + 0.00163946355855558*x_24 - 0.00192919291898349*x_25 + 0.000340409212269145*x_26 + 0.0015871216410191*x_27 - 0.000420829851374769*x_28 - 0.000586815183531592*x_29 + 0.00167035708040974*x_3 + 0.00151418209373309*x_30 - 0.000413458824547451*x_31 + 0.00171455159755978*x_32 - 0.00138457058500778*x_33 - 0.00378441543916146*x_34 - 6.02920226782896e-5*x_35 - 0.000743162763501874*x_36 - 5.15823134689586e-6*x_37 - 0.000581545254923604*x_38 - 0.00107688416058387*x_39 + 0.000678035062594256*x_4 + 0.00084397244458599*x_40 + 0.000695040874674487*x_41 - 0.00145395610137673*x_42 + 0.000136368212501096*x_43 + 0.00111427271435083*x_44 + 0.000649772744758829*x_45 + 0.000857752514782582*x_46 + 0.00143405737173218*x_47 - 0.00344413247990193*x_48 + 0.000572652441013748*x_49 - 0.000518035913119468*x_5 - 0.000525077019606399*x_50 + 0.00085488668684602*x_51 - 0.00183954313337497*x_52 + 5.74677215527166e-5*x_53 + 0.00181733535430965*x_54 + 0.00235794290928333*x_55 + 0.00171003294345314*x_56 + 0.00108860501382438*x_57 + 0.000835826679705528*x_58 - 0.000924838183496042*x_59 - 0.000511351236108842*x_6 - 0.00121886619165242*x_60 + 0.00148101998660941*x_61 + 0.000764943843619888*x_62 - 0.000516968043526887*x_63 - 0.00164895332725507*x_64 - 0.000535803408270128*x_65 - 0.000253354525120927*x_66 - 0.00264224263966435*x_67 + 0.000652172482126234*x_68 + 0.00107724767323801*x_69 + 0.00155980545949448*x_7 + 0.000588129911107597*x_70 + 0.001417238914918*x_71 - 7.95248417514775e-5*x_72 - 2.77448217194336e-5*x_73 + 0.0011132736887729*x_74 + 0.00181417439885012*x_75 + 0.000439767882469475*x_76 + 0.000129872828116197*x_77 - 0.00030452965246975*x_78 + 0.000806673694539242*x_79 + 0.00126370469709715*x_8 + 5.53566083405143e-5*x_80 + 0.000305723034847398*x_81 + 0.000673739880589665*x_82 + 0.000237527973925503*x_83 + 0.000597749831477627*x_84 - 0.000814166356970666*x_85 + 7.08512801669794e-5*x_86 - 1.54448308714619e-5*x_87 - 0.000133206485621444*x_88 + 0.000737430770453308*x_89 + 0.00154993967971562*x_9 + 0.000481924372570844*x_90 + 0.000904265838661099*x_91 + 0.000219067678350828*x_92 - 0.00313416975810105*x_93 - 0.00177244047759397*x_94 - 0.000146341667123465*x_95 - 0.000316598480861376*x_96 - 0.00116798893034165*x_97 - 0.00057578234691726*x_98 - 0.00465281538115856*x_99 - 5.80582426779344e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 2.17568553281163e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 6.47127321157516e-6*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) + 2.03855844078492e-5*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.000296447498697635*std::exp(0.241199851036072*x_59) - 0.000194761263043432*std::exp(0.262799859046936*x_59) - 0.00450424318019285*std::sin(0.308639913797379*x_1 + 8.31319999694824) + 0.113594216989667*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.00222908165464395*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.218813493624365*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.00137754092677084*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.0131117562287349*std::sin(0.278079956769943*x_10 + 1.9722398519516) + 0.0013363530956321*std::sin(0.613919854164124*x_10 + 4.98239946365356) - 0.00933559661848757*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.000731947705371235*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.00858844856318237*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.00120298004527566*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.000640813921147475*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.00693229328124962*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.0131690531823211*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.0150057858478616*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.000902303613336432*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00100392593117102*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.0187616823033141*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.00200272435614722*std::sin(0.245119974017143*x_116 - 7.42927980422974) - 0.052996697904146*std::sin(0.250159978866577*x_116 + 5.1715202331543) - 0.016433451833093*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.000925105102307631*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.0201197080549282*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.0205373651800802*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.0481819656300724*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.0113762869699327*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.0466225494112*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.0206292986983336*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.000555933972999394*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.000224627793561608*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.00677470985659512*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.00328750731521836*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.00533623006923804*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.00689909376660889*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.000520118177648797*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.00620972138542724*std::sin(0.35319983959198*x_17 + 2.01239991188049) + 0.0509077135371235*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.0125424155274801*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.00282882713152637*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.000945428148921585*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.00299642045101068*std::sin(0.377039849758148*x_2 - 7.3931999206543) + 0.0195013523522109*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00857716533094983*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.000853518546467679*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.000929416988148923*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.0374218810836439*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.0392297360885181*std::sin(0.376879841089249*x_23 + 2.00415992736816) - 0.00340266854284097*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.00440597482996941*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.00872851552101412*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.00748437288316854*std::sin(0.0878400802612305*x_25 - 7.56063985824585) + 0.00669462125924729*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.00179944915690779*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.00813472478838984*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 0.000305126028183823*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.00378854748868807*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.000427994720043321*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.000374086447088748*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.0162086803986022*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.000541665175813865*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0651227786800127*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.0143391919438118*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.000372580813196413*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.0490999688508842*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.0588171283046*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.00568769750145762*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.00458212439565708*std::sin(0.377999842166901*x_30 + 2.00567984580994) - 0.0647940400785983*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.0469092266298514*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.000846060826706141*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 0.000221462855037552*std::sin(0.46375983953476*x_31 + 5.03119993209839) - 0.00440349671360275*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.00404955342349733*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.0462809022205018*std::sin(0.30447992682457*x_32 + 2.02991986274719) - 0.00819650153302572*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.00111412656500657*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.0278272742633673*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.00385648329078544*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 0.00032226023794324*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.000474134792750702*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.00391875373054163*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.00594804676833495*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.00852435336972418*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.00255518753488062*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.000719424192472374*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.000322271855636792*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.00157586677299173*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 0.000327709566168469*std::sin(0.245839968323708*x_53 - 7.60552024841309) + 0.0444718732253531*std::sin(0.254719972610474*x_53 - 7.42695951461792) - 0.0287720781067139*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.0170616729721204*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.00226380055901904*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.0321609204973712*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.0666599212037134*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.000413293108946415*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.000521653605666756*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 2.38234300639776e-5*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.00326721487324614*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.073311854972972*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.00190040999949676*std::sin(0.367039829492569*x_7 + 2.01095986366272) - 0.00234829474672674*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 5.37762310844801e-5*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.00922258760216359*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.000887035384127509*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00841727451904502*std::sin(0.240479975938797*x_8 + 1.98351979255676) - 0.00031534939046142*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.0102083197722035*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.00259752908682929*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.00672752899064427*std::sin(0.354159861803055*x_91 - 7.39296007156372) + 0.0124202819383546*std::sin(0.15776002407074*x_92 + 8.38064002990723) - 0.0146367458235588*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.0064815755694849*std::sin(0.279439955949783*x_94 - 1.18527984619141) + 0.0132186964132986*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 0.00646880552527064*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.0139461402746568*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.00428551060338569*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.00376693846553406*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.00634441736163943*std::sin(0.268399953842163*x_97 + 5.17671966552734) + 0.0197193728787043);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000262421674322207*x_1 + 0.000596981046123288*x_10 - 0.000869314387444099*x_100 + 0.000621263706719468*x_101 - 0.000276955324168534*x_102 - 0.000290061805921428*x_103 + 0.000768319626469004*x_104 + 0.000735836034900117*x_105 + 0.00195662188864166*x_106 - 0.0002605371471157*x_107 - 0.00138445926482317*x_108 + 0.000520194350058081*x_109 - 0.0018681122339282*x_11 + 0.00165161566703047*x_110 + 0.000394934745491104*x_111 - 0.00426850343722043*x_112 + 0.000216783149997549*x_113 + 0.000321713850161884*x_114 - 0.0020042256841875*x_115 - 0.00221529411613206*x_116 - 0.00104588707135704*x_117 + 0.00258414130123687*x_118 - 0.00778839794144622*x_119 - 0.000729141859788181*x_12 + 0.00385726920648483*x_120 - 0.000992843248423462*x_13 - 0.000141432928365805*x_14 - 0.000202857173061972*x_15 + 0.000291993883085826*x_16 - 0.000665259876865302*x_17 + 0.000847989970346948*x_18 + 0.00064677692112069*x_19 + 0.000245064605306792*x_2 + 0.00158761673567988*x_20 + 0.00208336280207977*x_21 + 0.00143709163720001*x_22 + 4.65784780713402e-5*x_23 + 0.000835866643270761*x_24 + 0.00189663169724981*x_25 + 0.00132355500755464*x_26 + 0.000610368833641291*x_27 + 0.0010933647525071*x_28 + 0.00128201181873553*x_29 + 7.47862827187645e-5*x_3 + 0.000696257768172516*x_30 + 0.00040648040143001*x_31 - 0.00171397245318877*x_32 - 0.000133520857834975*x_33 + 4.64902986033695e-5*x_34 - 0.00261503444073998*x_35 + 0.000335655168774591*x_36 + 0.00133097624475247*x_37 + 0.000470828714766619*x_38 + 0.000307890059424594*x_39 + 0.0012687740316008*x_4 - 0.000762119529732685*x_40 + 0.000278610353184041*x_41 + 0.0011144376042229*x_42 + 0.000957849815866322*x_43 + 0.000954298942103766*x_44 + 0.00153553584550027*x_45 + 0.00102874503115795*x_46 - 0.0015965697148828*x_47 - 0.00264092830998085*x_48 - 0.00082767016283197*x_49 - 0.000238205517153177*x_5 + 0.00142282765247206*x_50 + 0.00124643733187121*x_51 - 0.00105722818870627*x_52 + 0.000101286064255206*x_53 - 0.00178684106846275*x_54 - 0.00221027235330645*x_55 + 0.00159627901170823*x_56 - 0.00188876308490127*x_57 + 0.00127749405668589*x_58 - 0.000346122812898582*x_59 - 0.000198623874111876*x_6 + 0.000278639525749335*x_60 + 0.000681349532104864*x_61 - 0.000606437879623645*x_62 + 0.000156723393747672*x_63 - 2.41624335492056e-5*x_64 - 0.000232253225394571*x_65 - 7.2193476112455e-5*x_66 + 0.00214477741653262*x_67 + 0.00074617517002939*x_68 - 0.000547432517967292*x_69 + 0.000580715666988975*x_7 - 0.00053147285414976*x_70 - 0.000495857307228541*x_71 + 0.000785497679295546*x_72 + 0.00104195966776525*x_73 + 0.000518363801913554*x_74 - 0.000146663505818202*x_75 + 0.000890840206265217*x_76 + 0.000769929741376377*x_77 + 0.000659860198536466*x_78 - 8.59231315851197e-5*x_79 + 0.00053608714376382*x_8 - 0.000200065344326999*x_80 - 0.000485737045198102*x_81 - 0.000413925215106351*x_82 - 2.7442784704373e-5*x_83 + 7.53436453011448e-5*x_84 - 2.85608423635002e-6*x_85 - 5.64486728863933e-5*x_86 + 0.000540702050584746*x_87 + 0.000902288580524176*x_88 + 0.00161179094482768*x_89 + 0.000770440314252811*x_9 + 8.16177802564722e-5*x_90 - 0.00146657269166159*x_91 + 0.000575181196228448*x_92 - 0.000971231129243592*x_93 - 0.00117254504980576*x_94 + 0.00048472892875645*x_95 - 0.000294903868929423*x_96 + 1.62903711845763e-6*x_97 + 0.000632750208940785*x_98 - 0.00044059709720585*x_99 + 5.70783265198861e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) + 2.13896396994482e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 2.40925540839284e-6*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) + 9.3737877111651e-6*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) - 0.00157833634138296*std::exp(0.241199851036072*x_59) + 8.70630300924942e-5*std::exp(0.262799859046936*x_59) + 0.00442821985484808*std::sin(0.308639913797379*x_1 + 8.31319999694824) + 0.0522333848259544*std::sin(0.322319835424423*x_1 - 4.26448011398315) - 0.000996453812961848*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.0814642769217149*std::sin(0.351919859647751*x_1 - 4.22192001342773) + 0.000615794359139818*std::sin(0.177440017461777*x_10 - 7.61080026626587) - 0.0128904539433695*std::sin(0.278079956769943*x_10 + 1.9722398519516) + 0.000614487668098952*std::sin(0.613919854164124*x_10 + 4.98239946365356) - 0.00429273446902404*std::sin(0.248239979147911*x_100 - 4.40064001083374) + 0.00389701268674763*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.00319747991995446*std::sin(0.205119997262955*x_102 - 7.41111993789673) + 0.000537761391797655*std::sin(0.180640012025833*x_107 - 7.3918399810791) + 0.0002864594366905*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.00258089320823941*std::sin(0.278079956769943*x_108 - 4.41975975036621) + 0.0129467838299547*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.00558665497949906*std::sin(0.314319938421249*x_11 + 5.12199974060059) - 0.000403351700501951*std::sin(0.320399910211563*x_11 - 4.29864025115967) - 0.000448779352682092*std::sin(0.190880000591278*x_110 + 8.41744041442871) + 0.0184450196763866*std::sin(0.286959946155548*x_113 + 1.97287976741791) + 0.010662841302311*std::sin(0.245119974017143*x_116 - 7.42927980422974) - 0.0243691711558161*std::sin(0.250159978866577*x_116 + 5.1715202331543) - 0.00755650099419071*std::sin(0.178880020976067*x_117 - 0.982079803943634) + 0.00492541515440548*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.00749056852674929*std::sin(0.293759942054749*x_12 + 1.95231974124908) - 0.0201907322980734*std::sin(0.301919937133789*x_12 + 8.31360054016113) + 0.0473687428305235*std::sin(0.261279970407486*x_120 - 4.24855995178223) + 0.0050854774677818*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.0173575779679769*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.00768028915413599*std::sin(0.329119831323624*x_14 - 4.3219199180603) - 0.000248516031701297*std::sin(0.342479854822159*x_14 + 1.85703992843628) - 0.00119595615217037*std::sin(0.401919841766357*x_14 - 1.40335988998413) + 0.00666036523732386*std::sin(0.449519842863083*x_14 - 7.47095966339111) + 0.0175032418589027*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.00198667877779354*std::sin(0.336879849433899*x_15 - 1.09447979927063) - 0.00678264977612689*std::sin(0.357919842004776*x_15 - 4.34151983261108) - 0.000232505498499423*std::sin(0.479599863290787*x_15 + 8.09632015228271) + 0.00277589676405463*std::sin(0.35319983959198*x_17 + 2.01239991188049) + 0.0234086053169054*std::sin(0.370559841394424*x_17 - 1.17351984977722) - 0.0123307226640823*std::sin(0.445119857788086*x_18 + 5.17095994949341) + 0.00278108174195464*std::sin(0.497599840164185*x_19 + 1.90071988105774) + 0.000422629418671902*std::sin(0.366479843854904*x_2 - 4.19960021972656) - 0.0159534464371279*std::sin(0.377039849758148*x_2 - 7.3931999206543) + 0.0089671962977853*std::sin(0.428799867630005*x_2 - 7.37967967987061) - 0.00843239858448329*std::sin(0.268879950046539*x_20 + 1.9923198223114) - 0.000381543586924913*std::sin(0.446319848299026*x_20 + 1.76775991916656) - 0.00494837235982332*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.0139321685926868*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.0146052331204357*std::sin(0.376879841089249*x_23 + 2.00415992736816) - 0.00156462978612326*std::sin(0.494639873504639*x_23 + 8.32231998443604) - 0.00196957810405479*std::sin(0.120720058679581*x_24 + 7.95175981521606) - 0.00858119426221777*std::sin(0.243999972939491*x_24 + 8.21592044830322) - 0.00334569704143601*std::sin(0.0878400802612305*x_25 - 7.56063985824585) + 0.00307834974143171*std::sin(0.307679921388626*x_25 - 1.16671991348267) + 0.00958056995351919*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.0030285585311341*std::sin(0.277439951896667*x_26 - 7.40551996231079) + 0.000136398769234965*std::sin(0.598719835281372*x_26 - 4.38567972183228) + 0.00372460378787209*std::sin(0.356959849596024*x_27 + 5.00256013870239) + 0.000191324068288932*std::sin(0.559359848499298*x_28 + 4.81023979187012) + 0.00199169916040082*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.00603449269355422*std::sin(0.201120004057884*x_29 + 8.21127986907959) - 0.000242137531688846*std::sin(0.663759827613831*x_29 + 7.96551990509033) - 0.0640236261713922*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.00533848202867063*std::sin(0.360399842262268*x_3 + 5.18527984619141) - 0.000166552701724734*std::sin(0.532079875469208*x_3 + 1.79583990573883) + 0.0482712518484845*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.02189762042816*std::sin(0.335119843482971*x_30 + 2.01479983329773) + 0.0302822580888088*std::sin(0.349039852619171*x_30 - 1.13991987705231) + 0.00204832125194054*std::sin(0.377999842166901*x_30 + 2.00567984580994) - 0.0297938761280567*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.0174643079138341*std::sin(0.361119836568832*x_31 + 5.16720008850098) - 0.00450457013696322*std::sin(0.421839863061905*x_31 - 7.38175964355469) + 9.89992923192553e-5*std::sin(0.46375983953476*x_31 + 5.03119993209839) - 0.00202483493012994*std::sin(0.270479947328568*x_32 - 4.34687995910645) - 0.0215605035048609*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.0172303826981991*std::sin(0.30447992682457*x_32 + 2.02991986274719) - 0.00376895083347422*std::sin(0.235039994120598*x_36 + 5.17000007629395) - 0.00049804172113211*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.0103600958927107*std::sin(0.0996000692248344*x_4 - 7.55311965942383) - 0.00379139295880885*std::sin(0.255919963121414*x_41 - 7.42320013046265) - 0.000144058178485985*std::sin(0.244959965348244*x_44 - 4.23079967498779) + 0.000211949805028464*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.00145895225109325*std::sin(0.447439849376678*x_49 - 4.49327993392944) + 0.00584765469878073*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.00317361727555013*std::sin(0.198320001363754*x_5 + 1.98175978660583) - 0.00114223108725511*std::sin(0.321759849786758*x_5 - 1.14847981929779) + 0.00383033539779465*std::sin(0.394159853458405*x_5 - 7.39783954620361) - 0.00171582956102212*std::sin(0.250799983739853*x_50 - 7.64688014984131) - 0.00839017973812501*std::sin(0.240319982171059*x_53 - 7.40279960632324) + 0.000146494160979851*std::sin(0.245839968323708*x_53 - 7.60552024841309) - 0.0437212699493645*std::sin(0.254719972610474*x_53 - 7.42695951461792) - 0.0132301015651801*std::sin(0.105680070817471*x_54 + 1.75039982795715) - 0.0167737033702594*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.000842813085156668*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.0119735126479575*std::sin(0.14408004283905*x_6 - 7.45831966400146) - 0.0655348245616379*std::sin(0.341279834508896*x_6 - 1.14199984073639) + 0.00220044202214237*std::sin(0.446719855070114*x_6 + 5.15248012542725) - 0.000233191872235368*std::sin(0.576079845428467*x_60 + 8.0152006149292) + 1.06496537152975e-5*std::sin(1.24703979492188*x_67 + 2.59119987487793) + 0.00146052465661326*std::sin(0.344559848308563*x_7 + 2.00287985801697) + 0.0720744859457517*std::sin(0.357919842004776*x_7 + 1.9981597661972) + 0.0101181024596624*std::sin(0.367039829492569*x_7 + 2.01095986366272) - 0.00107980306076411*std::sin(0.393759846687317*x_7 + 1.80199980735779) - 0.000286313698702561*std::sin(1.01663982868195*x_71 + 8.21144008636475) - 0.00906692731701667*std::sin(0.141760036349297*x_75 + 2.03975987434387) + 0.00472272557202118*std::sin(0.221199989318848*x_8 + 2.01559972763062) - 0.00827520643486797*std::sin(0.240479975938797*x_8 + 1.98351979255676) - 0.000145005322481336*std::sin(1.24679982662201*x_88 + 8.19960021972656) + 0.0100360221443404*std::sin(0.305919945240021*x_9 - 1.20959985256195) + 0.00116115879266154*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.00250465945045211*std::sin(0.354159861803055*x_91 - 7.39296007156372) + 0.00571114783239308*std::sin(0.15776002407074*x_92 + 8.38064002990723) + 0.0143897045237848*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.00241309097686626*std::sin(0.279439955949783*x_94 - 1.18527984619141) + 0.00607827823414721*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 0.00240833668863229*std::sin(0.283439934253693*x_95 - 7.42248010635376) - 0.0137107551240357*std::sin(0.29079994559288*x_95 - 1.20351994037628) + 0.00421317908089989*std::sin(0.305119931697845*x_96 - 1.22831988334656) + 0.00370335948521205*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.00236202696778284*std::sin(0.268399953842163*x_97 + 5.17671966552734) - 0.263294428266913);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000326893816661293*x_1 + 2.21977434771402e-5*x_10 + 0.000484763793719613*x_100 + 0.000196837379695915*x_101 + 0.000389250360142092*x_102 + 0.00160663803105888*x_103 + 0.000399700295417773*x_104 + 0.000251428580503206*x_105 - 0.000403375981758605*x_106 + 0.00236443506286071*x_107 - 0.00105793164241695*x_108 - 0.000147731817986285*x_109 + 0.00247978462716023*x_11 + 0.00146846727170506*x_110 - 0.00052353848348571*x_111 + 0.000711166372544431*x_112 - 0.00496306954311656*x_113 + 0.000971938117399173*x_114 + 0.000844290541168841*x_115 + 0.000803867414345043*x_116 + 0.000878991796114614*x_117 - 0.00134643625862296*x_118 - 0.00650247474349629*x_119 - 0.00176764043183763*x_12 - 0.00432632233155775*x_120 - 0.00217501143291902*x_13 - 0.000338450441240583*x_14 - 0.000485439285779798*x_15 + 0.00143295830486462*x_16 - 0.000266004536207336*x_17 + 0.000476396983659131*x_18 + 0.000800321377279303*x_19 - 3.19786664769071e-5*x_2 + 0.000728841812586304*x_20 - 0.000101612708208125*x_21 + 0.00150666816976256*x_22 + 3.3997010230537e-5*x_23 + 0.00098537568645235*x_24 - 0.000686892891627313*x_25 + 0.000604800356630085*x_26 + 0.00142457611121891*x_27 - 0.000568712554124253*x_28 + 0.000302171991295657*x_29 + 0.00250106380714669*x_3 + 0.00166615194621216*x_30 - 0.000147212818773911*x_31 + 0.000629304427299257*x_32 - 0.00155008260870261*x_33 - 0.00311566638568864*x_34 + 0.000587005994813881*x_35 - 2.5793789114138e-6*x_36 - 0.000481697120149651*x_37 + 0.000267576811963337*x_38 - 0.000531477588770134*x_39 + 0.000555128141846671*x_4 + 0.00108278728215199*x_40 + 0.000518257055550187*x_41 - 0.00025944297579841*x_42 + 0.000461397741949036*x_43 + 0.000415467429680456*x_44 - 0.000261660555616838*x_45 + 0.00076237770585005*x_46 + 0.0019471499314797*x_47 + 0.00104099292337568*x_48 + 0.000586565492605677*x_49 - 0.000570028234004424*x_5 - 4.38662397405392e-5*x_50 + 0.000652605742159955*x_51 + 0.00134297014540095*x_52 + 0.00100439587862671*x_53 + 0.00106825884248377*x_54 + 0.00460729115688187*x_55 + 0.00117277350581712*x_56 + 0.0012803505006226*x_57 + 0.000861455514510017*x_58 - 0.000976836142859439*x_59 - 0.000518374246617857*x_6 + 0.000648453942001826*x_60 + 0.000631377649636869*x_61 + 0.000165805768822609*x_62 - 0.000145988645671919*x_63 - 0.000910743074102383*x_64 + 0.000312320798029514*x_65 + 0.00143739375740639*x_66 - 0.0013918045625138*x_67 + 0.000954792675092168*x_68 + 0.00111985282242617*x_69 + 0.00108792546543859*x_70 + 0.00107025448171078*x_71 + 5.01672739953061e-5*x_72 + 0.000501010735920581*x_73 + 0.00121744207492904*x_74 + 0.00234529071626296*x_75 + 0.000322308171250219*x_76 + 0.000734174155902397*x_77 + 6.07153559472916e-5*x_78 + 0.00131300282580485*x_79 + 0.000390887328491209*x_8 + 0.00185750071469106*x_80 - 0.00037346722345769*x_81 - 0.00138124443987369*x_82 - 0.000770875668853757*x_83 + 0.000103814052341704*x_84 - 0.000483174015645836*x_85 - 0.000249828909153424*x_86 - 0.000561660732512585*x_87 - 0.00087374669631047*x_88 + 0.000468773231141478*x_89 + 3.61353298526805e-5*x_9 - 0.000113180246127048*x_90 + 0.0014605246188405*x_91 - 0.000554624097468329*x_92 - 0.00364632667860144*x_93 - 0.000934916848546405*x_94 - 0.00057020246140212*x_95 + 0.000650606865712349*x_96 - 0.00159793240372355*x_97 - 0.000323790784817332*x_98 - 0.00249628145661333*x_99 - 2.06717502451023e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 7.74657066278336e-6*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 2.24315696747352e-5*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.00196610433167347*std::exp(0.241199851036072*x_59) - 0.00160374454632847*std::sin(0.308639913797379*x_1 + 8.31319999694824) + 0.124995023055095*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.00466846631129753*std::sin(0.278079956769943*x_10 + 1.9722398519516) + 0.00147047526207673*std::sin(0.613919854164124*x_10 + 4.98239946365356) - 0.010272557401994*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.00485443648676778*std::sin(0.209440007805824*x_101 + 2.00071978569031) - 0.00468886700308057*std::sin(0.309439927339554*x_11 - 7.45864009857178) - 0.00668013348084793*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.0132825038128764*std::sin(0.245119974017143*x_116 - 7.42927980422974) - 0.0583156753215282*std::sin(0.250159978866577*x_116 + 5.1715202331543) - 0.0180827840112592*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.00613549838298828*std::sin(0.222479999065399*x_119 - 4.20864009857178) + 0.0073123688233235*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.0171552825900723*std::sin(0.261279970407486*x_120 - 4.24855995178223) + 0.00148978041601285*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.00241214862315825*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.0218034640240012*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.00245643575628037*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.0560170314641436*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.00446575144708781*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.00100720940304497*std::sin(0.497599840164185*x_19 + 1.90071988105774) + 0.0198729125869803*std::sin(0.377039849758148*x_2 - 7.3931999206543) + 0.0214585922722797*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00305391640108549*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.00616409574834805*std::sin(0.299359947443008*x_21 + 8.36335945129395) - 0.00374417504898108*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.0031078049306766*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.00736652235316577*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.0119343384496932*std::sin(0.323279827833176*x_25 - 1.15535986423492) - 0.00134891970313862*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.00248102273513092*std::sin(0.576079845428467*x_28 + 1.81583988666534) + 0.0231870920311533*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.017482139422617*std::sin(0.327359855175018*x_30 - 1.15199983119965) - 0.0377220477284918*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.0712970496921851*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.0056112595436092*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 0.00484545065608295*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.0268575196696195*std::sin(0.302479922771454*x_32 - 1.16159987449646) - 0.00901913781565894*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.00137310837762965*std::sin(0.255919963121414*x_41 - 7.42320013046265) - 0.00211781362249083*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.00477137782354278*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.00213737708743568*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.0104514914179779*std::sin(0.240319982171059*x_53 - 7.40279960632324) + 0.015834296972198*std::sin(0.254719972610474*x_53 - 7.42695951461792) - 0.0316597680902968*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.00607484185147978*std::sin(0.178720012307167*x_56 + 4.99911975860596) + 0.0237343946168918*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.00274104984970421*std::sin(0.446719855070114*x_6 + 5.15248012542725) - 0.0261028285753198*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.0126039327313642*std::sin(0.367039829492569*x_7 + 2.01095986366272) - 0.00258397974638064*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 0.000356655668679161*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.00328372025627913*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.00588301172633456*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00299698696647414*std::sin(0.240479975938797*x_8 + 1.98351979255676) - 0.000346999216823872*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.00363469211294837*std::sin(0.305919945240021*x_9 - 1.20959985256195) + 0.0136668350588361*std::sin(0.15776002407074*x_92 + 8.38064002990723) - 0.00521144182306857*std::sin(0.299599945545197*x_92 + 1.99519979953766) + 0.0145453818576773*std::sin(0.222959995269775*x_95 - 4.21456003189087) + 0.00496555037395984*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.00152586438685985*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.001341225768409*std::sin(0.243519976735115*x_97 - 1.02255988121033) - 0.158370330929756*std::sin(0.0251623795584979*x_10 - 0.000143164067791566*x_100 + 0.0322211945724363*x_101 + 0.00398303626326234*x_103 + 0.0209656143828371*x_104 + 0.00617655523650888*x_105 + 0.011729977485211*x_106 + 0.00147736065257521*x_107 - 0.000827260342968819*x_109 + 0.0192741282521803*x_110 + 0.0051698960106843*x_111 - 0.00683597918257743*x_112 - 0.00174052678327041*x_113 + 0.0667612477653442*x_114 + 0.0014933550905279*x_115 - 5.21736501524983e-5*x_116 + 0.0962766285519288*x_117 + 0.0474087619475094*x_118 + 0.0129457104889732*x_119 + 0.0429832155889516*x_120 + 0.00524178062958473*x_16 + 0.00634714835503678*x_17 + 0.00951743346086261*x_18 + 0.0180093037703535*x_19 + 0.0064160669032063*x_2 + 0.0203123620299619*x_20 + 0.0163232110107394*x_21 + 0.00952541085069196*x_24 + 0.00723778346922919*x_27 + 0.0111109190944608*x_28 - 0.00491718382382026*x_33 - 0.0086391374639966*x_34 - 0.0125347115982925*x_35 - 0.001881756368202*x_36 + 0.00521929082341305*x_37 - 0.00312547473806837*x_38 - 0.011366789502674*x_39 - 0.00525676391458724*x_40 + 0.00548449403857175*x_41 - 0.0153174457185246*x_42 - 0.000449090456446201*x_43 + 0.00232357441720745*x_44 + 0.00735189281588309*x_45 + 0.000991313799264827*x_46 - 0.015383927945341*x_47 - 0.0486990280299274*x_48 + 0.00657362103894201*x_50 + 0.00507260386770129*x_51 - 0.0430895321510237*x_52 - 0.0130327948093961*x_53 + 0.0047620595438049*x_54 - 0.0017536689067861*x_55 + 9.47392228347449e-5*x_56 - 0.0118018602417444*x_57 + 0.0104693506973924*x_58 - 0.0147620420471731*x_60 + 0.0127374692196615*x_61 - 0.00110106610933647*x_62 - 0.00557799935131891*x_63 - 0.00102481715220848*x_64 - 0.0105220656605381*x_65 - 0.0133584745513021*x_66 - 0.00510222241909189*x_67 + 0.000559986910592898*x_68 + 0.00201523361078214*x_69 + 0.0237673534389983*x_7 - 0.00251013734609165*x_70 - 0.00127085888210885*x_71 + 0.00606026045986441*x_72 + 0.00200149471983693*x_73 + 0.0148262368628457*x_74 + 0.00770478803743951*x_75 + 0.00839292341084335*x_76 + 0.000701558374750895*x_77 - 0.00186744185535465*x_78 - 0.000967879304261933*x_79 + 0.0144846606000476*x_8 - 0.00559876433316599*x_80 + 0.0055934670247095*x_81 + 0.0114392955413065*x_82 - 0.000596694327654291*x_83 + 0.00427423939953495*x_84 + 0.00171778317265736*x_85 + 0.00225581601249861*x_86 + 0.0153714345474955*x_87 + 0.00273361122034412*x_88 + 0.00834018342668102*x_89 + 0.0209282179072176*x_9 + 0.00412741460956044*x_90 + 0.00493307955396538*x_92 - 0.00187361284664833*x_93 - 0.00959111371445894*x_96 + 0.000269314834155412*x_98 - 0.00934332629439895*x_99 + 9.86052694479447e-5*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) + 3.33414504259895*std::sin(0.351919859647751*x_1 - 4.22192001342773) + 0.130865481494062*std::sin(0.205119997262955*x_102 - 7.41111993789673) + 0.105630008893321*std::sin(0.278079956769943*x_108 - 4.41975975036621) + 0.228648908557886*std::sin(0.314319938421249*x_11 + 5.12199974060059) - 0.306571700669593*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.710405649203381*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.314336528557135*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.0813101821867548*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.570211540582363*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.597758519986598*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.123951918489439*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 0.246977873726763*std::sin(0.201120004057884*x_29 + 8.21127986907959) - 0.218491761830776*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.896219120258365*std::sin(0.335119843482971*x_30 + 2.01479983329773) + 0.714773859826778*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.705199840053695*std::sin(0.30447992682457*x_32 + 2.02991986274719) - 0.424014840206894*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.0597115520959655*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.129888838472723*std::sin(0.198320001363754*x_5 + 1.98175978660583) - 0.0344943965121427*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.490048268347692*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.102509936940194*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.0987622504228511*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.0985676683662078*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.0966723182565801*std::sin(0.268399953842163*x_97 + 5.17671966552734) - 10.0674521276824) + 0.143264055252075*std::sin(-0.000321056680046162*x_100 + 0.010737503114797*x_101 + 0.0304169266331047*x_102 + 0.0637437011014816*x_103 + 0.00164539136345192*x_104 + 0.00792383158274332*x_105 + 0.00614358231879163*x_106 + 0.0134878259608322*x_109 + 0.0246465277272946*x_111 + 0.0242799866799871*x_112 + 0.0721515965726703*x_113 + 0.0324318193827919*x_114 + 0.0242529754364165*x_115 + 0.00310798949436439*x_116 + 0.0105841930443641*x_117 + 0.0359499853223806*x_118 + 0.0233403305179501*x_119 + 0.019275389649485*x_12 + 0.0188823382095545*x_13 + 0.000747523553904808*x_16 + 0.0181423363492986*x_18 + 0.0277813374945989*x_19 - 0.0261496957523931*x_21 + 0.00530679086650034*x_22 + 0.0410014189069932*x_23 + 0.0159359964262223*x_27 + 0.0131253816683652*x_32 + 0.00608444769826821*x_33 + 0.00628473072281688*x_34 + 0.0113617295306581*x_35 + 0.0657080499919318*x_36 + 0.0735978713933044*x_37 + 0.026071758097039*x_39 + 0.00553755851917562*x_4 + 0.00647413121914902*x_40 + 0.0177104202317415*x_41 + 0.0259892391879694*x_42 + 0.0173031359522681*x_43 + 0.00989002091845842*x_45 + 0.0438846011336852*x_46 + 0.0539688539378674*x_47 + 0.0276984679055655*x_48 + 0.05125153032027*x_50 + 0.0172524092556663*x_51 - 0.000385140900044939*x_52 + 0.047503636657266*x_54 + 0.0357945141563684*x_55 + 0.00922174872942388*x_56 + 0.0160464556833142*x_57 + 0.0464222512779616*x_58 + 0.00998875570891729*x_6 - 0.000109198367492449*x_61 - 0.0036404704896654*x_62 - 0.00366343945225232*x_63 + 0.00317165011138903*x_64 - 0.0315644849923606*x_65 - 0.00863690053692135*x_66 - 0.00537049276501778*x_68 - 0.00552610074383948*x_69 - 0.0121415062798733*x_70 + 0.00576524425683391*x_71 - 0.00292283853105956*x_72 - 0.0039297703473459*x_73 + 0.0100875011170912*x_74 + 0.00121789111181438*x_75 + 0.0109609457342834*x_76 + 0.00112948967037465*x_77 + 0.00334702181916135*x_78 - 0.00240481304186682*x_79 + 0.0104532576497823*x_8 - 0.00921023310488401*x_80 + 0.00346742161141394*x_81 + 0.000570328794168382*x_82 - 0.0136339516920375*x_83 - 0.00117652029051509*x_84 - 0.00176879655380683*x_85 + 0.000598519948669789*x_86 - 0.00322140261783173*x_87 - 0.000689958690475046*x_88 - 0.00172731187743565*x_89 + 0.00153325644472729*x_9 - 0.00179462711780358*x_90 + 0.00522415697028389*x_92 + 0.0559943262581028*x_93 + 0.00616039433892392*x_94 + 0.0149782003534048*x_95 + 0.0139785375555464*x_96 + 0.0255342103525941*x_97 + 0.0243846914449712*x_98 + 0.00758761192362532*x_99 + 0.0483239427005564*std::exp(0.262799859046936*x_59) - 0.553077200623076*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.341793885358509*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.298482038314006*std::sin(0.180640012025833*x_107 - 7.3918399810791) + 0.158998020054654*std::sin(0.241119980812073*x_108 + 4.99031972885132) - 0.223878544573061*std::sin(0.320399910211563*x_11 - 4.29864025115967) - 0.249092958298862*std::sin(0.190880000591278*x_110 + 8.41744041442871) + 2.82267136231047*std::sin(0.267119973897934*x_120 + 5.15655994415283) - 0.137937704021382*std::sin(0.342479854822159*x_14 + 1.85703992843628) - 0.129051129682874*std::sin(0.479599863290787*x_15 + 8.09632015228271) + 1.54074899559923*std::sin(0.35319983959198*x_17 + 2.01239991188049) + 0.234578555211934*std::sin(0.366479843854904*x_2 - 4.19960021972656) - 0.211774049360979*std::sin(0.446319848299026*x_20 + 1.76775991916656) - 1.09320545521445*std::sin(0.120720058679581*x_24 + 7.95175981521606) - 1.85701407304583*std::sin(0.0878400802612305*x_25 - 7.56063985824585) + 0.0757075224918586*std::sin(0.598719835281372*x_26 - 4.38567972183228) + 0.10619356233535*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.134397346319729*std::sin(0.663759827613831*x_29 + 7.96551990509033) - 0.0924443268999293*std::sin(0.532079875469208*x_3 + 1.79583990573883) + 1.13691148477085*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.0549491112857989*std::sin(0.46375983953476*x_31 + 5.03119993209839) - 0.276435814017796*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.0799588430968639*std::sin(0.244959965348244*x_44 - 4.23079967498779) + 0.117641784609477*std::sin(0.316959917545319*x_49 + 5.04191970825195) - 0.633990220104558*std::sin(0.321759849786758*x_5 - 1.14847981929779) + 0.0813109242078482*std::sin(0.245839968323708*x_53 - 7.60552024841309) - 0.129432098333422*std::sin(0.576079845428467*x_60 + 8.0152006149292) + 0.00591104232614079*std::sin(1.24703979492188*x_67 + 2.59119987487793) + 0.810657632108001*std::sin(0.344559848308563*x_7 + 2.00287985801697) + 0.644495957735575*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 1.56802817953249) - 0.0467064939904432);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00154942680951018*x_1 - 0.00540579253280397*x_10 - 0.000499485962545088*x_100 - 0.00660039970566519*x_101 - 0.000761575004413658*x_102 - 0.00491651986479454*x_103 + 0.000194614013085438*x_104 + 0.00110668617182373*x_105 + 0.0050689323322155*x_106 + 0.00172437234389816*x_107 - 0.00151730575372888*x_108 + 0.00146759341124183*x_109 - 0.0112900934733218*x_11 - 0.0081683115494212*x_110 + 0.00783954850291992*x_111 + 0.0144808718967398*x_112 + 0.00922813882004312*x_113 - 0.00877199744086862*x_114 - 0.0027248243556472*x_115 + 0.00204264428614871*x_116 - 0.014390884222122*x_117 - 0.00118027755124804*x_118 + 0.00257800483260056*x_119 + 9.98115168414924e-5*x_12 + 0.00893230140069878*x_120 - 0.000200614176234281*x_13 + 4.15344684556777e-5*x_14 + 5.95728657597923e-5*x_15 - 0.000789805996389872*x_16 + 0.00376258248881083*x_17 - 0.000632588187900123*x_18 - 0.00459568258425596*x_19 - 0.00143253696558994*x_2 - 0.00139247662347003*x_20 - 0.00487787288723029*x_21 - 0.000820891354735499*x_22 - 0.000207488235770161*x_23 - 0.00140369399390867*x_24 - 0.00173902019903852*x_25 + 0.000663644123450841*x_26 - 0.0024380489832984*x_27 - 0.0031554713726995*x_28 - 0.00164915359591025*x_29 - 0.00397733838570226*x_3 - 0.000204469331458555*x_30 - 0.000372701579133721*x_31 + 0.00157838555446352*x_32 + 0.00351746245931577*x_33 + 0.00304173362095696*x_34 - 8.37770188839902e-5*x_35 - 0.000635408745225901*x_36 + 0.00216018159797293*x_37 - 0.0010998834015042*x_38 + 0.00449215219609464*x_39 + 0.00213554264581977*x_4 + 0.000273317294681326*x_40 - 0.00163185578235715*x_41 + 0.00503529274894976*x_42 + 0.000386910392171753*x_43 + 0.00270802188603812*x_44 + 0.00222719877027744*x_45 + 0.00156406313614441*x_46 + 0.00327234391883655*x_47 + 0.0032303743202525*x_48 - 0.00145546228346173*x_49 + 6.99535790744405e-5*x_5 - 0.00242944007828613*x_50 - 3.81198919615912e-6*x_51 + 0.0072196251194625*x_52 + 0.00262216316297968*x_53 - 0.00192004036821585*x_54 - 0.012127137799657*x_55 + 0.00393827633796377*x_56 + 0.00211291959005478*x_57 - 0.00323123825248053*x_58 + 6.80405871239109e-5*x_59 + 5.23234378217412e-5*x_6 + 0.000376090448546026*x_60 - 0.00233987088630031*x_61 + 0.00184342049837955*x_62 + 0.00158758017474689*x_63 - 0.00194754712528394*x_64 + 0.00117289255461111*x_65 - 0.000545371929174903*x_66 + 0.00137062834971961*x_67 - 0.00077649233839537*x_68 - 0.00242325098806934*x_69 - 0.00500670952455148*x_7 - 0.00196068129412825*x_70 + 0.000900065898130287*x_71 - 0.00241654439990833*x_72 - 0.00173646233996394*x_73 - 0.00732095603543097*x_74 - 0.00689442876149714*x_75 - 0.00242371429762058*x_76 - 0.001797857337312*x_77 + 0.000498217255798164*x_78 - 0.00208249177115841*x_79 - 0.0031110505235322*x_8 - 0.00514951391907374*x_80 - 0.000705411875459431*x_81 + 0.0020649145768703*x_82 + 0.00420771715563372*x_83 - 0.000185735677742427*x_84 - 0.00194685307636366*x_85 + 0.00011994748628004*x_86 - 0.00458180060264575*x_87 + 0.00306391358069179*x_88 - 0.000995764174112826*x_89 - 0.00350234305627763*x_9 + 0.000353256808323398*x_90 - 0.00475105298511237*x_91 + 0.00158375086260398*x_92 + 0.0034913901580816*x_93 - 0.00442831990441092*x_94 + 0.0026857414502899*x_95 + 0.00057206318663268*x_96 + 0.0025251463873761*x_97 + 0.000219792686457309*x_98 - 0.00316087749980438*x_99 - 5.2335075328188e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 1.96121448046206e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) - 2.07716834347205e-5*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) - 2.75279098367122e-6*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) - 0.0093190345198404*std::exp(0.241199851036072*x_59) - 5.46249028145043e-5*std::exp(0.262799859046936*x_59) - 0.00406023150648101*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.0153393265589161*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.000625192950835233*std::sin(0.332799851894379*x_1 - 4.25767993927002) - 0.702353999315111*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.000386360398736368*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.0118192476772377*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.000180455986890458*std::sin(0.613919854164124*x_10 + 4.98239946365356) + 0.00126064309388496*std::sin(0.248239979147911*x_100 - 4.40064001083374) + 0.0230092881978732*std::sin(0.209440007805824*x_101 + 2.00071978569031) - 0.027567455262236*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.000337401118857589*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.000179729775920873*std::sin(0.241119980812073*x_108 + 4.99031972885132) - 0.022251479238613*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.0118708965085439*std::sin(0.309439927339554*x_11 - 7.45864009857178) - 0.0481660135695494*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.000253070073676239*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.000281572195447041*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.0169122248855226*std::sin(0.286959946155548*x_113 + 1.97287976741791) + 0.0629570412658365*std::sin(0.245119974017143*x_116 - 7.42927980422974) + 0.0071564704369578*std::sin(0.250159978866577*x_116 + 5.1715202331543) + 0.00221911018745754*std::sin(0.178880020976067*x_117 - 0.982079803943634) + 0.0290813261058359*std::sin(0.222479999065399*x_119 - 4.20864009857178) + 0.0645808317547823*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.0185128674959102*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.0434323652318943*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.00319071955280914*std::sin(0.267119973897934*x_120 + 5.15655994415283) - 0.149650432863325*std::sin(0.188800007104874*x_13 - 1.17847990989685) + 0.0662165308173993*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.000155923404746051*std::sin(0.342479854822159*x_14 + 1.85703992843628) - 0.00706133184294906*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.00610688395510592*std::sin(0.449519842863083*x_14 - 7.47095966339111) + 0.103345092434042*std::sin(0.280479967594147*x_15 + 1.99391984939575) - 0.0171283885116743*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.00621900655820115*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.000145878109754232*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.00174164729620011*std::sin(0.35319983959198*x_17 + 2.01239991188049) - 0.00687438201528098*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.0113060304816559*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.00254997179022646*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.000265165258973606*std::sin(0.366479843854904*x_2 - 4.19960021972656) - 0.0941945732097586*std::sin(0.377039849758148*x_2 - 7.3931999206543) - 0.00263338768467642*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00773166001919286*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.000239387273026551*std::sin(0.446319848299026*x_20 + 1.76775991916656) - 0.0292168732539048*std::sin(0.299359947443008*x_21 + 8.36335945129395) - 0.120117856561955*std::sin(0.399359852075577*x_22 + 1.99407982826233) - 0.125920762826205*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.000459483284744475*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.00123574854223737*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.00786809066594684*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.00209915018511367*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.000904015929729922*std::sin(0.307679921388626*x_25 - 1.16671991348267) + 0.0565669431639402*std::sin(0.323279827833176*x_25 - 1.15535986423492) - 0.0261110793206455*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 8.55790282690874e-5*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.00341508645559235*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.000120040143620725*std::sin(0.559359848499298*x_28 + 4.81023979187012) + 0.0117596691796688*std::sin(0.576079845428467*x_28 + 1.81583988666534) + 0.0520270999425745*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.000151921419713917*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0587032154367067*std::sin(0.354879856109619*x_3 - 7.40855979919434) + 0.0460263608147144*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.000104498145028277*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.044259875082291*std::sin(0.327359855175018*x_30 - 1.15199983119965) - 0.188792951516432*std::sin(0.335119843482971*x_30 + 2.01479983329773) + 0.178796750140757*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.00128515340209578*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.00874953819108174*std::sin(0.358559846878052*x_31 + 5.17304039001465) - 0.15057061784688*std::sin(0.361119836568832*x_31 + 5.16720008850098) - 0.0265965140019653*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 6.21139272995535e-5*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.000594631275086925*std::sin(0.270479947328568*x_32 - 4.34687995910645) - 0.127300544984529*std::sin(0.302479922771454*x_32 - 1.16159987449646) - 0.148553803643769*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.00110682407069345*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.000312480286816428*std::sin(0.230319991707802*x_38 + 1.96823978424072) + 0.0893208048790012*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.00347632539697695*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 9.03846786755687e-5*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.000132981099887438*std::sin(0.316959917545319*x_49 + 5.04191970825195) - 0.0125785311928791*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.00536171026400535*std::sin(0.182640001177788*x_5 - 0.996399819850922) + 0.027361720621668*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.000716656220978403*std::sin(0.321759849786758*x_5 - 1.14847981929779) + 0.0226156028082953*std::sin(0.394159853458405*x_5 - 7.39783954620361) - 0.0101308412472574*std::sin(0.250799983739853*x_50 - 7.64688014984131) - 0.0495384745045805*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 9.19130576768955e-5*std::sin(0.245839968323708*x_53 - 7.60552024841309) + 0.0400880000475634*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.00388527086636525*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.0153797962017923*std::sin(0.178720012307167*x_56 + 4.99911975860596) + 0.00726641373867156*std::sin(0.446799844503403*x_59 + 1.90111982822418) - 0.103231070254567*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.0600888321219084*std::sin(0.341279834508896*x_6 - 1.14199984073639) + 0.0129921580246227*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.000146308752916784*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 6.68178328491694e-6*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.000916359301312263*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.066085042803369*std::sin(0.357919842004776*x_7 + 1.9981597661972) + 0.0597407178841596*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.000317104698911788*std::sin(0.393759846687317*x_7 + 1.80199980735779) - 0.00169049344664679*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.00831345894427986*std::sin(0.141760036349297*x_75 + 2.03975987434387) + 0.0278845778808053*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00758753065358766*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 4.25835699090464e-5*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.0092020212739844*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.000728531802005496*std::sin(0.344239860773087*x_91 - 7.38695955276489) - 0.0215942207851171*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.00167718714609881*std::sin(0.15776002407074*x_92 + 8.38064002990723) - 0.0131939094244515*std::sin(0.299599945545197*x_92 + 1.99519979953766) + 0.0208047522467048*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.001785001968764*std::sin(0.222959995269775*x_95 - 4.21456003189087) + 0.0207637625825083*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.0125713812224812*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.00386306078005319*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.00339560757021156*std::sin(0.243519976735115*x_97 - 1.02255988121033) - 0.020364497789708*std::sin(0.268399953842163*x_97 + 5.17671966552734) + 0.676885790407703);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.4717041622123e-5*x_1 + 0.000872767408861888*x_10 - 0.000391568630016582*x_100 + 0.000811864253997539*x_101 - 0.000637168883657569*x_102 - 0.000815841084979078*x_103 + 0.000399276946385752*x_104 + 0.000153413646722351*x_105 + 0.000432932471549835*x_106 - 0.000202528660360109*x_107 - 0.000643834124333611*x_108 - 0.000127854473002291*x_109 + 0.000208160116929931*x_11 + 0.00176949702877452*x_110 - 0.00104226004627826*x_111 - 0.00415024694906495*x_112 - 0.00238258382590477*x_113 + 0.000514035272599787*x_114 - 0.00123595655407095*x_115 - 0.00141564842293691*x_116 + 0.000765371331893146*x_117 + 0.000802763116781934*x_118 - 0.00516632901331564*x_119 - 0.000848122272322766*x_12 + 0.00104866773164295*x_120 - 0.000971284997729523*x_13 - 9.52107616032824e-5*x_14 - 0.000136560744142726*x_15 + 0.000288324724964401*x_16 - 0.000732105866380669*x_17 + 0.000201916338794204*x_18 + 0.000319077727095315*x_19 + 0.000276136714734724*x_2 + 0.00104080139436622*x_20 + 0.00210644059927213*x_21 + 0.000819477835577809*x_22 - 0.00073472503992526*x_23 + 0.000639204030783589*x_24 + 0.00116035152882482*x_25 + 0.000674380376323264*x_26 + 0.000332649979965884*x_27 + 0.000881433716084831*x_28 + 0.000864656545383267*x_29 + 0.000540059859673109*x_3 + 0.000468711446095847*x_30 + 0.000248683050019973*x_31 - 0.00129909193714453*x_32 - 0.000604798720244739*x_33 - 0.000537987148677539*x_34 - 0.00160085795633804*x_35 - 0.0010115429218682*x_36 - 0.000914521341403276*x_37 + 0.000370073487684385*x_38 - 0.000803924280955733*x_39 + 0.000393255104201581*x_4 - 0.000516877519525054*x_40 - 3.17822887742109e-7*x_41 - 0.000412705212571924*x_42 + 0.000167990856109705*x_43 + 0.000269426479122697*x_44 + 0.000415095190861925*x_45 - 0.000400997706020248*x_46 - 0.00213503652834174*x_47 - 0.0022617058384161*x_48 - 0.000277184323079163*x_49 - 0.000160356778073621*x_5 + 3.01427995983098e-5*x_50 + 0.000375809489728214*x_51 - 0.00124555924774243*x_52 - 0.000168628112201451*x_53 - 0.00162802235203359*x_54 - 0.000483608729891877*x_55 + 0.000350593081413356*x_56 - 0.0014825465719694*x_57 + 0.000165953290376023*x_58 - 0.000236315489585357*x_59 - 0.000325445580207125*x_6 + 0.000129064319388456*x_60 + 0.00063672650151212*x_61 - 0.000430813019602416*x_62 - 1.23620600342459e-5*x_63 + 7.55753286962383e-5*x_64 + 0.000366681092158721*x_65 + 0.000231193827430881*x_66 + 0.000954189001537798*x_67 + 0.00062277959834826*x_68 + 9.90337825666341e-5*x_69 + 0.000822794998932738*x_7 + 0.000183131049551434*x_70 - 0.000418375663138018*x_71 + 0.000722259955438442*x_72 + 0.000829475240472669*x_73 + 0.000869364524419134*x_74 + 0.000682625914763894*x_75 + 0.000529128107651523*x_76 + 0.000601826539425162*x_77 + 0.00024372530132796*x_78 + 0.000260592687871866*x_79 + 0.000423429627593352*x_8 + 0.000648792120625304*x_80 - 0.000270269205360542*x_81 - 0.00048679956804849*x_82 - 0.000200914982346563*x_83 + 8.94908250743898e-5*x_84 + 0.000202537194131069*x_85 - 6.26308823847332e-5*x_86 + 0.000788839455101894*x_87 + 0.000162923971181267*x_88 + 0.00102592426987612*x_89 + 0.000747753529160583*x_9 + 4.22033760693067e-5*x_90 - 0.00026013770878692*x_91 + 3.48988570234383e-5*x_92 - 0.00209494087992484*x_93 - 0.00035719700262705*x_94 - 0.000312455013249079*x_95 - 0.000460637870603829*x_96 - 0.000803632037410463*x_97 - 0.000159876909002979*x_98 - 0.000191825467484577*x_99 + 3.49202871259348e-5*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) + 1.30860942386738e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 3.41358674109082e-6*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) + 6.31030890330698e-6*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.000148660758088801*std::exp(0.241199851036072*x_59) - 0.000868970686002232*std::exp(0.262799859046936*x_59) + 0.00270916682769572*std::sin(0.308639913797379*x_1 + 8.31319999694824) + 0.0351628182196279*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.00994554350450578*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.115423783881022*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.00614620518180385*std::sin(0.177440017461777*x_10 - 7.61080026626587) - 0.00788632709351199*std::sin(0.278079956769943*x_10 + 1.9722398519516) + 0.00041366490499444*std::sin(0.613919854164124*x_10 + 4.98239946365356) - 0.00288981160808134*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.000367052855024526*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.00453039350732091*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.00536736299023217*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.00285913381315012*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.00365677412412429*std::sin(0.278079956769943*x_108 - 4.41975975036621) + 0.0079207894881416*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.00791552912930413*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.00402582822482724*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00447923879457781*std::sin(0.190880000591278*x_110 + 8.41744041442871) + 0.0112845877308356*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.00100431449864052*std::sin(0.245119974017143*x_116 - 7.42927980422974) - 0.016405001099779*std::sin(0.250159978866577*x_116 + 5.1715202331543) - 0.00508693571593194*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.000463916296899312*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.0106131152874326*std::sin(0.293759942054749*x_12 + 1.95231974124908) - 0.0123526075854022*std::sin(0.301919937133789*x_12 + 8.31360054016113) + 0.0289800034669928*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.0507578341706283*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.0245933236478492*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.010881923573969*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.00248042304891759*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.000112645032342618*std::sin(0.401919841766357*x_14 - 1.40335988998413) + 0.00407478425930923*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.00164859994383464*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.00281485321608409*std::sin(0.336879849433899*x_15 - 1.09447979927063) - 0.00414959744088659*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.00232062291325825*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.0277060528765112*std::sin(0.35319983959198*x_17 + 2.01239991188049) + 0.0157583609845701*std::sin(0.370559841394424*x_17 - 1.17351984977722) - 0.00754388578211044*std::sin(0.445119857788086*x_18 + 5.17095994949341) + 0.00170145445514973*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.00421823793035786*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.00150262740538208*std::sin(0.377039849758148*x_2 - 7.3931999206543) + 0.00603659698503911*std::sin(0.428799867630005*x_2 - 7.37967967987061) - 0.0051589070262579*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.0038081628001881*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.000466078596196068*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.0197399851493383*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.0206936259048259*std::sin(0.376879841089249*x_23 + 2.00415992736816) - 0.00105328791028549*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.0196582365028783*std::sin(0.120720058679581*x_24 + 7.95175981521606) - 0.00524993961439406*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.0333931939901885*std::sin(0.0878400802612305*x_25 - 7.56063985824585) + 0.00207230400126427*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.000902377240433434*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.00429105490870031*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 0.00136138762854965*std::sin(0.598719835281372*x_26 - 4.38567972183228) + 0.00227869739063782*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.00190959362077273*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.000187594683912923*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.00855005416867258*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.00241675963718478*std::sin(0.663759827613831*x_29 + 7.96551990509033) - 0.0391693930965128*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.00756390186243397*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.00166235215245219*std::sin(0.532079875469208*x_3 + 1.79583990573883) + 0.0295321547994248*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.0310259453998156*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.00285223328265922*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.0204441669622658*std::sin(0.377999842166901*x_30 + 2.00567984580994) - 0.0200568401576841*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.024744545443092*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.000424277635803767*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 0.000988105776573647*std::sin(0.46375983953476*x_31 + 5.03119993209839) - 0.00136309187716155*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.00203074636994067*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.02441310527626*std::sin(0.30447992682457*x_32 + 2.02991986274719) - 0.00253720744841175*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.00497092342880922*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.0146788446972411*std::sin(0.0996000692248344*x_4 - 7.55311965942383) - 0.00231955873273064*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 0.0014378357156902*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.00211545781576814*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.00206713661111536*std::sin(0.447439849376678*x_49 - 4.49327993392944) + 0.00357757126995658*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.00449658339060924*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.0114005374084805*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.000360772637010683*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.000161611005591637*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.000790256454006549*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 0.00146214910538655*std::sin(0.245839968323708*x_53 - 7.60552024841309) - 0.0267484944501726*std::sin(0.254719972610474*x_53 - 7.42695951461792) - 0.00890632797230641*std::sin(0.105680070817471*x_54 + 1.75039982795715) - 0.0102620832383837*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.00119415133932514*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.016964836470624*std::sin(0.14408004283905*x_6 - 7.45831966400146) - 0.0400939381017566*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.000207255811429593*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.00232747356680826*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 0.000106293531075552*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.014577405718961*std::sin(0.344559848308563*x_7 + 2.00287985801697) + 0.0440948762364806*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.000953006493378724*std::sin(0.367039829492569*x_7 + 2.01095986366272) - 0.000726909023130733*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 2.69673898929785e-5*std::sin(1.01663982868195*x_71 + 8.21144008636475) - 0.00554710911417303*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.000444825317249467*std::sin(0.221199989318848*x_8 + 2.01559972763062) - 0.00506273751090609*std::sin(0.240479975938797*x_8 + 1.98351979255676) - 9.76156496899311e-5*std::sin(1.24679982662201*x_88 + 8.19960021972656) + 0.00613999737291715*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.0115894536583974*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.00354876127339052*std::sin(0.354159861803055*x_91 - 7.39296007156372) + 0.0038446685721212*std::sin(0.15776002407074*x_92 + 8.38064002990723) + 0.00880356247748189*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.00341902121916227*std::sin(0.279439955949783*x_94 - 1.18527984619141) + 0.00409181586350954*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 0.00341228504033196*std::sin(0.283439934253693*x_95 - 7.42248010635376) - 0.0083881840067245*std::sin(0.29079994559288*x_95 - 1.20351994037628) + 0.00257760576016096*std::sin(0.305119931697845*x_96 - 1.22831988334656) + 0.00226570021300647*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.00334667047388767*std::sin(0.268399953842163*x_97 + 5.17671966552734) - 0.221222261998459);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00242368013805117*x_1 - 0.00030145343886855*x_10 - 0.00168221874967492*x_100 - 0.000358794980672522*x_101 - 0.00161685485170882*x_102 - 0.00770520822709015*x_103 + 0.0043544277481207*x_104 + 0.00230342566948931*x_105 + 0.00950664526045057*x_106 - 0.00234248969790105*x_107 + 0.000103343789973407*x_108 + 0.00185855297216915*x_109 - 0.01784239535237*x_11 - 0.00737741732640005*x_110 + 0.0111276791761484*x_111 + 0.0126940388721537*x_112 + 0.0197498971401236*x_113 + 0.00354098131958417*x_114 - 0.00467211836572057*x_115 + 0.000361744659335765*x_116 + 0.00385010685994636*x_117 + 0.0125659289724705*x_118 + 0.0171547002150155*x_119 + 0.00343796093067837*x_12 + 0.0288905653419486*x_120 + 0.00384283404184226*x_13 + 0.000678114901832488*x_14 + 0.000972619838862036*x_15 - 0.00241988356741215*x_16 + 0.00608839097141038*x_17 + 0.000702011899738846*x_18 - 0.00247774756741287*x_19 - 4.92285092367336e-5*x_2 + 0.00191654616501155*x_20 - 0.00126427375531359*x_21 - 0.00359101307468785*x_22 - 0.000234946415617601*x_23 - 0.00117789261148989*x_24 - 0.000307754310320117*x_25 - 0.000198367903818388*x_26 - 0.00373135805812845*x_27 + 0.000261927707667369*x_28 - 0.00222592765408273*x_29 - 0.00931235134797015*x_3 - 0.00333828036773199*x_30 - 6.59569782484028e-5*x_31 + 0.00028743187932764*x_32 + 0.00583099539394756*x_33 + 0.00750915381244521*x_34 - 0.00451493389067797*x_35 - 0.000991752617492005*x_36 + 0.00488417963572225*x_37 - 0.00238971046315689*x_38 + 0.00359051306367866*x_39 + 0.00155497420992763*x_4 - 0.00310654347485469*x_40 - 0.00152124220371635*x_41 + 0.00291272986722926*x_42 - 0.000373017761075328*x_43 + 0.00293883057441112*x_44 + 0.00496597307680764*x_45 + 0.000747844442459479*x_46 - 0.00378335020712186*x_47 - 0.00987950711266364*x_48 - 0.00291656362133664*x_49 + 0.00114210115527338*x_5 - 0.000842792128304146*x_50 + 0.000123279196916036*x_51 - 0.00446045971641256*x_52 - 0.00194150131748953*x_53 - 0.00338501819105885*x_54 - 0.0233131339611134*x_55 + 0.00247300112999326*x_56 - 0.00308501693475334*x_57 - 0.00264319708399955*x_58 + 0.00190930051206447*x_59 + 0.00104277786769207*x_6 - 0.00414740953511028*x_60 - 0.000842151944510704*x_61 + 0.00139758337032022*x_62 + 0.000822627417372373*x_63 - 0.000664591242551125*x_64 - 0.00176315717277844*x_65 - 0.00646525191361894*x_66 + 0.00344141266708771*x_67 - 0.00247695825125604*x_68 - 0.0045407835660647*x_69 - 0.000129284914127721*x_7 - 0.00499505816417505*x_70 - 0.00142366529002274*x_71 - 0.00131056818182314*x_72 - 0.00229956483319154*x_73 - 0.00712818573830453*x_74 - 0.0105788866858385*x_75 - 0.00127704298062412*x_76 - 0.00315554891628389*x_77 + 0.000135183230531158*x_78 - 0.00512764077307432*x_79 - 0.000857603654444538*x_8 - 0.0107221808081828*x_80 + 0.00112473123967606*x_81 + 0.00753807741476518*x_82 + 0.00607512196589999*x_83 + 0.000574567979906488*x_84 - 0.000870112384382038*x_85 + 0.00112405945175531*x_86 - 0.00048687558142956*x_87 + 0.00591977666424968*x_88 + 0.000141468205105859*x_89 + 0.000883681382807293*x_9 + 0.00156891540235248*x_90 - 0.00843131843188641*x_91 + 0.00408748163391648*x_92 + 0.0104807209439629*x_93 - 0.00337096656642758*x_94 + 0.00423388985218295*x_95 - 0.00283074240702025*x_96 + 0.00597542973454736*x_97 + 0.00107723138116727*x_98 - 0.00092166397365207*x_99 - 9.26173544279869e-6*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 3.47076020254472e-6*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) - 5.3637329986437e-7*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) - 4.49436012320604e-5*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) - 0.0145772350994047*std::exp(0.241199851036072*x_59) + 2.01736214005281e-5*std::exp(0.262799859046936*x_59) - 0.000718538949523379*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.250438402378398*std::sin(0.322319835424423*x_1 - 4.26448011398315) - 0.000230891136507067*std::sin(0.332799851894379*x_1 - 4.25767993927002) - 0.0181364179494416*std::sin(0.351919859647751*x_1 - 4.22192001342773) + 0.00014268745584285*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.00209165162050563*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.00294622510857197*std::sin(0.613919854164124*x_10 + 4.98239946365356) + 0.0205819623951092*std::sin(0.248239979147911*x_100 - 4.40064001083374) + 0.0359921194428732*std::sin(0.209440007805824*x_101 + 2.00071978569031) - 0.000711855974232348*std::sin(0.205119997262955*x_102 - 7.41111993789673) + 0.000124606215869372*std::sin(0.180640012025833*x_107 - 7.3918399810791) + 6.63763277738354e-5*std::sin(0.241119980812073*x_108 + 4.99031972885132) - 0.000574585077978248*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.00210079191138107*std::sin(0.309439927339554*x_11 - 7.45864009857178) - 0.00124375877962916*std::sin(0.314319938421249*x_11 + 5.12199974060059) - 9.34617654421272e-5*std::sin(0.320399910211563*x_11 - 4.29864025115967) - 0.000103987935450493*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.00299295552087342*std::sin(0.286959946155548*x_113 + 1.97287976741791) + 0.0984801150528131*std::sin(0.245119974017143*x_116 - 7.42927980422974) + 0.116840528560113*std::sin(0.250159978866577*x_116 + 5.1715202331543) + 0.0362304308415325*std::sin(0.178880020976067*x_117 - 0.982079803943634) + 0.0454902626173*std::sin(0.222479999065399*x_119 - 4.20864009857178) + 0.00166762765979754*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.00327622115683394*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.00768622331983449*std::sin(0.261279970407486*x_120 - 4.24855995178223) + 0.00117837039403469*std::sin(0.267119973897934*x_120 + 5.15655994415283) - 0.00386432311821495*std::sin(0.188800007104874*x_13 - 1.17847990989685) + 0.00170986522357315*std::sin(0.329119831323624*x_14 - 4.3219199180603) - 5.75843538891006e-5*std::sin(0.342479854822159*x_14 + 1.85703992843628) - 0.0110456393492728*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.00108073492237049*std::sin(0.449519842863083*x_14 - 7.47095966339111) + 0.16165684391161*std::sin(0.280479967594147*x_15 + 1.99391984939575) - 0.000442294929837462*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.00110057725336006*std::sin(0.357919842004776*x_15 - 4.34151983261108) - 5.38745078741842e-5*std::sin(0.479599863290787*x_15 + 8.09632015228271) + 0.00064321090485245*std::sin(0.35319983959198*x_17 + 2.01239991188049) - 0.112234995626002*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.0020008276012343*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.000451268369436298*std::sin(0.497599840164185*x_19 + 1.90071988105774) + 9.79286601437418e-5*std::sin(0.366479843854904*x_2 - 4.19960021972656) - 0.147343207694251*std::sin(0.377039849758148*x_2 - 7.3931999206543) - 0.0429941563640529*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00136827145432347*std::sin(0.268879950046539*x_20 + 1.9923198223114) - 8.84085456507245e-5*std::sin(0.446319848299026*x_20 + 1.76775991916656) - 0.0457022913033455*std::sin(0.299359947443008*x_21 + 8.36335945129395) - 0.00310172313665619*std::sin(0.399359852075577*x_22 + 1.99407982826233) - 0.00325156770710428*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.00750178042751806*std::sin(0.494639873504639*x_23 + 8.32231998443604) - 0.00045637652339643*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.00139241557848115*std::sin(0.243999972939491*x_24 + 8.21592044830322) - 0.000775240941684337*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.0147594683701799*std::sin(0.307679921388626*x_25 - 1.16671991348267) + 0.0884844484264814*std::sin(0.323279827833176*x_25 - 1.15535986423492) - 0.000674248951571478*std::sin(0.277439951896667*x_26 - 7.40551996231079) + 3.16053453127105e-5*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.00060436766485259*std::sin(0.356959849596024*x_27 + 5.00256013870239) + 4.43322419903055e-5*std::sin(0.559359848499298*x_28 + 4.81023979187012) + 0.0183949809348052*std::sin(0.576079845428467*x_28 + 1.81583988666534) + 0.00134346103272142*std::sin(0.201120004057884*x_29 + 8.21127986907959) - 5.61063735773915e-5*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0103887048524712*std::sin(0.354879856109619*x_3 - 7.40855979919434) + 0.00118850795644569*std::sin(0.360399842262268*x_3 + 5.18527984619141) - 3.85923984527107e-5*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.00783266769318491*std::sin(0.327359855175018*x_30 - 1.15199983119965) - 0.00487507421891175*std::sin(0.335119843482971*x_30 + 2.01479983329773) + 0.279681576054079*std::sin(0.349039852619171*x_30 - 1.13991987705231) + 0.000474622321315999*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.142849841399955*std::sin(0.358559846878052*x_31 + 5.17304039001465) - 0.00388808444009655*std::sin(0.361119836568832*x_31 + 5.16720008850098) - 0.0416034125215254*std::sin(0.421839863061905*x_31 - 7.38175964355469) + 2.29394065431344e-5*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.00970828190957567*std::sin(0.270479947328568*x_32 - 4.34687995910645) - 0.199128994379302*std::sin(0.302479922771454*x_32 - 1.16159987449646) - 0.00383600559474268*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.0180706272152021*std::sin(0.235039994120598*x_36 + 5.17000007629395) - 0.000115402658431627*std::sin(0.230319991707802*x_38 + 1.96823978424072) + 0.00230647145235275*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.000615205116988553*std::sin(0.255919963121414*x_41 - 7.42320013046265) - 3.33801287336141e-5*std::sin(0.244959965348244*x_44 - 4.23079967498779) + 4.91114898943611e-5*std::sin(0.316959917545319*x_49 + 5.04191970825195) - 0.000324807004910058*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.000948861574665765*std::sin(0.182640001177788*x_5 - 0.996399819850922) + 0.000706543426098988*std::sin(0.198320001363754*x_5 + 1.98175978660583) - 0.000264669601801336*std::sin(0.321759849786758*x_5 - 1.14847981929779) + 0.0353762998033108*std::sin(0.394159853458405*x_5 - 7.39783954620361) - 0.0158470981410793*std::sin(0.250799983739853*x_50 - 7.64688014984131) - 0.0774902150841589*std::sin(0.240319982171059*x_53 - 7.40279960632324) + 3.39445771397556e-5*std::sin(0.245839968323708*x_53 - 7.60552024841309) + 0.00709437119452195*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.0634330995459687*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.00272176169981434*std::sin(0.178720012307167*x_56 + 4.99911975860596) + 0.000187635745915338*std::sin(0.446799844503403*x_59 + 1.90111982822418) - 0.0026656669390801*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.010633917362112*std::sin(0.341279834508896*x_6 - 1.14199984073639) + 0.0203228930604697*std::sin(0.446719855070114*x_6 + 5.15248012542725) - 5.4033549477417e-5*std::sin(0.576079845428467*x_60 + 8.0152006149292) + 2.46766143874035e-6*std::sin(1.24703979492188*x_67 + 2.59119987487793) + 0.000338422306659326*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.0116950664412471*std::sin(0.357919842004776*x_7 + 1.9981597661972) + 0.0934490035153897*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.00517722820993013*std::sin(0.393759846687317*x_7 + 1.80199980735779) - 0.00264434264658086*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.00147123237854627*std::sin(0.141760036349297*x_75 + 2.03975987434387) + 0.0436182575084098*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00134276488830818*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 0.000695243117396932*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.00162848120584906*std::sin(0.305919945240021*x_9 - 1.20959985256195) + 0.000269055394053734*std::sin(0.344239860773087*x_91 - 7.38695955276489) - 0.000557613132171675*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.0273826929588655*std::sin(0.15776002407074*x_92 + 8.38064002990723) - 0.00233492543536478*std::sin(0.299599945545197*x_92 + 1.99519979953766) + 0.000537227213696743*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.0291429378977337*std::sin(0.222959995269775*x_95 - 4.21456003189087) + 0.000536168764991105*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.00222475665322061*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.000683645656759637*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.000600920487563054*std::sin(0.243519976735115*x_97 - 1.02255988121033) - 0.000525858817070563*std::sin(0.268399953842163*x_97 + 5.17671966552734) + 0.125556200684765);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00137215049277291*x_1 - 2.88512925269589e-5*x_10 - 0.00247196319950343*x_100 - 0.000669301027159846*x_101 - 0.0019610604349603*x_102 - 0.00527503996227632*x_103 + 0.00160795844343571*x_104 + 0.00156164919932262*x_105 + 0.00618761786937009*x_106 - 0.00236043597516907*x_107 - 0.00232901850513763*x_108 + 0.00136367634110116*x_109 - 0.0100041811700336*x_11 - 0.000243723231834763*x_110 + 0.00332698484912842*x_111 - 0.00584175541904242*x_112 + 0.00658050443778546*x_113 - 0.00268711329723007*x_114 - 0.00650071675708088*x_115 - 0.00490647899039337*x_116 - 0.00619252505330374*x_117 + 0.00638601614487005*x_118 - 0.00937387066525489*x_119 - 0.000194057821456011*x_12 + 0.0160705433013115*x_120 - 0.000424155269123409*x_13 + 5.64422473926838e-5*x_14 + 8.09550850685246e-5*x_15 - 0.00100465932094383*x_16 + 0.00016958484758074*x_17 + 0.000830075216376228*x_18 - 0.0012589819426017*x_19 + 0.000208979551534589*x_2 + 0.00252832446517993*x_20 + 0.00387656848163267*x_21 + 0.00111816127157883*x_22 - 0.00100552055723874*x_23 + 0.00049190836510465*x_24 + 0.00413651412434589*x_25 + 0.00238753085920487*x_26 - 0.00118345222712577*x_27 + 0.00207474963305138*x_28 + 0.00187365199256959*x_29 - 0.00362137912862611*x_3 - 0.000277858583954572*x_30 + 0.000886525266989441*x_31 - 0.00406591764148203*x_32 + 0.00215758822175055*x_33 + 0.0038934272667653*x_34 - 0.00662547551209494*x_35 - 0.00113339162028501*x_36 + 0.00226242426969887*x_37 + 0.000318569500843187*x_38 + 0.0017650761721815*x_39 + 0.00265217193119557*x_4 - 0.00286158822554232*x_40 - 0.0007881020744693*x_41 + 0.00329315373944842*x_42 + 0.00124287686174067*x_43 + 0.002488484804694*x_44 + 0.0040899856967851*x_45 + 0.000835884438875975*x_46 - 0.00588381957933429*x_47 - 0.00713036290760016*x_48 - 0.00279453365289829*x_49 + 9.50617008698833e-5*x_5 + 0.00113408193505311*x_50 + 0.00163341487153246*x_51 - 0.0020511018667975*x_52 - 0.000200816547361953*x_53 - 0.00652541312170843*x_54 - 0.0140412714195235*x_55 + 0.00320090648886297*x_56 - 0.00520187280883604*x_57 - 0.00015082723560122*x_58 + 0.000277246785472238*x_59 - 0.000123751652167252*x_6 - 0.000209527438143138*x_60 + 0.000286862077069489*x_61 - 0.000791628525347428*x_62 + 0.000970100950908033*x_63 + 0.000155396176754031*x_64 + 0.00015324125252612*x_65 - 0.00179868937181115*x_66 + 0.00626263644415102*x_67 + 0.000504786251519665*x_68 - 0.00287699532557694*x_69 + 6.07584455291508e-5*x_7 - 0.00258317046031177*x_70 - 0.00200202488922904*x_71 + 0.00101832403305157*x_72 + 0.00127176344373575*x_73 - 0.00243500384223131*x_74 - 0.00474652300312133*x_75 + 0.000665049700787174*x_76 + 0.000297565162200286*x_77 + 0.00137093151892369*x_78 - 0.002121305997602*x_79 - 0.000248132613920315*x_8 - 0.00379595837042118*x_80 - 0.000855307638621317*x_81 + 0.00136239636795039*x_82 + 0.0023731346337043*x_83 + 9.98380010600194e-5*x_84 - 6.09448505210017e-5*x_85 + 0.000196208727937753*x_86 + 0.000607074186009372*x_87 + 0.00381516491885258*x_88 + 0.00279694017592377*x_89 + 0.000811787999858662*x_9 + 0.000514764683588117*x_90 - 0.00606317896636454*x_91 + 0.00223073375609451*x_92 + 0.00133031286273243*x_93 - 0.00307817705242054*x_94 + 0.00207825375082371*x_95 - 0.00160809778923562*x_96 + 0.00178761979498082*x_97 + 0.00113622430912378*x_98 + 0.000237357384557907*x_99 + 0.000124486638173293*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) + 4.66503575046935e-5*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 2.52072781600065e-7*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) - 3.74083780286061e-6*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) - 0.00825280531489521*std::exp(0.241199851036072*x_59) - 0.00101690880527125*std::exp(0.262799859046936*x_59) + 0.00965785502891729*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.0208450016737161*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.0116387249027572*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.00852334991680815*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.00719256733174089*std::sin(0.177440017461777*x_10 - 7.61080026626587) - 0.0281138108591649*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.000245226238212995*std::sin(0.613919854164124*x_10 + 4.98239946365356) + 0.00171312001873487*std::sin(0.248239979147911*x_100 - 4.40064001083374) + 0.0203767005613169*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.000334542221935257*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.00628113096767928*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.00334588772311435*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.000270030702327077*std::sin(0.278079956769943*x_108 - 4.41975975036621) + 0.0282366651654703*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.000584514060077007*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.00471120629991636*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00524180785899037*std::sin(0.190880000591278*x_110 + 8.41744041442871) + 0.0402282027268901*std::sin(0.286959946155548*x_113 + 1.97287976741791) + 0.0557538663112143*std::sin(0.245119974017143*x_116 - 7.42927980422974) + 0.00972511000814274*std::sin(0.250159978866577*x_116 + 5.1715202331543) + 0.00301560537185548*std::sin(0.178880020976067*x_117 - 0.982079803943634) + 0.0257540115491013*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.000783714519318296*std::sin(0.293759942054749*x_12 + 1.95231974124908) - 0.0440355654990759*std::sin(0.301919937133789*x_12 + 8.31360054016113) + 0.10331023891201*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.0593991136134566*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.0018160685434122*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.000803564389160106*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.00290270325555674*std::sin(0.342479854822159*x_14 + 1.85703992843628) - 0.00625341572022923*std::sin(0.401919841766357*x_14 - 1.40335988998413) + 0.0145261174942094*std::sin(0.449519842863083*x_14 - 7.47095966339111) + 0.0915209538383176*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.000207859923825304*std::sin(0.336879849433899*x_15 - 1.09447979927063) - 0.014792817519671*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.00271569790813458*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.0324228763792416*std::sin(0.35319983959198*x_17 + 2.01239991188049) - 0.00934177286492433*std::sin(0.370559841394424*x_17 - 1.17351984977722) - 0.0268930486279067*std::sin(0.445119857788086*x_18 + 5.17095994949341) + 0.00606548120187861*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.00493637284111914*std::sin(0.366479843854904*x_2 - 4.19960021972656) - 0.0834173832884456*std::sin(0.377039849758148*x_2 - 7.3931999206543) - 0.00357857761771922*std::sin(0.428799867630005*x_2 - 7.37967967987061) - 0.0183908852189953*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.00445648437375223*std::sin(0.446319848299026*x_20 + 1.76775991916656) - 0.0258740501884711*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.00145767878268346*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.00152809939774776*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.000624403542277799*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.0230049576100779*std::sin(0.120720058679581*x_24 + 7.95175981521606) - 0.0187154054848343*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.0390782261723689*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.00122849027927715*std::sin(0.307679921388626*x_25 - 1.16671991348267) + 0.0500948857091192*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.000316868510711714*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 0.00159315738627337*std::sin(0.598719835281372*x_26 - 4.38567972183228) + 0.00812328308045558*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.00223469283686356*std::sin(0.559359848499298*x_28 + 4.81023979187012) + 0.0104141968892548*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.000631369905204113*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.00282820145128698*std::sin(0.663759827613831*x_29 + 7.96551990509033) - 0.139634191674549*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.000558548508307238*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.00194535968648994*std::sin(0.532079875469208*x_3 + 1.79583990573883) + 0.105278592233089*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.00229107884225145*std::sin(0.335119843482971*x_30 + 2.01479983329773) + 0.158339875950251*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.0239246889857805*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.0118899703671364*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.0018272353604456*std::sin(0.361119836568832*x_31 + 5.16720008850098) - 0.0235534970544205*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 0.00115632607741908*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.000808059589632122*std::sin(0.270479947328568*x_32 - 4.34687995910645) - 0.112735564183249*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.00180276050419495*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.00150409142914449*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.0058171994596746*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.00108394410165964*std::sin(0.0996000692248344*x_4 - 7.55311965942383) - 0.00826894886751053*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 0.00168262039602921*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.00247560443026151*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.00015264556463114*std::sin(0.447439849376678*x_49 - 4.49327993392944) + 0.0127536127814794*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.000332045548842658*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.01334142458688*std::sin(0.321759849786758*x_5 - 1.14847981929779) + 0.0200280583421484*std::sin(0.394159853458405*x_5 - 7.39783954620361) - 0.0089717298837903*std::sin(0.250799983739853*x_50 - 7.64688014984131) - 0.0438705731599978*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 0.00171107302448548*std::sin(0.245839968323708*x_53 - 7.60552024841309) - 0.095355176728371*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.00527979356858719*std::sin(0.105680070817471*x_54 + 1.75039982795715) - 0.0365830967653217*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 8.81808703237881e-5*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.00125275079934658*std::sin(0.14408004283905*x_6 - 7.45831966400146) - 0.142930083805322*std::sin(0.341279834508896*x_6 - 1.14199984073639) + 0.0115056715981991*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.00272371485281303*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 0.000124389498328629*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.0170591395917179*std::sin(0.344559848308563*x_7 + 2.00287985801697) + 0.157192948716339*std::sin(0.357919842004776*x_7 + 1.9981597661972) + 0.0529055357634292*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.000430921654491885*std::sin(0.393759846687317*x_7 + 1.80199980735779) - 0.00149707711368378*std::sin(1.01663982868195*x_71 + 8.21144008636475) - 0.0197747791337883*std::sin(0.141760036349297*x_75 + 2.03975987434387) + 0.0246941882282309*std::sin(0.221199989318848*x_8 + 2.01559972763062) - 0.0180480524233276*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 5.78678980864985e-5*std::sin(1.24679982662201*x_88 + 8.19960021972656) + 0.0218883547145761*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.0135625029282946*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.000262054605102047*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.00227917234392819*std::sin(0.15776002407074*x_92 + 8.38064002990723) + 0.0313836450662038*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.000252474085011379*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.00242568465333599*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 0.000251976658854114*std::sin(0.283439934253693*x_95 - 7.42248010635376) - 0.0299028706038499*std::sin(0.29079994559288*x_95 - 1.20351994037628) + 0.00918885559163234*std::sin(0.305119931697845*x_96 - 1.22831988334656) + 0.00807694969999875*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.000247131419072156*std::sin(0.268399953842163*x_97 + 5.17671966552734) - 0.459281113788072);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.42105594870586e-5*x_1 + 0.00482486998357228*x_10 + 9.85030091654471e-5*x_100 + 0.00606247016383118*x_101 - 0.000125645544976096*x_102 - 0.000107397740106128*x_103 + 0.00292315579253052*x_104 + 0.000286764609215113*x_105 + 0.000715196869668211*x_106 - 0.00209841823416658*x_107 + 0.00208468345256896*x_108 - 0.000504922289958895*x_109 + 5.25796995198251e-5*x_11 + 0.00199410119974663*x_110 + 0.000285275306385309*x_111 - 0.00098476509372533*x_112 + 0.00333715507607089*x_113 + 0.0120311178789402*x_114 + 0.0010092223382741*x_115 + 0.000342466406857789*x_116 + 0.0190183117817131*x_117 + 0.00848150523980139*x_118 + 0.0133187035853579*x_119 + 0.00218079708803848*x_12 + 0.00863089117382268*x_120 + 0.00278194317426234*x_13 + 0.000416663657499653*x_14 + 0.000597620459780262*x_15 - 0.000545396255219027*x_16 + 0.00139168064673993*x_17 + 0.000806641760728497*x_18 + 0.00262476705563014*x_19 + 0.00121569307159816*x_2 + 0.00215507597503772*x_20 + 0.00235000763932916*x_21 - 0.00228540717264192*x_22 - 4.48680238835561e-5*x_23 + 0.00040817789660765*x_24 - 0.000304247361773003*x_25 - 0.00150022448531779*x_26 - 0.000181155322263959*x_27 + 0.00227198995924833*x_28 - 0.000904547201992677*x_29 - 0.00204150066936396*x_3 - 0.00205118646415191*x_30 - 6.52053795825722e-5*x_31 + 0.000263570353292613*x_32 + 0.000299172721117903*x_33 + 0.00110573999727956*x_34 - 0.00121998419064795*x_35 - 0.000486027141569543*x_36 + 0.000327789976272955*x_37 - 0.000997724625713497*x_38 - 0.00227222261862286*x_39 - 0.00159098237346978*x_4 - 0.00158077456106567*x_40 + 0.000503863264565132*x_41 - 0.00382747644912589*x_42 - 0.00118271264048338*x_43 - 0.000900076999288415*x_44 + 0.000374437426716939*x_45 - 0.00140354753421268*x_46 - 0.00411569251279005*x_47 - 0.00863171407206727*x_48 + 0.00011064502656763*x_49 + 0.000701757243949108*x_5 + 0.00062914553132524*x_50 - 0.000499299564137587*x_51 - 0.00936057810792048*x_52 - 0.00373468225867531*x_53 + 0.0011500942866021*x_54 - 0.0020550870859325*x_55 - 0.00259882047053559*x_56 - 0.00248165936978376*x_57 + 0.000633466586850031*x_58 + 0.00116988464946822*x_59 + 0.000626622281425717*x_6 - 0.00354616141206068*x_60 + 0.001548449335074*x_61 - 0.000201034105670846*x_62 - 0.00115642483299187*x_63 + 0.000953329730196656*x_64 - 0.00221210006085718*x_65 - 0.00373825753496071*x_66 - 0.0010603347959634*x_67 - 0.00121194077363114*x_68 - 0.000107627010235313*x_69 + 0.00455582175522049*x_7 - 0.000963932514661906*x_70 - 0.00108211354376303*x_71 + 0.000848504472579708*x_72 - 0.000574777584349645*x_73 + 0.00203757958568239*x_74 - 3.44318059850429e-6*x_75 + 0.000938354828287041*x_76 - 0.00086482638903365*x_77 - 0.000871317996107526*x_78 - 0.00117013544370035*x_79 + 0.00228317863982495*x_8 - 0.00211702912937857*x_80 + 0.00177252262931101*x_81 + 0.00345974235228675*x_82 + 0.000175060285406545*x_83 + 0.000651481292636883*x_84 + 0.00101949742665293*x_85 + 0.000678007087837959*x_86 + 0.00355467583271648*x_87 + 0.000434587298617841*x_88 + 0.00016843202059564*x_89 + 0.0037074167726836*x_9 + 0.000771192285292984*x_90 + 3.66899536628184e-5*x_91 + 0.000898478043119419*x_92 + 0.00343560172501115*x_93 + 0.00217229375478314*x_94 - 5.9541115997675e-5*x_95 - 0.00227319613179344*x_96 + 0.00127116470909527*x_97 - 5.72622855352481e-5*x_98 + 0.00140068615322364*x_99 - 9.15619531365774e-6*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) - 3.43120989555785e-6*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 1.8901054039665e-5*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) - 2.76153277563307e-5*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.000145614519007757*std::exp(0.241199851036072*x_59) - 5.58486714540375e-5*std::exp(0.262799859046936*x_59) - 0.000710350992310191*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.153880382854542*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.000639199227962856*std::sin(0.332799851894379*x_1 - 4.25767993927002) + 0.639102311459252*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.000395016079848273*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.00206781665096786*std::sin(0.278079956769943*x_10 + 1.9722398519516) - 0.00181029044817858*std::sin(0.613919854164124*x_10 + 4.98239946365356) + 0.0126464640533515*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.000359531497228701*std::sin(0.209440007805824*x_101 + 2.00071978569031) + 0.0250848210394258*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.000344959959000581*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.000183756284931044*std::sin(0.241119980812073*x_108 + 4.99031972885132) + 0.0202475843074183*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.00207685278560979*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.0438283410304408*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.000258739634697171*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00028788029312408*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.00295884993513984*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.000983734877530351*std::sin(0.245119974017143*x_116 - 7.42927980422974) + 0.0717919659964582*std::sin(0.250159978866577*x_116 + 5.1715202331543) + 0.0222615721707739*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.000454410089799899*std::sin(0.222479999065399*x_119 - 4.20864009857178) - 0.0587648947549096*std::sin(0.293759942054749*x_12 + 1.95231974124908) + 0.00323888767801433*std::sin(0.301919937133789*x_12 + 8.31360054016113) - 0.00759863660276709*std::sin(0.261279970407486*x_120 - 4.24855995178223) - 0.00326220164843013*std::sin(0.267119973897934*x_120 + 5.15655994415283) + 0.13617340777883*std::sin(0.188800007104874*x_13 - 1.17847990989685) - 0.0602532881474007*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.000159416576597458*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.000110336799126139*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.0010684196382665*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.00161481813320432*std::sin(0.280479967594147*x_15 + 1.99391984939575) + 0.0155858622575762*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.00108803586020901*std::sin(0.357919842004776*x_15 - 4.34151983261108) + 0.000149146235585372*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.00178066564190693*std::sin(0.35319983959198*x_17 + 2.01239991188049) - 0.0689621237501419*std::sin(0.370559841394424*x_17 - 1.17351984977722) + 0.00197802759741998*std::sin(0.445119857788086*x_18 + 5.17095994949341) - 0.000446126037064392*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.000271105789967822*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.00147183674895486*std::sin(0.377039849758148*x_2 - 7.3931999206543) - 0.0264175029826782*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00135267960904986*std::sin(0.268879950046539*x_20 + 1.9923198223114) + 0.000244750296525706*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.000456528080963779*std::sin(0.299359947443008*x_21 + 8.36335945129395) + 0.109300438028594*std::sin(0.399359852075577*x_22 + 1.99407982826233) + 0.114580753667545*std::sin(0.376879841089249*x_23 + 2.00415992736816) + 0.0046094242468972*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.00126343317386911*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.00137654860399474*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.00214617771347259*std::sin(0.0878400802612305*x_25 - 7.56063985824585) - 0.00906886732211758*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.000883886437271977*std::sin(0.323279827833176*x_25 - 1.15535986423492) + 0.0237596015183129*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 8.74962661148567e-5*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.000597480722141788*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.000122729418213065*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.000183750641511429*std::sin(0.576079845428467*x_28 + 1.81583988666534) - 0.0473417106818565*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.000155324934586073*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0102703225839959*std::sin(0.354879856109619*x_3 - 7.40855979919434) - 0.0418813783553957*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.00010683923025106*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.00774341220052239*std::sin(0.327359855175018*x_30 - 1.15199983119965) + 0.171790880124586*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.00279378756634785*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.00131394485708133*std::sin(0.377999842166901*x_30 + 2.00567984580994) + 0.0877732331646264*std::sin(0.358559846878052*x_31 + 5.17304039001465) + 0.137010723933552*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.000415583672904517*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 6.3505473506337e-5*std::sin(0.46375983953476*x_31 + 5.03119993209839) + 0.00596519592409836*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.0019891339159526*std::sin(0.302479922771454*x_32 - 1.16159987449646) + 0.135175537374852*std::sin(0.30447992682457*x_32 + 2.02991986274719) + 0.0111033891283793*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.000319480822392242*std::sin(0.230319991707802*x_38 + 1.96823978424072) - 0.0812768673848744*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.0006081946784054*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 9.24095781181007e-5*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.000135960292367569*std::sin(0.316959917545319*x_49 + 5.04191970825195) + 0.0114457501031821*std::sin(0.447439849376678*x_49 - 4.49327993392944) - 0.000938049025144608*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.0248976141829653*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.000732711561370275*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.000353379968492359*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.000158299400246089*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.000774063141627474*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 9.39721975884219e-5*std::sin(0.245839968323708*x_53 - 7.60552024841309) + 0.00701352880200621*std::sin(0.254719972610474*x_53 - 7.42695951461792) + 0.0389760897333766*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.00269074644537704*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.00661202445053741*std::sin(0.446799844503403*x_59 + 1.90111982822418) + 0.0939344200765432*std::sin(0.14408004283905*x_6 - 7.45831966400146) + 0.0105127408268284*std::sin(0.341279834508896*x_6 - 1.14199984073639) - 0.000203008888699835*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.000149586526501422*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 6.83147612497574e-6*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.000936888615191295*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.0115617978081551*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.000933478235471651*std::sin(0.367039829492569*x_7 + 2.01095986366272) + 0.0031811169992438*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 2.64147953948617e-5*std::sin(1.01663982868195*x_71 + 8.21144008636475) + 0.0014544672640397*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.000435710307457618*std::sin(0.221199989318848*x_8 + 2.01559972763062) + 0.00132746369766273*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 0.000427187987409286*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.00160992419589877*std::sin(0.305919945240021*x_9 - 1.20959985256195) - 0.000744853192548277*std::sin(0.344239860773087*x_91 - 7.38695955276489) + 0.0196495163854516*std::sin(0.354159861803055*x_91 - 7.39296007156372) - 0.016825132392164*std::sin(0.15776002407074*x_92 + 8.38064002990723) - 0.0023083182910013*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.0189311447833597*std::sin(0.279439955949783*x_94 - 1.18527984619141) - 0.0179067043976488*std::sin(0.222959995269775*x_95 - 4.21456003189087) - 0.0188938465133143*std::sin(0.283439934253693*x_95 - 7.42248010635376) + 0.00219940491369638*std::sin(0.29079994559288*x_95 - 1.20351994037628) - 0.000675855318615486*std::sin(0.305119931697845*x_96 - 1.22831988334656) - 0.000594072826425188*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 0.0185305381927071*std::sin(0.268399953842163*x_97 + 5.17671966552734) - 0.281170586106968);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00339079377207687*x_1 - 0.00203167789789279*x_10 + 0.00252165997540124*x_100 - 0.00289791484831532*x_101 + 0.00188453408095528*x_102 + 0.00847214244056052*x_103 - 0.0100470113130184*x_104 - 0.00540556497736796*x_105 - 0.0170126349042327*x_106 - 0.00119475686963481*x_107 + 0.00351814718187492*x_108 - 0.00313904252874539*x_109 + 0.0247400493055409*x_11 + 0.00537766005047709*x_110 - 0.0172942392708865*x_111 - 0.0167187759714393*x_112 - 0.0208986497756027*x_113 - 0.0130041036472125*x_114 + 0.00741754020646103*x_115 - 1.50718146612901e-5*x_116 - 0.0139669082720958*x_117 - 0.0231968386839641*x_118 - 0.00618249588070571*x_119 - 0.000969212447005285*x_12 - 0.0434039467377005*x_120 - 0.000465200058557847*x_13 - 0.000200767488558881*x_14 - 0.00028796070082399*x_15 + 6.74490630991227e-5*x_16 - 0.00880578115525936*x_17 - 0.00376227353986282*x_18 + 0.000103222844043314*x_19 - 0.000576761582546959*x_2 - 0.00769680106529622*x_20 - 0.00103031408899241*x_21 + 0.00094453599677502*x_22 + 9.19391935869892e-5*x_23 - 0.0018048470806243*x_24 - 0.00233899546925104*x_26 + 0.00161927214710934*x_27 - 0.00113845011391596*x_28 + 0.0015437514755729*x_29 + 0.00925794139960225*x_3 + 0.000988354869836693*x_30 - 8.34565835233281e-5*x_32 - 0.00540466413342058*x_33 - 0.00462108444333113*x_34 + 0.00942536504045349*x_35 + 0.00110794965674719*x_36 - 0.0087017374111437*x_37 + 0.00293900080076995*x_38 - 0.00410605756617777*x_39 - 0.00496029838111061*x_4 + 0.00372829170480235*x_40 + 0.000534003486900594*x_41 - 0.00415803962497673*x_42 - 0.00141544350903138*x_43 - 0.00666821811830017*x_44 - 0.00942169040906977*x_45 - 0.0041043158266117*x_46 + 0.00436839612648757*x_47 + 0.0195243099577497*x_48 + 0.00419454764993098*x_49 - 0.000338138536706389*x_5 - 0.0007211111920978*x_50 - 0.00330682502677062*x_51 + 0.00841060015781868*x_52 + 0.00176736498785298*x_53 + 0.004359172420364*x_54 + 0.0291623807699529*x_55 - 0.00808235280134941*x_56 + 0.00487461310858234*x_57 + 6.60636759276462e-5*x_58 - 0.00056787139380764*x_59 - 0.000371010215375733*x_6 + 0.00594655536606179*x_60 - 0.00165473325478895*x_61 - 0.00183720171228774*x_62 - 0.000722526062932954*x_63 + 0.00307802104396157*x_64 + 0.00324335246546727*x_65 + 0.00820599230675159*x_66 - 0.00428362726954031*x_67 + 0.00107742157363414*x_68 + 0.005200883100975*x_69 - 0.00213652640928342*x_7 + 0.00632561311800037*x_70 + 0.000540333116299606*x_71 + 0.000716732191591573*x_72 + 0.00135071479618585*x_73 + 0.00697337443313639*x_74 + 0.0112436725129259*x_75 - 0.00024955750598832*x_76 + 0.00255740611437569*x_77 - 0.000897022330592049*x_78 + 0.0054455017556998*x_79 - 0.00113666756362376*x_8 + 0.0135808722047197*x_80 - 0.000899158283830062*x_81 - 0.00934428916682392*x_82 - 0.00780187483069924*x_83 - 0.00151311913776322*x_84 + 0.00228550322376147*x_85 - 0.00134755060533029*x_86 + 0.000294491183787575*x_87 - 0.00858779070020589*x_88 - 0.00348556785880722*x_89 - 0.00380230118662817*x_9 - 0.00260998945166745*x_90 + 0.0116751153635072*x_91 - 0.00622965543910183*x_92 - 0.00781127722767821*x_93 + 0.00848766881393859*x_94 - 0.00600981550246107*x_95 + 0.00402441511951013*x_96 - 0.00610455594556709*x_97 - 0.00177055954240611*x_98 + 0.00788728410072701*x_99 - 8.86395545935555e-6*std::pow(-4.7184796333313*x_25 - 7.79176044464111, 2) + 1.33063200967401e-5*std::pow(-2.64039993286133*x_49 - 8.54191970825195, 2) + 0.0203939444042752*std::exp(0.241199851036072*x_59) - 0.00030726353427769*std::exp(0.262799859046936*x_59) + 0.0741465626965826*std::sin(0.322319835424423*x_1 - 4.26448011398315) + 0.00351669267644216*std::sin(0.332799851894379*x_1 - 4.25767993927002) - 0.299717381414692*std::sin(0.351919859647751*x_1 - 4.22192001342773) - 0.00217326632184236*std::sin(0.177440017461777*x_10 - 7.61080026626587) + 0.000872280220031543*std::sin(0.613919854164124*x_10 + 4.98239946365356) - 0.00609364119342147*std::sin(0.248239979147911*x_100 - 4.40064001083374) - 0.050353944208526*std::sin(0.209440007805824*x_101 + 2.00071978569031) - 0.0117639331612279*std::sin(0.205119997262955*x_102 - 7.41111993789673) - 0.00189787175643088*std::sin(0.180640012025833*x_107 - 7.3918399810791) - 0.00101097490922622*std::sin(0.241119980812073*x_108 + 4.99031972885132) - 0.00949543264009859*std::sin(0.278079956769943*x_108 - 4.41975975036621) - 0.0205540104766643*std::sin(0.314319938421249*x_11 + 5.12199974060059) + 0.00142351201102786*std::sin(0.320399910211563*x_11 - 4.29864025115967) + 0.00158383564033388*std::sin(0.190880000591278*x_110 + 8.41744041442871) - 0.137776332591063*std::sin(0.245119974017143*x_116 - 7.42927980422974) - 0.0345926323363719*std::sin(0.250159978866577*x_116 + 5.1715202331543) - 0.0107266373144201*std::sin(0.178880020976067*x_117 - 0.982079803943634) - 0.0636421022523665*std::sin(0.222479999065399*x_119 - 4.20864009857178) + 0.0275587492945165*std::sin(0.293759942054749*x_12 + 1.95231974124908) - 0.0179477072941309*std::sin(0.267119973897934*x_120 + 5.15655994415283) - 0.0638607253736841*std::sin(0.188800007104874*x_13 - 1.17847990989685) + 0.0282567554855656*std::sin(0.329119831323624*x_14 - 4.3219199180603) + 0.000877064744290239*std::sin(0.342479854822159*x_14 + 1.85703992843628) + 0.01545314685965*std::sin(0.401919841766357*x_14 - 1.40335988998413) - 0.226162277333279*std::sin(0.280479967594147*x_15 + 1.99391984939575) - 0.00730924257223356*std::sin(0.336879849433899*x_15 - 1.09447979927063) + 0.000820560243906418*std::sin(0.479599863290787*x_15 + 8.09632015228271) - 0.00979671681088161*std::sin(0.35319983959198*x_17 + 2.01239991188049) + 0.0332290857188914*std::sin(0.370559841394424*x_17 - 1.17351984977722) - 0.0014915470864372*std::sin(0.366479843854904*x_2 - 4.19960021972656) + 0.206137114862533*std::sin(0.377039849758148*x_2 - 7.3931999206543) + 0.0127291536767482*std::sin(0.428799867630005*x_2 - 7.37967967987061) + 0.00134654664413802*std::sin(0.446319848299026*x_20 + 1.76775991916656) + 0.063938736093135*std::sin(0.299359947443008*x_21 + 8.36335945129395) - 0.0512582109093149*std::sin(0.399359852075577*x_22 + 1.99407982826233) - 0.0537345004610394*std::sin(0.376879841089249*x_23 + 2.00415992736816) - 0.00222103011168603*std::sin(0.494639873504639*x_23 + 8.32231998443604) + 0.00695105061981985*std::sin(0.120720058679581*x_24 + 7.95175981521606) + 0.011807660455671*std::sin(0.0878400802612305*x_25 - 7.56063985824585) + 0.00436979247784952*std::sin(0.307679921388626*x_25 - 1.16671991348267) - 0.123792125841911*std::sin(0.323279827833176*x_25 - 1.15535986423492) - 0.0111424500003226*std::sin(0.277439951896667*x_26 - 7.40551996231079) - 0.000481379614995453*std::sin(0.598719835281372*x_26 - 4.38567972183228) - 0.000675222414753877*std::sin(0.559359848499298*x_28 + 4.81023979187012) - 0.0257350736229425*std::sin(0.576079845428467*x_28 + 1.81583988666534) + 0.0222016620857781*std::sin(0.201120004057884*x_29 + 8.21127986907959) + 0.000854553691606525*std::sin(0.663759827613831*x_29 + 7.96551990509033) + 0.0196409507924578*std::sin(0.360399842262268*x_3 + 5.18527984619141) + 0.000587799111989001*std::sin(0.532079875469208*x_3 + 1.79583990573883) - 0.0805641159774605*std::sin(0.335119843482971*x_30 + 2.01479983329773) - 0.391282055482519*std::sin(0.349039852619171*x_30 - 1.13991987705231) - 0.00722895156002171*std::sin(0.377999842166901*x_30 + 2.00567984580994) - 0.0422931332454158*std::sin(0.358559846878052*x_31 + 5.17304039001465) - 0.0642533983476505*std::sin(0.361119836568832*x_31 + 5.16720008850098) + 0.058204294312765*std::sin(0.421839863061905*x_31 - 7.38175964355469) - 0.000349389085317707*std::sin(0.46375983953476*x_31 + 5.03119993209839) - 0.00287430252887822*std::sin(0.270479947328568*x_32 - 4.34687995910645) + 0.27858682479619*std::sin(0.302479922771454*x_32 - 1.16159987449646) - 0.0633927578838018*std::sin(0.30447992682457*x_32 + 2.02991986274719) - 0.00535011755806556*std::sin(0.235039994120598*x_36 + 5.17000007629395) + 0.00175769278062364*std::sin(0.230319991707802*x_38 + 1.96823978424072) + 0.0381161035180154*std::sin(0.0996000692248344*x_4 - 7.55311965942383) + 0.000508411262693074*std::sin(0.244959965348244*x_44 - 4.23079967498779) - 0.000748014927958815*std::sin(0.316959917545319*x_49 + 5.04191970825195) - 0.00536766991410172*std::sin(0.447439849376678*x_49 - 4.49327993392944) + 0.011676139473433*std::sin(0.198320001363754*x_5 + 1.98175978660583) + 0.0040311709856525*std::sin(0.321759849786758*x_5 - 1.14847981929779) - 0.0494923959514901*std::sin(0.394159853458405*x_5 - 7.39783954620361) + 0.0221705169913507*std::sin(0.250799983739853*x_50 - 7.64688014984131) + 0.10841089737012*std::sin(0.240319982171059*x_53 - 7.40279960632324) - 0.000517008351373638*std::sin(0.245839968323708*x_53 - 7.60552024841309) - 0.0187804515915145*std::sin(0.105680070817471*x_54 + 1.75039982795715) + 0.00310081597051358*std::sin(0.446799844503403*x_59 + 1.90111982822418) - 0.0440520678852909*std::sin(0.14408004283905*x_6 - 7.45831966400146) - 0.0284322745968593*std::sin(0.446719855070114*x_6 + 5.15248012542725) + 0.000822982599523006*std::sin(0.576079845428467*x_60 + 8.0152006149292) - 3.7584842107143e-5*std::sin(1.24703979492188*x_67 + 2.59119987487793) - 0.0051544951676267*std::sin(0.344559848308563*x_7 + 2.00287985801697) - 0.130737672084716*std::sin(0.367039829492569*x_7 + 2.01095986366272) - 0.00153280675973204*std::sin(0.393759846687317*x_7 + 1.80199980735779) + 0.00369950656297136*std::sin(1.01663982868195*x_71 + 8.21144008636475) - 0.0610231167002444*std::sin(0.221199989318848*x_8 + 2.01559972763062) - 0.000205838589065707*std::sin(1.24679982662201*x_88 + 8.19960021972656) - 0.00409797079324898*std::sin(0.344239860773087*x_91 - 7.38695955276489) - 0.00921495900032924*std::sin(0.354159861803055*x_91 - 7.39296007156372) + 0.00810711352968972*std::sin(0.15776002407074*x_92 + 8.38064002990723) + 0.00887806700103407*std::sin(0.279439955949783*x_94 - 1.18527984619141) + 0.00862826408200771*std::sin(0.222959995269775*x_95 - 4.21456003189087) + 0.00886057537312277*std::sin(0.283439934253693*x_95 - 7.42248010635376) - 0.00869019605114857*std::sin(0.268399953842163*x_97 + 5.17671966552734) + 0.489935010671616*std::sin(-0.00661625366546157*x_100 - 0.00229103682537515*x_101 - 0.00220767032293196*x_102 - 0.00116979562234044*x_103 - 0.00804020373049285*x_104 - 0.00127296331418255*x_105 - 0.00108424530404539*x_106 - 0.0133217519122821*x_107 - 0.00355494769403278*x_108 + 0.00165984436291326*x_109 + 0.0112593286990122*x_110 - 0.0133802007033723*x_111 - 0.0555463401920089*x_112 - 0.0225418380749687*x_114 - 0.012866534433696*x_115 - 0.0218784317632861*x_116 - 0.0376850413168881*x_117 - 0.0026063556912623*x_118 - 0.0464826869318956*x_119 - 0.00396989026469409*x_16 - 0.0143681695897123*x_17 + 0.000870346353031284*x_2 + 0.0151884364053838*x_21 + 0.00676391017209466*x_22 + 0.0186947984082658*x_25 + 0.00614164937999783*x_26 + 0.00907093462388256*x_28 + 0.0110941758442262*x_29 + 0.00400661297217796*x_31 - 0.0171274438113882*x_32 + 0.000110828751032685*x_33 + 0.00928818797603139*x_34 - 0.0131617345339363*x_35 + 0.00362967766998524*x_36 + 0.00283332869022652*x_37 + 0.00625244775303196*x_38 + 0.00151213696498186*x_39 + 0.00310374587236011*x_4 - 0.00641263880664408*x_40 + 0.00752352368070784*x_42 + 0.00454037932813329*x_43 - 0.000946135147705983*x_44 + 0.00318886373166238*x_45 + 0.000703518337326909*x_46 - 0.015563881344799*x_47 - 0.000840870457671241*x_48 - 0.00495842552480888*x_49 + 0.0101724316338657*x_50 + 0.00358279822227359*x_51 - 0.000822802521191029*x_52 - 0.0157207381727002*x_54 - 0.00710853252920307*x_55 - 0.0148117297318326*x_57 + 0.00566267161768674*x_58 + 0.000531486958112403*x_59 + 0.00750402615915456*x_60 - 3.32242877198118e-5*x_61 - 0.0075221372082133*x_62 + 0.00180503979919384*x_63 + 0.00684689380377586*x_64 + 0.00158776698164857*x_65 + 0.00359900446305683*x_66 + 0.0197628072839367*x_67 + 0.00342169011772984*x_68 - 0.00393396051292463*x_69 - 0.00193847943178584*x_70 - 0.00789712279234481*x_71 + 0.00646842593683928*x_72 + 0.00787778841226255*x_73 + 0.00488426243860993*x_74 + 0.00484572395865586*x_76 + 0.00600342581674634*x_77 + 0.004512206285457*x_78 - 0.000308863433774252*x_79 + 0.00555999975058045*x_80 - 0.00411331599929795*x_81 - 0.00880560819265524*x_82 - 0.00502321605160592*x_83 - 0.00183957050961861*x_84 + 0.00417633679229817*x_85 - 0.00110568086629902*x_86 + 0.00547071033701648*x_87 + 0.00188057735293578*x_88 + 0.00700823782750186*x_89 - 0.00201799088102923*x_90 - 0.00608890197910589*x_91 - 0.00154091124554097*x_93 + 0.00284922889428143*x_94 + 0.0045420425346665*x_98 + 0.0157927531717859*x_99 + 0.00056261202916609*std::pow(-2.25751972198486*x_13 - 5.53679990768433, 2) + 0.000210834292596954*std::pow(-2.65167999267578*x_23 - 5.70391988754272, 2) + 0.0436482621343437*std::sin(0.308639913797379*x_1 + 8.31319999694824) - 0.127059163996766*std::sin(0.278079956769943*x_10 + 1.9722398519516) + 0.127614398771971*std::sin(0.309439927339554*x_11 - 7.45864009857178) + 0.1818096391548*std::sin(0.286959946155548*x_113 + 1.97287976741791) - 0.199016852125311*std::sin(0.301919937133789*x_12 + 8.31360054016113) + 0.466906199740151*std::sin(0.261279970407486*x_120 - 4.24855995178223) + 0.0656501658269981*std::sin(0.449519842863083*x_14 - 7.47095966339111) - 0.066855505168677*std::sin(0.357919842004776*x_15 - 4.34151983261108) - 0.121541981380737*std::sin(0.445119857788086*x_18 + 5.17095994949341) + 0.0274126824929377*std::sin(0.497599840164185*x_19 + 1.90071988105774) - 0.0831168180219954*std::sin(0.268879950046539*x_20 + 1.9923198223114) - 0.0845834734634821*std::sin(0.243999972939491*x_24 + 8.21592044830322) + 0.0367128299426289*std::sin(0.356959849596024*x_27 + 5.00256013870239) - 0.631070748409357*std::sin(0.354879856109619*x_3 - 7.40855979919434) + 0.475802088265525*std::sin(0.327359855175018*x_30 - 1.15199983119965) - 0.0373711602280125*std::sin(0.255919963121414*x_41 - 7.42320013046265) + 0.0576394066983976*std::sin(0.182640001177788*x_5 - 0.996399819850922) - 0.430953636935385*std::sin(0.254719972610474*x_53 - 7.42695951461792) - 0.165335738890029*std::sin(0.178720012307167*x_56 + 4.99911975860596) - 0.645966391723505*std::sin(0.341279834508896*x_6 - 1.14199984073639) + 0.710426798776496*std::sin(0.357919842004776*x_7 + 1.9981597661972) - 0.0893712672944424*std::sin(0.141760036349297*x_75 + 2.03975987434387) - 0.0815673998863176*std::sin(0.240479975938797*x_8 + 1.98351979255676) + 0.0989234816023554*std::sin(0.305919945240021*x_9 - 1.20959985256195) + 0.14183703964072*std::sin(0.299599945545197*x_92 + 1.99519979953766) - 0.135144742883195*std::sin(0.29079994559288*x_95 - 1.20351994037628) + 0.0415286392658931*std::sin(0.305119931697845*x_96 - 1.22831988334656) + 0.0365034282142229*std::sin(0.243519976735115*x_97 - 1.02255988121033) + 6.7182591148642) + 0.270538997731423);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
