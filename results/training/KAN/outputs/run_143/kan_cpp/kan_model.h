
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-12.5235099339338*x_1 + 57231004231.9816*x_10 + 4152597673.67866*x_100 - 1541108429.75809*x_101 + 562827336.865385*x_102 + 1964910232.40415*x_103 + 87670919625.8571*x_104 + 310449924.752413*x_105 - 3184356510.51389*x_106 - 7557962942.0239*x_107 - 378899461.678981*x_108 + 3108997292.02477*x_109 - 4655148578.92798*x_11 + 3983191500.32237*x_110 - 255951711.391296*x_111 - 1554444838.7608*x_112 - 481951270.597066*x_113 + 3226344941.221*x_114 + 4405035853.29456*x_115 - 375146438.685095*x_116 - 737865779.599213*x_117 - 3894737773.89187*x_118 + 4862464180.52708*x_119 - 3458421086.19471*x_12 - 1688996699.55662*x_120 - 5882365013.07928*x_13 - 2619187973.34369*x_14 - 2966344758.84951*x_15 + 11284490.7492005*x_16 + 7952813559.30107*x_17 - 59907554950.2163*x_18 + 4050167456.24189*x_19 - 1403242029.10805*x_2 + 32530345196.3919*x_20 - 3744263796.43014*x_21 + 35966571150.8928*x_22 + 70541544305.6881*x_23 + 122298744634.929*x_24 + 1515446592.60139*x_25 - 27870022404.1358*x_26 + 3467712261.14875*x_27 + 252762479043.057*x_28 + 26553818421.2078*x_29 + 7315401097.56891*x_3 + 3217609552.41584*x_30 + 2091484789.83116*x_31 + 2830947982.53952*x_32 + 7932706744.63182*x_33 - 316670224354.065*x_34 - 999534152.936172*x_35 + 21803028505.6004*x_36 + 92891442487.1447*x_37 + 6392405739.52029*x_38 - 56443051293.7235*x_39 - 22938545847.8265*x_4 + 22663408569.6535*x_40 + 1829743474887.86*x_41 + 87439342735.7442*x_42 + 4823553116.82687*x_43 - 3241671426.98306*x_44 + 446672444399.613*x_45 + 264262850117.69*x_46 - 355270509051.746*x_47 - 1390409846.98791*x_48 - 399018282699.58*x_49 + 0.57129003731275*x_5 + 44059017550.0614*x_50 + 19812633111.2126*x_51 - 19901674890.9911*x_52 + 73545660438.1519*x_53 + 11945561921.9297*x_54 - 35643155908.2771*x_55 - 49009547409.8474*x_56 + 30078422335.2732*x_57 + 213969370996.611*x_58 + 52079886110.7877*x_59 - 3267356608.50294*x_6 - 421918165.148059*x_60 - 1393430320.82244*x_61 + 8920701808.23477*x_62 - 71745777.1484447*x_63 - 2162925035.0828*x_64 + 2389140527.7229*x_65 + 3484842268.85428*x_66 + 167234951.164309*x_67 - 1911128972.36731*x_68 + 1597257949.19903*x_69 + 473056141.124226*x_7 - 2373456136.5832*x_70 + 4943274710.67026*x_71 - 1707325494.66434*x_72 - 3814339567.06582*x_73 - 3018162715.33351*x_74 + 1318016919.87439*x_75 + 4908102399.12135*x_76 - 3105714057.2135*x_77 + 2224947540.50998*x_78 + 279460759.958139*x_79 + 2012901222.05366*x_8 - 4058514695.60117*x_80 - 133737800.288751*x_81 + 486415075.696919*x_82 - 9077380564.79347*x_83 + 10156819863.4695*x_84 - 155330834037.372*x_85 - 22078776144.6559*x_86 - 146228579257.336*x_87 + 2170874517.27831*x_88 + 4733662595.03005*x_89 + 6559814670.19032*x_9 - 1753416083.92836*x_90 + 3037965255.91297*x_91 + 2053912247.42547*x_92 - 0.37854855722083*x_93 - 403884221.109806*x_94 - 2.47458348843998*x_95 + 2637001650.8577*x_96 + 1684254145.24025*x_97 - 3193206785.1987*x_98 + 4048375760.18787*x_99 - 1844211576.86967*std::exp(1.23943984508514*x_1) - 0.000377686651241583*std::exp(1.89615988731384*x_1) + 0.00024313608439966*std::exp(1.04759979248047*x_13) - 0.0383296648016654*std::exp(0.979599833488464*x_23) - 0.13663679040322*std::exp(0.99103981256485*x_23) - 0.000502495599064041*std::exp(0.677759826183319*x_24) - 0.0565048988620517*std::exp(0.865199863910675*x_24) - 0.0422466924329092*std::exp(0.602639853954315*x_3) + 226499510.890261*std::exp(1.07583975791931*x_5) - 0.000114509116810999*std::exp(1.08143985271454*x_5) + 0.00907071197238572*std::exp(1.26119983196259*x_5) - 0.000108705466931722*std::exp(1.49183988571167*x_6) - 1.57924444634682e-5*std::exp(1.57999980449677*x_6) + 0.0225168009388061*std::exp(1.61871981620789*x_6) + 4.34911080869252e-5*std::exp(1.62087976932526*x_6) + 0.00075862681543137*std::exp(1.64087975025177*x_6) + 0.000144551802488198*std::exp(1.64399981498718*x_6) + 0.00261900197982587*std::exp(0.98527979850769*x_8) - 5.46533001214341*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.00632815995373084*std::sin(0.291439920663834*x_120 + 1.93135988712311) + 6.27129651648346*std::sin(0.471919864416122*x_16 - 4.2958402633667) - 7.49467838257402*std::sin(0.429439842700958*x_5 + 5.17456007003784) + 4.27746984686953*std::sin(0.241599977016449*x_8 - 1.17303991317749) + 0.266606316215073*std::sin(0.456479847431183*x_8 + 5.12495994567871) - 0.0849923811958475*std::sin(0.464399844408035*x_9 + 1.9022399187088) + 0.272227454929777*std::sin(0.338399857282639*x_91 + 2.00351977348328) - 2.38484969483376*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.104274671761943*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.0120453727305049*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0746460739517812*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 0.721389959646268*std::sin(0.2882399559021*x_94 - 7.43400001525879) - 4.45026209676575*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 19893634285.2302*std::sin(0.273119956254959*x_95 + 1.97671973705292) - 3.70008104477482*std::sin(0.301679939031601*x_97 - 1.2176798582077) - 17.0878194526847*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 4743249617751.66 - 1032195.42886883*std::exp(-6.41904020309448*x_93) + 2.41740135604808e-5*std::exp(-6.28024005889893*x_93) + 7.50564812399328e-5*std::exp(-5.94159984588623*x_93) - 6.85922559132864e-6*std::exp(-8.01832008361816*x_113) - 2.53082134970922e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (45.7119988686771*x_1 + 549764999094.823*x_10 + 39890141533.7786*x_100 - 14803994537.6975*x_101 + 5406558477.82699*x_102 + 18875064123.4443*x_103 + 842172939962.743*x_104 + 2982203542.18*x_105 - 30589149726.8337*x_106 - 72602316758.1624*x_107 - 3639734534.46098*x_108 + 29865243788.2192*x_109 - 44717680522.0014*x_11 + 38262814102.9768*x_110 - 2458689899.53212*x_111 - 14932105009.6974*x_112 - 4629657385.98487*x_113 + 30992493459.1025*x_114 + 42315080211.97*x_115 - 3603682749.74758*x_116 - 7087989970.60823*x_117 - 37413121469.9878*x_118 + 46709168483.5421*x_119 - 33221833153.2137*x_12 - 16224619540.0911*x_120 - 56506406695.7186*x_13 - 25160101698.7651*x_14 - 28494913619.8984*x_15 + 108399605.603524*x_16 + 76395279130.4471*x_17 - 575476131724.577*x_18 + 38906189596.6373*x_19 - 13479640369.5584*x_2 + 312488754256.747*x_20 - 35967658089.5077*x_21 + 345497379119.041*x_22 + 677626973145.624*x_23 + 1174810231738.72*x_24 + 14557485174.9839*x_25 - 267721370114.648*x_26 + 33311084124.5966*x_27 + 2428053921046.46*x_28 + 255077821909.109*x_29 + 70272250777.8354*x_3 + 30908580872.3573*x_30 + 20090948063.539*x_31 + 27194282914.9713*x_32 + 76202131704.3797*x_33 - 3041956159462.24*x_34 - 9601594487.24484*x_35 + 209441405170.765*x_36 + 892321644870.548*x_37 + 61405893286.5997*x_38 - 542195869783.667*x_39 - 220349264121.016*x_4 + 217706276183.0*x_40 + 17576642861686.8*x_41 + 839948392810.977*x_42 + 46335385757.5769*x_43 - 31139720782.3238*x_44 + 4290766511031.7*x_45 + 2538527284139.63*x_46 - 3412753174313.54*x_47 - 13356373563.4788*x_48 - 3832997324854.03*x_49 - 0.216320086841529*x_5 + 423233980464.023*x_50 + 190321529179.188*x_51 - 191176871012.241*x_52 + 706484719858.848*x_53 + 114749896705.741*x_54 - 342390629867.357*x_55 - 470789116012.725*x_56 + 288935413195.623*x_57 + 2055404632305.79*x_58 + 500283000233.796*x_59 - 31386454426.3921*x_6 - 4052975217.22959*x_60 - 13385388402.3728*x_61 + 85692880782.0085*x_62 - 689194932.313371*x_63 - 20777208048.8738*x_64 + 22950249772.8024*x_65 + 33475636638.0752*x_66 + 1606470528.18445*x_67 - 18358437593.2129*x_68 + 15343370736.7395*x_69 + 4544210150.75718*x_7 - 22799584428.5929*x_70 + 47485440011.9501*x_71 - 16400687250.8132*x_72 - 36640810713.2108*x_73 - 28992680537.114*x_74 + 12660962042.4806*x_75 + 47147572356.5865*x_76 - 29833704869.2412*x_77 + 21373000611.6521*x_78 + 2684519451.94397*x_79 + 19336068876.4454*x_8 - 38986373956.8727*x_80 - 1284694613.14117*x_81 + 4672536964.09921*x_82 - 87197947919.8118*x_83 + 97567116802.7113*x_84 - 1492118775316.12*x_85 - 212090256368.962*x_86 - 1404681884822.86*x_87 + 20853571299.6631*x_88 + 45471891547.3628*x_89 + 63014035151.044*x_9 - 16843436669.8982*x_90 + 29182905164.9295*x_91 + 19730023623.5356*x_92 + 0.268027404812813*x_93 - 3879739842.47351*x_94 + 9.3722651017156*x_95 + 25331220908.9459*x_96 + 16179062277.2977*x_97 - 30674166060.1771*x_98 + 38888978619.8441*x_99 - 17715624439.903*std::exp(1.23943984508514*x_1) - 0.000431937126269203*std::exp(1.89615988731384*x_1) + 0.000278059871172839*std::exp(1.04759979248047*x_13) - 0.011756569324415*std::exp(0.979599833488464*x_23) - 0.0432421931454307*std::exp(0.99103981256485*x_23) - 0.000372080714751308*std::exp(0.677759826183319*x_24) + 0.0153197313721274*std::exp(0.865199863910675*x_24) - 0.0472764645955673*std::exp(0.602639853954315*x_3) + 2175770026.10756*std::exp(1.07583975791931*x_5) - 8.47900640481974e-5*std::exp(1.08143985271454*x_5) - 0.0024592712060266*std::exp(1.26119983196259*x_5) - 7.19636934951118e-5*std::exp(1.49183988571167*x_6) - 1.16937621634547e-5*std::exp(1.57999980449677*x_6) - 0.081288690631471*std::exp(1.61871981620789*x_6) + 4.86690368709635e-5*std::exp(1.62087976932526*x_6) - 0.00045132903337207*std::exp(1.64087975025177*x_6) + 0.00016531505669722*std::exp(1.64399981498718*x_6) + 0.00293081297598833*std::exp(0.98527979850769*x_8) + 1.48177218846937*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.00468578487658494*std::sin(0.291439920663834*x_120 + 1.93135988712311) - 22.6402269031063*std::sin(0.471919864416122*x_16 - 4.2958402633667) + 27.0568005676803*std::sin(0.429439842700958*x_5 + 5.17456007003784) - 1.15971695067355*std::sin(0.241599977016449*x_8 - 1.17303991317749) - 0.158611808257551*std::sin(0.456479847431183*x_8 + 5.12495994567871) - 0.0972005888156979*std::sin(0.464399844408035*x_9 + 1.9022399187088) + 0.304638088659068*std::sin(0.338399857282639*x_91 + 2.00351977348328) + 0.646585648740802*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.0330003762764035*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.00891918437367446*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0228956279098844*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 0.228302230139792*std::sin(0.2882399559021*x_94 - 7.43400001525879) + 1.20656476218912*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 191099632039.031*std::sin(0.273119956254959*x_95 + 1.97671973705292) + 1.00317403981975*std::sin(0.301679939031601*x_97 - 1.2176798582077) + 61.6893346808337*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 45564641403038.0 - 9915340.94882059*std::exp(-6.41904020309448*x_93) + 2.76463409902933e-5*std::exp(-6.28024005889893*x_93) + 2.30215090455365e-5*std::exp(-5.94159984588623*x_93) - 7.84447684505423e-6*std::exp(-8.01832008361816*x_113) - 1.87398619701675e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-64.3297420159445*x_1 - 382876332963.208*x_10 - 27780944838.5776*x_100 + 10310040018.3554*x_101 - 3765323889.72455*x_102 - 13145280896.2502*x_103 - 586519854033.719*x_104 - 2076914972.79237*x_105 + 21303395995.867*x_106 + 50562892982.5049*x_107 + 2534843459.26649*x_108 - 20799241571.9927*x_109 + 31143018527.1233*x_11 - 26647614859.0879*x_110 + 1712321034.8893*x_111 + 10399260807.8614*x_112 + 3224261728.45256*x_113 - 21584299226.8229*x_114 - 29469760296.6862*x_115 + 2509735683.56648*x_116 + 4936333924.25309*x_117 + 26055858015.7005*x_118 - 32529963125.5477*x_119 + 23136892459.9347*x_12 + 11299414922.6283*x_120 + 39353116012.1318*x_13 + 17522409589.6888*x_14 + 19844893812.347*x_15 - 75493425.9211083*x_16 - 53204449868.2985*x_17 + 400782500608.024*x_18 - 27095684927.7292*x_19 + 9387711632.26904*x_2 - 217628529540.358*x_20 + 25049184777.2705*x_21 - 240616935975.375*x_22 - 471924060687.701*x_23 - 818180557776.242*x_24 - 10138361937.5969*x_25 + 186450895648.457*x_26 - 23199049992.6556*x_27 - 1690985026762.18*x_28 - 177645468761.081*x_29 - 48940150309.4528*x_3 - 21525859485.4074*x_30 - 13992066670.3076*x_31 - 18939087327.1911*x_32 - 53069934985.612*x_33 + 2118528865237.02*x_34 + 6686899487.5516*x_35 - 145862609151.916*x_36 - 621445235406.864*x_37 - 42765296603.8821*x_38 + 377604916289.999*x_39 + 153459238759.468*x_4 - 151618565851.632*x_40 - 12241013121231.4*x_41 - 584970598088.881*x_42 - 32269647174.9943*x_43 + 21686833697.1974*x_44 - 2988245796793.4*x_45 - 1767922693282.15*x_46 + 2376765387311.59*x_47 + 9301864151.73646*x_48 + 2669438692384.65*x_49 - 0.343202314113147*x_5 - 294755531347.121*x_50 - 132546832410.57*x_51 + 133142523618.897*x_52 - 492021644429.437*x_53 - 79915999931.6921*x_54 + 238453282846.266*x_55 + 327874656949.131*x_56 - 201225126535.177*x_57 - 1431458513896.02*x_58 - 348415269944.413*x_59 + 21858667972.5096*x_6 + 2822639294.29751*x_60 + 9322071134.18503*x_61 - 59679637681.2129*x_62 + 479980409.268836*x_63 + 14470003078.3184*x_64 - 15983388339.2858*x_65 - 23313650401.0131*x_66 - 1118804478.25129*x_67 + 12785483395.2711*x_68 - 10685681215.7692*x_69 - 3164753166.82397*x_7 + 15878459516.1156*x_70 - 33070586836.4763*x_71 + 11422034881.204*x_72 + 25517992731.9989*x_73 + 20191556796.7752*x_74 - 8817554280.02669*x_75 - 32835283516.874*x_76 + 20777276732.956*x_77 - 14884934691.4614*x_78 - 1869596945.1052*x_79 - 13466341362.2959*x_8 + 27151528247.7386*x_80 + 894708038.049266*x_81 - 3254124616.51748*x_82 + 60727821169.3849*x_83 - 67949287377.0555*x_84 + 1039165763752.58*x_85 + 147707365447.073*x_86 + 978271534415.821*x_87 - 14523185218.0311*x_88 - 31668278488.1742*x_89 - 43885265071.3091*x_9 + 11730381674.2527*x_90 - 20324036155.3781*x_91 - 13740705767.782*x_92 - 0.309965240477309*x_93 + 2701991877.10839*x_94 - 11.9452729211574*x_95 - 17641583199.3297*x_96 - 11267687195.0901*x_97 + 21362604458.1254*x_98 - 27083698591.7952*x_99 + 12337804943.181*std::exp(1.23943984508514*x_1) + 0.000445981410505099*std::exp(1.89615988731384*x_1) - 0.000287100890404221*std::exp(1.04759979248047*x_13) - 0.0193823987210045*std::exp(0.979599833488464*x_23) - 0.599049966053564*std::exp(0.99103981256485*x_23) - 0.000463622365397551*std::exp(0.677759826183319*x_24) + 0.0116319006380876*std::exp(0.865199863910675*x_24) + 0.0126016284837195*std::exp(0.602639853954315*x_3) - 1515285350.19462*std::exp(1.07583975791931*x_5) - 0.000105650651855229*std::exp(1.08143985271454*x_5) - 0.00186726500718262*std::exp(1.26119983196259*x_5) - 1.30244637319329e-5*std::exp(1.49183988571167*x_6) - 1.45707354874355e-5*std::exp(1.57999980449677*x_6) + 0.107841318744232*std::exp(1.61871981620789*x_6) - 1.29728211818493e-5*std::exp(1.62087976932526*x_6) - 0.000508307953853685*std::exp(1.64087975025177*x_6) - 0.000170690217811021*std::exp(1.64399981498718*x_6) - 0.000781213582585276*std::exp(0.98527979850769*x_8) + 1.12507370043812*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.00583861130689989*std::sin(0.291439920663834*x_120 + 1.93135988712311) + 30.0355671488006*std::sin(0.471919864416122*x_16 - 4.2958402633667) - 35.8947970689627*std::sin(0.429439842700958*x_5 + 5.17456007003784) - 0.880544965891752*std::sin(0.241599977016449*x_8 - 1.17303991317749) - 0.178636067593648*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.100361031885306*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.081201842145191*std::sin(0.338399857282639*x_91 + 2.00351977348328) + 0.490936808059842*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.457166319516874*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.0111135385221555*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0377467420019845*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 3.16275455213924*std::sin(0.2882399559021*x_94 - 7.43400001525879) + 0.916115373454667*std::sin(0.295199930667877*x_94 + 1.96535980701447) + 133088731521.119*std::sin(0.273119956254959*x_95 + 1.97671973705292) + 0.761685728714697*std::sin(0.301679939031601*x_97 - 1.2176798582077) - 81.8399109735424*std::sin(0.271999955177307*x_98 + 1.96007990837097) - 31730089570973.4 + 6905403.92672454*std::exp(-6.41904020309448*x_93) - 2.85452520755798e-5*std::exp(-6.28024005889893*x_93) + 3.79542751943075e-5*std::exp(-5.94159984588623*x_93) + 8.09953725962294e-6*std::exp(-8.01832008361816*x_113) - 2.33503613312496e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (84.4124632399779*x_1 + 37068481539.3655*x_10 + 2689634639.02778*x_100 - 998174851.675285*x_101 + 364542880.004081*x_102 + 1272671013.24236*x_103 + 56784393885.1076*x_104 + 201078209.935741*x_105 - 2062505520.64413*x_106 - 4895287394.69874*x_107 - 245412918.757553*x_108 + 2013695379.50492*x_109 - 3015136578.71383*x_11 + 2579910397.28381*x_110 - 165779741.280534*x_111 - 1006812833.63616*x_112 - 312159518.583734*x_113 + 2089701371.88526*x_114 + 2853138671.63017*x_115 - 242982081.837146*x_116 - 477915195.996204*x_117 - 2522618977.34689*x_118 + 3149414688.72588*x_119 - 2240016994.84141*x_12 - 1093961991.39527*x_120 - 3810003752.04572*x_13 - 1696446337.74854*x_14 - 1921299406.90322*x_15 + 7308957.29412885*x_16 + 5151031833.50425*x_17 - 38802081968.0245*x_18 + 2623290599.43371*x_19 - 908878902.556344*x_2 + 21069882091.8244*x_20 - 2425157126.70816*x_21 + 23295523201.0602*x_22 + 45689710313.1347*x_23 + 79212812606.4975*x_24 + 981553702.555069*x_25 - 18051394310.7223*x_26 + 2246034546.8497*x_27 + 163714082732.063*x_28 + 17198889127.9197*x_29 + 4738180223.56646*x_3 + 2084043561.07481*x_30 + 1354653241.77762*x_31 + 1833603083.596*x_32 + 5138008684.8704*x_33 - 205107085729.848*x_34 - 647397592.489303*x_35 + 14121806386.1819*x_36 + 60165723044.0905*x_37 + 4140356769.51621*x_38 - 36558125634.0826*x_39 - 14857280405.7253*x_4 + 14679074132.2335*x_40 + 1185123592191.89*x_41 + 56634400350.9685*x_42 + 3124211827.89353*x_43 - 2099628357.69807*x_44 + 289309434016.904*x_45 + 171162865300.463*x_46 - 230108463321.725*x_47 - 900567514.024604*x_48 - 258443865990.783*x_49 - 0.650757027452625*x_5 + 28536995040.8976*x_50 + 12832628818.9084*x_51 - 12890301269.8564*x_52 + 47635473482.1456*x_53 + 7737131976.37927*x_54 - 23086047413.914*x_55 - 31743450584.9398*x_56 + 19481773432.89*x_57 + 138587813890.225*x_58 + 33732105874.7055*x_59 - 2116264619.79531*x_6 - 273276103.084117*x_60 - 902523859.693054*x_61 + 5777932356.38128*x_62 - 46469697.1658375*x_63 - 1400925053.12915*x_64 + 1547444670.08801*x_65 + 2257129864.23238*x_66 + 108317949.843899*x_67 - 1237836920.31248*x_68 + 1034542864.85009*x_69 + 306398150.969746*x_7 - 1537285902.29069*x_70 + 3201755595.78244*x_71 - 1105833555.31542*x_72 - 2470545131.33355*x_73 - 1954861886.0638*x_74 + 853678654.056995*x_75 + 3178974518.02431*x_76 - 2011568863.75677*x_77 + 1441097023.0888*x_78 + 181006535.199696*x_79 + 1303754727.52364*x_8 - 2628697179.99884*x_80 - 86621889.1449197*x_81 + 315050697.770671*x_82 - 5879413132.06242*x_83 + 6578565241.26474*x_84 - 100607673882.617*x_85 - 14300408031.522*x_86 - 94712150087.1545*x_87 + 1406073913.54218*x_88 + 3065990003.97001*x_89 + 4248787445.04936*x_9 - 1135686404.66408*x_90 + 1967688003.79451*x_91 + 1330317531.8887*x_92 + 0.286592669881884*x_93 - 261595517.971305*x_94 + 16.8599241684817*x_95 + 1707984138.88921*x_96 + 1090890263.33924*x_97 - 2068237829.89231*x_98 + 2622130194.3154*x_99 - 1194494564.99465*std::exp(1.23943984508514*x_1) + 0.000373723278387608*std::exp(1.89615988731384*x_1) - 0.000240584659948825*std::exp(1.04759979248047*x_13) + 0.0172290389334922*std::exp(0.979599833488464*x_23) - 0.203212390025922*std::exp(0.99103981256485*x_23) - 0.00164409739878438*std::exp(0.677759826183319*x_24) - 0.018375115997511*std::exp(0.865199863910675*x_24) - 0.0114259564913681*std::exp(0.602639853954315*x_3) + 146703576.816058*std::exp(1.07583975791931*x_5) - 0.000374658288424266*std::exp(1.08143985271454*x_5) + 0.00294975104865709*std::exp(1.26119983196259*x_5) - 5.58742291027974e-5*std::exp(1.49183988571167*x_6) - 5.16707348506068e-5*std::exp(1.57999980449677*x_6) - 0.14687208131611*std::exp(1.61871981620789*x_6) + 1.17625186765035e-5*std::exp(1.62087976932526*x_6) - 0.00103753062497307*std::exp(1.64087975025177*x_6) - 0.000143034902994685*std::exp(1.64399981498718*x_6) + 0.000708330071515531*std::exp(0.98527979850769*x_8) - 1.77729851677089*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.02070488047736*std::sin(0.291439920663834*x_120 + 1.93135988712311) - 40.9062714738923*std::sin(0.471919864416122*x_16 - 4.2958402633667) + 48.8861191176773*std::sin(0.429439842700958*x_5 + 5.17456007003784) + 1.39101221655084*std::sin(0.241599977016449*x_8 - 1.17303991317749) - 0.364622252018742*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.0841004870944304*std::sin(0.464399844408035*x_9 + 1.9022399187088) + 0.0736260965452651*std::sin(0.338399857282639*x_91 + 2.00351977348328) - 0.775541424933504*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.155081989304497*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.0394108247126907*std::sin(0.2811199426651*x_94 - 7.43088006973267) + 0.0335531270884398*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 1.07288364581614*std::sin(0.2882399559021*x_94 - 7.43400001525879) - 1.44720340880596*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 12885093190.898*std::sin(0.273119956254959*x_95 + 1.97671973705292) - 1.20324820975107*std::sin(0.301679939031601*x_97 - 1.2176798582077) + 111.460043324555*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 3071943398501.28 - 668552.266594558*std::exp(-6.41904020309448*x_93) - 2.39203359978709e-5*std::exp(-6.28024005889893*x_93) - 3.37376036076773e-5*std::exp(-5.94159984588623*x_93) + 6.78724616494808e-6*std::exp(-8.01832008361816*x_113) - 8.28050395982595e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-48.6583730998387*x_1 + 23402382513.1552*x_10 + 1698042520.69424*x_100 - 630176065.253467*x_101 + 230146240.779808*x_102 + 803473236.340661*x_103 + 35849596114.1085*x_104 + 126946359.229001*x_105 - 1302118132.51363*x_106 - 3090533539.19029*x_107 - 154936125.891378*x_108 + 1271302938.87904*x_109 - 1903541042.42907*x_11 + 1628770477.0061*x_110 - 104661451.092433*x_111 - 635629469.102997*x_112 - 197075128.453046*x_113 + 1319287672.56922*x_114 + 1801267248.51784*x_115 - 153401476.375695*x_116 - 301721353.384713*x_117 - 1592600784.30853*x_118 + 1988314682.25204*x_119 - 1414186112.2707*x_12 - 690649188.622909*x_120 - 2405363266.28618*x_13 - 1071014509.04056*x_14 - 1212970774.3445*x_15 + 4614351.4660695*x_16 + 3251992282.21794*x_17 - 24496853147.3151*x_18 + 1656157709.46206*x_19 - 573800978.852513*x_2 + 13302013254.8482*x_20 - 1531070314.01748*x_21 + 14707123578.7472*x_22 + 28845207097.5639*x_23 + 50009291567.1461*x_24 + 619682657.322737*x_25 - 11396356360.5408*x_26 + 1417985529.17904*x_27 + 103357336917.442*x_28 + 10858146558.077*x_29 + 2991347369.23827*x_3 + 1315715629.52402*x_30 + 855230966.131412*x_31 + 1157605518.16721*x_32 + 3243770376.39507*x_33 - 129489911358.364*x_34 - 408720420.130032*x_35 + 8915496402.61601*x_36 + 37984324864.3677*x_37 + 2613924489.17302*x_38 - 23080179647.3584*x_39 - 9379821735.58439*x_4 + 9267315124.77689*x_40 + 748202076511.52*x_41 + 35754902440.6538*x_42 + 1972403624.97769*x_43 - 1325554825.06989*x_44 + 182649238147.953*x_45 + 108059964124.642*x_46 - 145273989175.804*x_47 - 568553754.290547*x_48 - 163162931431.66*x_49 + 0.544768074185563*x_5 + 18016213322.1004*x_50 + 8101601932.10704*x_51 - 8138012008.6135*x_52 + 30073623348.4418*x_53 + 4884670769.86931*x_54 - 14574875541.156*x_55 - 20040538628.0535*x_56 + 12299395190.6286*x_57 + 87494411372.4197*x_58 + 21296034099.4617*x_59 - 1336057782.55582*x_6 - 172526942.107652*x_60 - 569788866.58073*x_61 + 3647772365.41055*x_62 - 29337628.4606096*x_63 - 884443655.94081*x_64 + 976945640.756585*x_65 + 1424990074.35644*x_66 + 68384202.8777026*x_67 - 781481495.85973*x_68 + 653136212.885111*x_69 + 193437812.488472*x_7 - 970532121.474326*x_70 + 2021358997.86222*x_71 - 698144025.848439*x_72 - 1559725072.32109*x_73 - 1234159690.8252*x_74 + 538951502.983693*x_75 + 2006976654.78017*x_76 - 1269960372.44924*x_77 + 909805318.321169*x_78 + 114274557.921594*x_79 + 823097283.277364*x_8 - 1659570952.93412*x_80 - 54686842.8169939*x_81 + 198900439.319051*x_82 - 3711839995.00192*x_83 + 4153234496.15731*x_84 - 63516473603.3998*x_85 - 9028252584.27651*x_86 - 59794462094.4048*x_87 + 887694292.429361*x_88 + 1935646302.17238*x_89 + 2682379817.09429*x_9 - 716990968.572677*x_90 + 1242257151.97052*x_91 + 839867143.119326*x_92 - 0.681211934770265*x_93 - 165152672.831801*x_94 - 9.59508320147975*x_95 + 1078298764.10035*x_96 + 688709896.342763*x_97 - 1305737110.4476*x_98 + 1655425034.3647*x_99 - 754118244.462035*std::exp(1.23943984508514*x_1) + 0.000107849190967174*std::exp(1.89615988731384*x_1) - 6.94280031111218e-5*std::exp(1.04759979248047*x_13) - 0.0185773672206721*std::exp(0.979599833488464*x_23) - 0.420624485309823*std::exp(0.99103981256485*x_23) - 0.000286437230708165*std::exp(0.677759826183319*x_24) - 0.0210573862327017*std::exp(0.865199863910675*x_24) + 0.0455441161086503*std::exp(0.602639853954315*x_3) + 92618122.3815971*std::exp(1.07583975791931*x_5) - 6.52735553729695e-5*std::exp(1.08143985271454*x_5) + 0.00338033496660933*std::exp(1.26119983196259*x_5) + 1.12142293700048e-5*std::exp(1.49183988571167*x_6) - 9.00215656943855e-6*std::exp(1.57999980449677*x_6) + 0.0855972725880231*std::exp(1.61871981620789*x_6) - 4.68856604466818e-5*std::exp(1.62087976932526*x_6) + 0.000927490727186153*std::exp(1.64087975025177*x_6) - 4.12770610238671e-5*std::exp(1.64399981498718*x_6) - 0.00282341938241437*std::exp(0.98527979850769*x_8) - 2.03673605780349*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.00360723679172752*std::sin(0.291439920663834*x_120 + 1.93135988712311) + 23.8402372903963*std::sin(0.471919864416122*x_16 - 4.2958402633667) - 28.4909046456565*std::sin(0.429439842700958*x_5 + 5.17456007003784) + 1.59406239951274*std::sin(0.241599977016449*x_8 - 1.17303991317749) + 0.325950626933921*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.0242697472103208*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.293475254541491*std::sin(0.338399857282639*x_91 + 2.00351977348328) - 0.888749509200197*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.32100051539036*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.00686621577223754*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.036178963071011*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 2.22073630087798*std::sin(0.2882399559021*x_94 - 7.43400001525879) - 1.65845598692479*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 8134724210.22967*std::sin(0.273119956254959*x_95 + 1.97671973705292) - 1.37888992319652*std::sin(0.301679939031601*x_97 - 1.2176798582077) - 64.9590829355145*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 1939615477628.33 - 422075.977899205*std::exp(-6.41904020309448*x_93) - 6.90293870952751e-6*std::exp(-6.28024005889893*x_93) + 3.63778765481177e-5*std::exp(-5.94159984588623*x_93) + 1.95866581001548e-6*std::exp(-8.01832008361816*x_113) - 1.44264240359132e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (212.936031043363*x_1 + 65446736470.2306*x_10 + 4748719198.15516*x_100 - 1762340501.82101*x_101 + 643623396.265437*x_102 + 2246980765.99479*x_103 + 100256420442.366*x_104 + 355016237.43039*x_105 - 3641483285.79699*x_106 - 8642937945.09184*x_107 - 433291950.49535*x_108 + 3555305892.86305*x_109 - 5323413404.31696*x_11 + 4554994157.75918*x_110 - 292694562.251053*x_111 - 1777591401.78527*x_112 - 551137282.017766*x_113 + 3689499255.0517*x_114 + 5037395855.45716*x_115 - 429000148.053763*x_116 - 843789378.952174*x_117 - 4453842548.73828*x_118 + 5560489810.17229*x_119 - 3954890991.21101*x_12 - 1931458731.42967*x_120 - 6726801369.48323*x_13 - 2995182821.79181*x_14 - 3392174972.59328*x_15 + 12904423.9834439*x_16 + 9094470823.69159*x_17 - 68507517350.8734*x_18 + 4631584580.75501*x_19 - 1604682900.61031*x_2 + 37200202650.6773*x_20 - 4281767546.2928*x_21 + 41129712041.9064*x_22 + 80668059108.9877*x_23 + 139855205276.561*x_24 + 1732994822.17275*x_25 - 31870872582.0002*x_26 + 3965515132.24364*x_27 + 289047514636.483*x_28 + 30365720559.6831*x_29 + 8365555329.18652*x_3 + 3679510092.24363*x_30 + 2391725532.57688*x_31 + 3237341645.5616*x_32 + 9071477648.67396*x_33 - 362129466425.929*x_34 - 1143021194.09396*x_35 + 24932937720.4785*x_36 + 106226369972.289*x_37 + 7310060401.04189*x_38 - 64545671421.4235*x_39 - 26231463531.6385*x_4 + 25916829103.2412*x_40 + 2092410281413.65*x_41 + 99991596454.7983*x_42 + 5515992448.36592*x_43 - 3707025991.70784*x_44 + 510794010904.418*x_45 + 302198809052.799*x_46 - 406270971663.587*x_47 - 1590008626.25269*x_48 - 456298908031.451*x_49 - 0.0666460781382903*x_5 + 50383860308.4343*x_50 + 22656813714.4722*x_51 - 22758638135.7516*x_52 + 84103425919.7233*x_53 + 13660393208.6707*x_54 - 40759869359.5773*x_55 - 56045059841.2216*x_56 + 34396296936.7406*x_57 + 244685506178.918*x_58 + 59556155243.8927*x_59 - 3736398354.97102*x_6 - 482486150.749347*x_60 - 1593462667.79214*x_61 + 10201303125.7966*x_62 - 82045179.3618115*x_63 - 2473421337.13833*x_64 + 2732110939.21585*x_65 + 3985104762.61838*x_66 + 191242148.441401*x_67 - 2185478977.8963*x_68 + 1826550523.20272*x_69 + 540965225.493464*x_7 - 2714174996.57038*x_70 + 5652900963.06659*x_71 - 1952418734.2121*x_72 - 4361902907.44031*x_73 - 3451431655.78357*x_74 + 1507223385.0588*x_75 + 5612679540.62223*x_76 - 3551551417.14728*x_77 + 2544347500.56004*x_78 + 319578423.497061*x_79 + 2301861008.16075*x_8 - 4641130292.39944*x_80 - 152936401.929755*x_81 + 556241824.539949*x_82 - 10380473855.1046*x_83 + 11614870914.6735*x_84 - 177629179010.39*x_85 - 25248270220.7539*x_86 - 167220260981.61*x_87 + 2482511964.04617*x_88 + 5413198292.40736*x_89 + 7501501600.9715*x_9 - 2005125822.47185*x_90 + 3474076992.62737*x_91 + 2348759304.65579*x_92 - 0.00285777333320534*x_93 - 461863339.471155*x_94 + 42.186500013433*x_95 + 3015553466.31841*x_96 + 1926035416.51464*x_97 - 3651604034.27487*x_98 + 4629535864.12864*x_99 - 2108955318.94273*std::exp(1.23943984508514*x_1) + 0.000608955771287813*std::exp(1.89615988731384*x_1) - 0.000392015765759191*std::exp(1.04759979248047*x_13) - 0.0360273947914642*std::exp(0.979599833488464*x_23) - 0.688445350889509*std::exp(0.99103981256485*x_23) + 0.000334250665267152*std::exp(0.677759826183319*x_24) + 0.0131085489108612*std::exp(0.865199863910675*x_24) + 0.0280124200938055*std::exp(0.602639853954315*x_3) + 259014396.298684*std::exp(1.07583975791931*x_5) + 7.616932077519e-5*std::exp(1.08143985271454*x_5) - 0.00210431084633278*std::exp(1.26119983196259*x_5) - 3.7945476399257e-5*std::exp(1.49183988571167*x_6) + 1.05048384064276e-5*std::exp(1.57999980449677*x_6) - 0.36712535053582*std::exp(1.61871981620789*x_6) - 2.88375520050661e-5*std::exp(1.62087976932526*x_6) - 6.08451724691821e-5*std::exp(1.64087975025177*x_6) - 0.000233065304494808*std::exp(1.64399981498718*x_6) - 0.00173657579944036*std::exp(0.98527979850769*x_8) + 1.26789972588189*std::sin(0.2291199862957*x_109 - 7.42439985275269) + 0.00420937353161158*std::sin(0.291439920663834*x_120 + 1.93135988712311) - 102.250401297465*std::sin(0.471919864416122*x_16 - 4.2958402633667) + 122.197040149417*std::sin(0.429439842700958*x_5 + 5.17456007003784) - 0.992328520741416*std::sin(0.241599977016449*x_8 - 1.17303991317749) - 0.0213829869462964*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.137035822882709*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.180505251166601*std::sin(0.338399857282639*x_91 + 2.00351977348328) + 0.553260327854086*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.52538860711081*std::sin(0.382559835910797*x_91 + 1.99143981933594) + 0.00801235643866594*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0701624600634859*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 3.63472797063843*std::sin(0.2882399559021*x_94 - 7.43400001525879) + 1.03241452575688*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 22749442832.4492*std::sin(0.273119956254959*x_95 + 1.97671973705292) + 0.858380323235214*std::sin(0.301679939031601*x_97 - 1.2176798582077) + 278.608480996427*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 5424058686395.61 - 1180371.09581334*std::exp(-6.41904020309448*x_93) - 3.89765034704087e-5*std::exp(-6.28024005889893*x_93) + 7.05482162518596e-5*std::exp(-5.94159984588623*x_93) + 1.1059339790468e-5*std::exp(-8.01832008361816*x_113) + 1.68345498226902e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-65.9528746455411*x_1 - 222737505194.93*x_10 - 16161506508.12*x_100 + 5997844197.00764*x_101 - 2190469292.07978*x_102 - 7647239650.26229*x_103 - 341206697363.537*x_104 - 1208240940.72172*x_105 + 12393206031.8921*x_106 + 29414857161.9182*x_107 + 1474639876.49249*x_108 - 12099915243.2673*x_109 + 18117385860.1422*x_11 - 15502194171.219*x_110 + 996139176.487777*x_111 + 6049748203.87445*x_112 + 1875707516.10548*x_113 - 12556620891.0513*x_114 - 17143971365.2088*x_115 + 1460033477.49686*x_116 + 2871701939.59301*x_117 + 15157940864.7601*x_118 - 18924237957.4106*x_119 + 13459838771.0881*x_12 + 6573410979.54051*x_120 + 22893592866.3041*x_13 + 10193625126.4149*x_14 + 11544725422.8518*x_15 - 43918142.1691641*x_16 - 30951577342.2031*x_17 + 233154380850.214*x_18 - 15762857980.0981*x_19 + 5461281594.67215*x_2 - 126604941526.853*x_20 + 14572310825.6343*x_21 - 139978398841.727*x_22 - 274540834732.933*x_23 - 475974826973.947*x_24 - 5897970833.2345*x_25 + 108467418289.251*x_26 - 13495998703.974*x_27 - 983726999737.202*x_28 - 103344879410.679*x_29 - 28470829999.4946*x_3 - 12522623723.679*x_30 - 8139855495.07087*x_31 - 11017774418.3604*x_32 - 30873323597.4459*x_33 + 1232449733029.49*x_34 + 3890089783.64378*x_35 - 84855267539.601*x_36 - 361524464921.476*x_37 - 24878621783.2792*x_38 + 219670869745.671*x_39 + 89274590963.8909*x_4 - 88203783341.5623*x_40 - 7121183763040.49*x_41 - 340305420640.719*x_42 - 18772799642.5431*x_43 + 12616270114.9237*x_44 - 1738405737525.76*x_45 - 1028485326230.87*x_46 + 1382678289145.51*x_47 + 5411340004.54552*x_48 + 1552940371713.93*x_49 - 0.284365580200767*x_5 - 171473413366.479*x_50 - 77108842326.7404*x_51 + 77455384487.5375*x_52 - 286232561789.857*x_53 - 46490965620.8769*x_54 + 138719698175.422*x_55 + 190740395548.209*x_56 - 117062296189.759*x_57 - 832747994260.8*x_58 - 202689853945.992*x_59 + 12716234339.0021*x_6 + 1642064499.29079*x_60 + 5423095370.97494*x_61 - 34718504292.1217*x_62 + 279227599.858597*x_63 + 8417894003.52895*x_64 - 9298302711.07033*x_65 - 13562667303.9057*x_66 - 650862159.948613*x_67 + 7437928204.87155*x_68 - 6216372679.4205*x_69 - 1841088535.40029*x_7 + 9237260587.99825*x_70 - 19238744665.5127*x_71 + 6644744887.47142*x_72 + 14845038868.8508*x_73 + 11746395895.8377*x_74 - 5129593747.68676*x_75 - 19101857451.7981*x_76 + 12087137253.6071*x_77 - 8659279610.96688*x_78 - 1087634107.78621*x_79 - 7834015899.73031*x_8 + 15795344730.0732*x_80 + 520494530.313457*x_81 - 1893080181.27764*x_82 + 35328282854.901*x_83 - 39529355711.526*x_84 + 604532507928.828*x_85 + 85928450670.0732*x_86 + 569107417568.492*x_87 - 8448832598.26936*x_88 - 18422954726.1085*x_89 - 25530161101.3158*x_9 + 6824124989.90453*x_90 - 11823465494.0553*x_91 - 7993626815.31972*x_92 - 0.158058395280102*x_93 + 1571878115.21261*x_94 - 11.9901150356027*x_95 - 10262954097.2452*x_96 - 6554953446.06904*x_97 + 12427650428.7467*x_98 - 15755884968.6847*x_99 + 7177492201.05276*std::exp(1.23943984508514*x_1) - 3.82808918059086e-5*std::exp(1.89615988731384*x_1) + 2.46433547768206e-5*std::exp(1.04759979248047*x_13) - 0.0129922087518003*std::exp(0.979599833488464*x_23) - 0.519714518161346*std::exp(0.99103981256485*x_23) - 0.000733862919506463*std::exp(0.677759826183319*x_24) + 0.0450605200839225*std::exp(0.865199863910675*x_24) - 0.00815669075690821*std::exp(0.602639853954315*x_3) - 881514080.784886*std::exp(1.07583975791931*x_5) - 0.000167233295036911*std::exp(1.08143985271454*x_5) - 0.00723354978486057*std::exp(1.26119983196259*x_5) - 0.000191672566401981*std::exp(1.49183988571167*x_6) - 2.30638624929079e-5*std::exp(1.57999980449677*x_6) + 0.108296729867625*std::exp(1.61871981620789*x_6) + 8.39695367640147e-6*std::exp(1.62087976932526*x_6) - 0.000517724803148556*std::exp(1.64087975025177*x_6) + 1.46512244825414e-5*std::exp(1.64399981498718*x_6) + 0.000505658266031003*std::exp(0.98527979850769*x_8) + 4.35839401073322*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.00924187584408463*std::sin(0.291439920663834*x_120 + 1.93135988712311) + 30.1624065785873*std::sin(0.471919864416122*x_16 - 4.2958402633667) - 36.0463798764383*std::sin(0.429439842700958*x_5 + 5.17456007003784) - 3.4111204484021*std::sin(0.241599977016449*x_8 - 1.17303991317749) - 0.181945456940017*std::sin(0.456479847431183*x_8 + 5.12495994567871) - 0.00861450659743773*std::sin(0.464399844408035*x_9 + 1.9022399187088) + 0.0525597398880073*std::sin(0.338399857282639*x_91 + 2.00351977348328) + 1.90182744744923*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.39662129526949*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.0175915021246291*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0253020051258504*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 2.74389375056016*std::sin(0.2882399559021*x_94 - 7.43400001525879) + 3.54891573347647*std::sin(0.295199930667877*x_94 + 1.96535980701447) + 77424090990.253*std::sin(0.273119956254959*x_95 + 1.97671973705292) + 2.95067471295289*std::sin(0.301679939031601*x_97 - 1.2176798582077) - 82.185518818743*std::sin(0.271999955177307*x_98 + 1.96007990837097) - 18460659637196.3 + 4017204.28045654*std::exp(-6.41904020309448*x_93) + 2.45018666818438e-6*std::exp(-6.28024005889893*x_93) + 2.54411166257426e-5*std::exp(-5.94159984588623*x_93) - 6.95225186992422e-7*std::exp(-8.01832008361816*x_113) - 3.69610390201684e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (97.3245775708025*x_1 - 193313226673.807*x_10 - 14026524009.8893*x_100 + 5205511371.25677*x_101 - 1901101856.45352*x_102 - 6637016795.44914*x_103 - 296132290134.924*x_104 - 1048628748.0236*x_105 + 10756027078.4456*x_106 + 25529068052.5794*x_107 + 1279835615.95759*x_108 - 10501480907.6942*x_109 + 15724025836.1412*x_11 - 13454308736.7544*x_110 + 864546271.520634*x_111 + 5250558709.04856*x_112 + 1627921017.08685*x_113 - 10897854396.3634*x_114 - 14879202375.3057*x_115 + 1267158782.64509*x_116 + 2492341607.44984*x_117 + 13155532310.5423*x_118 - 16424290508.4861*x_119 + 11681754441.5995*x_12 + 5705044074.01385*x_120 + 19869281972.2647*x_13 + 8847017141.90668*x_14 + 10019633339.8617*x_15 - 38116427.3225852*x_16 - 26862783031.0383*x_17 + 202354001839.359*x_18 - 13680538197.5328*x_19 + 4739830230.71969*x_2 - 109880056685.691*x_20 + 12647265660.2204*x_21 - 121486841058.613*x_22 - 238273182297.065*x_23 - 413097153129.686*x_24 - 5118831567.17961*x_25 + 94138553460.6087*x_26 - 11713138038.1557*x_27 - 853773772467.8*x_28 - 89692718233.066*x_29 - 24709749702.0796*x_3 - 10868348199.5037*x_30 - 7064556678.7018*x_31 - 9562293988.64706*x_32 - 26794866800.1246*x_33 + 1069639500761.88*x_34 + 3376197471.91596*x_35 - 73645637459.9358*x_36 - 313766020612.352*x_37 - 21592082743.273*x_38 + 190651701800.299*x_39 + 77481154956.4368*x_4 - 76551804236.7235*x_40 - 6180454447111.43*x_41 - 295350076664.843*x_42 - 16292857949.2309*x_43 + 10949623728.6944*x_44 - 1508757229911.93*x_45 - 892619392246.089*x_46 + 1200022423469.07*x_47 + 4696486061.38567*x_48 + 1347792384735.27*x_49 + 0.593358799797487*x_5 - 148821271697.58*x_50 - 66922537559.9646*x_51 + 67223300249.3575*x_52 - 248420399074.785*x_53 - 40349372791.9438*x_54 + 120394418393.233*x_55 + 165543027824.327*x_56 - 101598022704.071*x_57 - 722739536538.596*x_58 - 175913928993.726*x_59 + 11036382410.2467*x_6 + 1425142964.80839*x_60 + 4706688528.24302*x_61 - 30132087900.3476*x_62 + 242340803.630836*x_63 + 7305865461.81067*x_64 - 8069969593.8423*x_65 - 11770999195.3148*x_66 - 564881375.234812*x_67 + 6455356020.08764*x_68 - 5395171586.37136*x_69 - 1597875302.625*x_7 + 8016991313.03577*x_70 - 16697249982.2979*x_71 + 5766954540.32307*x_72 + 12883965553.0296*x_73 + 10194662510.6296*x_74 - 4451959328.72714*x_75 - 16578445967.5387*x_76 + 10490390875.4402*x_77 - 7515363265.16457*x_78 - 943954455.526783*x_79 - 6799119380.55131*x_8 + 13708733246.1979*x_80 + 451735661.012094*x_81 - 1642998742.43146*x_82 + 30661312847.5007*x_83 - 34307411597.6418*x_84 + 524671986941.28*x_85 + 74577049828.6559*x_86 + 493926654629.2*x_87 - 7332716999.30334*x_88 - 15989228244.8757*x_89 - 22157551762.3509*x_9 + 5922637996.43911*x_90 - 10261550942.775*x_91 - 6937645240.88548*x_92 - 0.558834873191837*x_93 + 1364228416.90269*x_94 + 18.730639144809*x_95 - 8907187712.38885*x_96 - 5689024802.39942*x_97 + 10785921280.0861*x_98 - 13674486239.6929*x_99 + 6229324385.59149*std::exp(1.23943984508514*x_1) + 0.000505221662284217*std::exp(1.89615988731384*x_1) - 0.000325236849959783*std::exp(1.04759979248047*x_13) - 0.00605321456265217*std::exp(0.979599833488464*x_23) - 0.498717105322376*std::exp(0.99103981256485*x_23) + 0.000903614635293351*std::exp(0.677759826183319*x_24) - 0.0606882943946192*std::exp(0.865199863910675*x_24) + 0.0171457757542093*std::exp(0.602639853954315*x_3) - 765063479.81404*std::exp(1.07583975791931*x_5) + 0.0002059164578111*std::exp(1.08143985271454*x_5) + 0.00974227101782573*std::exp(1.26119983196259*x_5) + 0.000228453823909382*std::exp(1.49183988571167*x_6) + 2.83988237326405e-5*std::exp(1.57999980449677*x_6) - 0.163319686598134*std::exp(1.61871981620789*x_6) - 1.76508205404413e-5*std::exp(1.62087976932526*x_6) + 0.00102293862150817*std::exp(1.64087975025177*x_6) - 0.000193363206507804*std::exp(1.64399981498718*x_6) - 0.00106291920289941*std::exp(0.98527979850769*x_8) - 5.86996107276394*std::sin(0.2291199862957*x_109 - 7.42439985275269) + 0.0113796378701014*std::sin(0.291439920663834*x_120 + 1.93135988712311) - 45.4871979558547*std::sin(0.471919864416122*x_16 - 4.2958402633667) + 54.3606761867434*std::sin(0.429439842700958*x_5 + 5.17456007003784) + 4.59415651667089*std::sin(0.241599977016449*x_8 - 1.17303991317749) + 0.359494143954487*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.113692109498977*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.110483226675733*std::sin(0.338399857282639*x_91 + 2.00351977348328) - 2.56141437789901*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.380597072765636*std::sin(0.382559835910797*x_91 + 1.99143981933594) + 0.0216606376396552*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0117884856084132*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 2.63303544690797*std::sin(0.2882399559021*x_94 - 7.43400001525879) - 4.77974161003442*std::sin(0.295199930667877*x_94 + 1.96535980701447) + 67196141009.6825*std::sin(0.273119956254959*x_95 + 1.97671973705292) - 3.97402016907336*std::sin(0.301679939031601*x_97 - 1.2176798582077) + 123.941998920826*std::sin(0.271999955177307*x_98 + 1.96007990837097) - 16021873251135.2 + 3486519.78785571*std::exp(-6.41904020309448*x_93) - 3.23369525371317e-5*std::exp(-6.28024005889893*x_93) + 1.18532992034736e-5*std::exp(-5.94159984588623*x_93) + 9.17540861939776e-6*std::exp(-8.01832008361816*x_113) + 4.55105918374156e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (58.3070640826527*x_1 + 169313871345.019*x_10 + 12285166039.7378*x_100 - 4559260101.61429*x_101 + 1665084808.28992*x_102 + 5813047739.40828*x_103 + 259368204837.599*x_104 + 918444117.774674*x_105 - 9420693163.50117*x_106 - 22359697972.1037*x_107 - 1120947215.49561*x_108 + 9197748225.22922*x_109 - 13771927356.7367*x_11 + 11783989895.6001*x_110 - 757215001.050151*x_111 - 4598714922.58129*x_112 - 1425818705.37482*x_113 + 9544912934.34138*x_114 + 13031986509.7697*x_115 - 1109844162.3177*x_116 - 2182923677.76832*x_117 - 11522305811.5984*x_118 + 14385255815.6929*x_119 - 10231493838.5799*x_12 - 4996777080.72029*x_120 - 17402560179.9166*x_13 - 7748682176.98868*x_14 - 8775720789.31604*x_15 + 33384367.6829447*x_16 + 23527835515.7459*x_17 - 177232257407.157*x_18 + 11982133425.5601*x_19 - 4151392146.99024*x_2 + 96238721763.2199*x_20 - 11077139255.2442*x_21 + 106404552730.275*x_22 + 208692162392.807*x_23 + 361812172474.947*x_24 + 4483341383.34764*x_25 - 82451486997.8306*x_26 + 10258980758.9184*x_27 + 747779888112.556*x_28 + 78557589979.0447*x_29 + 21642095904.9496*x_3 + 9519070000.44265*x_30 + 6187509575.46205*x_31 + 8375159092.80253*x_32 + 23468350949.2305*x_33 - 936846425710.25*x_34 - 2957050996.42329*x_35 + 64502715154.1625*x_36 + 274812751941.586*x_37 + 18911479523.3342*x_38 - 166982769101.516*x_39 - 67862063025.144*x_4 + 67048088816.9583*x_40 + 5413166458106.03*x_41 + 258683099401.388*x_42 + 14270140000.3985*x_43 - 9590255284.394*x_44 + 1321448784514.66*x_45 + 781802921375.271*x_46 - 1051042633494.42*x_47 - 4113429055.11258*x_48 - 1180467322595.63*x_49 - 0.367313801019215*x_5 + 130345481940.017*x_50 + 58614271554.6158*x_51 - 58877695516.5937*x_52 + 217579626370.538*x_53 + 35340098479.4769*x_54 - 105447751679.571*x_55 - 144991274762.829*x_56 + 88984881763.7117*x_57 + 633013226421.742*x_58 + 154074653152.712*x_59 - 9666243068.69271*x_6 - 1248215008.92077*x_60 - 4122364895.3933*x_61 + 26391264303.7388*x_62 - 212254807.052283*x_63 - 6398860495.39151*x_64 + 7068103003.60983*x_65 + 10309658914.8655*x_66 + 494752743.216873*x_67 - 5653939683.86104*x_68 + 4725374486.11189*x_69 + 1399503095.00707*x_7 - 7021701845.88627*x_70 + 14624328026.0386*x_71 - 5051001539.64204*x_72 - 11284453422.4691*x_73 - 8929020564.34199*x_74 + 3899259693.57889*x_75 + 14520273239.0603*x_76 - 9188035042.05066*x_77 + 6582349721.80398*x_78 + 826764855.375733*x_79 + 5955025666.80439*x_8 - 12006828235.9953*x_80 - 395653817.557288*x_81 + 1439024532.05027*x_82 - 26854787367.062*x_83 + 30048232085.5968*x_84 - 459535268730.339*x_85 - 65318495118.914*x_86 - 432606893172.697*x_87 + 6422378460.87256*x_88 + 14004205465.8424*x_89 + 19406747014.4142*x_9 - 5187357291.39337*x_90 + 8987605004.22614*x_91 + 6076353872.64815*x_92 + 0.00902692115786734*x_93 - 1194862843.18742*x_94 + 11.4266284123087*x_95 + 7801382567.31702*x_96 + 4982746592.35424*x_97 - 9446876065.13425*x_98 + 11976832906.8244*x_99 - 5455969305.54803*std::exp(1.23943984508514*x_1) + 0.000285118517457326*std::exp(1.89615988731384*x_1) - 0.000183545274095665*std::exp(1.04759979248047*x_13) - 0.0136088472140972*std::exp(0.979599833488464*x_23) - 0.234934343619189*std::exp(0.99103981256485*x_23) + 0.000807652080103222*std::exp(0.677759826183319*x_24) - 0.0246527017502551*std::exp(0.865199863910675*x_24) + 0.0296721826389986*std::exp(0.602639853954315*x_3) + 670082757.660857*std::exp(1.07583975791931*x_5) + 0.000184048430584164*std::exp(1.08143985271454*x_5) + 0.00395748972958295*std::exp(1.26119983196259*x_5) + 0.000106171648652842*std::exp(1.49183988571167*x_6) + 2.53829101082518e-5*std::exp(1.57999980449677*x_6) - 0.0991792084958871*std::exp(1.61871981620789*x_6) - 3.05462044011385e-5*std::exp(1.62087976932526*x_6) - 0.000475627661601714*std::exp(1.64087975025177*x_6) - 0.00010912325200198*std::exp(1.64399981498718*x_6) - 0.00183946956795975*std::exp(0.98527979850769*x_8) - 2.38448618561419*std::sin(0.2291199862957*x_109 - 7.42439985275269) + 0.0101711369400576*std::sin(0.291439920663834*x_120 + 1.93135988712311) - 27.62302808637*std::sin(0.471919864416122*x_16 - 4.2958402633667) + 33.0116286027948*std::sin(0.429439842700958*x_5 + 5.17456007003784) + 1.86623090217411*std::sin(0.241599977016449*x_8 - 1.17303991317749) - 0.167151142261585*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.064161393160352*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.191200359054235*std::sin(0.338399857282639*x_91 + 2.00351977348328) - 1.04049364621389*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.17929066903727*std::sin(0.382559835910797*x_91 + 1.99143981933594) + 0.0193603095420763*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0265028932759634*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 1.24036342015083*std::sin(0.2882399559021*x_94 - 7.43400001525879) - 1.94161898156607*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 58853907760.5434*std::sin(0.273119956254959*x_95 + 1.97671973705292) - 1.61432010826704*std::sin(0.301679939031601*x_97 - 1.2176798582077) + 75.2663050512251*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 14032652113739.6 - 3053677.05520771*std::exp(-6.41904020309448*x_93) - 1.82491461763336e-5*std::exp(-6.28024005889893*x_93) + 2.66486073099605e-5*std::exp(-5.94159984588623*x_93) + 5.17808142034132e-6*std::exp(-8.01832008361816*x_113) + 4.06774334197062e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-33.407343406863*x_1 + 53720790614.6823*x_10 + 3897901723.49326*x_100 - 1446585891.71034*x_101 + 528306813.498757*x_102 + 1844394175.80408*x_103 + 82293700352.8123*x_104 + 291408747.65638*x_105 - 2989046782.63101*x_106 - 7094401880.9566*x_107 - 355659994.082272*x_108 + 2918309661.81967*x_109 - 4369629092.08815*x_11 + 3738885924.00366*x_110 - 240253137.566304*x_111 - 1459104324.63961*x_112 - 452391206.275002*x_113 + 3028459895.10096*x_114 + 4134856828.36838*x_115 - 352137163.582509*x_116 - 692609417.69456*x_117 - 3655857431.76422*x_118 + 4564229186.78868*x_119 - 3246301842.27806*x_12 - 1585403561.34823*x_120 - 5521575293.94763*x_13 - 2458542350.43933*x_14 - 2784406605.9539*x_15 + 10592367.0035735*x_16 + 7465034686.35925*x_17 - 56233177352.5613*x_18 + 3801753973.56857*x_19 - 1317175403.12284*x_2 + 30535124880.8907*x_20 - 3514612638.95231*x_21 + 33760592911.288*x_22 + 66214940089.0972*x_23 + 114797657872.691*x_24 + 1422498001.73724*x_25 - 26160638903.2059*x_26 + 3255023201.58864*x_27 + 237259513182.019*x_28 + 24925163314.2977*x_29 + 6866717362.57071*x_3 + 3020260258.82883*x_30 + 1963205398.23525*x_31 + 2657314254.79451*x_32 + 7446161100.16361*x_33 - 297247532580.251*x_34 - 938228596.092962*x_35 + 20465758797.213*x_36 + 87194026957.1292*x_37 + 6000333114.98929*x_38 - 52981165973.1637*x_39 - 21531630147.3931*x_4 + 21273368179.8307*x_40 + 1717517755206.17*x_41 + 82076327206.8416*x_42 + 4527704749.98197*x_43 - 3042846335.24272*x_44 + 419276180004.103*x_45 + 248054519017.84*x_46 - 333480302605.023*x_47 - 1305130269.46124*x_48 - 374544844805.827*x_49 + 0.00716178912296553*x_5 + 41356696180.2551*x_50 + 18597442550.3124*x_51 - 18681022992.2557*x_52 + 69034801549.5442*x_53 + 11212891358.0406*x_54 - 33457014049.7637*x_55 - 46003589498.1075*x_56 + 28233588546.7059*x_57 + 200845746393.753*x_58 + 48885611766.2859*x_59 - 3066956145.47715*x_6 - 396040185.798801*x_60 - 1307965487.58706*x_61 + 8373558358.77956*x_62 - 67345311.9792524*x_63 - 2030263916.36202*x_64 + 2242604679.38353*x_65 + 3271102524.07337*x_66 + 156977743.988*x_67 - 1793911544.30755*x_68 + 1499291528.06041*x_69 + 444041651.223367*x_7 - 2227882276.91398*x_70 + 4640083276.1993*x_71 - 1602608173.62578*x_72 - 3580390371.50671*x_73 - 2833046346.98676*x_74 + 1237177501.53846*x_75 + 4607068228.61488*x_76 - 2915227794.27791*x_77 + 2088482318.24725*x_78 + 262320279.519867*x_79 + 1889441683.57239*x_8 - 3809589237.57038*x_80 - 125535108.232508*x_81 + 456581234.037545*x_82 - 8520627354.15529*x_83 + 9533860180.82976*x_84 - 145803752969.387*x_85 - 20724593691.7809*x_86 - 137259776975.607*x_87 + 2037725826.62878*x_88 + 4443327532.91277*x_89 + 6157474161.84667*x_9 - 1645871837.25047*x_90 + 2851634308.23955*x_91 + 1927937336.17049*x_92 - 0.295620507670731*x_93 - 379112337.677353*x_94 - 6.03893614811026*x_95 + 2475263458.91282*x_96 + 1580951883.51969*x_97 - 2997354234.92691*x_98 + 3800072165.33652*x_99 - 1731098469.98176*std::exp(1.23943984508514*x_1) + 0.000348898225150007*std::exp(1.89615988731384*x_1) - 0.000224603512033321*std::exp(1.04759979248047*x_13) - 0.00817002671020201*std::exp(0.979599833488464*x_23) - 0.472292952507065*std::exp(0.99103981256485*x_23) + 0.000171368397977145*std::exp(0.677759826183319*x_24) + 0.0217494996018773*std::exp(0.865199863910675*x_24) + 0.0186392970357577*std::exp(0.602639853954315*x_3) + 212607361.146317*std::exp(1.07583975791931*x_5) + 3.90515736619966e-5*std::exp(1.08143985271454*x_5) - 0.00349143968762398*std::exp(1.26119983196259*x_5) - 0.000136847183026794*std::exp(1.49183988571167*x_6) + 5.38577036871254e-6*std::exp(1.57999980449677*x_6) + 0.055123338838941*std::exp(1.61871981620789*x_6) - 1.91883348816905e-5*std::exp(1.62087976932526*x_6) + 4.39205898824261e-6*std::exp(1.64087975025177*x_6) - 0.000133533624142059*std::exp(1.64399981498718*x_6) - 0.00115550716583874*std::exp(0.98527979850769*x_8) + 2.10367942102578*std::sin(0.2291199862957*x_109 - 7.42439985275269) + 0.00215812165406799*std::sin(0.291439920663834*x_120 + 1.93135988712311) + 15.3527494326163*std::sin(0.471919864416122*x_16 - 4.2958402633667) - 18.3477083220784*std::sin(0.429439842700958*x_5 + 5.17456007003784) - 1.6464559817841*std::sin(0.241599977016449*x_8 - 1.17303991317749) + 0.00154351341613048*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.078514003216747*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.120107116119978*std::sin(0.338399857282639*x_91 + 2.00351977348328) + 0.917960894239544*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.360431421528713*std::sin(0.382559835910797*x_91 + 1.99143981933594) + 0.00410788916700768*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0159109248972944*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 2.49352603310463*std::sin(0.2882399559021*x_94 - 7.43400001525879) + 1.71296605517615*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 18673475595.459*std::sin(0.273119956254959*x_95 + 1.97671973705292) + 1.42421122470657*std::sin(0.301679939031601*x_97 - 1.2176798582077) - 41.8326592782381*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 4452470902775.0 - 968886.62344802*std::exp(-6.41904020309448*x_93) - 2.23313966704348e-5*std::exp(-6.28024005889893*x_93) + 1.59984038388299e-5*std::exp(-5.94159984588623*x_93) + 6.33639453989415e-6*std::exp(-8.01832008361816*x_113) + 8.63097708863217e-8*std::exp(-7.81071996688843*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (128.476910558679*x_1 + 299634435686.385*x_10 + 21741034950.1938*x_100 - 8068513918.22223*x_101 + 2946697416.27603*x_102 + 10287339520.7729*x_103 + 459003418256.657*x_104 + 1625368808.52536*x_105 - 16671782758.6979*x_106 - 39569914937.3849*x_107 - 1983738153.66086*x_108 + 16277237518.1422*x_109 - 24372153641.5891*x_11 + 20854104487.5428*x_110 - 1340041944.72908*x_111 - 8138337039.53403*x_112 - 2523268652.44379*x_113 + 16891614243.3119*x_114 + 23062681714.365*x_115 - 1964089100.55311*x_116 - 3863115887.27794*x_117 - 20391002661.7006*x_118 + 25457559829.4963*x_119 - 18106655181.065*x_12 - 8842786885.98279*x_120 - 30797277618.9077*x_13 - 13712828121.9228*x_14 - 15530376362.1619*x_15 + 59080251.8760157*x_16 + 41637165715.6832*x_17 - 313647588513.337*x_18 + 21204758694.0533*x_19 - 7346710781.64511*x_2 + 170313482675.151*x_20 - 19603192266.8886*x_21 + 188303934373.712*x_22 + 369322122673.778*x_23 + 640298312861.092*x_24 + 7934160710.18275*x_25 - 145914239578.626*x_26 + 18155298640.89*x_27 + 1323344644295.96*x_28 + 139023217247.455*x_29 + 38299975917.1019*x_3 + 16845880076.6619*x_30 + 10950023912.4689*x_31 + 14821503110.0566*x_32 + 41531895996.5891*x_33 - 1657935336025.2*x_34 - 5233087521.45992*x_35 + 114150332176.126*x_36 + 486335603887.715*x_37 + 33467609305.2585*x_38 - 295509088641.165*x_39 - 120095363771.95*x_4 + 118654875146.072*x_40 + 9579670377250.52*x_41 + 457790988030.911*x_42 + 25253839532.9986*x_43 - 16971856520.0063*x_44 + 2338565398222.98*x_45 + 1383555141501.69*x_46 - 1860028147506.81*x_47 - 7279527573.79916*x_48 - 2089070773352.17*x_49 + 0.0047498160727055*x_5 + 230672151152.562*x_50 + 103729564792.697*x_51 - 104195745713.927*x_52 + 385050250548.596*x_53 + 62541304934.6195*x_54 - 186610685363.851*x_55 - 256590783062.86*x_56 + 157476375863.421*x_57 + 1120242301678.73*x_58 + 272665620207.39*x_59 - 17106331956.8476*x_6 - 2208963725.09779*x_60 - 7295341307.81293*x_61 + 46704570182.0271*x_62 - 375626929.894729*x_63 - 11324051237.3144*x_64 + 12508408429.3215*x_65 + 18244983736.3254*x_66 + 875562984.645668*x_67 - 10005766295.8352*x_68 + 8362486230.6057*x_69 + 2476697966.28829*x_7 - 12426292389.3412*x_70 + 25880645460.4985*x_71 - 8938747811.36114*x_72 - 19970075744.2523*x_73 - 15801670686.1223*x_74 + 6900512457.52733*x_75 + 25696499903.1035*x_76 - 16260048125.3095*x_77 + 11648771781.263*x_78 + 1463124188.95697*x_79 + 10538597584.4758*x_8 - 21248461074.7065*x_80 - 700187810.099572*x_81 + 2546638971.62749*x_82 - 47524866078.9048*x_83 + 53176299125.1514*x_84 - 813238690194.47*x_85 - 115594016449.599*x_86 - 765583595338.365*x_87 + 11365670931.6952*x_88 + 24783215756.4965*x_89 + 34344083248.3089*x_9 - 9180056327.13756*x_90 + 15905347466.9839*x_91 + 10753311877.0658*x_92 - 0.00187888062590891*x_93 - 2114546495.30392*x_94 + 25.0287042258411*x_95 + 13806091874.0128*x_96 + 8817957163.44267*x_97 - 16718118587.3563*x_98 + 21195378396.0252*x_99 - 9655418492.97674*std::exp(1.23943984508514*x_1) + 0.000704914315379157*std::exp(1.89615988731384*x_1) - 0.000453789155415311*std::exp(1.04759979248047*x_13) + 0.00879565406015332*std::exp(0.979599833488464*x_23) - 0.22060562196644*std::exp(0.99103981256485*x_23) + 0.000364849973096023*std::exp(0.677759826183319*x_24) - 0.00795858479580995*std::exp(0.865199863910675*x_24) + 0.0569084060157782*std::exp(0.602639853954315*x_3) + 1185844180.53166*std::exp(1.07583975791931*x_5) + 8.31423166005034e-5*std::exp(1.08143985271454*x_5) + 0.001277588878919*std::exp(1.26119983196259*x_5) - 5.93541851419745e-5*std::exp(1.49183988571167*x_6) + 1.14665142308689e-5*std::exp(1.57999980449677*x_6) - 0.219361573906955*std::exp(1.61871981620789*x_6) - 5.85846960922995e-5*std::exp(1.62087976932526*x_6) + 0.000103549526727052*std::exp(1.64087975025177*x_6) - 0.000269791464836849*std::exp(1.64399981498718*x_6) - 0.00352792655332127*std::exp(0.98527979850769*x_8) - 0.769779137998602*std::sin(0.2291199862957*x_109 - 7.42439985275269) + 0.00459472479593154*std::sin(0.291439920663834*x_120 + 1.93135988712311) - 61.0957781272617*std::sin(0.471919864416122*x_16 - 4.2958402633667) + 73.0141217838133*std::sin(0.429439842700958*x_5 + 5.17456007003784) + 0.602471771004162*std::sin(0.241599977016449*x_8 - 1.17303991317749) + 0.0363906960641982*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.158629768900127*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.366703986552039*std::sin(0.338399857282639*x_91 + 2.00351977348328) - 0.335900583911014*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.16835567310609*std::sin(0.382559835910797*x_91 + 1.99143981933594) + 0.00874585553553512*std::sin(0.2811199426651*x_94 - 7.43088006973267) + 0.0171293186837356*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 1.16471325371794*std::sin(0.2882399559021*x_94 - 7.43400001525879) - 0.626809161222577*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 104153648518.009*std::sin(0.273119956254959*x_95 + 1.97671973705292) - 0.521147888753874*std::sin(0.301679939031601*x_97 - 1.2176798582077) + 166.471737258141*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 24832755742825.2 - 5404086.47102343*std::exp(-6.41904020309448*x_93) - 4.51183756771243e-5*std::exp(-6.28024005889893*x_93) - 1.72234964061087e-5*std::exp(-5.94159984588623*x_93) + 1.28020577265514e-5*std::exp(-8.01832008361816*x_113) + 1.83756853407699e-7*std::exp(-7.81071996688843*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-64.8783241724676*x_1 + 300194687236.423*x_10 + 21781685942.3115*x_100 - 8083600300.05834*x_101 + 2952207090.73518*x_102 + 10306574567.9367*x_103 + 459861654615.276*x_104 + 1628407875.45762*x_105 - 16702955327.7763*x_106 - 39643901985.6722*x_107 - 1987447311.48276*x_108 + 16307672429.6458*x_109 - 24417724110.2768*x_11 + 20893097070.9414*x_110 - 1342547540.22447*x_111 - 8153553978.65291*x_112 - 2527986583.41873*x_113 + 16923197902.7534*x_114 + 23105803901.2797*x_115 - 1967761537.26623*x_116 - 3870338986.66136*x_117 - 20429129353.7234*x_118 + 25505159902.2814*x_119 - 18140510576.5049*x_12 - 8859320968.95429*x_120 - 30854861800.5296*x_13 - 13738467922.5342*x_14 - 15559414862.8222*x_15 + 59190719.4240146*x_16 + 41715018136.5863*x_17 - 314234040829.692*x_18 + 21244407064.3265*x_19 - 7360447505.07378*x_2 + 170631931668.018*x_20 - 19639845847.9371*x_21 + 188656021683.449*x_22 + 370012672601.389*x_23 + 641495530227.711*x_24 + 7948995873.71473*x_25 - 146187067177.681*x_26 + 18189245631.7057*x_27 + 1325819009975.16*x_28 + 139283161712.849*x_29 + 38371588522.4977*x_3 + 16877378022.6971*x_30 + 10970498084.3442*x_31 + 14849216017.6571*x_32 + 41609551540.8263*x_33 - 1661035311998.6*x_34 - 5242872226.24462*x_35 + 114363768528.596*x_36 + 487244945183.337*x_37 + 33530186433.3563*x_38 - 296061625407.349*x_39 - 120319915618.924*x_4 + 118876733685.12*x_40 + 9597582250324.35*x_41 + 458646959978.829*x_42 + 25301059095.3959*x_43 - 17003590147.3785*x_44 + 2342938003282.6*x_45 + 1386142087342.19*x_46 - 1863505993215.56*x_47 - 7293138663.66821*x_48 - 2092976878925.05*x_49 + 0.539341633442766*x_5 + 231103457935.541*x_50 + 103923516304.491*x_51 - 104390568565.132*x_52 + 385770210204.589*x_53 + 62658243956.1074*x_54 - 186959606581.678*x_55 - 257070550531.121*x_56 + 157770822095.413*x_57 + 1122336909426.16*x_58 + 273175445900.266*x_59 - 17138317055.3243*x_6 - 2213094011.75996*x_60 - 7308981992.59182*x_61 + 46791897593.1897*x_62 - 376329257.700534*x_63 - 11345224731.7328*x_64 + 12531796415.0692*x_65 + 18279097996.8393*x_66 + 877200120.939796*x_67 - 10024474879.0729*x_68 + 8378122260.2909*x_69 + 2481328816.92696*x_7 - 12449526833.7972*x_70 + 25929036644.3533*x_71 - 8955461290.27509*x_72 - 20007415354.0463*x_73 - 15831216397.6607*x_74 + 6913414894.68167*x_75 + 25744546769.576*x_76 - 16290450828.9276*x_77 + 11670552359.3746*x_78 + 1465859923.2649*x_79 + 10558302462.9192*x_8 - 21288191018.2835*x_80 - 701496992.698024*x_81 + 2551400651.24162*x_82 - 47613727164.0082*x_83 + 53275727109.9499*x_84 - 814759268685.342*x_85 - 115810152020.208*x_86 - 767015068551.309*x_87 + 11386922273.3831*x_88 + 24829554928.1307*x_89 + 34408299140.3035*x_9 - 9197220989.97791*x_90 + 15935086974.5072*x_91 + 10773418243.3241*x_92 - 0.536316661842116*x_93 - 2118500260.913*x_94 - 12.0464204072652*x_95 + 13831906263.3942*x_96 + 8834444778.31298*x_97 - 16749377809.7477*x_98 + 21235009094.2552*x_99 - 9673472012.0052*std::exp(1.23943984508514*x_1) + 0.00086473670928455*std::exp(1.89615988731384*x_1) - 0.000556674949567145*std::exp(1.04759979248047*x_13) - 0.0295099372069207*std::exp(0.979599833488464*x_23) - 0.601151175588819*std::exp(0.99103981256485*x_23) - 0.00136363950964898*std::exp(0.677759826183319*x_24) + 0.0825938831328966*std::exp(0.865199863910675*x_24) + 0.0127989492892112*std::exp(0.602639853954315*x_3) + 1188061449.57014*std::exp(1.07583975791931*x_5) - 0.000310747310402985*std::exp(1.08143985271454*x_5) - 0.0132587676408096*std::exp(1.26119983196259*x_5) - 4.0879132732547e-5*std::exp(1.49183988571167*x_6) - 4.28564971801432e-5*std::exp(1.57999980449677*x_6) + 0.108115288557474*std::exp(1.61871981620789*x_6) - 1.31759542553573e-5*std::exp(1.62087976932526*x_6) + 0.000847452629036582*std::exp(1.64087975025177*x_6) - 0.000330960200986399*std::exp(1.64399981498718*x_6) - 0.000793446104245153*std::exp(0.98527979850769*x_8) + 7.98873792178122*std::sin(0.2291199862957*x_109 - 7.42439985275269) - 0.0171729443051023*std::sin(0.291439920663834*x_120 + 1.93135988712311) + 30.1118722127427*std::sin(0.471919864416122*x_16 - 4.2958402633667) - 35.9859874490866*std::sin(0.429439842700958*x_5 + 5.17456007003784) - 6.25242858144641*std::sin(0.241599977016449*x_8 - 1.17303991317749) + 0.297822617126644*std::sin(0.456479847431183*x_8 + 5.12495994567871) + 0.194595259821731*std::sin(0.464399844408035*x_9 + 1.9022399187088) - 0.0824733296295429*std::sin(0.338399857282639*x_91 + 2.00351977348328) + 3.48596318109526*std::sin(0.347919851541519*x_91 - 7.40807962417603) - 0.458769862266563*std::sin(0.382559835910797*x_91 + 1.99143981933594) - 0.0326879403408894*std::sin(0.2811199426651*x_94 - 7.43088006973267) - 0.0574698726549916*std::sin(0.287519931793213*x_94 - 7.42568016052246) + 3.1738481343097*std::sin(0.2882399559021*x_94 - 7.43400001525879) + 6.50500106952467*std::sin(0.295199930667877*x_94 + 1.96535980701447) - 104348393041.695*std::sin(0.273119956254959*x_95 + 1.97671973705292) + 5.40845249790578*std::sin(0.301679939031601*x_97 - 1.2176798582077) - 82.0478244652008*std::sin(0.271999955177307*x_98 + 1.96007990837097) + 24879188745998.0 - 5414190.92977962*std::exp(-6.41904020309448*x_93) - 5.5347883934397e-5*std::exp(-6.28024005889893*x_93) + 5.77858444581702e-5*std::exp(-5.94159984588623*x_93) + 1.5704616900246e-5*std::exp(-8.01832008361816*x_113) - 6.867976537018e-7*std::exp(-7.81071996688843*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
