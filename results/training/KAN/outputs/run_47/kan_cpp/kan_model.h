
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.25272955019101*x_1 - 639.603074532914*x_10 - 957.681408843812*x_100 + 11199.4416784334*x_101 + 1481.20024032146*x_102 - 1983.7668938045*x_103 - 2565.62407727755*x_104 + 1220.9482092797*x_105 + 812.321951471293*x_106 - 6485.33989662812*x_107 - 97.9587340137035*x_108 + 182.097629208526*x_109 + 1648.5938596477*x_11 - 367.587980391451*x_110 - 449.105082673916*x_111 - 293.417140506827*x_112 + 2258.25363607833*x_113 - 90.5071186830982*x_114 + 232.218415241924*x_115 + 1558.89617154883*x_116 - 74.1830799618623*x_117 + 2618.1501397087*x_118 - 430.852083911637*x_119 - 449.362388173274*x_12 - 301.1411281354*x_120 + 304.905565843911*x_13 - 2.36273603248084*x_14 + 772.060486252466*x_15 - 942.032303529001*x_16 + 1683.98516728334*x_17 - 1065.81159781449*x_18 + 1203.12861443818*x_19 + 762.62872504743*x_2 - 2031.66549407905*x_20 - 936.174678941332*x_21 - 545.572488175377*x_22 + 523.663759679374*x_23 - 484.22877483542*x_24 - 373.180234464484*x_25 + 517.203665378045*x_26 - 628.903191745676*x_27 - 43.6908704748967*x_28 + 389.770758980933*x_29 - 540.504326844563*x_3 + 4557.6779758269*x_30 - 28601.5011389352*x_31 + 1667.99940886603*x_32 - 231.78948882039*x_33 - 817.487724521983*x_34 - 676.333157839445*x_35 + 52.0977251804559*x_36 - 625.463987585789*x_37 - 728.344218536735*x_38 + 109.347939627823*x_39 - 3539.47602623729*x_4 + 4195.17296353236*x_40 + 1492.37247371793*x_41 + 573.99342363169*x_42 - 2307.96414129569*x_43 - 650.972895002878*x_44 - 1578.09817334769*x_45 + 612.455759106488*x_46 + 301.936445035584*x_47 - 6639.07658241989*x_48 + 2271.37107464849*x_49 - 233.496217139545*x_5 - 13.2098292329409*x_50 + 447.047734713963*x_51 + 208.962668388804*x_52 + 2091.70430513791*x_53 - 1113.40316879717*x_54 + 1320.27347382304*x_55 - 1104.31255265638*x_56 + 1634.10135089287*x_57 - 295.709161836597*x_58 - 1477.32515631315*x_59 + 25.0672216165415*x_6 - 2582.9161420528*x_60 + 531.024852318086*x_61 - 5123.42520236404*x_62 + 473.381598583998*x_63 - 3557.98907867538*x_64 - 1114.63654542119*x_65 - 1956.87353381214*x_66 - 2114.82236813228*x_67 + 567.285855861505*x_68 - 370.175812273124*x_69 + 702.157451790432*x_7 + 46.7376407452343*x_70 + 193.407836998649*x_71 - 2177.35403680939*x_72 + 18.8976088201905*x_73 - 832.682120873351*x_74 + 202.648559318695*x_75 + 636.000895838987*x_76 + 558.17874620587*x_77 + 533.112161039216*x_78 + 881.822643309968*x_79 - 20445.4332111835*x_8 + 951.405496362204*x_80 + 202.093891838135*x_81 + 94.343636510127*x_82 + 2661.42180444783*x_83 - 4683.45372049844*x_84 - 1096.26366482821*x_85 - 1342.02234842388*x_86 - 902.172570587729*x_87 - 185.06317133059*x_88 - 1341.58086726222*x_89 + 5670.62330411066*x_9 - 3715.10702655808*x_90 + 2096.67128607945*x_91 + 497.686910263076*x_92 - 52121.400673584*x_93 - 2125.73709728124*x_94 + 619.939793913179*x_95 + 696.963834827671*x_96 + 1342.99597169983*x_97 + 7.13492937226995*x_98 - 1429.20162452305*x_99 - 0.115071167593757*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 1.53516915378726e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) - 5.17379403968139e-6*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) + 1.06051385319248*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) - 0.178168638111887*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) - 7.28594366882942*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) + 0.169403731721801*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 2.46197180430354e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 2.95913028720934e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) - 0.883900158761278*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) - 0.106235412491974*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.00824596087076981*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.174487179036967*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.00313585813694538*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) + 0.132728914006874*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) + 0.193772418442486*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.00620765204617611*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) - 0.294005479463*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) + 327.672477080475*std::exp(0.50519984960556*x_1) - 1.24092883244583*std::exp(0.69599986076355*x_1) - 0.783123252888981*std::exp(0.843999862670898*x_1) + 82.6472703673187*std::exp(0.92631983757019*x_1) - 0.298517534719007*std::exp(0.954959809780121*x_1) + 4.60534250000942e-5*std::exp(1.04391980171204*x_1) - 0.00199313180791181*std::exp(1.06287980079651*x_1) - 10.9320600256696*std::exp(1.09599983692169*x_1) - 0.825119109340178*std::exp(1.10639989376068*x_1) - 0.000299189890837166*std::exp(1.12911987304688*x_1) + 1.05191816622034e-5*std::exp(1.14607977867126*x_1) + 0.0178723427589247*std::exp(1.15999984741211*x_1) - 0.00538260866113338*std::exp(1.06799972057343*x_108) + 2.91135862279628*std::exp(1.30215978622437*x_108) - 4.18749437886629*std::exp(1.4450398683548*x_108) - 0.0212912922149994*std::exp(1.48199987411499*x_108) - 0.0396152754515846*std::exp(1.49183988571167*x_108) + 0.00712047305119696*std::exp(2.85751986503601*x_17) + 0.000404645294881249*std::exp(3.06975984573364*x_17) + 2.71159044752608*std::exp(3.2435998916626*x_17) + 0.135482733214941*std::exp(3.34063982963562*x_17) + 0.0560462846748023*std::exp(3.72783994674683*x_17) - 0.00916912861895517*std::exp(3.84783983230591*x_17) - 1.08186790833711e-6*std::exp(4.00047969818115*x_17) + 1.30389756448119e-5*std::exp(4.29528045654297*x_17) - 3.01243144323969*std::exp(0.968399822711945*x_29) - 0.129841427487791*std::exp(1.05535984039307*x_29) + 0.816527395691035*std::exp(1.22887980937958*x_29) + 1.99656175660759*std::exp(1.27927994728088*x_29) - 11.902637942757*std::exp(1.3769599199295*x_29) + 0.00436886392588459*std::exp(1.50023984909058*x_29) - 0.000670933016361936*std::exp(1.51847982406616*x_29) - 0.000420506860502343*std::exp(2.48135995864868*x_29) - 3.57553482761268e-6*std::exp(2.79688000679016*x_29) - 0.0238458526547509*std::exp(3.16279983520508*x_29) - 172.60260073907*std::exp(1.2364798784256*x_38) - 0.473935274238571*std::exp(1.59431982040405*x_38) - 0.000358894599093382*std::exp(1.63711988925934*x_38) - 0.13805521370735*std::exp(1.69327986240387*x_38) - 7.01542447047731e-6*std::exp(2.51567983627319*x_38) + 7.73769490741713e-5*std::exp(1.65847980976105*x_50) + 2.62468123949711*std::exp(1.70751988887787*x_50) + 0.527221496182188*std::exp(1.71991980075836*x_50) - 0.341346327097178*std::exp(1.87503981590271*x_50) - 892.703973683295*std::exp(1.90279984474182*x_50) - 0.0106035508309882*std::exp(1.92735981941223*x_50) - 0.0150827908855557*std::exp(1.93935978412628*x_50) - 979.300469800094*std::exp(1.95463979244232*x_50) - 3.24763768995217*std::exp(1.95655977725983*x_50) - 0.440909251308591*std::exp(1.98487973213196*x_50) - 2.89071713859011*std::exp(0.721999883651733*x_66) - 26.407754726613*std::exp(0.787759840488434*x_71) + 1.77391786175159*std::exp(0.791999816894531*x_71) - 5.18971097731002*std::exp(1.15183985233307*x_71) + 0.00951635813974766*std::exp(1.16359984874725*x_71) + 2.77456277886073*std::exp(1.43479979038239*x_71) + 0.000209534161627128*std::exp(1.56895983219147*x_71) + 285.48094462691*std::exp(1.71743988990784*x_71) - 0.00934480430356418*std::exp(1.76351988315582*x_71) + 0.000255725508159682*std::exp(1.83151996135712*x_71) - 0.575966184221122*std::exp(1.83999979496002*x_71) - 0.0292314523309362*std::exp(1.9236798286438*x_71) + 0.110185530894805*std::exp(1.14375984668732*x_72) + 980.97678631817*std::exp(0.821839869022369*x_73) + 12.1772399619423*std::exp(0.863199889659882*x_73) + 12.5225205749202*std::exp(0.740559816360474*x_76) - 0.000936650898479159*std::exp(0.98175984621048*x_76) + 0.838522739356761*std::exp(1.20527982711792*x_76) + 0.280394087007281*std::exp(1.75559985637665*x_76) - 5.89603361376395e-5*std::exp(2.1159999370575*x_76) - 0.0898608550531649*std::exp(1.01855981349945*x_77) + 0.873684592662124*std::exp(1.47807991504669*x_77) + 0.703724858833182*std::exp(1.27991986274719*x_78) - 0.00589228552014584*std::exp(1.7519998550415*x_78) - 7.42283879629247*std::exp(1.35511994361877*x_81) - 10.7846508609409*std::exp(0.975599825382233*x_88) - 64.5568809417305*std::sin(0.370799839496613*x_102 + 8.17463970184326) - 0.270807787124786*std::sin(0.199760004878044*x_104 - 7.60799980163574) + 0.00282258535114306*std::sin(0.329119831323624*x_105 - 7.45895957946777) + 279.4093594521*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 2.73848807598177*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 19.0391996952462*std::sin(0.493919849395752*x_105 + 2.05367970466614) + 45.0734199309174*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 23.4683440168128*std::sin(0.409119844436646*x_111 + 2.01191973686218) - 0.240082624219766*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 14.1813232893267*std::sin(0.48431983590126*x_112 - 4.16656017303467) - 101.865171800534*std::sin(0.452719867229462*x_117 - 7.37175989151001) - 237.356569261654*std::sin(0.427359849214554*x_120 - 1.15639984607697) - 138.536302830797*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 23.4254596973862*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0631823321612879*std::sin(0.548159837722778*x_15 - 7.25176000595093) - 51.843527273257*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 7.99374157639131*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 1.84161228238247*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 2.23219266812969*std::sin(0.489599853754044*x_19 - 1.11607992649078) - 167.440564331605*std::sin(0.308639913797379*x_21 + 8.310959815979) - 0.84610680990201*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 51.8688794540997*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 13.2536841653645*std::sin(0.299919933080673*x_28 + 5.10191965103149) + 91.8238096007001*std::sin(0.317279845476151*x_28 + 8.30079936981201) + 130.867669775997*std::sin(0.321599841117859*x_28 + 8.31328010559082) - 5430.53981329153*std::sin(0.33519983291626*x_28 - 4.27343988418579) - 82.2323086711813*std::sin(0.337279856204987*x_28 + 5.13632011413574) + 4831.44701122384*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 27.8496787711986*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 22.1958596414695*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 13.4965965351899*std::sin(0.377119839191437*x_34 + 1.99303984642029) + 221.192968921422*std::sin(0.239039987325668*x_36 + 1.82855987548828) + 11621.2413557053*std::sin(0.31535992026329*x_36 + 1.90343987941742) - 68.502106925017*std::sin(0.320719838142395*x_36 + 5.12007999420166) + 0.235173602147089*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 20.1513877003102*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 35.9983693649588*std::sin(0.352879852056503*x_36 + 1.94455981254578) - 0.00734121619453988*std::sin(0.357039839029312*x_36 + 5.15184020996094) + 3701.65247879253*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 1.51522070825626*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.0160297673138411*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 2.27204675310241*std::sin(0.448239862918854*x_45 - 7.35192012786865) - 12461.5565087353*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 3.73374177653765*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 12.5080797898715*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 38.252577862338*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.0788693830074976*std::sin(0.234399989247322*x_47 + 1.83199989795685) + 75.89215582548*std::sin(0.497679859399796*x_49 - 4.12728023529053) - 450.424128226972*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 2.02760490629489*std::sin(0.438159853219986*x_53 - 7.36560010910034) + 61.0649688852213*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 13.5823238751726*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 12.4864507578914*std::sin(0.488879859447479*x_58 + 2.04247975349426) + 0.0163205393438223*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.00683452744199346*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.00504879401996858*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.00290470507574807*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.0675573754044983*std::sin(0.530719876289368*x_73 - 4.05000019073486) - 3068.12192998562*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 5.13902583675961*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 75.1659974795941*std::sin(0.197119995951653*x_75 + 1.8083997964859) - 13224.9164418892*std::sin(0.277759969234467*x_75 - 7.51592016220093) - 0.0313413921443594*std::sin(0.420239865779877*x_75 + 8.41903972625732) - 0.0145192327850215*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 8.22803082700697*std::sin(0.179360002279282*x_80 + 1.77199983596802) - 256.794906573636*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 31.4641254305632*std::sin(0.23175998032093*x_80 + 5.05128002166748) + 0.231576542273622*std::sin(0.263199955224991*x_80 + 1.84135985374451) - 7742.4781105589*std::sin(0.289039850234985*x_80 - 1.3064798116684) - 36411.2987267074*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.132603517327809*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 4.42883313207204*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 23.4900696576375*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 23.9328909010551*std::sin(0.347199827432632*x_92 + 1.99871981143951) + 0.0120783853840463*std::sin(0.349439829587936*x_92 - 7.41207981109619) - 9736.55825661171*std::sin(0.361599832773209*x_92 - 1.17927992343903) - 160.029080976293*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 2.44402287181035*std::sin(0.272639960050583*x_96 + 5.06655979156494) - 103.401939587641*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.102757571030293*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.00958462962417315*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 5.50047395284344*std::sin(0.54943984746933*x_99 - 7.41207981109619) + 419187.098430053 + 1.30835999251576*std::exp(-2.47855997085571*x_86) - 30.881050369661*std::exp(-2.40647983551025*x_86) + 0.000107974098926337*std::exp(-2.36967992782593*x_86) - 0.200599381404372*std::exp(-2.33151984214783*x_86) - 0.210641508462006*std::exp(-2.33007979393005*x_86) + 0.17533151126877*std::exp(-2.11759996414185*x_23) - 0.0144449196698316*std::exp(-2.09047985076904*x_23) + 49.6597231821639*std::exp(-2.06727981567383*x_23));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.60873725290326*x_1 - 878.560050290501*x_10 - 215.05706382445*x_100 - 17186.5726966669*x_101 + 370.528068344907*x_102 - 553.716523633231*x_103 - 718.381286276585*x_104 - 439.347535221513*x_105 - 159.30249519512*x_106 - 2154.77456783213*x_107 - 137.755507808695*x_108 - 555.376277123265*x_109 + 624.197467201522*x_11 - 527.126160333594*x_110 + 834.853145702493*x_111 - 614.686132394018*x_112 + 1671.41168820807*x_113 + 25.860359459901*x_114 - 425.671435153176*x_115 - 235.096820762448*x_116 - 548.917235695622*x_117 + 29.8297829543491*x_118 + 522.716908684875*x_119 + 937.578076418405*x_12 - 770.499902236733*x_120 + 139.649856269658*x_13 - 782.236954910766*x_14 - 171.723987030435*x_15 + 537.486462667475*x_16 + 66.1424024586292*x_17 - 757.877597893865*x_18 + 96.5295323923843*x_19 + 722.253275709413*x_2 - 124.871473651461*x_20 + 181.313433856211*x_21 - 241.921922490067*x_22 + 406.977114584963*x_23 - 214.314496393882*x_24 + 235.312670080804*x_25 + 143.275060017264*x_26 - 427.090413954772*x_27 + 4.19425011410752*x_28 + 399.268571900337*x_29 - 481.221275624523*x_3 + 809.694472633457*x_30 - 21835.884962318*x_31 + 357.629550317772*x_32 - 641.660596042057*x_33 + 497.56359871806*x_34 - 229.259570635153*x_35 - 2.05282570769486*x_36 - 1195.22267337129*x_37 - 20.5507128793047*x_38 + 519.651487261516*x_39 - 1642.91766588142*x_4 + 1207.32389107977*x_40 + 119.109201300958*x_41 + 436.890516457095*x_42 - 843.792154090129*x_43 - 399.490332997953*x_44 - 718.930052001758*x_45 + 490.008047256604*x_46 - 386.301157938752*x_47 - 43.229589771285*x_48 + 265.012527042744*x_49 + 7.09865704390016*x_5 + 12.5179678824289*x_50 + 681.541212952957*x_51 + 273.940430972969*x_52 + 617.060499938567*x_53 - 1589.61086529719*x_54 + 627.706587229844*x_55 - 531.623134706246*x_56 + 643.082833289048*x_57 - 317.298114299239*x_58 + 261.575558161024*x_59 - 332.623338373079*x_6 - 910.823389279352*x_60 + 763.723167978808*x_61 - 623.651792905426*x_62 - 639.771161663455*x_63 - 1573.7164667462*x_64 - 687.056930577571*x_65 - 929.904755662499*x_66 - 773.590761832288*x_67 - 111.744185606141*x_68 - 471.677866986406*x_69 - 401.910292204929*x_7 + 1060.26902237905*x_70 + 124.08732697494*x_71 - 1853.83447707052*x_72 - 1.92115056538446*x_73 + 36.2397472103896*x_74 + 178.29043941071*x_75 + 501.111885844648*x_76 + 778.615342412228*x_77 + 964.96565826927*x_78 + 707.750861746824*x_79 - 7642.40905586016*x_8 + 42.5694910611797*x_80 + 305.726518264271*x_81 + 840.305086485775*x_82 + 294.36627411029*x_83 - 1348.32584973995*x_84 - 911.354608669808*x_85 - 1172.66108820152*x_86 - 107.109644231043*x_87 - 603.652141730316*x_88 - 1446.99746404286*x_89 + 3467.95439042463*x_9 - 2355.95763534313*x_90 + 1450.10843652936*x_91 + 386.32336847655*x_92 - 19592.7461054969*x_93 - 701.876566057747*x_94 - 880.277410704371*x_95 + 823.428152066065*x_96 + 732.001752039827*x_97 - 425.199248498686*x_98 - 888.305377645344*x_99 + 0.135381385272023*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 1.01027456456436e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) - 8.00359754329703e-6*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.0354103716324812*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) + 0.00652969211628294*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) + 1.9124819067846*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) - 0.0444666588963333*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 1.62019116032029e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 1.94736459824278e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.0295132713387246*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) + 0.00389341548978607*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.00892200193674538*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.18879242500695*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) + 0.00330500814822587*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) - 0.0348399134118062*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) - 0.00710155415939366*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) + 0.00654249640704343*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.00981679141524718*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) + 282.770039194928*std::exp(0.50519984960556*x_1) + 1.45995446012686*std::exp(0.69599986076355*x_1) + 0.95924272726428*std::exp(0.843999862670898*x_1) + 4.04821355342953*std::exp(0.92631983757019*x_1) + 0.0783576445218069*std::exp(0.954959809780121*x_1) + 3.03071513480366e-5*std::exp(1.04391980171204*x_1) + 0.00210064249655546*std::exp(1.06287980079651*x_1) + 0.365019567686207*std::exp(1.09599983692169*x_1) + 0.0302397425290388*std::exp(1.10639989376068*x_1) - 0.000205164371148231*std::exp(1.12911987304688*x_1) + 1.62726416752166e-5*std::exp(1.14607977867126*x_1) + 0.0134872940906082*std::exp(1.15999984741211*x_1) - 0.00510447711870867*std::exp(1.06799972057343*x_108) - 3.56610479266586*std::exp(1.30215978622437*x_108) + 1.09917226900969*std::exp(1.4450398683548*x_108) + 0.0224397568970948*std::exp(1.48199987411499*x_108) - 0.0217345440910658*std::exp(1.49183988571167*x_108) + 0.00390657981590017*std::exp(2.85751986503601*x_17) + 0.00038373635888282*std::exp(3.06975984573364*x_17) + 2.34000897469099*std::exp(3.2435998916626*x_17) - 0.00496529885585425*std::exp(3.34063982963562*x_17) - 0.00187137561945113*std::exp(3.72783994674683*x_17) + 0.0107874922982779*std::exp(3.84783983230591*x_17) - 1.67359490287558e-6*std::exp(4.00047969818115*x_17) + 8.9412554384763e-6*std::exp(4.29528045654297*x_17) - 2.27331969573381*std::exp(0.968399822711945*x_29) - 0.0712362642544097*std::exp(1.05535984039307*x_29) + 0.883469994574565*std::exp(1.22887980937958*x_29) - 2.34895762372836*std::exp(1.27927994728088*x_29) + 0.397426994179395*std::exp(1.3769599199295*x_29) + 0.00414311486277248*std::exp(1.50023984909058*x_29) - 0.000441532165549779*std::exp(1.51847982406616*x_29) - 0.000288355416545254*std::exp(2.48135995864868*x_29) - 5.53117142715175e-6*std::exp(2.79688000679016*x_29) + 0.0062592800365954*std::exp(3.16279983520508*x_29) - 148.950087633227*std::exp(1.2364798784256*x_38) - 0.357653415100083*std::exp(1.59431982040405*x_38) - 0.000236183800286163*std::exp(1.63711988925934*x_38) + 0.162422146803177*std::exp(1.69327986240387*x_38) - 1.08525066182487e-5*std::exp(2.51567983627319*x_38) + 0.000119698224314317*std::exp(1.65847980976105*x_50) - 3.21495547614842*std::exp(1.70751988887787*x_50) + 0.570445492496274*std::exp(1.71991980075836*x_50) + 0.401594418360974*std::exp(1.87503981590271*x_50) - 770.37272058067*std::exp(1.90279984474182*x_50) - 0.00727120435817798*std::exp(1.92735981941223*x_50) - 0.0143034290264333*std::exp(1.93935978412628*x_50) - 47.967917356558*std::exp(1.95463979244232*x_50) + 0.852469989357348*std::exp(1.95655977725983*x_50) + 0.0161588576574175*std::exp(1.98487973213196*x_50) - 3.12771116832577*std::exp(0.721999883651733*x_66) + 6.93175179620446*std::exp(0.787759840488434*x_71) + 1.91935164939697*std::exp(0.791999816894531*x_71) + 6.35684420456605*std::exp(1.15183985233307*x_71) + 0.00902462642854488*std::exp(1.16359984874725*x_71) - 0.101684790854616*std::exp(1.43479979038239*x_71) + 0.000137891667101944*std::exp(1.56895983219147*x_71) + 13.9833756656229*std::exp(1.71743988990784*x_71) - 0.0051269380016408*std::exp(1.76351988315582*x_71) + 0.000395594419330859*std::exp(1.83151996135712*x_71) - 0.43465064528021*std::exp(1.83999979496002*x_71) + 0.0308082138665646*std::exp(1.9236798286438*x_71) - 0.116129002499664*std::exp(1.14375984668732*x_72) + 846.549111442085*std::exp(0.821839869022369*x_73) - 0.44628296326566*std::exp(0.863199889659882*x_73) - 3.28702706408936*std::exp(0.740559816360474*x_76) - 0.001448951537788*std::exp(0.98175984621048*x_76) + 0.632787930486596*std::exp(1.20527982711792*x_76) - 0.32988402494657*std::exp(1.75559985637665*x_76) - 3.88010192694875e-5*std::exp(2.1159999370575*x_76) - 0.04930130344798*std::exp(1.01855981349945*x_77) + 0.659322686600952*std::exp(1.47807991504669*x_77) + 0.761419396944019*std::exp(1.27991986274719*x_78) - 0.00558781782366279*std::exp(1.7519998550415*x_78) + 1.94841540645193*std::exp(1.35511994361877*x_81) + 2.83085494206849*std::exp(0.975599825382233*x_88) + 79.0753158072805*std::sin(0.370799839496613*x_102 + 8.17463970184326) - 0.18570182699702*std::sin(0.199760004878044*x_104 - 7.60799980163574) + 0.00436639669242534*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 9.32942952702443*std::sin(0.424079865217209*x_105 + 2.02815985679626) - 2.88620371511939*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 14.3678581483882*std::sin(0.493919849395752*x_105 + 2.05367970466614) - 1.65189316086031*std::sin(0.52183985710144*x_109 + 2.17431998252869) + 27.6105386733635*std::sin(0.409119844436646*x_111 + 2.01191973686218) - 0.164632569916853*std::sin(0.2223199903965*x_112 - 7.58296012878418) + 16.684346148962*std::sin(0.48431983590126*x_112 - 4.16656017303467) + 26.738512793268*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 7.92529423511496*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 4.62570286381551*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 17.6779322335102*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0599175584048563*std::sin(0.548159837722778*x_15 - 7.25176000595093) + 1.90001043339568*std::sin(0.580159842967987*x_15 + 2.16847991943359) + 9.40464784314168*std::sin(0.750319838523865*x_15 + 2.37279987335205) + 1.94094991971664*std::sin(0.438879877328873*x_17 - 4.15015983581543) + 2.35259843857764*std::sin(0.489599853754044*x_19 - 1.11607992649078) + 43.9513485557109*std::sin(0.308639913797379*x_21 + 8.310959815979) + 0.891746303204738*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 39.1426485483226*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 14.3402809745997*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 112.474404538794*std::sin(0.317279845476151*x_28 + 8.30079936981201) - 34.3513568050776*std::sin(0.321599841117859*x_28 + 8.31328010559082) - 4686.36844185398*std::sin(0.33519983291626*x_28 - 4.27343988418579) + 3.01372712574005*std::sin(0.337279856204987*x_28 + 5.13632011413574) + 236.653058069381*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 21.0166519847297*std::sin(0.354639858007431*x_28 - 4.23663997650146) + 26.1134590740744*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 14.6031083961709*std::sin(0.377119839191437*x_34 + 1.99303984642029) - 58.0607770521169*std::sin(0.239039987325668*x_36 + 1.82855987548828) + 569.229528752169*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 83.907798201234*std::sin(0.320719838142395*x_36 + 5.12007999420166) + 0.161266291652319*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 21.8034893577527*std::sin(0.348799854516983*x_36 + 5.15352010726929) - 42.3521305473091*std::sin(0.352879852056503*x_36 + 1.94455981254578) - 0.0113564899276605*std::sin(0.357039839029312*x_36 + 5.15184020996094) + 3194.39833897644*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 0.831311430146181*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.0105489783670465*std::sin(0.317759841680527*x_43 + 1.93063986301422) + 2.39460227606731*std::sin(0.448239862918854*x_45 - 7.35192012786865) - 610.389692621216*std::sin(0.324479848146439*x_46 + 8.31719970703125) + 3.93514197898271*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 9.43917386267381*std::sin(0.376079827547073*x_46 - 4.22552013397217) - 45.0042099121813*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.0747940239154728*std::sin(0.234399989247322*x_47 + 1.83199989795685) - 19.9208752469571*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 15.0395826747005*std::sin(0.281999945640564*x_53 + 5.10016012191772) + 2.13697509391002*std::sin(0.438159853219986*x_53 - 7.36560010910034) - 2.23796651384006*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 10.2498479919128*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 13.5101463117399*std::sin(0.488879859447479*x_58 + 2.04247975349426) + 0.0252470484127627*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.00449771233250039*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.00332254472903887*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.00191154808468483*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.0640665332856766*std::sin(0.530719876289368*x_73 - 4.05000019073486) - 150.282189905857*std::sin(0.682479858398438*x_73 - 3.94495987892151) + 6.04607089054148*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 56.7237282373045*std::sin(0.197119995951653*x_75 + 1.8083997964859) - 647.780449917908*std::sin(0.277759969234467*x_75 - 7.51592016220093) - 0.0214918257840042*std::sin(0.420239865779877*x_75 + 8.41903972625732) - 0.00995631655721599*std::sin(0.723519861698151*x_78 - 4.04087972640991) + 8.67185559408019*std::sin(0.179360002279282*x_80 + 1.77199983596802) + 9.41126168289216*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 23.7442801265592*std::sin(0.23175998032093*x_80 + 5.05128002166748) + 0.158799669117522*std::sin(0.263199955224991*x_80 + 1.84135985374451) - 6681.49140353621*std::sin(0.289039850234985*x_80 - 1.3064798116684) - 1783.49160653847*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.125751594194025*std::sin(0.364479839801788*x_85 - 4.43111991882324) - 4.66772696640191*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 25.4158915212219*std::sin(0.249119967222214*x_87 + 1.84423983097076) - 28.1570787148667*std::sin(0.347199827432632*x_92 + 1.99871981143951) + 0.0186846509245081*std::sin(0.349439829587936*x_92 - 7.41207981109619) - 476.914324248002*std::sin(0.361599832773209*x_92 - 1.17927992343903) + 42.0059138304729*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 1.34088990323581*std::sin(0.272639960050583*x_96 + 5.06655979156494) + 27.1418978208447*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.0974478553281567*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.00630751829281094*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 4.15091131814178*std::sin(0.54943984746933*x_99 - 7.41207981109619) + 138315.830791089 - 0.0436859107729588*std::exp(-2.47855997085571*x_86) - 1.51260998814591*std::exp(-2.40647983551025*x_86) + 7.404139907446e-5*std::exp(-2.36967992782593*x_86) + 0.245712915554476*std::exp(-2.33151984214783*x_86) + 0.00771978846413229*std::exp(-2.33007979393005*x_86) + 0.132313244420731*std::exp(-2.11759996414185*x_23) - 0.00792506778955894*std::exp(-2.09047985076904*x_23) + 2.43242352169793*std::exp(-2.06727981567383*x_23));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.08114828217049*x_1 - 1324.29884266623*x_10 - 910.430167017115*x_100 - 8570.06907003953*x_101 + 1460.28529078361*x_102 - 1985.94241784066*x_103 - 2551.73078019428*x_104 + 439.433467633001*x_105 + 475.942532002771*x_106 - 6738.24312794561*x_107 - 223.95317078979*x_108 - 416.212426710235*x_109 + 1794.63149260345*x_11 - 768.079330542832*x_110 + 520.562355385173*x_111 - 814.987587383935*x_112 + 3209.0395007323*x_113 - 23.0264854773341*x_114 - 256.472495392883*x_115 + 817.798088121217*x_116 - 586.505570310775*x_117 + 1911.97474557764*x_118 + 206.060065195341*x_119 + 620.423853826508*x_12 - 983.215555200814*x_120 + 345.43462885421*x_13 - 775.155875987122*x_14 + 385.716345386709*x_15 - 145.106966524678*x_16 + 1276.97552596478*x_17 - 1491.88839236247*x_18 + 970.52480544704*x_19 + 1238.76664355094*x_2 - 1607.05719853376*x_20 - 510.62590113309*x_21 - 612.599301741333*x_22 + 777.969140504178*x_23 - 580.400835451434*x_24 - 38.0334264782329*x_25 + 540.529836534826*x_26 - 866.728664024152*x_27 - 15.1874321975465*x_28 + 677.870261724714*x_29 - 840.193867788454*x_3 + 4026.17541819401*x_30 - 41940.443193181*x_31 + 1555.15567646016*x_32 - 786.819948050714*x_33 - 87.3220271247871*x_34 - 714.130465543011*x_35 + 10.1897418982851*x_36 - 1615.76558370794*x_37 - 510.761714273259*x_38 + 550.44650072064*x_39 - 4229.31306450078*x_4 + 4160.7835349205*x_40 + 1190.8745195326*x_41 + 825.142035785528*x_42 - 2484.86397832498*x_43 - 865.581008474979*x_44 - 1850.39909397707*x_45 + 913.752566852341*x_46 - 172.00433117044*x_47 - 4850.50148301803*x_48 + 1858.04634645327*x_49 - 159.245752690316*x_5 + 6.53997151393429*x_50 + 1008.87159558237*x_51 + 426.62472030136*x_52 + 2112.02705654658*x_53 - 2384.47076132358*x_54 + 1580.82702136033*x_55 - 1319.01779747591*x_56 + 1790.15447384838*x_57 - 501.224449818918*x_58 - 791.770044576936*x_59 - 290.172994118083*x_6 - 2770.8396663354*x_60 + 1105.44443476053*x_61 - 4364.672912833*x_62 - 305.413458819515*x_63 - 4096.93868378942*x_64 - 1472.75320469556*x_65 - 2358.25180976026*x_66 - 2261.05341362657*x_67 + 279.285520529897*x_68 - 776.494969758754*x_69 + 148.463121571567*x_7 + 1055.72169043811*x_70 + 243.641321561391*x_71 - 3406.17577055839*x_72 + 5.82855827440568*x_73 - 544.237433308366*x_74 + 323.281060712399*x_75 + 948.378225764497*x_76 + 1177.55311225136*x_77 + 1329.1502847308*x_78 + 1347.01014083294*x_79 - 22115.0983685151*x_8 + 739.490072345965*x_80 + 478.070728973314*x_81 + 858.329015835709*x_82 + 2250.84492393364*x_83 - 4733.42718904615*x_84 - 1664.90919302325*x_85 - 2131.54698358962*x_86 - 781.737202449502*x_87 - 739.153958142716*x_88 - 2379.38850351378*x_89 + 7526.84667824556*x_9 - 5088.15803927273*x_90 + 2854.91474613279*x_91 + 729.524994043244*x_92 - 57520.3332731942*x_93 - 2250.69687909883*x_94 - 415.490905036828*x_95 + 1321.43721568568*x_96 + 1699.30735011799*x_97 - 414.77994878325*x_98 - 1903.70720644752*x_99 - 0.0467715821479414*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) + 2.30009748903529e-6*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 4.87553802426413e-6*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) + 0.364762920032656*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) + 0.034572618257579*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) + 0.679831444428035*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) - 0.0158065981378133*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) + 3.68869785533679e-6*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) + 4.43357536630239e-6*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) - 0.304016776354712*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) + 0.0206143819722918*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.00598269450107637*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.126595736129819*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.00857450749056065*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) - 0.0123845713648174*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) - 0.0376004437293442*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.016973841495451*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) - 0.101122957396258*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) + 514.370437159772*std::exp(0.50519984960556*x_1) - 0.504385295119211*std::exp(0.69599986076355*x_1) + 0.17524288361138*std::exp(0.843999862670898*x_1) + 63.620396821872*std::exp(0.92631983757019*x_1) + 0.0278538533976511*std::exp(0.954959809780121*x_1) - 6.90004531050336e-6*std::exp(1.04391980171204*x_1) - 0.00544990330246952*std::exp(1.06287980079651*x_1) - 3.7600735953911*std::exp(1.09599983692169*x_1) + 0.160109704415753*std::exp(1.10639989376068*x_1) + 0.00162640832395293*std::exp(1.12911987304688*x_1) - 9.91277769947198e-6*std::exp(1.14607977867126*x_1) + 0.0148327210397478*std::exp(1.15999984741211*x_1) - 0.00500149379503146*std::exp(1.06799972057343*x_108) - 0.651487334086352*std::exp(1.30215978622437*x_108) + 0.390723629157062*std::exp(1.4450398683548*x_108) - 0.0582176669379122*std::exp(1.48199987411499*x_108) - 0.0145027626899052*std::exp(1.49183988571167*x_108) + 0.0026067351475968*std::exp(2.85751986503601*x_17) + 0.000375994440418988*std::exp(3.06975984573364*x_17) + 4.2565734428458*std::exp(3.2435998916626*x_17) - 0.0262896594236304*std::exp(3.34063982963562*x_17) + 0.019277076290348*std::exp(3.72783994674683*x_17) - 0.00372686452561701*std::exp(3.84783983230591*x_17) + 1.01950098590579e-6*std::exp(4.00047969818115*x_17) - 7.08803979479484e-5*std::exp(4.29528045654297*x_17) - 2.50009502680485*std::exp(0.968399822711945*x_29) - 0.0475336694926007*std::exp(1.05535984039307*x_29) + 0.592415369989855*std::exp(1.22887980937958*x_29) + 0.811518247058063*std::exp(1.27927994728088*x_29) - 4.09390311972052*std::exp(1.3769599199295*x_29) + 0.00405952711636435*std::exp(1.50023984909058*x_29) + 0.000100523863604077*std::exp(1.51847982406616*x_29) + 0.00228589226824025*std::exp(2.48135995864868*x_29) + 3.36941437471287e-6*std::exp(2.79688000679016*x_29) + 0.00222499118724342*std::exp(3.16279983520508*x_29) - 270.946391311543*std::exp(1.2364798784256*x_38) - 0.393331182626673*std::exp(1.59431982040405*x_38) + 5.37720917702474e-5*std::exp(1.63711988925934*x_38) - 0.0561136286690051*std::exp(1.69327986240387*x_38) + 6.61100316321665e-6*std::exp(2.51567983627319*x_38) - 7.2916365537408e-5*std::exp(1.65847980976105*x_50) - 0.587336293837988*std::exp(1.70751988887787*x_50) + 0.38251517263918*std::exp(1.71991980075836*x_50) - 0.138742902436578*std::exp(1.87503981590271*x_50) - 1401.33995167671*std::exp(1.90279984474182*x_50) + 0.0576413303495041*std::exp(1.92735981941223*x_50) - 0.0140148559509024*std::exp(1.93935978412628*x_50) - 753.848060796505*std::exp(1.95463979244232*x_50) + 0.303028176183227*std::exp(1.95655977725983*x_50) + 0.0855559507737509*std::exp(1.98487973213196*x_50) - 2.09730288564851*std::exp(0.721999883651733*x_66) + 2.46403525142529*std::exp(0.787759840488434*x_71) + 1.28703116631108*std::exp(0.791999816894531*x_71) + 1.16132411267115*std::exp(1.15183985233307*x_71) + 0.00884255371023446*std::exp(1.16359984874725*x_71) - 0.538388241621966*std::exp(1.43479979038239*x_71) - 3.13938693880544e-5*std::exp(1.56895983219147*x_71) + 219.758146899778*std::exp(1.71743988990784*x_71) - 0.00342104094073072*std::exp(1.76351988315582*x_71) - 0.000240983585593905*std::exp(1.83151996135712*x_71) - 0.478009282505161*std::exp(1.83999979496002*x_71) - 0.0799287773954375*std::exp(1.9236798286438*x_71) + 0.301284885587718*std::exp(1.14375984668732*x_72) + 1539.90796821834*std::exp(0.821839869022369*x_73) - 2.36292466001107*std::exp(0.863199889659882*x_73) - 1.16844209031547*std::exp(0.740559816360474*x_76) + 0.000882655365863291*std::exp(0.98175984621048*x_76) + 0.69591178090814*std::exp(1.20527982711792*x_76) + 0.113968384509289*std::exp(1.75559985637665*x_76) + 8.83384875004168e-6*std::exp(2.1159999370575*x_76) - 0.0328971751702382*std::exp(1.01855981349945*x_77) + 0.725093515410101*std::exp(1.47807991504669*x_77) + 0.510573711080317*std::exp(1.27991986274719*x_78) - 0.00547508305412599*std::exp(1.7519998550415*x_78) + 0.69260475375741*std::exp(1.35511994361877*x_81) + 1.00628622807119*std::exp(0.975599825382233*x_88) + 14.4461729765406*std::sin(0.370799839496613*x_102 + 8.17463970184326) + 1.47212206247548*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.00265987051295076*std::sin(0.329119831323624*x_105 - 7.45895957946777) + 96.1026332012507*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 7.48796198516478*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 15.801125890931*std::sin(0.493919849395752*x_105 + 2.05367970466614) - 8.7462426460069*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 9.53889321722728*std::sin(0.409119844436646*x_111 + 2.01191973686218) + 1.30509883664487*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 5.7641105158061*std::sin(0.48431983590126*x_112 - 4.16656017303467) + 9.50476012851098*std::sin(0.452719867229462*x_117 - 7.37175989151001) - 81.6386085218825*std::sin(0.427359849214554*x_120 - 1.15639984607697) - 47.6494542706537*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 19.441396889374*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0587087158206592*std::sin(0.548159837722778*x_15 - 7.25176000595093) + 10.0599437507016*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 3.24911920707656*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 5.0355971540788*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 6.10357736778767*std::sin(0.489599853754044*x_19 - 1.11607992649078) + 15.6234203665877*std::sin(0.308639913797379*x_21 + 8.310959815979) - 2.31354508478695*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 43.0473290471549*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 9.61594950761958*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 20.5478117515305*std::sin(0.317279845476151*x_28 + 8.30079936981201) - 12.2109037643769*std::sin(0.321599841117859*x_28 + 8.31328010559082) - 8524.69869506398*std::sin(0.33519983291626*x_28 - 4.27343988418579) + 15.95671520115*std::sin(0.337279856204987*x_28 + 5.13632011413574) + 3719.16186356537*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 23.1131711064291*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 9.02168192322653*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 9.79218979325435*std::sin(0.377119839191437*x_34 + 1.99303984642029) - 20.6389099880778*std::sin(0.239039987325668*x_36 + 1.82855987548828) + 8945.82462707785*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 15.3290132896831*std::sin(0.320719838142395*x_36 + 5.12007999420166) - 1.27841319449589*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 14.6204424533546*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 14.6318206823901*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.00691801382627649*std::sin(0.357039839029312*x_36 + 5.15184020996094) + 5810.74315638188*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 0.554707397693776*std::sin(0.3711998462677*x_39 - 1.21975982189178) - 0.00240169153069729*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 6.2125520519744*std::sin(0.448239862918854*x_45 - 7.35192012786865) - 9592.6842662843*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 10.2093256239987*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 10.3807800000605*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 15.5480614759655*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.0732850471887918*std::sin(0.234399989247322*x_47 + 1.83199989795685) - 7.08128915905863*std::sin(0.497679859399796*x_49 - 4.12728023529053) - 154.923030727647*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 5.54416453094347*std::sin(0.438159853219986*x_53 - 7.36560010910034) - 11.8493124297998*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 11.2723230428948*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 9.05929841990913*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.0153797019241617*std::sin(0.264479964971542*x_68 - 4.31527996063232) + 0.00102399656541369*std::sin(0.433999866247177*x_69 + 8.42216014862061) + 0.000756445530405399*std::sin(0.576959848403931*x_70 + 1.96287977695465) - 0.00043520317188721*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.0627739847286358*std::sin(0.530719876289368*x_73 - 4.05000019073486) - 2361.78561997323*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 2.08879751644613*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 62.3822118525823*std::sin(0.197119995951653*x_75 + 1.8083997964859) - 10180.3051477644*std::sin(0.277759969234467*x_75 - 7.51592016220093) + 0.170373072850919*std::sin(0.420239865779877*x_75 + 8.41903972625732) + 0.0789271355154885*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 22.4982473306202*std::sin(0.179360002279282*x_80 + 1.77199983596802) + 49.8296017163564*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 26.1128941832838*std::sin(0.23175998032093*x_80 + 5.05128002166748) - 1.25885943182165*std::sin(0.263199955224991*x_80 + 1.84135985374451) - 12153.9101663704*std::sin(0.289039850234985*x_80 - 1.3064798116684) - 28028.76929265*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.123214543517406*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 12.1099428631635*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 17.0427573903257*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 9.7277119562064*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.011382097308083*std::sin(0.349439829587936*x_92 - 7.41207981109619) - 7495.02914266674*std::sin(0.361599832773209*x_92 - 1.17927992343903) + 14.9318751579208*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 0.894732734141528*std::sin(0.272639960050583*x_96 + 5.06655979156494) + 9.64815172086289*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.0954818353434404*std::sin(0.382559835910797*x_97 - 7.41663980484009) + 0.00143603605358455*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 4.56498606978565*std::sin(0.54943984746933*x_99 - 7.41207981109619) + 441013.817598089 + 0.45000940806884*std::exp(-2.47855997085571*x_86) - 23.7716825983758*std::exp(-2.40647983551025*x_86) - 0.000586951560340941*std::exp(-2.36967992782593*x_86) + 0.0448889927840574*std::exp(-2.33151984214783*x_86) + 0.0408737954021082*std::exp(-2.33007979393005*x_86) + 0.145512171023489*std::exp(-2.11759996414185*x_23) - 0.00528814301196362*std::exp(-2.09047985076904*x_23) + 38.2271704905924*std::exp(-2.06727981567383*x_23));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.01780087979275*x_1 - 1253.14937938909*x_10 - 1580.9819881834*x_100 + 15707.3790321303*x_101 + 2586.87931788277*x_102 - 3338.18187314997*x_103 - 4268.95861241148*x_104 + 1878.00688328938*x_105 + 1400.83782090755*x_106 - 10718.6055599588*x_107 - 225.903857557218*x_108 + 152.161455675281*x_109 + 2783.15141885511*x_11 - 598.17310854561*x_110 - 490.415728781832*x_111 - 608.391983486449*x_112 + 3792.69232107328*x_113 - 81.9076794535856*x_114 + 331.059845973492*x_115 + 2265.14225767128*x_116 - 176.246747203045*x_117 + 4184.47927535709*x_118 - 606.587538492221*x_119 - 463.072838805569*x_12 - 626.04713973321*x_120 + 503.25624622674*x_13 - 155.195442107518*x_14 + 1215.50545599602*x_15 - 1399.63154194202*x_16 + 2709.28037060261*x_17 - 1817.41993584601*x_18 + 2013.80118549763*x_19 + 1302.22918798864*x_2 - 3397.00889564513*x_20 - 1519.85678172073*x_21 - 878.087527175549*x_22 + 900.464160492724*x_23 - 833.130350169424*x_24 - 569.911374920768*x_25 + 904.425209335872*x_26 - 1070.76359777376*x_27 - 9.46867484632689*x_28 + 696.703904642994*x_29 - 868.694462916264*x_3 + 7387.1553064619*x_30 - 50403.338440069*x_31 + 2599.49006785608*x_32 - 299.906143940714*x_33 - 1231.56423100701*x_34 - 1188.833335829*x_35 + 17.4348915934934*x_36 - 1155.42341511304*x_37 - 1050.05345050571*x_38 - 52.2565411343675*x_39 - 6162.39008407158*x_4 + 7008.18572695604*x_40 + 2447.21478135848*x_41 + 1033.84283395669*x_42 - 3888.8683757024*x_43 - 1158.31306278762*x_44 - 2713.45911210685*x_45 + 1023.9912223301*x_46 + 358.39939923417*x_47 - 10980.0394694799*x_48 + 3545.16586448118*x_49 - 372.044269908493*x_5 + 4.77830303339225*x_50 + 855.579926640561*x_51 + 382.268793144816*x_52 + 3478.6121127786*x_53 - 2147.58291771208*x_54 + 2291.59033592013*x_55 - 1862.65791025934*x_56 + 2755.30777102188*x_57 - 488.796674546144*x_58 - 2307.04276351831*x_59 + 70.5611313453169*x_6 - 4344.50480490325*x_60 + 939.144426426328*x_61 - 8542.61226331301*x_62 + 587.494118126193*x_63 - 5978.69738495653*x_64 - 1963.80291014406*x_65 - 3448.6909554394*x_66 - 3479.15975495613*x_67 + 847.335077168913*x_68 - 839.06588843973*x_69 + 1168.45093842781*x_7 + 264.170487108115*x_70 + 260.949716140357*x_71 - 3989.19173644422*x_72 + 0.718241623037823*x_73 - 1327.48685576363*x_74 + 358.277074381638*x_75 + 1116.39483255114*x_76 + 1067.68474030304*x_77 + 1057.7776237093*x_78 + 1630.86452972373*x_79 - 33195.4988109629*x_8 + 1584.23477228734*x_80 + 505.754620723402*x_81 + 230.420646885125*x_82 + 4383.42655253878*x_83 - 7820.26579944231*x_84 - 1895.76592358027*x_85 - 2406.59127048609*x_86 - 1552.05098530756*x_87 - 409.1615935358*x_88 - 2377.26149716184*x_89 + 10012.8414647959*x_9 - 6616.96436547765*x_90 + 3416.64426047777*x_91 + 807.029771185959*x_92 - 90061.7196304187*x_93 - 3551.19614334648*x_94 + 877.338138141068*x_95 + 1336.37111862545*x_96 + 2306.10185894457*x_97 - 80.9836561683626*x_98 - 2475.48223048674*x_99 - 0.197125872036018*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) + 1.28587123399455e-6*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 1.38622874396153e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) + 0.137647985479493*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) - 0.178500263217681*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) + 0.588158004924133*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) - 0.0136751209458919*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) + 2.06216931485993e-6*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) + 2.47859364850931e-6*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) - 0.114724645842425*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) - 0.106433148357725*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.0121176792779306*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.256413983381349*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.00975152538884395*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) - 0.010714545267761*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) + 0.194133086848816*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.0193038313245769*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) - 0.0381600502871217*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) + 580.185322269234*std::exp(0.50519984960556*x_1) - 2.12580773573201*std::exp(0.69599986076355*x_1) - 0.47348923181899*std::exp(0.843999862670898*x_1) + 134.519399659644*std::exp(0.92631983757019*x_1) + 0.024097836277042*std::exp(0.954959809780121*x_1) - 3.85747552889882e-6*std::exp(1.04391980171204*x_1) - 0.00619800851294155*std::exp(1.06287980079651*x_1) - 1.41891219538949*std::exp(1.09599983692169*x_1) - 0.826654902703291*std::exp(1.10639989376068*x_1) + 0.000596896364969102*std::exp(1.12911987304688*x_1) - 2.81843302444203e-5*std::exp(1.14607977867126*x_1) + 0.00568331372426125*std::exp(1.15999984741211*x_1) + 0.010128222749359*std::exp(1.06799972057343*x_108) + 1.76025542948962*std::exp(1.30215978622437*x_108) + 0.338035599978873*std::exp(1.4450398683548*x_108) - 0.0662091738620887*std::exp(1.48199987411499*x_108) + 0.041144365095917*std::exp(1.49183988571167*x_108) - 0.00739531252867678*std::exp(2.85751986503601*x_17) - 0.000761403612830063*std::exp(3.06975984573364*x_17) + 4.80121184323246*std::exp(3.2435998916626*x_17) + 0.135734907089152*std::exp(3.34063982963562*x_17) + 0.00727445299830184*std::exp(3.72783994674683*x_17) - 0.0157074314323722*std::exp(3.84783983230591*x_17) + 2.89867818510764e-6*std::exp(4.00047969818115*x_17) - 2.60133026003366e-5*std::exp(4.29528045654297*x_17) - 0.957937814627629*std::exp(0.968399822711945*x_29) + 0.134853109974249*std::exp(1.05535984039307*x_29) + 1.19991075117777*std::exp(1.22887980937958*x_29) + 3.4202657848619*std::exp(1.27927994728088*x_29) - 1.54488706562413*std::exp(1.3769599199295*x_29) - 0.0082207029692701*std::exp(1.50023984909058*x_29) + 5.61979416762411e-5*std::exp(1.51847982406616*x_29) + 0.000838928801291028*std::exp(2.48135995864868*x_29) + 9.58002795445147e-6*std::exp(2.79688000679016*x_29) + 0.00192495711751591*std::exp(3.16279983520508*x_29) - 305.614607691664*std::exp(1.2364798784256*x_38) - 0.150708996846346*std::exp(1.59431982040405*x_38) + 3.00613284126824e-5*std::exp(1.63711988925934*x_38) - 0.236499333067137*std::exp(1.69327986240387*x_38) + 1.87966180668947e-5*std::exp(2.51567983627319*x_38) - 0.000207318169420731*std::exp(1.65847980976105*x_50) + 1.58692555644926*std::exp(1.70751988887787*x_50) + 0.774767319332436*std::exp(1.71991980075836*x_50) - 0.584752842978659*std::exp(1.87503981590271*x_50) - 1580.64463417007*std::exp(1.90279984474182*x_50) + 0.0211545280793816*std::exp(1.92735981941223*x_50) + 0.0283806376030955*std::exp(1.93935978412628*x_50) - 1593.94146592418*std::exp(1.95463979244232*x_50) + 0.262165642675848*std::exp(1.95655977725983*x_50) - 0.441729915251809*std::exp(1.98487973213196*x_50) - 4.24799289223187*std::exp(0.721999883651733*x_66) + 2.1317667333854*std::exp(0.787759840488434*x_71) + 2.60682388031893*std::exp(0.791999816894531*x_71) - 3.13778483137118*std::exp(1.15183985233307*x_71) - 0.0179065209956663*std::exp(1.16359984874725*x_71) + 2.77972706975289*std::exp(1.43479979038239*x_71) - 1.75507663315665e-5*std::exp(1.56895983219147*x_71) + 464.658120162981*std::exp(1.71743988990784*x_71) + 0.00970549959915428*std::exp(1.76351988315582*x_71) - 0.000685172326645129*std::exp(1.83151996135712*x_71) - 0.183154305154521*std::exp(1.83999979496002*x_71) - 0.0909005564376621*std::exp(1.9236798286438*x_71) + 0.342642095107841*std::exp(1.14375984668732*x_72) + 1736.94274838001*std::exp(0.821839869022369*x_73) + 12.1999054463589*std::exp(0.863199889659882*x_73) - 1.01088082103575*std::exp(0.740559816360474*x_76) + 0.00250959429109621*std::exp(0.98175984621048*x_76) + 0.266645948825689*std::exp(1.20527982711792*x_76) + 0.480336908635419*std::exp(1.75559985637665*x_76) + 4.93856979857909e-6*std::exp(2.1159999370575*x_76) + 0.0933293479849022*std::exp(1.01855981349945*x_77) + 0.277827238607133*std::exp(1.47807991504669*x_77) + 1.03414414316174*std::exp(1.27991986274719*x_78) + 0.0110872597299863*std::exp(1.7519998550415*x_78) + 0.599208867888798*std::exp(1.35511994361877*x_81) + 0.870591240131482*std::exp(0.975599825382233*x_88) - 39.0321547125141*std::sin(0.370799839496613*x_102 + 8.17463970184326) + 0.540272879166515*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.00756262989216363*std::sin(0.329119831323624*x_105 - 7.45895957946777) + 36.2655662978091*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 8.51583038319304*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 6.05436827093693*std::sin(0.493919849395752*x_105 + 2.05367970466614) + 45.1573150418161*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 40.203101057319*std::sin(0.409119844436646*x_111 + 2.01191973686218) + 0.478974892126334*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 24.2937112613855*std::sin(0.48431983590126*x_112 - 4.16656017303467) + 8.22306882137641*std::sin(0.452719867229462*x_117 - 7.37175989151001) - 30.8073803098736*std::sin(0.427359849214554*x_120 - 1.15639984607697) - 17.9811352232992*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 7.44917655122758*std::sin(0.435839861631393*x_14 - 1.17343986034393) + 0.118887471529236*std::sin(0.548159837722778*x_15 - 7.25176000595093) - 51.9400235781*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 13.6939018872196*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 5.72683078882925*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 6.94141205547691*std::sin(0.489599853754044*x_19 - 1.11607992649078) + 13.5166442038207*std::sin(0.308639913797379*x_21 + 8.310959815979) - 2.63112413831013*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 16.4940387748737*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 19.4766742753027*std::sin(0.299919933080673*x_28 + 5.10191965103149) + 55.5181893911816*std::sin(0.317279845476151*x_28 + 8.30079936981201) - 10.5642962755553*std::sin(0.321599841117859*x_28 + 8.31328010559082) - 9615.45357651947*std::sin(0.33519983291626*x_28 - 4.27343988418579) - 82.3853675840838*std::sin(0.337279856204987*x_28 + 5.13632011413574) + 7863.82113466886*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 8.85605562245512*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 38.0232362190015*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 19.8336410662342*std::sin(0.377119839191437*x_34 + 1.99303984642029) - 17.8558085565011*std::sin(0.239039987325668*x_36 + 1.82855987548828) + 18915.1124232105*std::sin(0.31535992026329*x_36 + 1.90343987941742) - 41.4175033958629*std::sin(0.320719838142395*x_36 + 5.12007999420166) - 0.469181187457586*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 29.6130501932394*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 61.6680103394309*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.0196695207162396*std::sin(0.357039839029312*x_36 + 5.15184020996094) + 6554.24116017379*std::sin(0.41967985033989*x_36 - 4.19840002059937) - 1.57370593314645*std::sin(0.3711998462677*x_39 - 1.21975982189178) - 0.00134266745952028*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 7.06534563425774*std::sin(0.448239862918854*x_45 - 7.35192012786865) - 20282.836843002*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 11.6107541027863*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 3.97750549509986*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 65.5296450572225*std::sin(0.406079858541489*x_46 - 7.39928007125854) + 0.148405119059175*std::sin(0.234399989247322*x_47 + 1.83199989795685) - 6.12639638577898*std::sin(0.497679859399796*x_49 - 4.12728023529053) - 58.4622008238363*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 6.30520892808601*std::sin(0.438159853219986*x_53 - 7.36560010910034) + 61.1786290500036*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 4.31910962811984*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 18.3492024731953*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.0437280660610811*std::sin(0.264479964971542*x_68 - 4.31527996063232) + 0.000572466051309392*std::sin(0.433999866247177*x_69 + 8.42216014862061) + 0.000422891443631817*std::sin(0.576959848403931*x_70 + 1.96287977695465) - 0.000243300661098353*std::sin(0.594559848308563*x_72 - 4.00647974014282) + 0.127119801853615*std::sin(0.530719876289368*x_73 - 4.05000019073486) - 4993.77557504254*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 8.80355149487358*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 23.9024033298736*std::sin(0.197119995951653*x_75 + 1.8083997964859) - 21525.3064306327*std::sin(0.277759969234467*x_75 - 7.51592016220093) + 0.0625273901858565*std::sin(0.420239865779877*x_75 + 8.41903972625732) + 0.0289664776014651*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 25.5865692916537*std::sin(0.179360002279282*x_80 + 1.77199983596802) - 257.27287867334*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 10.0054312013517*std::sin(0.23175998032093*x_80 + 5.05128002166748) - 0.462004902332976*std::sin(0.263199955224991*x_80 + 1.84135985374451) - 13709.0310353831*std::sin(0.289039850234985*x_80 - 1.3064798116684) - 59264.2203883538*std::sin(0.180560007691383*x_85 + 1.76799988746643) - 0.249514323889514*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 13.7722680186109*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 34.5193404126507*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 40.9989060497665*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.0323619472897317*std::sin(0.349439829587936*x_92 - 7.41207981109619) - 15847.5405855445*std::sin(0.361599832773209*x_92 - 1.17927992343903) + 12.9183520042204*std::sin(0.381679862737656*x_95 + 2.00063967704773) + 2.53835845375939*std::sin(0.272639960050583*x_96 + 5.06655979156494) + 8.34712444365136*std::sin(0.459359854459763*x_96 - 7.34767961502075) + 0.193354492979012*std::sin(0.382559835910797*x_97 - 7.41663980484009) + 0.000802817037576053*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 1.74912262638463*std::sin(0.54943984746933*x_99 - 7.41207981109619) + 708807.930129056 + 0.169816845588222*std::exp(-2.47855997085571*x_86) - 50.2630073337387*std::exp(-2.40647983551025*x_86) - 0.000215412850279159*std::exp(-2.36967992782593*x_86) - 0.121285693732281*std::exp(-2.33151984214783*x_86) - 0.211033575288517*std::exp(-2.33007979393005*x_86) + 0.0557545251750317*std::exp(-2.11759996414185*x_23) + 0.0150024716956239*std::exp(-2.09047985076904*x_23) + 80.8277892305363*std::exp(-2.06727981567383*x_23));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.418054937075557*x_1 - 1506.41436587332*x_10 - 403.40479364545*x_100 - 28791.2885398832*x_101 + 689.304936134017*x_102 - 1057.48778929509*x_103 - 1313.58113865021*x_104 - 654.041995974783*x_105 - 166.034454914851*x_106 - 3738.61969392904*x_107 - 234.33813736727*x_108 - 888.366248979048*x_109 + 1141.64149035524*x_11 - 911.525128324045*x_110 + 1352.89926214348*x_111 - 1045.55384245398*x_112 + 2882.75901233733*x_113 + 69.2177240240945*x_114 - 633.414896234802*x_115 - 358.258320129434*x_116 - 950.044354780602*x_117 + 240.707336716904*x_118 + 815.997489960139*x_119 + 1574.42605273154*x_12 - 1297.03058565461*x_120 + 251.229855843294*x_13 - 1316.05940673819*x_14 - 257.324532547961*x_15 + 877.78665498178*x_16 + 229.348127156215*x_17 - 1296.68916073077*x_18 + 207.20508880795*x_19 + 1283.54529471499*x_2 - 365.367206564217*x_20 + 268.79911379926*x_21 - 444.210548448873*x_22 + 767.6828062558*x_23 - 342.5947114512*x_24 + 322.132467433836*x_25 + 255.715699078572*x_26 - 752.448321628122*x_27 + 12.4288429309227*x_28 + 708.167551009618*x_29 - 863.751448922241*x_3 + 1495.61460613479*x_30 - 37977.4822281135*x_31 + 733.09882188817*x_32 - 1161.34027312067*x_33 + 808.046829286281*x_34 - 480.974826627215*x_35 - 6.19257425261303*x_36 - 2008.91848563465*x_37 - 70.368369772551*x_38 + 876.129766922735*x_39 - 3076.89362251852*x_4 + 2134.94353623361*x_40 + 191.591613511452*x_41 + 641.723289251018*x_42 - 1535.71991015427*x_43 - 707.95812470639*x_44 - 1248.73580559277*x_45 + 852.368927261761*x_46 - 626.531142643089*x_47 - 571.766601715734*x_48 + 549.636387557461*x_49 - 3.54520614206566*x_5 - 3.45974375812893*x_50 + 1164.92093051813*x_51 + 486.561545701249*x_52 + 1151.01706865973*x_53 - 2816.63950161348*x_54 + 1113.27429002411*x_55 - 944.217994939961*x_56 + 1165.50298504869*x_57 - 492.770972239034*x_58 + 357.905024143071*x_59 - 562.955362571112*x_6 - 1672.90504648928*x_60 + 1243.82180168811*x_61 - 1396.86089076163*x_62 - 999.565291291922*x_63 - 2822.17390534351*x_64 - 1205.44011873407*x_65 - 1691.73481645*x_66 - 1370.88960654496*x_67 - 209.702803412207*x_68 - 800.406976790939*x_69 - 590.006407473617*x_7 + 1792.57331747762*x_70 + 198.279582081336*x_71 - 3258.90083021434*x_72 - 5.39051965761372*x_73 + 31.9977388821637*x_74 + 291.659896957325*x_75 + 865.567700467379*x_76 + 1327.05401271488*x_77 + 1626.93530786605*x_78 + 1252.40956408829*x_79 - 13237.4428324462*x_8 + 139.777916310599*x_80 + 487.722165809154*x_81 + 1381.8862125509*x_82 + 644.424967964124*x_83 - 2520.12066621622*x_84 - 1601.69391599276*x_85 - 2013.3705255459*x_86 - 201.788628452581*x_87 - 994.709942075585*x_88 - 2497.71054818286*x_89 + 6524.62244697698*x_9 - 4128.38015098733*x_90 + 2520.04313016999*x_91 + 653.164917565512*x_92 - 35436.949559955*x_93 - 1309.32318848443*x_94 - 1374.7927198763*x_95 + 1432.07913361221*x_96 + 1270.65934432312*x_97 - 670.168023758231*x_98 - 1560.69290634062*x_99 - 0.0657187098686654*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 1.981285339565e-6*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) - 1.48463719931464e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.3540025594384*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) - 0.0929771050250143*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) - 1.32505233965459*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) + 0.0308084746831779*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 3.17741444338906e-6*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 3.81904589565711e-6*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.295048402760194*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) - 0.0554388314874985*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) + 0.000922934837573934*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) + 0.0195295974316433*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.00352718997743044*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) + 0.0241386381831411*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) + 0.101119920382194*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.00698232098661717*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.0981398705028758*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) + 488.083383436685*std::exp(0.50519984960556*x_1) - 0.708711344574851*std::exp(0.69599986076355*x_1) - 0.991206236835555*std::exp(0.843999862670898*x_1) + 10.7630471583301*std::exp(0.92631983757019*x_1) - 0.054289653583184*std::exp(0.954959809780121*x_1) + 5.94364312000029e-6*std::exp(1.04391980171204*x_1) - 0.0022418598768031*std::exp(1.06287980079651*x_1) + 3.64915292466139*std::exp(1.09599983692169*x_1) - 0.430587486665811*std::exp(1.10639989376068*x_1) - 0.00126142513913492*std::exp(1.12911987304688*x_1) + 3.01851374103353e-5*std::exp(1.14607977867126*x_1) - 0.0165463382726778*std::exp(1.15999984741211*x_1) + 0.00275514309970475*std::exp(1.06799972057343*x_108) + 3.6849331365592*std::exp(1.30215978622437*x_108) - 0.761555328480697*std::exp(1.4450398683548*x_108) - 0.0239482875907268*std::exp(1.48199987411499*x_108) - 0.0185023959443672*std::exp(1.49183988571167*x_108) + 0.003325631595455*std::exp(2.85751986503601*x_17) - 0.000207121818100988*std::exp(3.06975984573364*x_17) + 4.03903999479969*std::exp(3.2435998916626*x_17) + 0.0707015131770326*std::exp(3.34063982963562*x_17) - 0.0187084102316692*std::exp(3.72783994674683*x_17) - 0.00523661414112813*std::exp(3.84783983230591*x_17) - 3.10445551010166e-6*std::exp(4.00047969818115*x_17) + 5.49740889336576e-5*std::exp(4.29528045654297*x_17) + 2.7889298205298*std::exp(0.968399822711945*x_29) - 0.0606427059758046*std::exp(1.05535984039307*x_29) - 0.0913903899287385*std::exp(1.22887980937958*x_29) + 1.14026359131587*std::exp(1.27927994728088*x_29) + 3.97313461122683*std::exp(1.3769599199295*x_29) - 0.00223624752545459*std::exp(1.50023984909058*x_29) - 8.65904415724238e-5*std::exp(1.51847982406616*x_29) - 0.00177291392945173*std::exp(2.48135995864868*x_29) - 1.02601146698251e-5*std::exp(2.79688000679016*x_29) - 0.00433670699190471*std::exp(3.16279983520508*x_29) - 257.099595636793*std::exp(1.2364798784256*x_38) + 0.438772547767405*std::exp(1.59431982040405*x_38) - 4.63188441403061e-5*std::exp(1.63711988925934*x_38) - 0.0788452114044786*std::exp(1.69327986240387*x_38) - 2.01309910250974e-5*std::exp(2.51567983627319*x_38) + 0.000222035697756658*std::exp(1.65847980976105*x_50) + 3.32208296037357*std::exp(1.70751988887787*x_50) - 0.0590096282980504*std::exp(1.71991980075836*x_50) - 0.194947532942658*std::exp(1.87503981590271*x_50) - 1329.72405789122*std::exp(1.90279984474182*x_50) - 0.0447060077627526*std::exp(1.92735981941223*x_50) + 0.00772028023004714*std::exp(1.93935978412628*x_50) - 127.533033962137*std::exp(1.95463979244232*x_50) - 0.590629040659731*std::exp(1.95655977725983*x_50) - 0.230088000895395*std::exp(1.98487973213196*x_50) + 0.323545502408839*std::exp(0.721999883651733*x_66) - 4.80262527079695*std::exp(0.787759840488434*x_71) - 0.198546975818036*std::exp(0.791999816894531*x_71) - 6.56866447153355*std::exp(1.15183985233307*x_71) - 0.00487104489917054*std::exp(1.16359984874725*x_71) + 1.44790249071011*std::exp(1.43479979038239*x_71) + 2.70424247090756e-5*std::exp(1.56895983219147*x_71) + 37.1778142964425*std::exp(1.71743988990784*x_71) - 0.00436451008547147*std::exp(1.76351988315582*x_71) + 0.000733812748083194*std::exp(1.83151996135712*x_71) + 0.533233468398383*std::exp(1.83999979496002*x_71) - 0.0328793208062172*std::exp(1.9236798286438*x_71) + 0.123935868032788*std::exp(1.14375984668732*x_72) + 1461.21051485635*std::exp(0.821839869022369*x_73) + 6.35467908861323*std::exp(0.863199889659882*x_73) + 2.27739822600587*std::exp(0.740559816360474*x_76) - 0.00268775052889287*std::exp(0.98175984621048*x_76) - 0.776310139184247*std::exp(1.20527982711792*x_76) + 0.160136879100552*std::exp(1.75559985637665*x_76) - 7.60940573337745e-6*std::exp(2.1159999370575*x_76) - 0.0419696973235748*std::exp(1.01855981349945*x_77) - 0.80886322564485*std::exp(1.47807991504669*x_77) - 0.0787648884663345*std::exp(1.27991986274719*x_78) + 0.00301602639432861*std::exp(1.7519998550415*x_78) - 1.34994866292817*std::exp(1.35511994361877*x_81) - 1.96134193526417*std::exp(0.975599825382233*x_88) - 81.7102324366366*std::sin(0.370799839496613*x_102 + 8.17463970184326) - 1.14176234229324*std::sin(0.199760004878044*x_104 - 7.60799980163574) + 0.00809950140729922*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 93.2676438684248*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 3.08023107968927*std::sin(0.427519857883453*x_105 + 2.02951979637146) - 17.6266224774195*std::sin(0.493919849395752*x_105 + 2.05367970466614) + 23.5215139048306*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 13.4030906593724*std::sin(0.409119844436646*x_111 + 2.01191973686218) - 1.01222089026102*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 8.09914673061489*std::sin(0.48431983590126*x_112 - 4.16656017303467) - 18.5256283000195*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 79.2303021457022*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 46.2438143826249*std::sin(0.243999853730202*x_14 - 1.34103989601135) - 21.6874522592948*std::sin(0.435839861631393*x_14 - 1.17343986034393) + 0.0323405206353553*std::sin(0.548159837722778*x_15 - 7.25176000595093) - 27.0544868683666*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 4.56533460474291*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 2.07143183813146*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 2.51075375954034*std::sin(0.489599853754044*x_19 - 1.11607992649078) - 30.4514448100755*std::sin(0.308639913797379*x_21 + 8.310959815979) - 0.951694665189503*std::sin(0.407759845256805*x_21 - 7.39471960067749) - 48.0205665731042*std::sin(0.254479974508286*x_26 + 5.05503988265991) - 1.48342770892569*std::sin(0.299919933080673*x_28 + 5.10191965103149) + 116.2222324908*std::sin(0.317279845476151*x_28 + 8.30079936981201) + 23.8001444841927*std::sin(0.321599841117859*x_28 + 8.31328010559082) - 8089.04144032818*std::sin(0.33519983291626*x_28 - 4.27343988418579) - 42.9128385376579*std::sin(0.337279856204987*x_28 + 5.13632011413574) + 629.193097287554*std::sin(0.339599847793579*x_28 - 7.44679975509644) + 25.7834248117*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 12.676357514795*std::sin(0.36287984251976*x_3 + 5.1689600944519) - 1.51061584286217*std::sin(0.377119839191437*x_34 + 1.99303984642029) + 40.2270830391371*std::sin(0.239039987325668*x_36 + 1.82855987548828) + 1513.4192356733*std::sin(0.31535992026329*x_36 + 1.90343987941742) - 86.7037409117497*std::sin(0.320719838142395*x_36 + 5.12007999420166) + 0.99152378771616*std::sin(0.338559836149216*x_36 - 1.2196798324585) - 2.25545791758516*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 20.559158662514*std::sin(0.352879852056503*x_36 + 1.94455981254578) - 0.0210658610818922*std::sin(0.357039839029312*x_36 + 5.15184020996094) + 5513.78340425012*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 0.707686950745171*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.00206879762384496*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 2.55558133876634*std::sin(0.448239862918854*x_45 - 7.35192012786865) - 1622.85239153827*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 4.19968506143756*std::sin(0.366639852523804*x_46 - 4.23992013931274) + 11.5800665943198*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 21.8465678139162*std::sin(0.406079858541489*x_46 - 7.39928007125854) + 0.0403700974845389*std::sin(0.234399989247322*x_47 + 1.83199989795685) + 13.8020664458609*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 150.352863138147*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 2.28063496221758*std::sin(0.438159853219986*x_53 - 7.36560010910034) + 31.8666858856774*std::sin(0.430799871683121*x_55 + 5.22815990447998) + 12.5746091824167*std::sin(0.524799883365631*x_55 - 4.24552011489868) + 1.39755458250598*std::sin(0.488879859447479*x_58 + 2.04247975349426) + 0.0468323238939928*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.000882062344092203*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.000651596050478839*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.000374880485850175*std::sin(0.594559848308563*x_72 - 4.00647974014282) + 0.0345799311073592*std::sin(0.530719876289368*x_73 - 4.05000019073486) - 399.557551909179*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 2.93496759471401*std::sin(0.779519855976105*x_73 - 0.783679842948914) - 69.589199226808*std::sin(0.197119995951653*x_75 + 1.8083997964859) - 1722.26376862065*std::sin(0.277759969234467*x_75 - 7.51592016220093) - 0.132139558043749*std::sin(0.420239865779877*x_75 + 8.41903972625732) - 0.0612150537062961*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 9.25482805650056*std::sin(0.179360002279282*x_80 + 1.77199983596802) - 134.008135502455*std::sin(0.206720009446144*x_80 - 4.40223979949951) + 29.1297044741428*std::sin(0.23175998032093*x_80 + 5.05128002166748) + 0.976358095657955*std::sin(0.263199955224991*x_80 + 1.84135985374451) - 11532.7809831827*std::sin(0.289039850234985*x_80 - 1.3064798116684) - 4741.79635394908*std::sin(0.180560007691383*x_85 + 1.76799988746643) - 0.0678744617643009*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 4.98151866346002*std::sin(0.331359833478928*x_86 - 4.28560018539429) + 2.62914219019913*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 13.668399707193*std::sin(0.347199827432632*x_92 + 1.99871981143951) + 0.0346593237212003*std::sin(0.349439829587936*x_92 - 7.41207981109619) - 1267.97939254361*std::sin(0.361599832773209*x_92 - 1.17927992343903) - 29.103561295373*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 1.14148591309406*std::sin(0.272639960050583*x_96 + 5.06655979156494) - 18.8051113490753*std::sin(0.459359854459763*x_96 - 7.34767961502075) + 0.0525975099789103*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.00123698982048243*std::sin(0.527519822120667*x_98 + 5.16128015518188) - 5.09237674721479*std::sin(0.54943984746933*x_99 - 7.41207981109619) + 250409.981062731 - 0.436734310092338*std::exp(-2.47855997085571*x_86) - 4.02159926093408*std::exp(-2.40647983551025*x_86) + 0.000455233438469513*std::exp(-2.36967992782593*x_86) - 0.253900464862783*std::exp(-2.33151984214783*x_86) - 0.109923036188897*std::exp(-2.33007979393005*x_86) - 0.162323123187876*std::exp(-2.11759996414185*x_23) - 0.00674652946544417*std::exp(-2.09047985076904*x_23) + 6.46712154078111*std::exp(-2.06727981567383*x_23));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.575458167580417*x_1 + 100.54689440123*x_10 + 449.695955836836*x_100 - 9719.19020964276*x_101 - 711.814149312886*x_102 + 899.563378209088*x_103 + 1181.3170828802*x_104 - 753.753746273688*x_105 - 443.428145412733*x_106 + 2909.71465390209*x_107 + 18.3987252936815*x_108 - 240.516644848668*x_109 - 722.558645299934*x_11 + 75.4429598010068*x_110 + 459.954469597379*x_111 + 20.11050814987*x_112 - 763.618144079682*x_113 + 41.3333508055406*x_114 - 220.701539392906*x_115 - 924.892836027491*x_116 - 98.1375814109738*x_117 - 1372.06030585616*x_118 + 343.514578998814*x_119 + 481.842099749853*x_12 - 50.2168013077981*x_120 - 127.155180722989*x_13 - 189.329477316436*x_14 - 456.459361137197*x_15 + 619.635036542438*x_16 - 870.342188511125*x_17 + 383.427016628851*x_18 - 627.833090760975*x_19 - 226.49689682719*x_2 + 1033.13873862031*x_20 + 546.147881349496*x_21 + 246.073033196942*x_22 - 172.987939745332*x_23 + 205.065586733313*x_24 + 263.673461703512*x_25 - 244.637653512963*x_26 + 214.274683367064*x_27 + 28.6175511551843*x_28 - 102.932506653257*x_29 + 170.676033786233*x_3 - 2272.36777556459*x_30 + 9457.35721382266*x_31 - 817.088193991457*x_32 - 7.87222561553141*x_33 + 577.409250843909*x_34 + 292.889170373238*x_35 - 40.1780370256573*x_36 + 32.2363948951878*x_37 + 376.313224033278*x_38 + 64.675702257816*x_39 + 1480.89112593238*x_4 - 1926.66482901368*x_40 - 773.010093017164*x_41 - 209.1180157872*x_42 + 1000.89285793582*x_43 + 238.478968434427*x_44 + 657.292308385905*x_45 - 197.987020777845*x_46 - 271.618502941214*x_47 + 3520.73139962588*x_48 - 1165.31736174338*x_49 + 125.638929198584*x_5 + 29.3265839450468*x_50 - 74.2565629540472*x_51 - 36.1107650804404*x_52 - 948.575062511337*x_53 + 173.236070294*x_54 - 545.507515971724*x_55 + 450.945015852475*x_56 - 699.173291743429*x_57 + 104.271008940419*x_58 + 851.563473040608*x_59 - 111.258494934762*x_6 + 1143.31874744509*x_60 - 111.183139745977*x_61 + 2494.71254622083*x_62 - 413.363872570642*x_63 + 1512.48434396841*x_64 + 417.160401073167*x_65 + 803.545923793838*x_66 + 933.458390969867*x_67 - 321.053950881039*x_68 + 73.6968453732937*x_69 - 457.032660138086*x_7 + 269.445251307068*x_70 - 81.3424035590982*x_71 + 660.435594974873*x_72 - 12.6942131731921*x_73 + 456.992052047348*x_74 - 74.0001848613432*x_75 - 209.83831414318*x_76 - 105.818421116173*x_77 - 36.9266100952335*x_78 - 292.682702816698*x_79 + 9148.42033770106*x_8 - 486.008523398181*x_80 - 18.7522035416135*x_81 + 165.555501576089*x_82 - 1329.80962686073*x_83 + 2111.95767995094*x_84 + 350.544105208965*x_85 + 419.938402875978*x_86 + 460.999598394947*x_87 - 57.0966261024002*x_88 + 331.72030168862*x_89 - 2113.16590083866*x_9 + 1337.53835901334*x_90 - 766.340338363495*x_91 - 177.252212312017*x_92 + 23044.8748476814*x_93 + 933.871795994276*x_94 - 557.404675116117*x_95 - 156.085217018372*x_96 - 537.922795216425*x_97 - 98.0585131289904*x_98 + 507.974280991411*x_99 - 0.0544139953446348*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 3.62593793425143e-6*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 2.22171516929676e-6*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.762943774671047*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) + 0.162956899589368*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) - 0.0519568976743751*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) + 0.00120803738743989*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 5.81496634182549e-6*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 6.9892120580424e-6*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.635886199437765*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) + 0.0971652117328205*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.00576909094419622*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.12207581629799*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) + 0.013464142533072*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) + 0.000946505067420323*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) - 0.177228455411393*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) + 0.0266532184478367*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.211510344348854*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) - 102.461349512198*std::exp(0.50519984960556*x_1) - 0.586801169430336*std::exp(0.69599986076355*x_1) + 0.570939125249573*std::exp(0.843999862670898*x_1) - 42.9202193120993*std::exp(0.92631983757019*x_1) - 0.00212876268475104*std::exp(0.954959809780121*x_1) + 1.08774241781818e-5*std::exp(1.04391980171204*x_1) + 0.00855772473657395*std::exp(1.06287980079651*x_1) + 7.86462818548494*std::exp(1.09599983692169*x_1) + 0.754671828189977*std::exp(1.10639989376068*x_1) - 0.000372153430512652*std::exp(1.12911987304688*x_1) - 4.51711554195242e-6*std::exp(1.14607977867126*x_1) + 0.012430567026693*std::exp(1.15999984741211*x_1) - 0.00646523277045867*std::exp(1.06799972057343*x_108) - 2.12253759450397*std::exp(1.30215978622437*x_108) - 0.0298615013845876*std::exp(1.4450398683548*x_108) + 0.0914164418723613*std::exp(1.48199987411499*x_108) - 0.0529715345387042*std::exp(1.49183988571167*x_108) + 0.00952113496280902*std::exp(2.85751986503601*x_17) + 0.000486033108772819*std::exp(3.06975984573364*x_17) - 0.847899155441341*std::exp(3.2435998916626*x_17) - 0.123915445426123*std::exp(3.34063982963562*x_17) - 0.0403202314211739*std::exp(3.72783994674683*x_17) - 0.00433582914312285*std::exp(3.84783983230591*x_17) + 4.64572482919311e-7*std::exp(4.00047969818115*x_17) + 1.62187950368572e-5*std::exp(4.29528045654297*x_17) - 2.09520550683315*std::exp(0.968399822711945*x_29) - 0.173617363058094*std::exp(1.05535984039307*x_29) + 0.571264025865976*std::exp(1.22887980937958*x_29) + 0.944119229874016*std::exp(1.27927994728088*x_29) + 8.56287119046397*std::exp(1.3769599199295*x_29) + 0.00524758978434747*std::exp(1.50023984909058*x_29) - 0.000158468626689565*std::exp(1.51847982406616*x_29) - 0.000523056010522839*std::exp(2.48135995864868*x_29) + 1.53539547649738e-6*std::exp(2.79688000679016*x_29) - 0.000170047502788362*std::exp(3.16279983520508*x_29) + 53.9718671479901*std::exp(1.2364798784256*x_38) - 0.329631334414445*std::exp(1.59431982040405*x_38) - 8.4767827573937e-5*std::exp(1.63711988925934*x_38) - 0.0652825196185972*std::exp(1.69327986240387*x_38) + 3.0125426032759e-6*std::exp(2.51567983627319*x_38) - 3.32269781505596e-5*std::exp(1.65847980976105*x_50) - 1.91353430690415*std::exp(1.70751988887787*x_50) + 0.368858015078877*std::exp(1.71991980075836*x_50) - 0.161413304844069*std::exp(1.87503981590271*x_50) + 279.143535866847*std::exp(1.90279984474182*x_50) - 0.013189442351564*std::exp(1.92735981941223*x_50) - 0.0181164487411829*std::exp(1.93935978412628*x_50) + 508.568410662024*std::exp(1.95463979244232*x_50) - 0.0231592758343956*std::exp(1.95655977725983*x_50) + 0.403265161337752*std::exp(1.98487973213196*x_50) - 2.02242168351644*std::exp(0.721999883651733*x_66) - 0.188316719495179*std::exp(0.787759840488434*x_71) + 1.24107955790283*std::exp(0.791999816894531*x_71) + 3.78357944902389*std::exp(1.15183985233307*x_71) + 0.0114304186638682*std::exp(1.16359984874725*x_71) - 2.53767527748219*std::exp(1.43479979038239*x_71) + 4.94901726816913e-5*std::exp(1.56895983219147*x_71) - 148.255407569485*std::exp(1.71743988990784*x_71) - 0.0124953977545518*std::exp(1.76351988315582*x_71) - 0.000109812883214322*std::exp(1.83151996135712*x_71) - 0.400595845471578*std::exp(1.83999979496002*x_71) + 0.125508369143192*std::exp(1.9236798286438*x_71) - 0.473093369745029*std::exp(1.14375984668732*x_72) - 306.74595029113*std::exp(0.821839869022369*x_73) - 11.1375677042989*std::exp(0.863199889659882*x_73) + 0.0892995265554832*std::exp(0.740559816360474*x_76) + 0.000402213828677017*std::exp(0.98175984621048*x_76) + 0.583209110052205*std::exp(1.20527982711792*x_76) + 0.132590664230864*std::exp(1.75559985637665*x_76) - 1.39259259404914e-5*std::exp(2.1159999370575*x_76) - 0.12015737194466*std::exp(1.01855981349945*x_77) + 0.607664872801988*std::exp(1.47807991504669*x_77) + 0.492344406422252*std::exp(1.27991986274719*x_78) - 0.00707742283269105*std::exp(1.7519998550415*x_78) - 0.0529331124864862*std::exp(1.35511994361877*x_81) - 0.0769065788461952*std::exp(0.975599825382233*x_88) + 47.0654510611723*std::sin(0.370799839496613*x_102 + 8.17463970184326) - 0.336849773587034*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.00121206616327841*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 201.009756484637*std::sin(0.424079865217209*x_105 + 2.02815985679626) - 11.7579916469221*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 13.2421390490717*std::sin(0.493919849395752*x_105 + 2.05367970466614) - 41.2251271810215*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 11.0975354537589*std::sin(0.409119844436646*x_111 + 2.01191973686218) - 0.298631654832526*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 6.70595836978414*std::sin(0.48431983590126*x_112 - 4.16656017303467) - 0.726412191527869*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 170.756578379734*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 99.6643367670521*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 16.2928694255288*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0758904297376786*std::sin(0.548159837722778*x_15 - 7.25176000595093) + 47.4172141503458*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 3.78002088637511*std::sin(0.750319838523865*x_15 + 2.37279987335205) + 7.90715943700408*std::sin(0.438879877328873*x_17 - 4.15015983581543) + 9.58415812593246*std::sin(0.489599853754044*x_19 - 1.11607992649078) - 1.19403781623178*std::sin(0.308639913797379*x_21 + 8.310959815979) + 3.63285014475193*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 36.075829081315*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 9.27262577326578*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 66.9445139537174*std::sin(0.317279845476151*x_28 + 8.30079936981201) + 0.933232321919364*std::sin(0.321599841117859*x_28 + 8.31328010559082) + 1698.09940342629*std::sin(0.33519983291626*x_28 - 4.27343988418579) + 75.2114525268832*std::sin(0.337279856204987*x_28 + 5.13632011413574) - 2509.05764213252*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 19.3700010853016*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 10.4958125345955*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 9.44257365137909*std::sin(0.377119839191437*x_34 + 1.99303984642029) + 1.57735236160397*std::sin(0.239039987325668*x_36 + 1.82855987548828) - 6035.12040323772*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 49.9417337708223*std::sin(0.320719838142395*x_36 + 5.12007999420166) + 0.292525467889855*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 14.0984404506389*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 17.0226403711714*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.00315244311145804*std::sin(0.357039839029312*x_36 + 5.15184020996094) - 1157.48601097524*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 2.0260761831443*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.00378609361952661*std::sin(0.317759841680527*x_43 + 1.93063986301422) + 9.75527590523372*std::sin(0.448239862918854*x_45 - 7.35192012786865) + 6471.51123017047*std::sin(0.324479848146439*x_46 + 8.31719970703125) + 16.0312199294697*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 8.69961628984427*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 18.0885936698749*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.0947326754939232*std::sin(0.234399989247322*x_47 + 1.83199989795685) + 0.541195643795817*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 324.0394112325*std::sin(0.281999945640564*x_53 + 5.10016012191772) + 8.70573867404066*std::sin(0.438159853219986*x_53 - 7.36560010910034) - 55.8513445941471*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 9.44677424700106*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 8.73584911709362*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.00700831721424835*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.00161425679075628*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.00119248186521097*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.000686066437433586*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.0811454417084395*std::sin(0.530719876289368*x_73 - 4.05000019073486) + 1593.33109884917*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 2.43010420251065*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 52.2794343417431*std::sin(0.197119995951653*x_75 + 1.8083997964859) + 6867.93782235455*std::sin(0.277759969234467*x_75 - 7.51592016220093) - 0.0389846280264651*std::sin(0.420239865779877*x_75 + 8.41903972625732) - 0.0180600429855376*std::sin(0.723519861698151*x_78 - 4.04087972640991) + 35.3279309788056*std::sin(0.179360002279282*x_80 + 1.77199983596802) + 234.870189552116*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 21.8839200532669*std::sin(0.23175998032093*x_80 + 5.05128002166748) + 0.288051191810792*std::sin(0.263199955224991*x_80 + 1.84135985374451) + 2421.02956844217*std::sin(0.289039850234985*x_80 - 1.3064798116684) + 18909.0446646695*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.159274556201029*std::sin(0.364479839801788*x_85 - 4.43111991882324) - 19.0156690581339*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 16.4342700946826*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 11.3172069190364*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.00518666414289664*std::sin(0.349439829587936*x_92 - 7.41207981109619) + 5056.37045073002*std::sin(0.361599832773209*x_92 - 1.17927992343903) - 1.14118568069377*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 3.26802326859264*std::sin(0.272639960050583*x_96 + 5.06655979156494) - 0.737371058394438*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.123425583664463*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.00226380735010883*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 3.82568816364359*std::sin(0.54943984746933*x_99 - 7.41207981109619) - 181892.047922771 - 0.941246649738374*std::exp(-2.47855997085571*x_86) + 16.0370868700577*std::exp(-2.40647983551025*x_86) + 0.000134305778880136*std::exp(-2.36967992782593*x_86) + 0.146247777629013*std::exp(-2.33151984214783*x_86) + 0.192657290910201*std::exp(-2.33007979393005*x_86) + 0.12194652554039*std::exp(-2.11759996414185*x_23) - 0.0193150130215411*std::exp(-2.09047985076904*x_23) - 25.7891906227969*std::exp(-2.06727981567383*x_23));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.286890500950652*x_1 - 413.314839779844*x_10 + 1122.00609436728*x_100 - 47644.9175372453*x_101 - 1894.28019859441*x_102 + 2223.78519520452*x_103 + 2834.58082041018*x_104 - 2648.24724472591*x_105 - 1642.46241688479*x_106 + 6539.73715806388*x_107 - 17.1065041328958*x_108 - 1144.14864328889*x_109 - 1546.63840089287*x_11 - 436.110343422171*x_110 + 2035.36800779446*x_111 - 546.17762917757*x_112 - 559.462293141274*x_113 + 113.379462903709*x_114 - 1126.99782718897*x_115 - 2640.77436164274*x_116 - 889.038077290978*x_117 - 4011.5348800501*x_118 + 1576.78762384715*x_119 + 2202.28515277648*x_12 - 864.951750366732*x_120 - 230.943492730645*x_13 - 1303.52683499072*x_14 - 1520.27945480017*x_15 + 2369.70068294919*x_16 - 2507.0835295733*x_17 + 362.065297083652*x_18 - 1814.87881073803*x_19 + 104.393962752311*x_2 + 3082.53323873223*x_20 + 1845.52011734562*x_21 + 410.326959903844*x_22 - 84.7042661587979*x_23 + 413.682712756139*x_24 + 959.187271460804*x_25 - 628.84187661184*x_26 + 215.520866044327*x_27 - 4.3266885665958*x_28 + 78.5511702467301*x_29 - 87.4829108509029*x_3 - 5748.3374245146*x_30 + 8561.75888269551*x_31 - 1800.14020166149*x_32 - 994.917495148111*x_33 + 2168.34496542662*x_34 + 740.50789707533*x_35 - 15.1765015491722*x_36 - 1135.38907995106*x_37 + 954.36430770892*x_38 + 1126.50908406011*x_39 + 2888.18546587181*x_4 - 4671.24106751495*x_40 - 2224.7017103647*x_41 - 259.0704061851*x_42 + 2219.11298180176*x_43 + 383.835811992759*x_44 + 1319.71466642107*x_45 - 62.9628766453413*x_46 - 1042.67514760529*x_47 + 10778.6650613578*x_48 - 2967.43231067276*x_49 + 374.736495178771*x_5 + 19.7274832437338*x_50 + 451.858254975824*x_51 + 160.661398460271*x_52 - 2224.04316841993*x_53 - 911.572984549508*x_54 - 1080.12041794277*x_55 + 790.784244174851*x_56 - 1490.22499359494*x_57 - 89.5472244528134*x_58 + 2741.49662508837*x_59 - 736.322345714338*x_6 + 2522.34073145597*x_60 + 476.172269534924*x_61 + 7156.23532730707*x_62 - 1748.93441619149*x_63 + 2878.59658784784*x_64 + 666.875744044255*x_65 + 1664.18815464647*x_66 + 1941.17470402952*x_67 - 1045.64681056779*x_68 - 27.9602354942674*x_69 - 1882.96375417347*x_7 + 1736.36892277355*x_70 - 14.3082533240302*x_71 + 453.618998174536*x_72 + 3.91603028178614*x_73 + 1373.47468268957*x_74 - 23.7335215774582*x_75 - 155.846138253581*x_76 + 397.952438902639*x_77 + 775.733655333642*x_78 - 275.181178666822*x_79 + 17849.6332293957*x_8 - 1461.00626968659*x_80 + 28.9632940531886*x_81 + 1340.18209565399*x_82 - 3703.90612792186*x_83 + 5080.30977510316*x_84 + 134.160565223628*x_85 + 150.06279348996*x_86 + 1334.27776182413*x_87 - 738.24614486452*x_88 - 421.498305281005*x_89 - 3336.17944340374*x_9 + 1994.74950996038*x_90 - 568.860937161792*x_91 - 46.3296385934999*x_92 + 51637.8608105567*x_93 + 2121.29727534669*x_94 - 2511.10759545023*x_95 + 211.093349242287*x_96 - 877.218031207862*x_97 - 702.370329891106*x_98 + 741.743735416594*x_99 - 0.108310853851142*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 1.66653848597851e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 3.43839783944388e-6*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) + 0.0524773272244101*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) + 0.21663177077409*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) - 2.2814239628666*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) + 0.0530448423040355*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 2.67265060214621e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 3.21235252577411e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) - 0.043737965067963*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) + 0.129169565255362*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.000726460826331771*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.0153721442842186*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.0128536937469651*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) + 0.0415609753168999*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) - 0.23560410282764*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.0254447920807391*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) - 0.0145482510248258*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) - 36.1916028958964*std::exp(0.50519984960556*x_1) - 1.16802552908137*std::exp(0.69599986076355*x_1) + 1.11795447495271*std::exp(0.843999862670898*x_1) - 124.192990838242*std::exp(0.92631983757019*x_1) - 0.0934738296093944*std::exp(0.954959809780121*x_1) + 4.99943638031291e-5*std::exp(1.04391980171204*x_1) - 0.00816972730826044*std::exp(1.06287980079651*x_1) - 0.540950303927651*std::exp(1.09599983692169*x_1) + 1.00324622587985*std::exp(1.10639989376068*x_1) + 0.00029191821965189*std::exp(1.12911987304688*x_1) - 6.99083326909265e-6*std::exp(1.14607977867126*x_1) + 0.0174319991813093*std::exp(1.15999984741211*x_1) - 0.00462448498940853*std::exp(1.06799972057343*x_108) - 4.15613556172705*std::exp(1.30215978622437*x_108) - 1.31121656363968*std::exp(1.4450398683548*x_108) - 0.0872717252048038*std::exp(1.48199987411499*x_108) + 0.0108563626058715*std::exp(1.49183988571167*x_108) - 0.00195132903880991*std::exp(2.85751986503601*x_17) + 0.000347652264918531*std::exp(3.06975984573364*x_17) - 0.299496636298409*std::exp(3.2435998916626*x_17) - 0.164730811868445*std::exp(3.34063982963562*x_17) + 0.00277333408869505*std::exp(3.72783994674683*x_17) - 0.00863045166358298*std::exp(3.84783983230591*x_17) + 7.18987313770045e-7*std::exp(4.00047969818115*x_17) - 1.27220694043752e-5*std::exp(4.29528045654297*x_17) - 2.93821034884092*std::exp(0.968399822711945*x_29) + 0.0355823757882023*std::exp(1.05535984039307*x_29) + 0.0719352390694599*std::exp(1.22887980937958*x_29) + 1.87926578956896*std::exp(1.27927994728088*x_29) - 0.58897733799086*std::exp(1.3769599199295*x_29) + 0.00375352304393006*std::exp(1.50023984909058*x_29) - 0.000728346899442566*std::exp(1.51847982406616*x_29) + 0.000410286636776969*std::exp(2.48135995864868*x_29) + 2.37622741296382e-6*std::exp(2.79688000679016*x_29) - 0.00746677467385299*std::exp(3.16279983520508*x_29) + 19.0640509096319*std::exp(1.2364798784256*x_38) - 0.462258329753375*std::exp(1.59431982040405*x_38) - 0.000389606357269106*std::exp(1.63711988925934*x_38) - 0.129944610695479*std::exp(1.69327986240387*x_38) + 4.66230780681721e-6*std::exp(2.51567983627319*x_38) - 5.14231398619365e-5*std::exp(1.65847980976105*x_50) - 3.74688674636532*std::exp(1.70751988887787*x_50) + 0.0464476814502067*std::exp(1.71991980075836*x_50) - 0.321292578496895*std::exp(1.87503981590271*x_50) + 98.5996382943072*std::exp(1.90279984474182*x_50) + 0.0103458364582747*std::exp(1.92735981941223*x_50) - 0.0129584267480358*std::exp(1.93935978412628*x_50) + 1471.582228103*std::exp(1.95463979244232*x_50) - 1.01692228012463*std::exp(1.95655977725983*x_50) + 0.536092955942541*std::exp(1.98487973213196*x_50) - 0.254669260999723*std::exp(0.721999883651733*x_66) - 8.26897477900461*std::exp(0.787759840488434*x_71) + 0.156280372401578*std::exp(0.791999816894531*x_71) + 7.40861746780164*std::exp(1.15183985233307*x_71) + 0.00817600872396177*std::exp(1.16359984874725*x_71) - 3.37353674742142*std::exp(1.43479979038239*x_71) + 0.000227464669686323*std::exp(1.56895983219147*x_71) - 428.988545937054*std::exp(1.71743988990784*x_71) + 0.00256089558494647*std::exp(1.76351988315582*x_71) - 0.000169949949302792*std::exp(1.83151996135712*x_71) - 0.561775374791912*std::exp(1.83999979496002*x_71) - 0.119817963578818*std::exp(1.9236798286438*x_71) + 0.451643858751909*std::exp(1.14375984668732*x_72) - 108.349418348616*std::exp(0.821839869022369*x_73) - 14.8060684756425*std::exp(0.863199889659882*x_73) + 3.92113634330405*std::exp(0.740559816360474*x_76) + 0.000622479055204569*std::exp(0.98175984621048*x_76) + 0.817862991055109*std::exp(1.20527982711792*x_76) + 0.263921220351097*std::exp(1.75559985637665*x_76) - 6.40057605881407e-5*std::exp(2.1159999370575*x_76) + 0.0246259054218389*std::exp(1.01855981349945*x_77) + 0.852158517181717*std::exp(1.47807991504669*x_77) + 0.0619974494749738*std::exp(1.27991986274719*x_78) - 0.00506237544965531*std::exp(1.7519998550415*x_78) - 2.32428949112069*std::exp(1.35511994361877*x_81) - 3.37696282371251*std::exp(0.975599825382233*x_88) + 92.1587421539996*std::sin(0.370799839496613*x_102 + 8.17463970184326) + 0.264225929773678*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.00187583257056245*std::sin(0.329119831323624*x_105 - 7.45895957946777) + 13.8259923162639*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 11.2248977859289*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 18.5701067832633*std::sin(0.493919849395752*x_105 + 2.05367970466614) - 54.8038918518699*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 22.0896027396461*std::sin(0.409119844436646*x_111 + 2.01191973686218) + 0.234247527667074*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 13.348185008678*std::sin(0.48431983590126*x_112 - 4.16656017303467) - 31.8967115984578*std::sin(0.452719867229462*x_117 - 7.37175989151001) - 11.7450972625309*std::sin(0.427359849214554*x_120 - 1.15639984607697) - 6.85518145211086*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 22.8482969342515*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0542832973880319*std::sin(0.548159837722778*x_15 - 7.25176000595093) + 63.0355332756579*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 7.52411741106978*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 7.54865789351429*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 9.1496233845287*std::sin(0.489599853754044*x_19 - 1.11607992649078) - 52.4301220521794*std::sin(0.308639913797379*x_21 + 8.310959815979) - 3.46814088417148*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 50.5909200811285*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 1.16763619202236*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 131.083885546253*std::sin(0.317279845476151*x_28 + 8.30079936981201) + 40.9781699340863*std::sin(0.321599841117859*x_28 + 8.31328010559082) + 599.806069109468*std::sin(0.33519983291626*x_28 - 4.27343988418579) + 99.9846596520123*std::sin(0.337279856204987*x_28 + 5.13632011413574) - 7260.15332065519*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 27.1635109111163*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 20.891875523631*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 1.1890365265225*std::sin(0.377119839191437*x_34 + 1.99303984642029) + 69.2614385524088*std::sin(0.239039987325668*x_36 + 1.82855987548828) - 17463.0900065252*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 97.7907841428487*std::sin(0.320719838142395*x_36 + 5.12007999420166) - 0.229457817093371*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 1.7753169084748*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 33.8835018771376*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.0048788223320445*std::sin(0.357039839029312*x_36 + 5.15184020996094) - 408.849524881418*std::sin(0.41967985033989*x_36 - 4.19840002059937) - 0.415238446514385*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.0174014857476081*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 9.31298287989919*std::sin(0.448239862918854*x_45 - 7.35192012786865) + 18725.8207856262*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 15.3043827973078*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 12.199902362991*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 36.0052779242147*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.0677608759625645*std::sin(0.234399989247322*x_47 + 1.83199989795685) + 23.7638651578642*std::sin(0.497679859399796*x_49 - 4.12728023529053) - 22.2883032556166*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 8.31103046349713*std::sin(0.438159853219986*x_53 - 7.36560010910034) - 74.2477042091035*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 13.2476789342043*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 1.10004370354014*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.0108462970864247*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.00741937980414684*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.00548083546448185*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.003153269974979*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.0580421294116811*std::sin(0.530719876289368*x_73 - 4.05000019073486) + 4610.42738674633*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 4.83711330980455*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 73.3140374600456*std::sin(0.197119995951653*x_75 + 1.8083997964859) + 19872.9119449967*std::sin(0.277759969234467*x_75 - 7.51592016220093) + 0.0305796541808043*std::sin(0.420239865779877*x_75 + 8.41903972625732) + 0.0141663495830532*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 33.7262030909206*std::sin(0.179360002279282*x_80 + 1.77199983596802) + 312.231916494075*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 30.6889038636136*std::sin(0.23175998032093*x_80 + 5.05128002166748) - 0.225948182087638*std::sin(0.263199955224991*x_80 + 1.84135985374451) + 855.160908551677*std::sin(0.289039850234985*x_80 - 1.3064798116684) + 54714.7905681181*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.113926724759534*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 18.1535204240835*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 2.06945141767149*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 22.5268579682*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.00802704821451159*std::sin(0.349439829587936*x_92 - 7.41207981109619) + 14631.0009391133*std::sin(0.361599832773209*x_92 - 1.17927992343903) - 50.1093882535456*std::sin(0.381679862737656*x_95 + 2.00063967704773) + 0.669771905179453*std::sin(0.272639960050583*x_96 + 5.06655979156494) - 32.377914722477*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.0882844870757535*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.0104048170217129*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 5.36495179933248*std::sin(0.54943984746933*x_99 - 7.41207981109619) - 433604.874454487 + 0.0647414790932626*std::exp(-2.47855997085571*x_86) + 46.4045574474433*std::exp(-2.40647983551025*x_86) - 0.000105349838655637*std::exp(-2.36967992782593*x_86) + 0.286367408050333*std::exp(-2.33151984214783*x_86) + 0.256114900244082*std::exp(-2.33007979393005*x_86) + 0.171011646437269*std::exp(-2.11759996414185*x_23) + 0.00395855598530503*std::exp(-2.09047985076904*x_23) - 74.6230277029319*std::exp(-2.06727981567383*x_23));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.887169443094063*x_1 + 1486.35039059325*x_10 + 309.948363728268*x_100 + 30261.2627204321*x_101 - 557.596567802109*x_102 + 871.326912047836*x_103 + 1076.1567132195*x_104 + 798.350231767033*x_105 + 266.422100407633*x_106 + 3164.91462460074*x_107 + 229.781818129133*x_108 + 940.025269463089*x_109 - 994.024717876158*x_11 + 878.281671309077*x_110 - 1442.55401131058*x_111 + 1035.95963460908*x_112 - 2714.86735161421*x_113 - 72.8549628180908*x_114 + 674.63562403659*x_115 + 540.51747519144*x_116 + 950.193565770476*x_117 + 49.7668116456311*x_118 - 879.011927390258*x_119 - 1656.96544906878*x_12 + 1294.09367508899*x_120 - 228.120049142145*x_13 + 1334.1896041739*x_14 + 341.55005845303*x_15 - 993.339345218245*x_16 - 49.372941243677*x_17 + 1217.97674019623*x_18 - 91.4272675666047*x_19 - 1218.3649684629*x_2 + 162.515733164007*x_20 - 364.756449506502*x_21 + 389.92578469675*x_22 - 709.438579888994*x_23 + 299.228654244002*x_24 - 374.315688383459*x_25 - 200.063658743866*x_26 + 707.244516604826*x_27 - 21.8836291527545*x_28 - 673.432625355356*x_29 + 812.400871102321*x_3 - 1060.31637832186*x_30 + 35943.8154558756*x_31 - 526.326655015725*x_32 + 1112.17656702214*x_33 - 907.563177060863*x_34 + 419.896618619299*x_35 + 13.7808785321731*x_36 + 1975.76570550121*x_37 - 8.29667453536269*x_38 - 832.932745368716*x_39 + 2762.98641531421*x_4 - 1777.20934754563*x_40 - 57.2025118095517*x_41 - 635.356257497818*x_42 + 1338.23954920449*x_43 + 651.621056904322*x_44 + 1116.15412501787*x_45 - 797.211470517554*x_46 + 681.582285025131*x_47 - 117.861732421388*x_48 - 302.196260076385*x_49 - 26.2978919436542*x_5 - 6.97089057700708*x_50 - 1129.80839553351*x_51 - 466.730645003867*x_52 - 957.229339677938*x_53 + 2740.69045596122*x_54 - 997.003319054922*x_55 + 848.256501025677*x_56 - 1028.5147066123*x_57 + 479.725909863271*x_58 - 517.952535519294*x_59 + 570.5355761328*x_6 + 1427.75031925162*x_60 - 1221.05669423031*x_61 + 886.100700416339*x_62 + 1079.16992055559*x_63 + 2503.81557762727*x_64 + 1121.76980960512*x_65 + 1514.25380667723*x_66 + 1178.76473333916*x_67 + 256.367566444167*x_68 + 782.111079107965*x_69 + 680.561218049399*x_7 - 1832.33994337292*x_70 - 179.015654629084*x_71 + 3121.24991770546*x_72 + 7.42075682086855*x_73 - 106.707550570032*x_74 - 277.061803341034*x_75 - 817.943291321069*x_76 - 1296.80336287064*x_77 - 1618.72740210835*x_78 - 1192.54264106563*x_79 + 11389.0172157592*x_8 - 40.968108937428*x_80 - 497.240792316087*x_81 - 1413.49446978806*x_82 - 369.446578047328*x_83 + 2075.76707417903*x_84 + 1522.86979855759*x_85 + 1914.93021707317*x_86 + 117.942755818608*x_87 + 1000.09178090276*x_88 + 2405.86506269752*x_89 - 6012.02097835615*x_9 + 3842.75831282615*x_90 - 2350.6234050549*x_91 - 605.607217754539*x_92 + 30844.3591902702*x_93 + 1095.06234541636*x_94 + 1479.6242416628*x_95 - 1391.39978205135*x_96 - 1152.96381151202*x_97 + 694.60494683788*x_98 + 1449.7873810431*x_99 - 0.0141826062018349*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) + 1.23798725447941e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 2.71077591139387e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) + 0.554592472901445*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) + 0.0975584180833039*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) + 0.836507842131965*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) - 0.0194494435467511*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) + 1.9853771208836e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) + 2.38629441639811e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) - 0.462232882078557*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) + 0.0581705001338998*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.0032947708555782*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.0697184089486692*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) + 0.00835544722061164*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) - 0.015238764186362*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) - 0.106102458949893*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) + 0.0165401962622807*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) - 0.153749265425547*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) - 464.43795223427*std::exp(0.50519984960556*x_1) - 0.152945393038985*std::exp(0.69599986076355*x_1) + 0.0575077229895942*std::exp(0.843999862670898*x_1) - 2.39002678364791*std::exp(0.92631983757019*x_1) + 0.0342731525464114*std::exp(0.954959809780121*x_1) - 3.71382873571865e-5*std::exp(1.04391980171204*x_1) + 0.00531066996575026*std::exp(1.06287980079651*x_1) - 5.71688732334055*std::exp(1.09599983692169*x_1) + 0.451804065466231*std::exp(1.10639989376068*x_1) + 0.000102469688614323*std::exp(1.12911987304688*x_1) - 5.51145717026517e-5*std::exp(1.14607977867126*x_1) + 0.0137690997766672*std::exp(1.15999984741211*x_1) + 0.00309884801595187*std::exp(1.06799972057343*x_108) - 0.213792151600011*std::exp(1.30215978622437*x_108) + 0.480771200824828*std::exp(1.4450398683548*x_108) + 0.0567303304524919*std::exp(1.48199987411499*x_108) + 0.0167579637032655*std::exp(1.49183988571167*x_108) - 0.00301208631220727*std::exp(2.85751986503601*x_17) - 0.000232960326144718*std::exp(3.06975984573364*x_17) - 3.84336678493056*std::exp(3.2435998916626*x_17) - 0.0741852285010538*std::exp(3.34063982963562*x_17) + 0.0293092329922591*std::exp(3.72783994674683*x_17) - 0.001130101859014*std::exp(3.84783983230591*x_17) + 5.66837690626532e-6*std::exp(4.00047969818115*x_17) - 4.46572499637292e-6*std::exp(4.29528045654297*x_17) - 2.32081880209153*std::exp(0.968399822711945*x_29) + 0.054925225287902*std::exp(1.05535984039307*x_29) + 0.326253144814261*std::exp(1.22887980937958*x_29) + 0.246077707767567*std::exp(1.27927994728088*x_29) - 6.22444807378303*std::exp(1.3769599199295*x_29) - 0.00251522006540235*std::exp(1.50023984909058*x_29) + 0.000541052118469419*std::exp(1.51847982406616*x_29) + 0.000144019595499344*std::exp(2.48135995864868*x_29) + 1.87337833835364e-5*std::exp(2.79688000679016*x_29) + 0.00273777065191437*std::exp(3.16279983520508*x_29) + 244.644283681705*std::exp(1.2364798784256*x_38) - 0.36512628292194*std::exp(1.59431982040405*x_38) + 0.000289418881484819*std::exp(1.63711988925934*x_38) - 0.0170154068222711*std::exp(1.69327986240387*x_38) + 3.67568625981565e-5*std::exp(2.51567983627319*x_38) - 0.000405411518198607*std::exp(1.65847980976105*x_50) - 0.192740339531691*std::exp(1.70751988887787*x_50) + 0.21065756280908*std::exp(1.71991980075836*x_50) - 0.0420711863527199*std::exp(1.87503981590271*x_50) + 1265.30494469036*std::exp(1.90279984474182*x_50) + 0.00363161518865908*std::exp(1.92735981941223*x_50) + 0.00868338747124886*std::exp(1.93935978412628*x_50) + 28.3198022349536*std::exp(1.95463979244232*x_50) + 0.372865138619003*std::exp(1.95655977725983*x_50) + 0.241425256048416*std::exp(1.98487973213196*x_50) - 1.15502010368598*std::exp(0.721999883651733*x_66) + 3.03190567014888*std::exp(0.787759840488434*x_71) + 0.708789789654085*std::exp(0.791999816894531*x_71) + 0.381100242111582*std::exp(1.15183985233307*x_71) - 0.00547870919046807*std::exp(1.16359984874725*x_71) - 1.51924580244299*std::exp(1.43479979038239*x_71) - 0.000168972012518928*std::exp(1.56895983219147*x_71) - 8.25565201182041*std::exp(1.71743988990784*x_71) + 0.00395301785859434*std::exp(1.76351988315582*x_71) - 0.00133985725394456*std::exp(1.83151996135712*x_71) - 0.443732305579621*std::exp(1.83999979496002*x_71) + 0.0778867686185819*std::exp(1.9236798286438*x_71) - 0.293587703161665*std::exp(1.14375984668732*x_72) - 1390.42147783157*std::exp(0.821839869022369*x_73) - 6.66779675647427*std::exp(0.863199889659882*x_73) - 1.43772545332657*std::exp(0.740559816360474*x_76) + 0.00490752177900589*std::exp(0.98175984621048*x_76) + 0.646009503003858*std::exp(1.20527982711792*x_76) + 0.034558777845955*std::exp(1.75559985637665*x_76) + 4.75466462299271e-5*std::exp(2.1159999370575*x_76) + 0.0380127344858612*std::exp(1.01855981349945*x_77) + 0.673098680568579*std::exp(1.47807991504669*x_77) + 0.281181561684151*std::exp(1.27991986274719*x_78) + 0.00339227657871028*std::exp(1.7519998550415*x_78) + 0.852224934231154*std::exp(1.35511994361877*x_81) + 1.23819856835123*std::exp(0.975599825382233*x_88) + 4.74065763284844*std::sin(0.370799839496613*x_102 + 8.17463970184326) + 0.0927490883577792*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.0147887533192237*std::sin(0.329119831323624*x_105 - 7.45895957946777) + 146.116269149974*std::sin(0.424079865217209*x_105 + 2.02815985679626) - 7.29666062171692*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 14.6680624811108*std::sin(0.493919849395752*x_105 + 2.05367970466614) - 24.6805026555983*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 2.89249069388693*std::sin(0.409119844436646*x_111 + 2.01191973686218) + 0.0822260126392376*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 1.74785854562185*std::sin(0.48431983590126*x_112 - 4.16656017303467) + 11.6952613037367*std::sin(0.452719867229462*x_117 - 7.37175989151001) - 124.124891259041*std::sin(0.427359849214554*x_120 - 1.15639984607697) - 72.4471354544488*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 18.0472977850954*std::sin(0.435839861631393*x_14 - 1.17343986034393) + 0.0363750101461012*std::sin(0.548159837722778*x_15 - 7.25176000595093) + 28.3875577780494*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 0.985234539875688*std::sin(0.750319838523865*x_15 + 2.37279987335205) + 4.90694845056536*std::sin(0.438879877328873*x_17 - 4.15015983581543) + 5.94764406114421*std::sin(0.489599853754044*x_19 - 1.11607992649078) + 19.2240499681069*std::sin(0.308639913797379*x_21 + 8.310959815979) + 2.25443897153549*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 39.9605013254788*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 5.29566572064084*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 6.74297205055012*std::sin(0.317279845476151*x_28 + 8.30079936981201) - 15.0250725266375*std::sin(0.321599841117859*x_28 + 8.31328010559082) + 7697.163987906*std::sin(0.33519983291626*x_28 - 4.27343988418579) + 45.0273069060584*std::sin(0.337279856204987*x_28 + 5.13632011413574) - 139.717714926091*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 21.4557772823195*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 2.73565605693256*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 5.39272422105127*std::sin(0.377119839191437*x_34 + 1.99303984642029) - 25.3954273512725*std::sin(0.239039987325668*x_36 + 1.82855987548828) - 336.067700432554*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 5.03037060221975*std::sin(0.320719838142395*x_36 + 5.12007999420166) - 0.0805447193248794*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 8.05172446667708*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 4.43682555141736*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.0384638272568708*std::sin(0.357039839029312*x_36 + 5.15184020996094) - 5246.66554985357*std::sin(0.41967985033989*x_36 - 4.19840002059937) - 0.640965217127603*std::sin(0.3711998462677*x_39 - 1.21975982189178) - 0.0129266847095313*std::sin(0.317759841680527*x_43 + 1.93063986301422) + 6.05383467595298*std::sin(0.448239862918854*x_45 - 7.35192012786865) + 360.368269749858*std::sin(0.324479848146439*x_46 + 8.31719970703125) + 9.94849925821005*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 9.6363974753815*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 4.71465840984481*std::sin(0.406079858541489*x_46 - 7.39928007125854) + 0.0454062790811675*std::sin(0.234399989247322*x_47 + 1.83199989795685) - 8.71326850575482*std::sin(0.497679859399796*x_49 - 4.12728023529053) - 235.547918941268*std::sin(0.281999945640564*x_53 + 5.10016012191772) + 5.40252302207229*std::sin(0.438159853219986*x_53 - 7.36560010910034) - 33.4368709772996*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 10.464009959907*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 4.98910856981451*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.0855104099136385*std::sin(0.264479964971542*x_68 - 4.31527996063232) + 0.00551148245957408*std::sin(0.433999866247177*x_69 + 8.42216014862061) + 0.0040714357970217*std::sin(0.576959848403931*x_70 + 1.96287977695465) - 0.00234240497402287*std::sin(0.594559848308563*x_72 - 4.00647974014282) + 0.03889378773657*std::sin(0.530719876289368*x_73 - 4.05000019073486) + 88.7251757447369*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 0.633388721327019*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 57.9089229134455*std::sin(0.197119995951653*x_75 + 1.8083997964859) + 382.443417273699*std::sin(0.277759969234467*x_75 - 7.51592016220093) + 0.0107341283650515*std::sin(0.420239865779877*x_75 + 8.41903972625732) + 0.00497269897133572*std::sin(0.723519861698151*x_78 - 4.04087972640991) + 21.9234653808639*std::sin(0.179360002279282*x_80 + 1.77199983596802) + 140.611193544855*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 24.2403969240495*std::sin(0.23175998032093*x_80 + 5.05128002166748) - 0.0793127605707589*std::sin(0.263199955224991*x_80 + 1.84135985374451) + 10974.0699338733*std::sin(0.289039850234985*x_80 - 1.3064798116684) + 1052.95648358942*std::sin(0.180560007691383*x_85 + 1.76799988746643) - 0.076341820936504*std::sin(0.364479839801788*x_85 - 4.43111991882324) - 11.8005598046506*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 9.3857341935532*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 2.94974643969424*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.0632839187190001*std::sin(0.349439829587936*x_92 - 7.41207981109619) + 281.565681606009*std::sin(0.361599832773209*x_92 - 1.17927992343903) + 18.3731287655354*std::sin(0.381679862737656*x_95 + 2.00063967704773) + 1.03386499548144*std::sin(0.272639960050583*x_96 + 5.06655979156494) + 11.8716994377496*std::sin(0.459359854459763*x_96 - 7.34767961502075) + 0.0591590648992501*std::sin(0.382559835910797*x_97 - 7.41663980484009) + 0.007729212956344*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 4.23764112501931*std::sin(0.54943984746933*x_99 - 7.41207981109619) - 213762.409902718 + 0.684202852711755*std::exp(-2.47855997085571*x_86) + 0.893030552160322*std::exp(-2.40647983551025*x_86) - 3.69801007127457e-5*std::exp(-2.36967992782593*x_86) + 0.01473077656056*std::exp(-2.33151984214783*x_86) + 0.115339335620499*std::exp(-2.33007979393005*x_86) + 0.135077818572387*std::exp(-2.11759996414185*x_23) + 0.00611045705890558*std::exp(-2.09047985076904*x_23) - 1.43607971499136*std::exp(-2.06727981567383*x_23));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.660986503510865*x_1 + 680.31384408285*x_10 + 202.90344113168*x_100 + 12666.4900180088*x_101 - 331.409955104965*x_102 + 478.613438365293*x_103 + 656.213161647457*x_104 + 300.07069293145*x_105 + 139.226887987433*x_106 + 1940.65134529737*x_107 + 114.006983088395*x_108 + 414.110676291938*x_109 - 528.528896575776*x_11 + 434.886450191327*x_110 - 631.232133401996*x_111 + 487.219775567999*x_112 - 1373.59158264464*x_113 + 5.77101880332878*x_114 + 358.280890802101*x_115 + 80.1818882415241*x_116 + 416.194952930798*x_117 - 84.1426469500788*x_118 - 416.335747929963*x_119 - 680.736160087854*x_12 + 612.751387017224*x_120 - 114.701191104996*x_13 + 584.88693979535*x_14 + 94.4707437077032*x_15 - 369.727536929834*x_16 - 94.1718624908476*x_17 + 632.519983205379*x_18 - 127.925703298773*x_19 - 571.903248781908*x_2 + 138.625868101501*x_20 - 89.8276594605911*x_21 + 203.139667273412*x_22 - 300.468010260489*x_23 + 211.349020810406*x_24 - 170.860001484559*x_25 - 131.477688946824*x_26 + 358.421218563748*x_27 + 13.1613859901728*x_28 - 307.687655377368*x_29 + 387.491363390749*x_3 - 849.209258524101*x_30 + 17591.6911616938*x_31 - 321.920953159789*x_32 + 504.709094305475*x_33 - 350.515877324142*x_34 + 164.456369831567*x_35 - 9.86874853294806*x_36 + 951.841227527149*x_37 + 55.9522871074505*x_38 - 429.663934294073*x_39 + 1362.97897665072*x_4 - 1086.10463779519*x_40 - 175.405605051145*x_41 - 414.887784345878*x_42 + 729.804671148415*x_43 + 319.476569940608*x_44 + 611.957701572351*x_45 - 400.177142663104*x_46 + 262.212447702663*x_47 + 108.470890464869*x_48 - 303.67821644501*x_49 - 6.16135521948631*x_5 + 12.9437821505223*x_50 - 527.51453292011*x_51 - 205.434662342333*x_52 - 552.324676893372*x_53 + 1198.95005448027*x_54 - 522.504584972627*x_55 + 461.812858212214*x_56 - 537.921326904465*x_57 + 287.150765414938*x_58 - 142.311236111537*x_59 + 254.767945371892*x_6 + 799.218285807157*x_60 - 625.275516097752*x_61 + 591.291279870094*x_62 + 483.45362634351*x_63 + 1358.61259873127*x_64 + 547.436536278829*x_65 + 737.356433136039*x_66 + 688.021101492726*x_67 + 42.9287918434983*x_68 + 354.124502053554*x_69 + 297.27972815716*x_7 - 784.540618056026*x_70 - 121.12146561028*x_71 + 1451.98775579998*x_72 - 6.25936063368*x_73 + 19.7426475652569*x_74 - 156.363309710928*x_75 - 406.167710849029*x_76 - 613.168499551311*x_77 - 766.516378425486*x_78 - 569.810445083972*x_79 + 7257.13819635996*x_8 - 54.7245791860609*x_80 - 240.184804438495*x_81 - 652.801491504932*x_82 - 344.607460549469*x_83 + 1190.69778382494*x_84 + 735.738568530206*x_85 + 953.03090087198*x_86 + 131.989441654569*x_87 + 489.086900555214*x_88 + 1166.47447743*x_89 - 2556.38368780089*x_9 + 1980.64554466983*x_90 - 1222.63349149562*x_91 - 334.442336390261*x_92 + 17029.818372945*x_93 + 611.552176020437*x_94 + 683.762572736267*x_95 - 621.311896746008*x_96 - 632.302766225454*x_97 + 356.076598476636*x_98 + 726.599531444147*x_99 - 0.12310158792258*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 2.26962496672246e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 2.68378651658047e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.403512994683147*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) - 0.0613920671198881*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) - 3.17114311231285*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) + 0.0737314892164123*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 3.63982865381907e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 4.37483775847519e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.336313570057569*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) - 0.0366058339073152*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) + 0.00627016815779728*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) + 0.132678770987101*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) + 0.0188283034407671*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) + 0.0577690963022894*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) + 0.0667687054527158*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) + 0.0372719527720582*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.111865612235277*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) - 229.590774294678*std::exp(0.50519984960556*x_1) - 1.32752898025938*std::exp(0.69599986076355*x_1) - 2.05522132889612*std::exp(0.843999862670898*x_1) - 6.30212942341019*std::exp(0.92631983757019*x_1) - 0.129927140142285*std::exp(0.954959809780121*x_1) + 6.8086310179848e-5*std::exp(1.04391980171204*x_1) + 0.0119671518410471*std::exp(1.06287980079651*x_1) + 4.15951971370735*std::exp(1.09599983692169*x_1) - 0.284313604679985*std::exp(1.10639989376068*x_1) + 0.00132534916744026*std::exp(1.12911987304688*x_1) - 5.45658325282323e-5*std::exp(1.14607977867126*x_1) + 0.00939543179731151*std::exp(1.15999984741211*x_1) + 0.000707427418856308*std::exp(1.06799972057343*x_108) + 7.64054229722226*std::exp(1.30215978622437*x_108) - 1.82257022027239*std::exp(1.4450398683548*x_108) + 0.127837068184642*std::exp(1.48199987411499*x_108) + 0.0541020547489826*std::exp(1.49183988571167*x_108) - 0.00972433533436667*std::exp(2.85751986503601*x_17) - 5.31818667363264e-5*std::exp(3.06975984573364*x_17) - 1.89993421469044*std::exp(3.2435998916626*x_17) + 0.0466836652020331*std::exp(3.34063982963562*x_17) - 0.0213249493176484*std::exp(3.72783994674683*x_17) - 0.00980901051464605*std::exp(3.84783983230591*x_17) + 5.61194064326353e-6*std::exp(4.00047969818115*x_17) - 5.77599579543635e-5*std::exp(4.29528045654297*x_17) - 1.58362530032062*std::exp(0.968399822711945*x_29) + 0.177322710458385*std::exp(1.05535984039307*x_29) - 0.620881442037828*std::exp(1.22887980937958*x_29) + 2.13589492279755*std::exp(1.27927994728088*x_29) + 4.52881314699753*std::exp(1.3769599199295*x_29) - 0.000574192612726966*std::exp(1.50023984909058*x_29) - 0.000991920871505786*std::exp(1.51847982406616*x_29) + 0.00186275818314001*std::exp(2.48135995864868*x_29) + 1.85472635483992e-5*std::exp(2.79688000679016*x_29) - 0.0103786983320844*std::exp(3.16279983520508*x_29) + 120.937727519988*std::exp(1.2364798784256*x_38) - 0.249146214657564*std::exp(1.59431982040405*x_38) - 0.000530596996763958*std::exp(1.63711988925934*x_38) - 0.147689611426938*std::exp(1.69327986240387*x_38) + 3.63908989371273e-5*std::exp(2.51567983627319*x_38) - 0.000401375105051887*std::exp(1.65847980976105*x_50) + 6.8881888579711*std::exp(1.70751988887787*x_50) - 0.400895358257889*std::exp(1.71991980075836*x_50) - 0.365167711216332*std::exp(1.87503981590271*x_50) + 625.492254827208*std::exp(1.90279984474182*x_50) + 0.0469715311116887*std::exp(1.92735981941223*x_50) + 0.0019823064422951*std::exp(1.93935978412628*x_50) + 74.6749200264824*std::exp(1.95463979244232*x_50) - 1.41350583533047*std::exp(1.95655977725983*x_50) - 0.151925336787489*std::exp(1.98487973213196*x_50) + 2.19808010729676*std::exp(0.721999883651733*x_66) - 11.4937437508902*std::exp(0.787759840488434*x_71) - 1.34887412948205*std::exp(0.791999816894531*x_71) - 13.6198288737136*std::exp(1.15183985233307*x_71) - 0.00125071932580296*std::exp(1.16359984874725*x_71) + 0.956038875041479*std::exp(1.43479979038239*x_71) + 0.000309779520671695*std::exp(1.56895983219147*x_71) - 21.7688721352813*std::exp(1.71743988990784*x_71) + 0.0127620749391946*std::exp(1.76351988315582*x_71) - 0.0013265171854172*std::exp(1.83151996135712*x_71) - 0.302783528404806*std::exp(1.83999979496002*x_71) + 0.175511337077673*std::exp(1.9236798286438*x_71) - 0.661575402926314*std::exp(1.14375984668732*x_72) - 687.342501093185*std::exp(0.821839869022369*x_73) + 4.19594571188826*std::exp(0.863199889659882*x_73) + 5.45031730616362*std::exp(0.740559816360474*x_76) + 0.00485866084502303*std::exp(0.98175984621048*x_76) + 0.440808645760062*std::exp(1.20527982711792*x_76) + 0.299961824290824*std::exp(1.75559985637665*x_76) - 8.71681473108071e-5*std::exp(2.1159999370575*x_76) + 0.122721774478593*std::exp(1.01855981349945*x_77) + 0.459293116377807*std::exp(1.47807991504669*x_77) - 0.535107220475359*std::exp(1.27991986274719*x_78) + 0.000774413411619537*std::exp(1.7519998550415*x_78) - 3.23072551650036*std::exp(1.35511994361877*x_81) - 4.69392474754971*std::exp(0.975599825382233*x_88) - 169.422473600412*std::sin(0.370799839496613*x_102 + 8.17463970184326) + 1.19962233415672*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.0146415115275091*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 106.311960975915*std::sin(0.424079865217209*x_105 + 2.02815985679626) - 16.4424161463287*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 10.0088446503609*std::sin(0.493919849395752*x_105 + 2.05367970466614) + 15.5310746663734*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 25.1061188896791*std::sin(0.409119844436646*x_111 + 2.01191973686218) + 1.06351623457664*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 15.1709889824244*std::sin(0.48431983590126*x_112 - 4.16656017303467) - 44.3359230626233*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 90.3113710228021*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 52.7114268798149*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 12.3146871048876*std::sin(0.435839861631393*x_14 - 1.17343986034393) + 0.00830395017957153*std::sin(0.548159837722778*x_15 - 7.25176000595093) - 17.8638695329354*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 8.55159725997176*std::sin(0.750319838523865*x_15 + 2.37279987335205) + 11.0573990782367*std::sin(0.438879877328873*x_17 - 4.15015983581543) + 13.4025198393512*std::sin(0.489599853754044*x_19 - 1.11607992649078) - 72.8770378192142*std::sin(0.308639913797379*x_21 + 8.310959815979) + 5.08019019497245*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 27.2672993063885*std::sin(0.254479974508286*x_26 + 5.05503988265991) - 10.0780042167981*std::sin(0.299919933080673*x_28 + 5.10191965103149) + 240.981545747319*std::sin(0.317279845476151*x_28 + 8.30079936981201) + 56.9590060667131*std::sin(0.321599841117859*x_28 + 8.31328010559082) + 3805.02461384776*std::sin(0.33519983291626*x_28 - 4.27343988418579) - 28.3350171324439*std::sin(0.337279856204987*x_28 + 5.13632011413574) - 368.413914116651*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 14.6404845185262*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 23.7448322139025*std::sin(0.36287984251976*x_3 + 5.1689600944519) - 10.262713000927*std::sin(0.377119839191437*x_34 + 1.99303984642029) + 96.2723007162493*std::sin(0.239039987325668*x_36 + 1.82855987548828) - 886.15832995862*std::sin(0.31535992026329*x_36 + 1.90343987941742) - 179.776287713648*std::sin(0.320719838142395*x_36 + 5.12007999420166) - 1.04177028487639*std::sin(0.338559836149216*x_36 - 1.2196798324585) - 15.3229673865912*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 38.5105715368655*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.0380808684827771*std::sin(0.357039839029312*x_36 + 5.15184020996094) - 2593.6424882187*std::sin(0.41967985033989*x_36 - 4.19840002059937) - 2.06931676683807*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.0236987305382551*std::sin(0.317759841680527*x_43 + 1.93063986301422) + 13.6418115331877*std::sin(0.448239862918854*x_45 - 7.35192012786865) + 950.235157025155*std::sin(0.324479848146439*x_46 + 8.31719970703125) + 22.4181133418869*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 6.57545640021837*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 40.9220934787963*std::sin(0.406079858541489*x_46 - 7.39928007125854) + 0.0103656735163866*std::sin(0.234399989247322*x_47 + 1.83199989795685) + 33.0313955423719*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 171.381060522011*std::sin(0.281999945640564*x_53 + 5.10016012191772) + 12.1741350426316*std::sin(0.438159853219986*x_53 - 7.36560010910034) + 21.0413275209587*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 7.14018298213623*std::sin(0.524799883365631*x_55 - 4.24552011489868) + 9.49460556180459*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.0846590395719904*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.0101043028905515*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.00746423866796093*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.00429437443073902*std::sin(0.594559848308563*x_72 - 4.00647974014282) + 0.00887895492982906*std::sin(0.530719876289368*x_73 - 4.05000019073486) + 233.95450816024*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 5.49766074429403*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 39.5145176165424*std::sin(0.197119995951653*x_75 + 1.8083997964859) + 1008.44389246191*std::sin(0.277759969234467*x_75 - 7.51592016220093) + 0.138835867310613*std::sin(0.420239865779877*x_75 + 8.41903972625732) + 0.0643171900950779*std::sin(0.723519861698151*x_78 - 4.04087972640991) + 49.4027007490139*std::sin(0.179360002279282*x_80 + 1.77199983596802) - 88.4845408680385*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 16.5405872376351*std::sin(0.23175998032093*x_80 + 5.05128002166748) - 1.02583605563091*std::sin(0.263199955224991*x_80 + 1.84135985374451) + 5424.93394685156*std::sin(0.289039850234985*x_80 - 1.3064798116684) + 2776.48270814398*std::sin(0.180560007691383*x_85 + 1.76799988746643) - 0.0174278625663132*std::sin(0.364479839801788*x_85 - 4.43111991882324) - 26.5915773155486*std::sin(0.331359833478928*x_86 - 4.28560018539429) + 17.8616766560049*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 25.6030849004578*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.0626538427837422*std::sin(0.349439829587936*x_92 - 7.41207981109619) + 742.44497124982*std::sin(0.361599832773209*x_92 - 1.17927992343903) - 69.6512546588575*std::sin(0.381679862737656*x_95 + 2.00063967704773) + 3.337769527314*std::sin(0.272639960050583*x_96 + 5.06655979156494) - 45.0047877704523*std::sin(0.459359854459763*x_96 - 7.34767961502075) + 0.0135052588472217*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.0141701092926113*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 2.89158106320574*std::sin(0.54943984746933*x_99 - 7.41207981109619) - 120191.87951154 - 0.49781552321489*std::exp(-2.47855997085571*x_86) + 2.35478286573165*std::exp(-2.40647983551025*x_86) - 0.000478302865503622*std::exp(-2.36967992782593*x_86) - 0.526451137422781*std::exp(-2.33151984214783*x_86) - 0.0725813350922795*std::exp(-2.33007979393005*x_86) + 0.0921711987211456*std::exp(-2.11759996414185*x_23) + 0.0197272346566664*std::exp(-2.09047985076904*x_23) - 3.78671916487728*std::exp(-2.06727981567383*x_23));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.70425870920748*x_1 - 248.695903477444*x_10 + 1415.65508866361*x_100 - 51337.5465944382*x_101 - 2327.09107536134*x_102 + 2808.00257903278*x_103 + 3604.8228283756*x_104 - 3039.15298747582*x_105 - 1850.01522237992*x_106 + 8498.66235718419*x_107 - 4.57626152014808*x_108 - 1217.30578790571*x_109 - 2054.06187880822*x_11 - 325.899511031918*x_110 + 2208.39492221354*x_111 - 459.989393565371*x_112 - 1244.22753289789*x_113 + 156.942399904939*x_114 - 1193.61012056092*x_115 - 3198.85024402615*x_116 - 883.627036331198*x_117 - 4784.1347394904*x_118 + 1699.02218441012*x_119 + 2377.32674753974*x_12 - 789.755893113102*x_120 - 329.616610689092*x_13 - 1339.03699572205*x_14 - 1771.84270641336*x_15 + 2681.22229592305*x_16 - 3013.21929155076*x_17 + 689.370405635308*x_18 - 2192.30285180825*x_19 - 118.205732778807*x_2 + 3690.62082332734*x_20 + 2143.08584181164*x_21 + 580.137659856364*x_22 - 214.23731348863*x_23 + 556.873269071307*x_24 + 1090.58883379035*x_25 - 770.833073374154*x_26 + 405.95706909148*x_27 + 24.3927854107558*x_28 - 18.5864680291455*x_29 + 74.4798779750577*x_3 - 7202.04334222951*x_30 + 16706.3943444827*x_31 - 2264.8833516364*x_32 - 956.080361345267*x_33 + 2446.83376242033*x_34 + 919.408492214081*x_35 - 53.5216436343283*x_36 - 975.859533603165*x_37 + 1196.68807991904*x_38 + 1108.004069969*x_39 + 3910.33527977151*x_4 - 5956.46140365063*x_40 - 2694.63827265697*x_41 - 476.811220309933*x_42 + 2917.31631751583*x_43 + 573.802844692826*x_44 + 1787.54985882842*x_45 - 234.949028236011*x_46 - 1177.55199736821*x_47 + 12739.1399189647*x_48 - 3677.62095632776*x_49 + 441.05940479466*x_5 + 48.203445247403*x_50 + 349.581080758065*x_51 + 117.721470223581*x_52 - 2860.79390515186*x_53 - 649.789046546775*x_54 - 1462.50265808671*x_55 + 1133.13516429687*x_56 - 1991.73088214844*x_57 + 31.515101384069*x_58 + 3226.83937055643*x_59 - 748.33289683174*x_6 + 3291.34306978549*x_60 + 308.472602734222*x_61 + 8640.85272012136*x_62 - 1913.12004663906*x_63 + 3963.06491851333*x_64 + 982.972001788578*x_65 + 2197.09549796613*x_66 + 2593.39250102928*x_67 - 1232.01270298369*x_68 + 39.4954360748568*x_69 - 2081.78039701631*x_7 + 1757.77664978928*x_70 - 86.5979267407872*x_71 + 1049.41380079453*x_72 - 8.31619255130481*x_73 + 1658.35405399223*x_74 - 89.6647810271172*x_75 - 340.411190844033*x_76 + 254.591943417397*x_77 + 623.726947657375*x_78 - 530.707357341352*x_79 + 24383.1544807398*x_8 - 1743.68684935452*x_80 - 1.98573930341616*x_81 + 1318.10239540704*x_82 - 4496.39364419701*x_83 + 6447.45970450795*x_84 + 460.518976435446*x_85 + 533.436201346022*x_86 + 1611.34727734963*x_87 - 694.075817287569*x_88 - 41.1860423778025*x_89 - 4765.62383002453*x_9 + 3069.71523626694*x_90 - 1257.65808610535*x_91 - 195.526705505478*x_92 + 67188.7758517221*x_93 + 2723.20712890202*x_94 - 2715.60056890584*x_95 + 44.8187377623109*x_96 - 1275.06159749576*x_97 - 689.043447078772*x_98 + 1150.28408849444*x_99 + 0.00469602032253093*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 1.17311961308627e-6*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 3.4657275032904e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.625063601768175*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) + 0.3904167836758*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) - 0.276524121828999*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) + 0.0064293961466288*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 1.88134799567117e-6*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 2.261258161056e-6*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.520968033727806*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) + 0.232791183101159*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.00524816329465918*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.111052820012344*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.0103888296493664*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) + 0.00503747325745715*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) - 0.424608983798193*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.0205654199947591*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.173285924912258*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) - 129.887980336045*std::exp(0.50519984960556*x_1) + 0.0506419387048644*std::exp(0.69599986076355*x_1) + 0.340707130774221*std::exp(0.843999862670898*x_1) - 149.677845358612*std::exp(0.92631983757019*x_1) - 0.0113296647477366*std::exp(0.954959809780121*x_1) + 3.51923278188111e-6*std::exp(1.04391980171204*x_1) - 0.00660307511273435*std::exp(1.06287980079651*x_1) + 6.44332254012594*std::exp(1.09599983692169*x_1) + 1.80806427119757*std::exp(1.10639989376068*x_1) + 0.00244272968363004*std::exp(1.12911987304688*x_1) - 7.04639900993265e-5*std::exp(1.14607977867126*x_1) + 0.0277327919771843*std::exp(1.15999984741211*x_1) - 0.00826908354013753*std::exp(1.06799972057343*x_108) - 1.26662136434905*std::exp(1.30215978622437*x_108) - 0.158928377491273*std::exp(1.4450398683548*x_108) - 0.070536229056577*std::exp(1.48199987411499*x_108) + 0.0498349672360141*std::exp(1.49183988571167*x_108) - 0.00895736649982393*std::exp(2.85751986503601*x_17) + 0.000621640167091783*std::exp(3.06975984573364*x_17) - 1.07486295420892*std::exp(3.2435998916626*x_17) - 0.296880155261481*std::exp(3.34063982963562*x_17) - 0.0330335077275016*std::exp(3.72783994674683*x_17) + 0.000374189427594281*std::exp(3.84783983230591*x_17) + 7.24702092138573e-6*std::exp(4.00047969818115*x_17) - 0.000106456447317085*std::exp(4.29528045654297*x_17) - 4.67443668061801*std::exp(0.968399822711945*x_29) + 0.163337076695059*std::exp(1.05535984039307*x_29) + 0.519680989797043*std::exp(1.22887980937958*x_29) - 0.0814790948964525*std::exp(1.27927994728088*x_29) + 7.01537817789532*std::exp(1.3769599199295*x_29) + 0.0067117085883457*std::exp(1.50023984909058*x_29) - 5.12702250836386e-5*std::exp(1.51847982406616*x_29) + 0.00343321957652036*std::exp(2.48135995864868*x_29) + 2.39511455152417e-5*std::exp(2.79688000679016*x_29) - 0.000905023942585341*std::exp(3.16279983520508*x_29) + 68.4189389676465*std::exp(1.2364798784256*x_38) - 0.735412729511621*std::exp(1.59431982040405*x_38) - 2.74254007897767e-5*std::exp(1.63711988925934*x_38) + 0.00563399244795914*std::exp(1.69327986240387*x_38) + 4.6993655619285e-5*std::exp(2.51567983627319*x_38) - 0.000518318700880428*std::exp(1.65847980976105*x_50) - 1.14189894248072*std::exp(1.70751988887787*x_50) + 0.335551495790732*std::exp(1.71991980075836*x_50) + 0.0139302426714631*std::exp(1.87503981590271*x_50) + 353.864069429328*std::exp(1.90279984474182*x_50) + 0.0865724717311113*std::exp(1.92735981941223*x_50) - 0.023171080363257*std::exp(1.93935978412628*x_50) + 1773.55626661224*std::exp(1.95463979244232*x_50) - 0.123257906052006*std::exp(1.95655977725983*x_50) + 0.966154165025972*std::exp(1.98487973213196*x_50) - 1.83980445938916*std::exp(0.721999883651733*x_66) - 1.00225605867544*std::exp(0.787759840488434*x_71) + 1.12901464798194*std::exp(0.791999816894531*x_71) + 2.25784578622062*std::exp(1.15183985233307*x_71) + 0.0146195953318426*std::exp(1.16359984874725*x_71) - 6.07983474369456*std::exp(1.43479979038239*x_71) + 1.60118273618228e-5*std::exp(1.56895983219147*x_71) - 517.018559630421*std::exp(1.71743988990784*x_71) + 0.0117555162998736*std::exp(1.76351988315582*x_71) - 0.00171300774658688*std::exp(1.83151996135712*x_71) - 0.893735677988866*std::exp(1.83999979496002*x_71) - 0.0968413000230564*std::exp(1.9236798286438*x_71) + 0.365035234472108*std::exp(1.14375984668732*x_72) - 388.855038014432*std::exp(0.821839869022369*x_73) - 26.6837020834405*std::exp(0.863199889659882*x_73) + 0.475268429521323*std::exp(0.740559816360474*x_76) + 0.00627426750068463*std::exp(0.98175984621048*x_76) + 1.3011487644566*std::exp(1.20527982711792*x_76) - 0.0114427997771975*std::exp(1.75559985637665*x_76) - 4.50553129904856e-6*std::exp(2.1159999370575*x_76) + 0.113042575529929*std::exp(1.01855981349945*x_77) + 1.35570995861023*std::exp(1.47807991504669*x_77) + 0.447887521120717*std::exp(1.27991986274719*x_78) - 0.00905207944249271*std::exp(1.7519998550415*x_78) - 0.281719715787038*std::exp(1.35511994361877*x_81) - 0.409310892878913*std::exp(0.975599825382233*x_88) + 28.0862426141088*std::sin(0.370799839496613*x_102 + 8.17463970184326) + 2.21100458413518*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.0189074238495267*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 164.683016691504*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 9.07237664325861*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 29.5434220170529*std::sin(0.493919849395752*x_105 + 2.05367970466614) - 98.7683344565194*std::sin(0.52183985710144*x_109 + 2.17431998252869) + 0.95773617964992*std::sin(0.409119844436646*x_111 + 2.01191973686218) + 1.9601496262606*std::sin(0.2223199903965*x_112 - 7.58296012878418) + 0.578735609967625*std::sin(0.48431983590126*x_112 - 4.16656017303467) - 3.86609867677282*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 139.897231553748*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 81.6528705988982*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 36.3496498204253*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0970644562505491*std::sin(0.548159837722778*x_15 - 7.25176000595093) + 113.603512868089*std::sin(0.580159842967987*x_15 + 2.16847991943359) + 0.32622222995355*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 6.10110389129049*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 7.39506328444857*std::sin(0.489599853754044*x_19 - 1.11607992649078) - 6.35488786558075*std::sin(0.308639913797379*x_21 + 8.310959815979) - 2.80307945365257*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 80.4857462389412*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 8.43534184139028*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 39.9490458116278*std::sin(0.317279845476151*x_28 + 8.30079936981201) + 4.96683327589176*std::sin(0.321599841117859*x_28 + 8.31328010559082) + 2152.64295240056*std::sin(0.33519983291626*x_28 - 4.27343988418579) + 180.193741198587*std::sin(0.337279856204987*x_28 + 5.13632011413574) - 8749.96325214692*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 43.2147793051572*std::sin(0.354639858007431*x_28 - 4.23663997650146) + 0.905806468570498*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 8.58994405247464*std::sin(0.377119839191437*x_34 + 1.99303984642029) + 8.39495805429034*std::sin(0.239039987325668*x_36 + 1.82855987548828) - 21046.5797452664*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 29.8026603300465*std::sin(0.320719838142395*x_36 + 5.12007999420166) - 1.9200700169497*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 12.8254032395549*std::sin(0.348799854516983*x_36 + 5.15352010726929) - 1.46908280893287*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.0491760102506602*std::sin(0.357039839029312*x_36 + 5.15184020996094) - 1467.31934479256*std::sin(0.41967985033989*x_36 - 4.19840002059937) - 1.90610751763081*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.00122493566149923*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 7.52709645735743*std::sin(0.448239862918854*x_45 - 7.35192012786865) + 22568.4274840812*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 12.3695669820564*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 19.4089817728741*std::sin(0.376079827547073*x_46 - 4.22552013397217) - 1.56107639113312*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.121163836701956*std::sin(0.234399989247322*x_47 + 1.83199989795685) + 2.88034229980838*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 265.478595178466*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 6.71728153756212*std::sin(0.438159853219986*x_53 - 7.36560010910034) - 133.810242925353*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 21.0759030127043*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 7.94703413891132*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.109325074864985*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.000522269364818799*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.000385810206819631*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.00022196684229779*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.103785657873668*std::sin(0.530719876289368*x_73 - 4.05000019073486) + 5556.50389585458*std::sin(0.682479858398438*x_73 - 3.94495987892151) + 0.209722124769194*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 116.636246292792*std::sin(0.197119995951653*x_75 + 1.8083997964859) + 23950.9059315817*std::sin(0.277759969234467*x_75 - 7.51592016220093) + 0.255886148770257*std::sin(0.420239865779877*x_75 + 8.41903972625732) + 0.118541976161919*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 27.2587619970513*std::sin(0.179360002279282*x_80 + 1.77199983596802) + 562.708693018389*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 48.8233723513448*std::sin(0.23175998032093*x_80 + 5.05128002166748) - 1.89070189591417*std::sin(0.263199955224991*x_80 + 1.84135985374451) + 3069.08548907374*std::sin(0.289039850234985*x_80 - 1.3064798116684) + 65942.465079614*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.203713409525269*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 14.6723451588868*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 14.9503160757409*std::sin(0.249119967222214*x_87 + 1.84423983097076) - 0.976694200627613*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.080908501768284*std::sin(0.349439829587936*x_92 - 7.41207981109619) + 17633.3356755908*std::sin(0.361599832773209*x_92 - 1.17927992343903) - 6.07359912393899*std::sin(0.381679862737656*x_95 + 2.00063967704773) + 3.07451603837999*std::sin(0.272639960050583*x_96 + 5.06655979156494) - 3.92442377261497*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.157862291822677*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.000732422024540193*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 8.53517090443857*std::sin(0.54943984746933*x_99 - 7.41207981109619) - 555464.164521514 - 0.771143353638826*std::exp(-2.47855997085571*x_86) + 55.926941823954*std::exp(-2.40647983551025*x_86) - 0.000881552300355346*std::exp(-2.36967992782593*x_86) + 0.0872731583709672*std::exp(-2.33151984214783*x_86) + 0.461573827548207*std::exp(-2.33007979393005*x_86) + 0.272064630510403*std::exp(-2.11759996414185*x_23) + 0.0181713263448763*std::exp(-2.09047985076904*x_23) - 89.9359450587568*std::exp(-2.06727981567383*x_23));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.579461593821713*x_1 + 86.6522177294414*x_10 + 671.182757040728*x_100 - 16263.6676309888*x_101 - 1039.52991459123*x_102 + 1352.63797808475*x_103 + 1732.08454500217*x_104 - 1117.85413830543*x_105 - 768.988019806003*x_106 + 4231.46787690992*x_107 + 79.0616877966621*x_108 - 376.898441110227*x_109 - 976.751057693806*x_11 + 83.7606878728598*x_110 + 682.229380530373*x_111 - 50.6238729778656*x_112 - 991.503821965237*x_113 + 64.2093514475357*x_114 - 331.558601126276*x_115 - 1203.34454599895*x_116 - 170.695832206092*x_117 - 2106.90613135751*x_118 + 568.683091591109*x_119 + 742.34909262669*x_12 - 77.6683829592274*x_120 - 144.426838334721*x_13 - 291.595927489265*x_14 - 676.016815842496*x_15 + 963.611627816889*x_16 - 1311.50532505014*x_17 + 478.204352858287*x_18 - 895.497935738656*x_19 - 272.485431309146*x_2 + 1528.62701587347*x_20 + 835.917315398287*x_21 + 310.703479812737*x_22 - 260.641788967129*x_23 + 359.779477165283*x_24 + 341.709339246652*x_25 - 424.162053837158*x_26 + 288.872723224787*x_27 + 25.5421468748952*x_28 - 167.127866833461*x_29 + 211.617645587269*x_3 - 3150.59000122855*x_30 + 13028.5236066634*x_31 - 1315.62578218651*x_32 + 37.7762121416129*x_33 + 809.398963473938*x_34 + 418.358869250546*x_35 + 4.94854198018346*x_36 + 23.8659271547991*x_37 + 539.792977001542*x_38 - 3.25880266703572*x_39 + 2155.4250117467*x_4 - 2646.44255078436*x_40 - 1132.90869308514*x_41 - 180.490306376008*x_42 + 1422.21207846954*x_43 + 327.28493225986*x_44 + 934.707237702322*x_45 - 295.70651266168*x_46 - 373.087918320426*x_47 + 5190.46074877497*x_48 - 1709.12948209003*x_49 + 184.714644762853*x_5 + 29.0207221852212*x_50 - 115.488330084443*x_51 - 75.074044183543*x_52 - 1373.71536994372*x_53 + 238.663540007804*x_54 - 796.674295382055*x_55 + 622.569886049486*x_56 - 930.563099886974*x_57 + 50.1277356480803*x_58 + 1222.37666733578*x_59 - 168.154826326983*x_6 + 1697.24061602728*x_60 - 64.3934353996164*x_61 + 3877.5568939484*x_62 - 621.307639451751*x_63 + 2121.6057605002*x_64 + 565.344313280876*x_65 + 1221.40350780837*x_66 + 1309.7268219807*x_67 - 470.23080999898*x_68 + 152.317370869774*x_69 - 769.307412283047*x_7 + 470.933302326483*x_70 - 95.6692835525817*x_71 + 893.704530963449*x_72 - 10.7668145108417*x_73 + 591.595471931522*x_74 - 90.7056278743006*x_75 - 286.86318822134*x_76 - 145.557574954943*x_77 + 35.2390434172353*x_78 - 379.162201426648*x_79 + 13109.5810375717*x_8 - 735.204210636186*x_80 - 76.2576668982947*x_81 + 333.282738106744*x_82 - 2109.39196025315*x_83 + 3247.48553694453*x_84 + 435.558389743592*x_85 + 574.61750794268*x_86 + 691.375189972055*x_87 - 67.0892983447809*x_88 + 455.744152337004*x_89 - 3149.65979440252*x_9 + 2056.08815681136*x_90 - 882.80686635347*x_91 - 254.131682387674*x_92 + 33065.8517708337*x_93 + 1513.11460679889*x_94 - 841.666347384674*x_95 - 216.494554737078*x_96 - 789.817901676055*x_97 - 203.446958074346*x_98 + 753.468052669365*x_99 - 0.086889059436755*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) - 2.07625628163001e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) + 2.97756070369409e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.701664547057715*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) - 0.431230102185375*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) + 1.49600279635735*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) - 0.0347832028201641*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) - 3.3297206443151e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) - 4.00210806204839e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.584812166926884*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) - 0.257126665332932*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) - 0.00600865943123319*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) - 0.127145162386863*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) + 0.00288144568320002*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) - 0.027252863257953*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) + 0.468996680286604*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) + 0.00570402467526338*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.194521948920219*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) - 140.959695120769*std::exp(0.50519984960556*x_1) - 0.937012644729772*std::exp(0.69599986076355*x_1) + 2.51811663920229*std::exp(0.843999862670898*x_1) - 63.5158464379583*std::exp(0.92631983757019*x_1) + 0.0612937852665399*std::exp(0.954959809780121*x_1) + 6.22854574110813e-5*std::exp(1.04391980171204*x_1) + 0.00183142884440253*std::exp(1.06287980079651*x_1) + 7.23294554166188*std::exp(1.09599983692169*x_1) - 1.99707536414138*std::exp(1.10639989376068*x_1) - 0.00175450058028777*std::exp(1.12911987304688*x_1) - 6.05387491503726e-5*std::exp(1.14607977867126*x_1) + 0.0095690860324839*std::exp(1.15999984741211*x_1) - 0.00264232557343669*std::exp(1.06799972057343*x_108) - 9.3614134987097*std::exp(1.30215978622437*x_108) + 0.859806716227484*std::exp(1.4450398683548*x_108) + 0.0195639277554885*std::exp(1.48199987411499*x_108) - 0.0564935027163531*std::exp(1.49183988571167*x_108) + 0.0101541756071123*std::exp(2.85751986503601*x_17) + 0.000198640599409733*std::exp(3.06975984573364*x_17) - 1.16648479659093*std::exp(3.2435998916626*x_17) + 0.32791535877343*std::exp(3.34063982963562*x_17) - 0.0370817324377519*std::exp(3.72783994674683*x_17) - 0.00692351505781429*std::exp(3.84783983230591*x_17) + 6.22623812572694e-6*std::exp(4.00047969818115*x_17) + 7.64627784420407e-5*std::exp(4.29528045654297*x_17) - 1.61289518873655*std::exp(0.968399822711945*x_29) - 0.185160823769642*std::exp(1.05535984039307*x_29) + 0.594986456262578*std::exp(1.22887980937958*x_29) + 1.50758332227474*std::exp(1.27927994728088*x_29) + 7.87510604953949*std::exp(1.3769599199295*x_29) + 0.002144677721341*std::exp(1.50023984909058*x_29) - 0.000907410682619462*std::exp(1.51847982406616*x_29) - 0.00246592399463083*std::exp(2.48135995864868*x_29) + 2.05774948050401e-5*std::exp(2.79688000679016*x_29) + 0.00489620341228415*std::exp(3.16279983520508*x_29) + 74.2510026902739*std::exp(1.2364798784256*x_38) - 0.253751143551289*std::exp(1.59431982040405*x_38) - 0.000485390918630964*std::exp(1.63711988925934*x_38) - 0.104244077123822*std::exp(1.69327986240387*x_38) + 4.03743404990925e-5*std::exp(2.51567983627319*x_38) - 0.000445310658228636*std::exp(1.65847980976105*x_50) - 8.43960829588176*std::exp(1.70751988887787*x_50) + 0.38417529079158*std::exp(1.71991980075836*x_50) - 0.257747113580812*std::exp(1.87503981590271*x_50) + 384.027615272036*std::exp(1.90279984474182*x_50) - 0.0621810316987107*std::exp(1.92735981941223*x_50) - 0.00740415040080398*std::exp(1.93935978412628*x_50) + 752.609226898792*std::exp(1.95463979244232*x_50) + 0.666828524424282*std::exp(1.95655977725983*x_50) - 1.06715381287744*std::exp(1.98487973213196*x_50) - 2.10640519280021*std::exp(0.721999883651733*x_66) + 5.42223172621361*std::exp(0.787759840488434*x_71) + 1.29261688932216*std::exp(0.791999816894531*x_71) + 16.6874084205845*std::exp(1.15183985233307*x_71) + 0.00467158548237148*std::exp(1.16359984874725*x_71) + 6.71540739900858*std::exp(1.43479979038239*x_71) + 0.000283386764397358*std::exp(1.56895983219147*x_71) - 219.397008023344*std::exp(1.71743988990784*x_71) - 0.0133261910030736*std::exp(1.76351988315582*x_71) - 0.00147172117441954*std::exp(1.83151996135712*x_71) - 0.308379827029738*std::exp(1.83999979496002*x_71) + 0.0268599019644077*std::exp(1.9236798286438*x_71) - 0.101246168826121*std::exp(1.14375984668732*x_72) - 422.001231082951*std::exp(0.821839869022369*x_73) + 29.4731580640277*std::exp(0.863199889659882*x_73) - 2.57121474568481*std::exp(0.740559816360474*x_76) + 0.0053905023798803*std::exp(0.98175984621048*x_76) + 0.448956040141526*std::exp(1.20527982711792*x_76) + 0.2117227017084*std::exp(1.75559985637665*x_76) - 7.97415502850541e-5*std::exp(2.1159999370575*x_76) - 0.128146388007425*std::exp(1.01855981349945*x_77) + 0.467782156218143*std::exp(1.47807991504669*x_77) + 0.512789604060599*std::exp(1.27991986274719*x_78) - 0.00289252622586048*std::exp(1.7519998550415*x_78) + 1.52411109677814*std::exp(1.35511994361877*x_81) + 2.21438273187986*std::exp(0.975599825382233*x_88) + 207.581316829342*std::sin(0.370799839496613*x_102 + 8.17463970184326) - 1.58806308036482*std::sin(0.199760004878044*x_104 - 7.60799980163574) - 0.0162442091044346*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 184.864762542674*std::sin(0.424079865217209*x_105 + 2.02815985679626) - 2.51631429115564*std::sin(0.427519857883453*x_105 + 2.02951979637146) + 10.1938364953568*std::sin(0.493919849395752*x_105 + 2.05367970466614) + 109.093360585984*std::sin(0.52183985710144*x_109 + 2.17431998252869) - 17.7207060708551*std::sin(0.409119844436646*x_111 + 2.01191973686218) - 1.40788548146448*std::sin(0.2223199903965*x_112 - 7.58296012878418) - 10.7081718900105*std::sin(0.48431983590126*x_112 - 4.16656017303467) + 20.9156958647614*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 157.041503192815*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 91.6593516286477*std::sin(0.243999853730202*x_14 - 1.34103989601135) + 12.5422974602944*std::sin(0.435839861631393*x_14 - 1.17343986034393) - 0.0310162418577147*std::sin(0.548159837722778*x_15 - 7.25176000595093) - 125.479376172014*std::sin(0.580159842967987*x_15 + 2.16847991943359) - 6.03599234697266*std::sin(0.750319838523865*x_15 + 2.37279987335205) + 1.69220211165807*std::sin(0.438879877328873*x_17 - 4.15015983581543) + 2.0510946754493*std::sin(0.489599853754044*x_19 - 1.11607992649078) + 34.380111053477*std::sin(0.308639913797379*x_21 + 8.310959815979) + 0.777462088030913*std::sin(0.407759845256805*x_21 - 7.39471960067749) + 27.7712763569827*std::sin(0.254479974508286*x_26 + 5.05503988265991) + 9.65768278638083*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 295.257562557965*std::sin(0.317279845476151*x_28 + 8.30079936981201) - 26.8706990935486*std::sin(0.321599841117859*x_28 + 8.31328010559082) + 2336.13528741619*std::sin(0.33519983291626*x_28 - 4.27343988418579) - 199.030801643911*std::sin(0.337279856204987*x_28 + 5.13632011413574) - 3713.04999032821*std::sin(0.339599847793579*x_28 - 7.44679975509644) - 14.9110822086021*std::sin(0.354639858007431*x_28 - 4.23663997650146) - 16.7598661590547*std::sin(0.36287984251976*x_3 + 5.1689600944519) + 9.83468795591641*std::sin(0.377119839191437*x_34 + 1.99303984642029) - 45.4169446103054*std::sin(0.239039987325668*x_36 + 1.82855987548828) - 8931.123533625*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 220.267109464509*std::sin(0.320719838142395*x_36 + 5.12007999420166) + 1.37909813824557*std::sin(0.338559836149216*x_36 - 1.2196798324585) + 14.6838952616327*std::sin(0.348799854516983*x_36 + 5.15352010726929) + 27.1819998074641*std::sin(0.352879852056503*x_36 + 1.94455981254578) + 0.0422492984655622*std::sin(0.357039839029312*x_36 + 5.15184020996094) - 1592.39436129231*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 2.16078581360276*std::sin(0.3711998462677*x_39 - 1.21975982189178) + 0.0216796338021276*std::sin(0.317759841680527*x_43 + 1.93063986301422) + 2.08771539491029*std::sin(0.448239862918854*x_45 - 7.35192012786865) + 9576.92015802808*std::sin(0.324479848146439*x_46 + 8.31719970703125) + 3.43082296913719*std::sin(0.366639852523804*x_46 - 4.23992013931274) - 6.69698948956676*std::sin(0.376079827547073*x_46 - 4.22552013397217) + 28.8841295434123*std::sin(0.406079858541489*x_46 - 7.39928007125854) - 0.0387170238079324*std::sin(0.234399989247322*x_47 + 1.83199989795685) - 15.5827278520184*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 298.012742563281*std::sin(0.281999945640564*x_53 + 5.10016012191772) + 1.86310513720166*std::sin(0.438159853219986*x_53 - 7.36560010910034) + 147.798473689763*std::sin(0.430799871683121*x_55 + 5.22815990447998) - 7.27215382089093*std::sin(0.524799883365631*x_55 - 4.24552011489868) - 9.09861582959809*std::sin(0.488879859447479*x_58 + 2.04247975349426) - 0.0939260361748983*std::sin(0.264479964971542*x_68 - 4.31527996063232) - 0.00924343125212249*std::sin(0.433999866247177*x_69 + 8.42216014862061) - 0.00682829659048011*std::sin(0.576959848403931*x_70 + 1.96287977695465) + 0.00392850009064229*std::sin(0.594559848308563*x_72 - 4.00647974014282) - 0.0331639530093539*std::sin(0.530719876289368*x_73 - 4.05000019073486) + 2357.9043868212*std::sin(0.682479858398438*x_73 - 3.94495987892151) - 3.8804257462097*std::sin(0.779519855976105*x_73 - 0.783679842948914) + 40.2448580078026*std::sin(0.197119995951653*x_75 + 1.8083997964859) + 10163.5753745355*std::sin(0.277759969234467*x_75 - 7.51592016220093) - 0.183791272326887*std::sin(0.420239865779877*x_75 + 8.41903972625732) - 0.0851432589362373*std::sin(0.723519861698151*x_78 - 4.04087972640991) + 7.56048994321226*std::sin(0.179360002279282*x_80 + 1.77199983596802) - 621.533031716229*std::sin(0.206720009446144*x_80 - 4.40223979949951) - 16.8463042166968*std::sin(0.23175998032093*x_80 + 5.05128002166748) + 1.35800436526525*std::sin(0.263199955224991*x_80 + 1.84135985374451) + 3330.69583282568*std::sin(0.289039850234985*x_80 - 1.3064798116684) + 27982.7083006323*std::sin(0.180560007691383*x_85 + 1.76799988746643) + 0.0650951401116996*std::sin(0.364479839801788*x_85 - 4.43111991882324) - 4.06952150024651*std::sin(0.331359833478928*x_86 - 4.28560018539429) - 17.1167230600152*std::sin(0.249119967222214*x_87 + 1.84423983097076) + 18.0714806626154*std::sin(0.347199827432632*x_92 + 1.99871981143951) - 0.0695120938479105*std::sin(0.349439829587936*x_92 - 7.41207981109619) + 7482.71220952179*std::sin(0.361599832773209*x_92 - 1.17927992343903) + 32.8583315381979*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 3.48530740159032*std::sin(0.272639960050583*x_96 + 5.06655979156494) + 21.2312361724227*std::sin(0.459359854459763*x_96 - 7.34767961502075) - 0.050443748541141*std::sin(0.382559835910797*x_97 - 7.41663980484009) - 0.0129628369715435*std::sin(0.527519822120667*x_98 + 5.16128015518188) + 2.94502568489026*std::sin(0.54943984746933*x_99 - 7.41207981109619) - 279054.597554009 - 0.865646232506485*std::exp(-2.47855997085571*x_86) + 23.7326174767153*std::exp(-2.40647983551025*x_86) + 0.000633178543206224*std::exp(-2.36967992782593*x_86) + 0.645023166231592*std::exp(-2.33151984214783*x_86) - 0.509825748129194*std::exp(-2.33007979393005*x_86) + 0.0938747839702476*std::exp(-2.11759996414185*x_23) - 0.0205992284365775*std::exp(-2.09047985076904*x_23) - 38.1643499872574*std::exp(-2.06727981567383*x_23));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.31044208563358*x_1 - 1437.18255733491*x_10 - 1756.70021567496*x_100 + 17790.3465447944*x_101 + 2906.91904996577*x_102 - 3734.96197159115*x_103 - 4766.81810518638*x_104 + 2050.66964194911*x_105 + 1509.12957250818*x_106 - 12041.6147504854*x_107 - 281.782333208293*x_108 + 97.3177392749715*x_109 + 3093.15653716768*x_11 - 645.052764184087*x_110 - 475.148938724456*x_111 - 684.424001675448*x_112 + 4282.51259685147*x_113 - 118.447638627414*x_114 + 335.328649675536*x_115 + 2447.34543120875*x_116 - 169.632937338293*x_117 + 4580.35023118972*x_118 - 652.621878393504*x_119 - 468.195122856238*x_12 - 729.378272437422*x_120 + 563.474595626496*x_13 - 172.235543018546*x_14 + 1357.25391412853*x_15 - 1548.08046848685*x_16 + 2981.11573113366*x_17 - 2044.57232067913*x_18 + 2251.37351648899*x_19 + 1428.12032253086*x_2 - 3767.04590810068*x_20 - 1722.10989382805*x_21 - 956.544811018313*x_22 + 942.793972866487*x_23 - 955.91225054815*x_24 - 580.62728427131*x_25 + 1010.72877261152*x_26 - 1208.45975317638*x_27 + 2.25077070601678*x_28 + 764.06759633292*x_29 - 939.584538139723*x_3 + 8226.03971351956*x_30 - 57043.0678765465*x_31 + 2753.29567286318*x_32 - 228.877853615753*x_33 - 1341.00951612035*x_34 - 1309.68435350293*x_35 + 4.4820920289024*x_36 - 1290.33949279515*x_37 - 1157.89255666514*x_38 - 149.990109736457*x_39 - 6866.57908431147*x_4 + 7851.61306009933*x_40 + 2777.99354037516*x_41 + 1278.34426985142*x_42 - 4374.22618230771*x_43 - 1284.63913381835*x_44 - 3037.52921705156*x_45 + 1126.83860649121*x_46 + 360.886267038121*x_47 - 12116.2907146016*x_48 + 3899.57559944337*x_49 - 384.890463022414*x_5 - 10.5236196746056*x_50 + 923.310509873757*x_51 + 404.430096451705*x_52 + 3883.51037473567*x_53 - 2375.90183565729*x_54 + 2559.82200672395*x_55 - 2074.36207486901*x_56 + 3081.23036993433*x_57 - 572.912770092323*x_58 - 2557.48068419121*x_59 + 87.9612613121567*x_6 - 4836.67261758951*x_60 + 1080.49492581783*x_61 - 9500.98111492959*x_62 + 598.358661738323*x_63 - 6675.81773653193*x_64 - 2209.92124792192*x_65 - 3832.61351184873*x_66 - 3874.8049490833*x_67 + 975.488257637238*x_68 - 953.24949630766*x_69 + 1276.31213359541*x_7 + 326.617181680709*x_70 + 287.852055816293*x_71 - 4534.61854878557*x_72 + 0.958891357321502*x_73 - 1492.83434504819*x_74 + 407.748607484433*x_75 + 1258.81622616528*x_76 + 1221.09468486823*x_77 + 1228.61016102715*x_78 + 1849.56162926632*x_79 - 37369.3559340253*x_8 + 1747.9874021874*x_80 + 641.907329351089*x_81 + 310.456276885125*x_82 + 4892.99475587848*x_83 - 8730.31063375514*x_84 - 2136.39763263036*x_85 - 2700.22910394767*x_86 - 1749.02838263137*x_87 - 507.405703130095*x_88 - 2689.0243302864*x_89 + 10992.4189160197*x_9 - 7527.72796507123*x_90 + 3812.86081820843*x_91 + 880.367132204495*x_92 - 100731.913187043*x_93 - 3943.3608742358*x_94 + 904.22184490158*x_95 + 1506.89680459935*x_96 + 2578.41025833749*x_97 - 142.341785263689*x_98 - 2797.37026354374*x_99 + 0.0592846939924014*std::pow(-4.49535989761353*x_110 - 5.27903985977173, 2) + 1.04102702991587e-5*std::pow(-6.69600009918213*x_117 - 6.89455986022949, 2) - 2.31346617736022e-5*std::pow(-6.09904003143311*x_13 - 9.64239978790283, 2) - 0.0256584321179288*std::pow(-4.52983999252319*x_13 - 6.38120031356812, 2) - 0.0699541111747113*std::pow(-4.37799978256226*x_14 - 6.77135992050171, 2) + 0.0387893259674608*std::pow(-1.07447981834412*x_15 - 1.50663983821869, 2) - 0.000901881330482061*std::pow(-8.04103946685791*x_18 - 8.23880004882813, 2) + 1.66950931032445e-5*std::pow(-6.55184030532837*x_18 - 8.34200000762939, 2) + 2.00664181300671e-5*std::pow(-6.59536027908325*x_23 - 7.60136032104492, 2) + 0.0213853804496097*std::pow(-5.16663980484009*x_26 - 4.96591949462891, 2) - 0.0417110661837576*std::pow(-5.81175994873047*x_49 - 8.41024017333984, 2) + 0.0047508716409063*std::pow(-9.09992027282715*x_52 - 8.68696022033691, 2) + 0.100529968984812*std::pow(-2.09983968734741*x_6 - 3.15583968162537, 2) - 0.00131884053940404*std::pow(-8.08888053894043*x_67 - 9.91239929199219, 2) - 0.000706629826517292*std::pow(-7.46287965774536*x_67 - 9.47175979614258, 2) + 0.0760806023213012*std::pow(-6.34416007995605*x_75 - 7.33464002609253, 2) - 0.00261073773604641*std::pow(-5.84904003143311*x_75 - 7.45959997177124, 2) + 0.00711326835985359*std::pow(-8.1832799911499*x_83 - 8.7772798538208, 2) + 654.182454595214*std::exp(0.50519984960556*x_1) + 0.639326841260718*std::exp(0.69599986076355*x_1) + 2.23224445411306*std::exp(0.843999862670898*x_1) + 149.571472838633*std::exp(0.92631983757019*x_1) + 0.00158926482107687*std::exp(0.954959809780121*x_1) - 3.12296922635701e-5*std::exp(1.04391980171204*x_1) - 0.000838246793654477*std::exp(1.06287980079651*x_1) + 0.264493970760848*std::exp(1.09599983692169*x_1) - 0.323965398842606*std::exp(1.10639989376068*x_1) - 0.000868039720419604*std::exp(1.12911987304688*x_1) + 4.70366056367295e-5*std::exp(1.14607977867126*x_1) - 0.012821808835657*std::exp(1.15999984741211*x_1) + 0.00549083094731169*std::exp(1.06799972057343*x_108) - 8.2986479020979*std::exp(1.30215978622437*x_108) + 0.0222936234250149*std::exp(1.4450398683548*x_108) - 0.0089544290854915*std::exp(1.48199987411499*x_108) - 0.0259494983802029*std::exp(1.49183988571167*x_108) + 0.00466417819394267*std::exp(2.85751986503601*x_17) - 0.000412781059834692*std::exp(3.06975984573364*x_17) + 5.41356085388852*std::exp(3.2435998916626*x_17) + 0.0531944021237898*std::exp(3.34063982963562*x_17) - 0.00135600283434442*std::exp(3.72783994674683*x_17) + 0.00472393733129393*std::exp(3.84783983230591*x_17) - 4.83758107708417e-6*std::exp(4.00047969818115*x_17) + 3.78299839664054e-5*std::exp(4.29528045654297*x_17) + 2.16115036605674*std::exp(0.968399822711945*x_29) - 0.0850510282680082*std::exp(1.05535984039307*x_29) - 0.470438425431125*std::exp(1.22887980937958*x_29) - 1.02862911059777*std::exp(1.27927994728088*x_29) + 0.287976462315088*std::exp(1.3769599199295*x_29) - 0.00445670394395524*std::exp(1.50023984909058*x_29) + 0.000454972276880802*std::exp(1.51847982406616*x_29) - 0.00122001668105704*std::exp(2.48135995864868*x_29) - 1.59880328173342e-5*std::exp(2.79688000679016*x_29) + 0.000126951921897824*std::exp(3.16279983520508*x_29) - 344.592850846217*std::exp(1.2364798784256*x_38) + 0.340006207844641*std::exp(1.59431982040405*x_38) + 0.00024337316681052*std::exp(1.63711988925934*x_38) + 0.0711260802322813*std::exp(1.69327986240387*x_38) - 3.1369527097128e-5*std::exp(2.51567983627319*x_38) + 0.000345991651808086*std::exp(1.65847980976105*x_50) - 7.48149173079477*std::exp(1.70751988887787*x_50) - 0.303756189720351*std::exp(1.71991980075836*x_50) + 0.17586171210871*std::exp(1.87503981590271*x_50) - 1782.24085811032*std::exp(1.90279984474182*x_50) - 0.0307640852203642*std::exp(1.92735981941223*x_50) + 0.0153860442361793*std::exp(1.93935978412628*x_50) - 1772.29584193849*std::exp(1.95463979244232*x_50) + 0.0172899603271302*std::exp(1.95655977725983*x_50) - 0.173113602432268*std::exp(1.98487973213196*x_50) + 1.66547310748122*std::exp(0.721999883651733*x_66) + 0.140591123500124*std::exp(0.787759840488434*x_71) - 1.02203444750351*std::exp(0.791999816894531*x_71) + 14.7929505410718*std::exp(1.15183985233307*x_71) - 0.00970769325229479*std::exp(1.16359984874725*x_71) + 1.08937282762274*std::exp(1.43479979038239*x_71) - 0.000142089049539898*std::exp(1.56895983219147*x_71) + 516.651126715201*std::exp(1.71743988990784*x_71) - 0.00612119899140955*std::exp(1.76351988315582*x_71) + 0.00114347867208899*std::exp(1.83151996135712*x_71) + 0.413204268153278*std::exp(1.83999979496002*x_71) - 0.0122938036977809*std::exp(1.9236798286438*x_71) + 0.0463404716201152*std::exp(1.14375984668732*x_72) + 1958.47331363426*std::exp(0.821839869022369*x_73) + 4.78113324054202*std::exp(0.863199889659882*x_73) - 0.0666681152906657*std::exp(0.740559816360474*x_76) - 0.00418824204637075*std::exp(0.98175984621048*x_76) - 0.601565134096089*std::exp(1.20527982711792*x_76) - 0.144459102945674*std::exp(1.75559985637665*x_76) + 3.99821110662533e-5*std::exp(2.1159999370575*x_76) - 0.0588622465971639*std::exp(1.01855981349945*x_77) - 0.626790621737525*std::exp(1.47807991504669*x_77) - 0.405447773428403*std::exp(1.27991986274719*x_78) + 0.00601075532725073*std::exp(1.7519998550415*x_78) + 0.0395181361208029*std::exp(1.35511994361877*x_81) + 0.0574159445508728*std::exp(0.975599825382233*x_88) + 184.015401056472*std::sin(0.370799839496613*x_102 + 8.17463970184326) - 0.785694714368502*std::sin(0.199760004878044*x_104 - 7.60799980163574) + 0.0126212131609785*std::sin(0.329119831323624*x_105 - 7.45895957946777) - 6.76012487817495*std::sin(0.424079865217209*x_105 + 2.02815985679626) + 1.1517195400929*std::sin(0.427519857883453*x_105 + 2.02951979637146) - 13.6589244157397*std::sin(0.493919849395752*x_105 + 2.05367970466614) + 17.6971158464587*std::sin(0.52183985710144*x_109 + 2.17431998252869) + 12.0908966393476*std::sin(0.409119844436646*x_111 + 2.01191973686218) - 0.696551789975928*std::sin(0.2223199903965*x_112 - 7.58296012878418) + 7.30622126459301*std::sin(0.48431983590126*x_112 - 4.16656017303467) + 0.542315660578958*std::sin(0.452719867229462*x_117 - 7.37175989151001) + 5.74268539898011*std::sin(0.427359849214554*x_120 - 1.15639984607697) + 3.35179433191966*std::sin(0.243999853730202*x_14 - 1.34103989601135) - 16.8056740058484*std::sin(0.435839861631393*x_14 - 1.17343986034393) + 0.0644526709250821*std::sin(0.548159837722778*x_15 - 7.25176000595093) - 20.3552539268168*std::sin(0.580159842967987*x_15 + 2.16847991943359) + 4.11837763638376*std::sin(0.750319838523865*x_15 + 2.37279987335205) - 0.774522580360182*std::sin(0.438879877328873*x_17 - 4.15015983581543) - 0.938788061808673*std::sin(0.489599853754044*x_19 - 1.11607992649078) + 0.891429707015248*std::sin(0.308639913797379*x_21 + 8.310959815979) - 0.355845166724146*std::sin(0.407759845256805*x_21 - 7.39471960067749) - 37.2112859433664*std::sin(0.254479974508286*x_26 + 5.05503988265991) - 7.6360479058253*std::sin(0.299919933080673*x_28 + 5.10191965103149) - 261.738096756213*std::sin(0.317279845476151*x_28 + 8.30079936981201) - 0.696720827428346*std::sin(0.321599841117859*x_28 + 8.31328010559082) - 10841.813436664*std::sin(0.33519983291626*x_28 - 4.27343988418579) - 32.2867600263325*std::sin(0.337279856204987*x_28 + 5.13632011413574) + 8743.7448593138*std::sin(0.339599847793579*x_28 - 7.44679975509644) + 19.979655837814*std::sin(0.354639858007431*x_28 - 4.23663997650146) + 11.4353123745848*std::sin(0.36287984251976*x_3 + 5.1689600944519) - 7.77600072722656*std::sin(0.377119839191437*x_34 + 1.99303984642029) - 1.17759985023079*std::sin(0.239039987325668*x_36 + 1.82855987548828) + 21031.6224366608*std::sin(0.31535992026329*x_36 + 1.90343987941742) + 195.261024001425*std::sin(0.320719838142395*x_36 + 5.12007999420166) + 0.682309242757581*std::sin(0.338559836149216*x_36 - 1.2196798324585) - 11.6101274127649*std::sin(0.348799854516983*x_36 + 5.15352010726929) - 18.5463687964074*std::sin(0.352879852056503*x_36 + 1.94455981254578) - 0.0328263074186907*std::sin(0.357039839029312*x_36 + 5.15184020996094) + 7390.17242525448*std::sin(0.41967985033989*x_36 - 4.19840002059937) + 0.992526667209453*std::sin(0.3711998462677*x_39 - 1.21975982189178) - 0.0108700862154523*std::sin(0.317759841680527*x_43 + 1.93063986301422) - 0.955549401329624*std::sin(0.448239862918854*x_45 - 7.35192012786865) - 22552.3886341252*std::sin(0.324479848146439*x_46 + 8.31719970703125) - 1.57029106659811*std::sin(0.366639852523804*x_46 - 4.23992013931274) + 8.97342951230002*std::sin(0.376079827547073*x_46 - 4.22552013397217) - 19.7077375715466*std::sin(0.406079858541489*x_46 - 7.39928007125854) + 0.0804551243228892*std::sin(0.234399989247322*x_47 + 1.83199989795685) - 0.404039024249118*std::sin(0.497679859399796*x_49 - 4.12728023529053) + 10.8977142388082*std::sin(0.281999945640564*x_53 + 5.10016012191772) - 0.852745064201483*std::sin(0.438159853219986*x_53 - 7.36560010910034) + 23.9758560628075*std::sin(0.430799871683121*x_55 + 5.22815990447998) + 9.74410364777049*std::sin(0.524799883365631*x_55 - 4.24552011489868) + 7.19400998027062*std::sin(0.488879859447479*x_58 + 2.04247975349426) + 0.0729774232963763*std::sin(0.264479964971542*x_68 - 4.31527996063232) + 0.00463462139417306*std::sin(0.433999866247177*x_69 + 8.42216014862061) + 0.00342368202897937*std::sin(0.576959848403931*x_70 + 1.96287977695465) - 0.00196973505514208*std::sin(0.594559848308563*x_72 - 4.00647974014282) + 0.0689156784272081*std::sin(0.530719876289368*x_73 - 4.05000019073486) - 5552.55501938418*std::sin(0.682479858398438*x_73 - 3.94495987892151) + 2.64762738157763*std::sin(0.779519855976105*x_73 - 0.783679842948914) - 53.9248862683973*std::sin(0.197119995951653*x_75 + 1.8083997964859) - 23933.8845867486*std::sin(0.277759969234467*x_75 - 7.51592016220093) - 0.0909307904703155*std::sin(0.420239865779877*x_75 + 8.41903972625732) - 0.0421246544532366*std::sin(0.723519861698151*x_78 - 4.04087972640991) - 3.46044372552302*std::sin(0.179360002279282*x_80 + 1.77199983596802) - 100.825036515521*std::sin(0.206720009446144*x_80 - 4.40223979949951) + 22.5726983246424*std::sin(0.23175998032093*x_80 + 5.05128002166748) + 0.671873091863044*std::sin(0.263199955224991*x_80 + 1.84135985374451) - 15457.4878553843*std::sin(0.289039850234985*x_80 - 1.3064798116684) - 65895.6013225406*std::sin(0.180560007691383*x_85 + 1.76799988746643) - 0.135269632719798*std::sin(0.364479839801788*x_85 - 4.43111991882324) + 1.86262401606024*std::sin(0.331359833478928*x_86 - 4.28560018539429) + 13.5336933473667*std::sin(0.249119967222214*x_87 + 1.84423983097076) - 12.3302313089553*std::sin(0.347199827432632*x_92 + 1.99871981143951) + 0.0540085976534812*std::sin(0.349439829587936*x_92 - 7.41207981109619) - 17620.8040791682*std::sin(0.361599832773209*x_92 - 1.17927992343903) + 0.851972025644266*std::sin(0.381679862737656*x_95 + 2.00063967704773) - 1.60092708760112*std::sin(0.272639960050583*x_96 + 5.06655979156494) + 0.550497193313754*std::sin(0.459359854459763*x_96 - 7.34767961502075) + 0.104823606285526*std::sin(0.382559835910797*x_97 - 7.41663980484009) + 0.00649951732412113*std::sin(0.527519822120667*x_98 + 5.16128015518188) - 3.94609853225041*std::sin(0.54943984746933*x_99 - 7.41207981109619) + 798611.453892551 - 0.0316549057352922*std::exp(-2.47855997085571*x_86) - 55.8871958634059*std::exp(-2.40647983551025*x_86) + 0.00031326528574318*std::exp(-2.36967992782593*x_86) + 0.571796144459395*std::exp(-2.33151984214783*x_86) - 0.0827038902980588*std::exp(-2.33007979393005*x_86) - 0.125784691502316*std::exp(-2.11759996414185*x_23) - 0.00946196676159832*std::exp(-2.09047985076904*x_23) + 89.8720297004773*std::exp(-2.06727981567383*x_23));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
