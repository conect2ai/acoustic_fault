
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.46132664734465*x_1 + 1.75296906659002*x_10 + 2.2839094401307*x_100 - 34.2907135891467*x_101 - 2.83565937137434*x_102 - 2.57178884188606*x_103 + 8.16692486011362*x_104 - 0.305679356971545*x_105 + 6.45355059903965*x_106 + 0.151801061540054*x_107 + 2.66971820893761*x_108 + 4.83637889569229*x_109 - 0.298696706757361*x_11 + 5.44742176731095*x_110 + 1.7256057189128*x_111 - 3.91858547977465*x_112 - 1.33351314871393*x_113 - 0.275774669780672*x_114 + 9.31324000904026*x_115 + 0.593323101801992*x_116 - 6.981063689043*x_117 + 9.73901080761713*x_118 - 4.7545783958795*x_119 + 0.404818358269345*x_12 + 5.64771364848551*x_120 - 2.25051800625126*x_13 - 2.42260305750237*x_14 - 0.303836387443172*x_15 - 4.90938247626755*x_16 - 2.02426530666361*x_17 + 4.85554302273353*x_18 + 2.6574556011956*x_19 - 0.782798980771536*x_2 - 1.19771611984563*x_20 + 2.14930485464105*x_21 + 2.51703792732186*x_22 + 3.64622183282754*x_23 + 0.618687160056547*x_24 + 8.72165853669525*x_25 + 6.18198421438318*x_26 - 2.29448043467814*x_27 - 0.160601240810991*x_28 + 0.535176391763109*x_29 + 4.58422831800341*x_3 + 10.9758967591118*x_30 + 135.894817477981*x_31 + 1.58486594505697*x_32 - 9.10276303355725*x_33 + 3.40396595000858*x_34 + 0.765943916249168*x_35 + 2.11959679953614*x_36 + 7.30715779572873*x_37 + 2.21684377917154*x_38 + 7.99105869005454*x_39 - 25.2882950557031*x_4 + 0.300701335788683*x_40 - 9.55011150605898*x_41 + 14.8365004268138*x_42 - 8.98550212920388*x_43 - 4.9628173677168*x_44 + 7.04470809623209*x_45 + 1.97960652757596*x_46 + 6.75689028029831*x_47 - 32.5167581256885*x_48 - 14.2426914855961*x_49 + 2.75867075088631*x_5 - 0.153088340441037*x_50 + 6.00454645167296*x_51 + 6.88181231288692*x_52 + 2.05870778973795*x_53 - 7.44015828538016*x_54 - 6.05215640994011*x_55 - 4.78464615983599*x_56 + 3.56407909500294*x_57 - 1.27674995673902*x_58 - 1.0854607238653*x_59 - 2.73366496064659*x_6 + 1.44748603379919*x_60 - 2.26038846636105*x_61 + 2.08794818003685*x_62 - 5.31966527303043*x_63 - 3.04183037666738*x_64 + 0.530771963037923*x_65 + 1.55897939429854*x_66 - 3.98730631252034*x_67 + 3.03621232990398*x_68 + 1.85899299335463*x_69 - 3.29446320518869*x_7 - 3.95650702027393*x_70 - 0.139580773768806*x_71 - 11.8648081272991*x_72 - 2.08467183484121*x_73 + 3.8580785073461*x_74 - 4.54737631405556*x_75 - 7.05943817693732*x_76 - 0.192600618245436*x_77 + 3.82687782971301*x_78 + 0.982078282087018*x_79 - 76.4097564107529*x_8 - 0.519404190758349*x_80 + 0.739770898445943*x_81 + 4.41618182311888*x_82 + 4.08906876729103*x_83 - 11.518854295112*x_84 - 0.264376256923232*x_85 + 9.65592938463205*x_86 - 6.38823736219138*x_87 + 2.0474355240364*x_88 - 12.8932192713385*x_89 + 55.5756102774908*x_9 - 1.30547940070077*x_90 - 3.7928337083998*x_91 + 3.61301411552919*x_92 + 290.694283969389*x_93 + 1.69292986993455*x_94 - 3.58371598710519*x_95 + 7.08050975156351*x_96 + 2.10310006945202*x_97 - 5.07292887160079*x_98 - 0.729401825329558*x_99 - 0.0268710777682535*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) - 0.00354913011718078*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.000117870892312841*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00510818209852815*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 3.86537502541426e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 8.05014992334296e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00226232756386985*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 1.33544145602211e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.0451801509653855*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) - 0.00529983031188938*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) + 0.0129961746900711*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 4.13194961386696e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.00807111443227182*std::exp(0.459359854459763*x_1) - 2.08531007979322*std::exp(0.553199887275696*x_1) - 0.000898119657418032*std::exp(1.07583975791931*x_1) - 0.00854882604574693*std::exp(1.12799990177155*x_1) - 0.024970176785237*std::exp(1.14143979549408*x_1) - 0.0473821700008505*std::exp(1.17095983028412*x_1) + 0.431433543647544*std::exp(0.854959905147552*x_108) - 0.155219602982804*std::exp(1.12103986740112*x_108) - 1.31155422532695*std::exp(0.783599853515625*x_15) - 0.0840749215780759*std::exp(2.65919995307922*x_17) - 0.00358417628105656*std::exp(3.37599992752075*x_17) - 0.0317210731823708*std::exp(3.38383984565735*x_17) - 0.00128391389872981*std::exp(3.54839992523193*x_17) + 0.0067443914895506*std::exp(3.8503999710083*x_17) - 2.29437026357576e-6*std::exp(4.05463981628418*x_17) - 0.27126087063701*std::exp(0.856879889965057*x_29) + 0.974539534810491*std::exp(0.877039849758148*x_29) + 1.17141869229219*std::exp(1.00639986991882*x_29) - 2.31071532200651*std::exp(1.10455989837646*x_29) - 0.000915034869228597*std::exp(1.58135986328125*x_29) - 6.79159468378069e-5*std::exp(2.08335995674133*x_29) + 0.000351847298034368*std::exp(1.54199981689453*x_38) + 0.0343952760130835*std::exp(1.65999984741211*x_38) - 0.34566889282099*std::exp(1.84159982204437*x_50) - 0.192167503344377*std::exp(1.84279990196228*x_50) - 0.00824758271436995*std::exp(1.86639988422394*x_50) - 0.00101694171164803*std::exp(1.92463982105255*x_50) - 0.592648584048581*std::exp(1.92519986629486*x_50) + 0.179404815220121*std::exp(1.9385598897934*x_50) - 1.33290095469207*std::exp(1.95839989185333*x_50) + 0.422110547565292*std::exp(1.97631978988647*x_50) + 4.32372246770601*std::exp(0.794959902763367*x_66) - 0.00269371487812866*std::exp(0.697999835014343*x_67) - 3.27932461435*std::exp(0.72519987821579*x_7) - 0.631709064594265*std::exp(1.3575998544693*x_71) + 0.504741517735246*std::exp(1.5887998342514*x_71) + 0.481532855450233*std::exp(1.62775981426239*x_71) + 0.00166103671327629*std::exp(1.83247983455658*x_71) + 0.000608913693262656*std::exp(1.8958398103714*x_71) - 0.0170212876005138*std::exp(1.97847986221313*x_71) + 0.0544413072232363*std::exp(1.99599981307983*x_71) - 0.00123455034911009*std::exp(1.21479988098145*x_77) - 0.308710419746884*std::exp(1.32791984081268*x_77) + 0.541113642453971*std::exp(0.814639866352081*x_78) + 0.118399934392225*std::exp(1.25415980815887*x_78) - 0.852221279689043*std::exp(1.2727198600769*x_78) + 0.00156572448650689*std::exp(1.48223996162415*x_78) - 0.395723631239438*std::exp(1.75423991680145*x_78) + 0.792682283645948*std::exp(0.863119900226593*x_87) - 0.00498460005089563*std::exp(0.901039838790894*x_87) + 6.81112529838874*std::sin(0.241679981350899*x_100 + 1.81343984603882) + 1.80543479668576*std::sin(0.609119892120361*x_100 - 0.991599798202515) - 1.19416107602023*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.0161239333460375*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.0530497557584064*std::sin(0.387279838323593*x_105 - 7.41224002838135) - 9.52280441966503*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 15.4503173504931*std::sin(0.502319812774658*x_105 + 2.05711984634399) + 13.0443678724793*std::sin(0.348479837179184*x_112 + 1.95431983470917) + 17.0718221914493*std::sin(0.379999846220016*x_112 + 1.9871199131012) - 8.64650421997874*std::sin(0.4059998691082*x_112 + 1.9936797618866) - 8.81371890256812*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 1.26303733040606*std::sin(0.56199985742569*x_118 + 8.39344024658203) + 17.7955289972211*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0164879289581103*std::sin(0.332639902830124*x_14 - 1.29095983505249) + 4.60739678853436*std::sin(0.419839859008789*x_14 - 1.15535986423492) + 5.9367974528015*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0209819659794358*std::sin(0.39727982878685*x_16 + 2.0079197883606) + 25.3640546065517*std::sin(0.128400042653084*x_26 + 1.70263993740082) - 5.13629044285441*std::sin(0.330239832401276*x_28 + 8.3089599609375) + 8.60041045635647*std::sin(0.333119839429855*x_28 - 4.27583980560303) + 3.85340879641798*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 37.5562792284819*std::sin(0.312319844961166*x_33 - 1.17319989204407) + 5.30957272656706*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 44.3242377124021*std::sin(0.293199926614761*x_36 + 1.90127992630005) - 12.7977305100871*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0383620468138715*std::sin(0.353839844465256*x_36 + 1.97599983215332) - 24.0617162878848*std::sin(0.370239853858948*x_36 - 1.19343984127045) + 10.4873568367305*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.0914970792304002*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.096843359859129*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 12.2006513791224*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 2.51547816334598*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.033755840837846*std::sin(0.321119844913483*x_53 + 5.12696027755737) - 3.2097691292854*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0326954474961015*std::sin(0.249279975891113*x_55 - 7.55600023269653) - 1.39314827114706*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.051947165596153*std::sin(0.217199996113777*x_64 - 4.36175966262817) - 1.45002006770399*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.00735187232479928*std::sin(0.694319844245911*x_73 + 8.65120029449463) + 33.7213639250379*std::sin(0.187120005488396*x_75 - 7.62423992156982) - 7.3155444308118*std::sin(0.484159857034683*x_75 + 8.49135971069336) - 19.2592563827845*std::sin(0.517359852790833*x_79 - 1.05527985095978) + 5.89047241743373*std::sin(0.388479858636856*x_8 + 8.37639999389648) - 15.1181326650302*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 1.1471990195878*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 2.28647557777362*std::sin(0.419279843568802*x_86 + 2.0163197517395) - 11.4204708065505*std::sin(0.425759851932526*x_86 + 1.99495983123779) + 2.2639411008831*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.0201769306242217*std::sin(0.347679853439331*x_92 + 5.18296003341675) + 10.7738980799813*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.0683573985986794*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.041644237690913*std::sin(0.362639844417572*x_92 + 1.99015974998474) - 4.10985761939823*std::sin(0.365199834108353*x_92 + 1.99327981472015) + 4.03735321515582*std::sin(0.380959838628769*x_92 + 1.98055982589722) - 8.93212233773946*std::sin(0.336159855127335*x_95 + 5.15320014953613) + 6.31560520892475*std::sin(0.31743985414505*x_97 + 5.14344024658203) + 15.2413963244954*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.0144164464059834*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 1.79900365925429*std::sin(0.469919860363007*x_98 + 2.05343985557556) + 3.96715785117213*std::sin(0.310239940881729*x_99 - 4.28975963592529) + 6.47215589610062*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 1781.93686638687 + 0.112333479569946*std::exp(-2.46455979347229*x_86) - 0.000314988011177398*std::exp(-2.44327998161316*x_86) + 0.0507601912505208*std::exp(-2.08607983589172*x_23) + 0.000202759932892628*std::exp(-2.06303977966309*x_23) + 0.00240456872306355*std::exp(-3.40519976615906*x_117) + 0.000182751538305594*std::exp(-4.41160011291504*x_111) - 0.00103611794579067*std::exp(-4.36687994003296*x_111) + 1.27754279019836e-5*std::exp(-4.15944004058838*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.58136684480463*x_1 + 4.41626293578164*x_10 + 5.61655441583845*x_100 + 38.9576277803517*x_101 - 4.96397844474744*x_102 - 0.358705752582702*x_103 + 2.35537340235559*x_104 + 0.801201689520277*x_105 - 1.75912176913967*x_106 + 17.8256168612321*x_107 + 0.303366922741572*x_108 + 5.59752325495163*x_109 - 0.0528491699987694*x_11 - 6.2848251454639*x_110 + 0.58360614113086*x_111 - 8.55314628861585*x_112 - 14.0834028861663*x_113 + 5.87352883538388*x_114 + 12.1096651376716*x_115 + 0.395541455386737*x_116 - 9.9125032186444*x_117 + 9.97945926999414*x_118 - 5.77465475492809*x_119 + 4.34809568036458*x_12 + 2.11233474832481*x_120 - 2.18839915447136*x_13 - 2.50279850387081*x_14 - 0.0880152100521579*x_15 + 0.125068762920448*x_16 - 0.950542894493393*x_17 + 10.7424053783955*x_18 + 8.01765945889072*x_19 - 8.58780567769923*x_2 + 11.3294309278784*x_20 + 1.86545998071112*x_21 - 0.379230042288563*x_22 + 0.691624751794096*x_23 + 1.6581771539975*x_24 + 14.1409656182983*x_25 + 4.85225302916076*x_26 - 3.06765646749502*x_27 - 5.77896908509944*x_28 + 0.317753455559473*x_29 + 8.25392419977224*x_3 + 13.1126557928815*x_30 - 118.076807530435*x_31 - 20.9878163464448*x_32 + 18.3390616732221*x_33 + 10.4377186700876*x_34 + 4.20214058424632*x_35 + 2.15658729223805*x_36 + 10.3174109345752*x_37 + 5.83758364099639*x_38 - 9.77280789170414*x_39 - 41.6857976505018*x_4 + 23.2019725681829*x_40 - 7.35945183289489*x_41 + 29.1377374170942*x_42 - 5.0668287747198*x_43 + 0.993359276970039*x_44 + 8.27578431701386*x_45 - 2.51070931104076*x_46 - 1.89894777196975*x_47 - 11.3675560907401*x_48 + 0.98144685957581*x_49 - 2.50598081965738*x_5 - 0.27991530966909*x_50 + 2.42652525760863*x_51 + 6.48314103203844*x_52 + 4.39116715514615*x_53 - 7.33250133132205*x_54 - 9.92915573945655*x_55 - 4.1545247515998*x_56 + 5.57696172323167*x_57 - 0.273429786314079*x_58 + 2.62246239508537*x_59 - 3.3632947555832*x_6 + 5.37663775696812*x_60 + 0.367349846387127*x_61 - 11.0631591021026*x_62 - 6.62428132260426*x_63 + 8.08174728467959*x_64 + 6.6037881580868*x_65 + 0.546145952269159*x_66 - 6.53383343823749*x_67 + 0.0713915225516842*x_68 + 5.90327973840311*x_69 + 2.56068519584613*x_7 - 6.44948427977477*x_70 + 0.43817710295986*x_71 - 20.6318425015966*x_72 - 3.94320169483847*x_73 + 10.0131507039336*x_74 - 4.97458313504221*x_75 - 14.8420400852119*x_76 + 6.26635279800385*x_77 + 4.29474332803859*x_78 - 5.11761706464982*x_79 + 53.4399858871945*x_8 - 0.959751105420599*x_80 + 12.1038162781643*x_81 + 1.97777556459647*x_82 + 3.29643404625659*x_83 - 15.4154749112017*x_84 + 4.98972381242344*x_85 + 14.8746332059295*x_86 - 7.53270967851793*x_87 - 1.94874292692888*x_88 - 2.97062687651143*x_89 - 59.9103863708515*x_9 - 17.4395581163091*x_90 - 21.0836971233948*x_91 + 9.87187652424862*x_92 + 429.609488007727*x_93 - 2.46933396976375*x_94 - 0.369069249771239*x_95 + 3.14123858674293*x_96 - 2.80698342695377*x_97 - 8.75804105371633*x_98 - 3.20851815449055*x_99 + 0.0388694903296952*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) - 0.00150336026228192*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.000290669837080451*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00880821546714625*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 0.000112317091345838*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 4.5498459502627e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00390100984175397*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 3.29320108498186e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.0850459228539901*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) - 0.00224493158173097*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.0187991970696298*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 0.000120063010488189*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.00456169483344593*std::exp(0.459359854459763*x_1) - 0.729818765432295*std::exp(0.553199887275696*x_1) - 0.00221476472586278*std::exp(1.07583975791931*x_1) - 0.0147410370949359*std::exp(1.12799990177155*x_1) + 0.080847963608703*std::exp(1.14143979549408*x_1) - 0.089190945325399*std::exp(1.17095983028412*x_1) + 0.443305601039179*std::exp(0.854959905147552*x_108) - 0.267650542096252*std::exp(1.12103986740112*x_108) + 4.24652533268267*std::exp(0.783599853515625*x_15) + 0.121615864441053*std::exp(2.65919995307922*x_17) - 0.00151820531117466*std::exp(3.37599992752075*x_17) - 0.0597109103238841*std::exp(3.38383984565735*x_17) - 0.00131924425195819*std::exp(3.54839992523193*x_17) - 0.0218368625260359*std::exp(3.8503999710083*x_17) - 6.66680445702925e-6*std::exp(4.05463981628418*x_17) - 0.467744522472079*std::exp(0.856879889965057*x_29) - 3.15534557577435*std::exp(0.877039849758148*x_29) - 1.69447790389224*std::exp(1.00639986991882*x_29) - 0.808706302201114*std::exp(1.10455989837646*x_29) - 0.000517166479351731*std::exp(1.58135986328125*x_29) - 0.000167480849725945*std::exp(2.08335995674133*x_29) + 0.000867656083619086*std::exp(1.54199981689453*x_38) - 0.0497533764707138*std::exp(1.65999984741211*x_38) - 0.355180904565321*std::exp(1.84159982204437*x_50) - 0.331361087485221*std::exp(1.84279990196228*x_50) - 0.00466143254097928*std::exp(1.86639988422394*x_50) - 0.00295495092635478*std::exp(1.92463982105255*x_50) + 0.857276682582467*std::exp(1.92519986629486*x_50) + 0.0759932888226146*std::exp(1.9385598897934*x_50) - 0.466489918512913*std::exp(1.95839989185333*x_50) - 1.36670150483617*std::exp(1.97631978988647*x_50) + 8.13886097264951*std::exp(0.794959902763367*x_66) - 0.00664270584029121*std::exp(0.697999835014343*x_67) - 6.17291403870857*std::exp(0.72519987821579*x_7) + 0.913778360108683*std::exp(1.3575998544693*x_71) + 0.950112101471402*std::exp(1.5887998342514*x_71) + 0.168527317584647*std::exp(1.62775981426239*x_71) + 0.000938797567138902*std::exp(1.83247983455658*x_71) + 0.00176933452661773*std::exp(1.8958398103714*x_71) - 0.0293503962509069*std::exp(1.97847986221313*x_71) + 0.0559394066022635*std::exp(1.99599981307983*x_71) - 0.00304440342990728*std::exp(1.21479988098145*x_77) - 0.31720541943941*std::exp(1.32791984081268*x_77) + 0.229207924360382*std::exp(0.814639866352081*x_78) + 0.204161111195153*std::exp(1.25415980815887*x_78) + 1.23275318821671*std::exp(1.2727198600769*x_78) + 0.00454956166005039*std::exp(1.48223996162415*x_78) - 0.138495725313038*std::exp(1.75423991680145*x_78) + 0.335768767698719*std::exp(0.863119900226593*x_87) - 0.0144838670389793*std::exp(0.901039838790894*x_87) + 11.7446594590324*std::sin(0.241679981350899*x_100 + 1.81343984603882) + 1.85511620379633*std::sin(0.609119892120361*x_100 - 0.991599798202515) - 0.505829386125374*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.0397616492657892*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.02998307096119*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 30.8327550820169*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 29.0832692982014*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 18.8689093622937*std::sin(0.348479837179184*x_112 + 1.95431983470917) + 5.97481224311671*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 27.9954869575708*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 28.5368914774146*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 2.17789905188997*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 57.6180254204515*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0479093544796031*std::sin(0.332639902830124*x_14 - 1.29095983505249) + 1.95162674113226*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 8.58768275583108*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0609677812381216*std::sin(0.39727982878685*x_16 + 2.0079197883606) + 26.0620149677876*std::sin(0.128400042653084*x_26 + 1.70263993740082) - 2.17565845499611*std::sin(0.330239832401276*x_28 + 8.3089599609375) + 8.83707394261729*std::sin(0.333119839429855*x_28 - 4.27583980560303) + 1.63224831651538*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 70.6949480623792*std::sin(0.312319844961166*x_33 - 1.17319989204407) + 5.4556799383567*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 83.4347743534306*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 41.4362485076693*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.111469481948783*std::sin(0.353839844465256*x_36 + 1.97599983215332) - 8.42114189422973*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 15.1701475714889*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.0517130263860262*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.0547346785911678*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 22.9661839056766*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 4.33752619587249*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0980851232781376*std::sin(0.321119844913483*x_53 + 5.12696027755737) - 1.35961184874787*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0950039139506035*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 4.51070898279811*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.150944074121118*std::sin(0.217199996113777*x_64 - 4.36175966262817) - 1.48992128010686*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.0181297306650904*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 109.182390933618*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 10.5820647002793*std::sin(0.484159857034683*x_75 + 8.49135971069336) - 6.74037250029581*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 19.0720595908761*std::sin(0.388479858636856*x_8 + 8.37639999389648) - 5.29105816163708*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 1.97815503702184*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 3.94264909921687*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 36.9769832269726*std::sin(0.425759851932526*x_86 + 1.99495983123779) + 2.3262395453984*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.0497563480028663*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 34.8835223469139*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.0386347628486824*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.121006619487246*std::sin(0.362639844417572*x_92 + 1.99015974998474) - 1.74087633438127*std::sin(0.365199834108353*x_92 + 1.99327981472015) + 4.14845187632017*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 28.9202558684724*std::sin(0.336159855127335*x_95 + 5.15320014953613) + 2.67519915863218*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 49.3483032173465*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.0355509833333955*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 3.10208437194558*std::sin(0.469919860363007*x_98 + 2.05343985557556) + 4.07632489760204*std::sin(0.310239940881729*x_99 - 4.28975963592529) + 2.74151176886696*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 2142.36722087657 + 0.0393145758853193*std::exp(-2.46455979347229*x_86) - 0.000178027358581372*std::exp(-2.44327998161316*x_86) - 0.16435038206935*std::exp(-2.08607983589172*x_23) + 0.000589164201513323*std::exp(-2.06303977966309*x_23) + 0.00414628120332812*std::exp(-3.40519976615906*x_117) + 0.000315124812565299*std::exp(-4.41160011291504*x_111) + 0.00149876297563005*std::exp(-4.36687994003296*x_111) + 7.22051507813104e-6*std::exp(-4.15944004058838*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.46235714531255*x_1 - 10.5605908777688*x_10 + 6.93781188181008*x_100 - 597.318095547887*x_101 + 11.4128016267433*x_102 + 20.372457853242*x_103 - 12.3364899045479*x_104 + 0.324185112648624*x_105 + 7.61373016971429*x_106 - 50.1074977390908*x_107 + 0.249168966611903*x_108 + 19.4773846986938*x_109 - 6.63333135993967*x_11 + 6.39777021778019*x_110 + 32.3649145442564*x_111 - 6.11063139873658*x_112 + 16.609779413525*x_113 - 0.869824286062557*x_114 + 1.85393538962856*x_115 - 7.27832919495695*x_116 + 14.2535734117938*x_117 + 1.96493046341123*x_118 + 1.18042928656737*x_119 + 8.8998741244403*x_12 + 22.2245237251088*x_120 + 2.02956925746067*x_13 - 2.33215011558919*x_14 + 1.07014298029872*x_15 - 5.61471105394298*x_16 + 3.18446825963485*x_17 - 2.71105946715055*x_18 + 6.39146086025917*x_19 + 8.47931491258528*x_2 + 0.0697301459826658*x_20 - 2.3412046941421*x_21 + 16.2057550607217*x_22 + 1.84500790534952*x_23 + 21.9830233998964*x_24 + 1.9154342209576*x_25 + 12.643259479883*x_26 - 0.946814947419662*x_27 + 12.9478438404532*x_28 - 0.208137489725904*x_29 - 0.380784692906496*x_3 + 2.42524518204026*x_30 - 170.50514542865*x_31 + 92.0691722069501*x_32 - 32.9204958310252*x_33 + 1.61832320732369*x_34 + 38.5152182090269*x_35 + 2.00672769828151*x_36 - 17.1365755784273*x_37 + 0.0265740833107078*x_38 - 11.5008670383343*x_39 - 36.3720355168631*x_4 - 16.6723835573974*x_40 - 2.45826570644912*x_41 + 11.4402456634841*x_42 - 10.1605024901294*x_43 - 11.0047822182158*x_44 + 6.75035339735798*x_45 + 8.65166772166459*x_46 - 4.49276948257058*x_47 - 9.89886607967277*x_48 + 18.6261043807083*x_49 - 0.528118048058794*x_5 - 0.170760881892334*x_50 - 17.4035640243538*x_51 + 13.1726211956623*x_52 + 1.80340628915389*x_53 + 5.12440992561882*x_54 - 8.18917007249476*x_55 + 3.37500392298876*x_56 + 31.3335352406645*x_57 - 8.61673157183433*x_58 + 17.2951455986326*x_59 + 2.98832710036773*x_6 - 3.00839506652323*x_60 + 3.77726646198271*x_61 - 5.67830500388559*x_62 - 18.7366905151576*x_63 - 5.55241150774329*x_64 + 3.55434861120263*x_65 - 2.58896778758721*x_66 - 1.86496104240175*x_67 + 6.4689058395847*x_68 - 14.78585699092*x_69 + 4.17890726989953*x_7 + 1.03125171734043*x_70 - 0.990142400460482*x_71 + 41.1480442042256*x_72 - 6.05123410210579*x_73 - 4.38659572535681*x_74 + 0.359355378417925*x_75 + 0.451077752520911*x_76 + 3.3002509885128*x_77 + 8.92446912071198*x_78 + 12.3931486990353*x_79 + 26.201453648539*x_8 - 0.520417025450218*x_80 - 8.57280729709*x_81 + 3.82993043014513*x_82 + 25.5950669954579*x_83 - 1.48378634324358*x_84 - 8.89607470335948*x_85 + 11.6113588267917*x_86 + 4.62824771912176*x_87 + 32.4838095190955*x_88 - 15.4999732673534*x_89 + 66.9599349607572*x_9 - 26.6758254966641*x_90 + 30.3810032740349*x_91 + 10.4938753620388*x_92 - 485.595648648503*x_93 + 22.3708220989085*x_94 + 5.08413101269004*x_95 + 2.85665680975503*x_96 - 4.03930296772533*x_97 - 5.15628461217114*x_98 - 0.472274757702879*x_99 - 0.00124263059595756*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.00187262587753515*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.000679098979992727*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00277882234649138*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 4.56822548693207e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) - 5.03032045926082e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00123069347730895*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 7.6939854516213e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.0681474383393899*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.00279634700924202*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) + 0.000600997267008439*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 4.88327197559912e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) - 0.00504342061257317*std::exp(0.459359854459763*x_1) + 3.70268516209717*std::exp(0.553199887275696*x_1) - 0.00517440846757346*std::exp(1.07583975791931*x_1) - 0.00465051331256064*std::exp(1.12799990177155*x_1) - 0.177715507743051*std::exp(1.14143979549408*x_1) - 0.071468851686514*std::exp(1.17095983028412*x_1) + 1.027172429605*std::exp(0.854959905147552*x_108) - 0.0844385914719867*std::exp(1.12103986740112*x_108) - 9.33447636719687*std::exp(0.783599853515625*x_15) - 0.00388797467696212*std::exp(2.65919995307922*x_17) + 0.00189111726872546*std::exp(3.37599992752075*x_17) - 0.0478464509870954*std::exp(3.38383984565735*x_17) - 0.00305678818483179*std::exp(3.54839992523193*x_17) + 0.0480005795830822*std::exp(3.8503999710083*x_17) - 2.71156114105708e-6*std::exp(4.05463981628418*x_17) - 0.147564388762104*std::exp(0.856879889965057*x_29) + 6.93590556983635*std::exp(0.877039849758148*x_29) + 0.0541712811176715*std::exp(1.00639986991882*x_29) + 4.10291563807743*std::exp(1.10455989837646*x_29) + 0.000571780484518756*std::exp(1.58135986328125*x_29) - 0.000391289565369401*std::exp(2.08335995674133*x_29) + 0.00202712592159028*std::exp(1.54199981689453*x_38) + 0.00159058087282074*std::exp(1.65999984741211*x_38) - 0.822980877833342*std::exp(1.84159982204437*x_50) - 0.104538041569951*std::exp(1.84279990196228*x_50) + 0.00515369085825826*std::exp(1.86639988422394*x_50) - 0.00120185467524642*std::exp(1.92463982105255*x_50) - 0.0274065398321966*std::exp(1.92519986629486*x_50) - 0.0946592794412606*std::exp(1.9385598897934*x_50) + 2.36670442218976*std::exp(1.95839989185333*x_50) + 3.00420741628928*std::exp(1.97631978988647*x_50) + 6.52168272944406*std::exp(0.794959902763367*x_66) - 0.0155195145318258*std::exp(0.697999835014343*x_67) - 4.94636620675473*std::exp(0.72519987821579*x_7) - 0.0292128592004586*std::exp(1.3575998544693*x_71) + 0.761326394937141*std::exp(1.5887998342514*x_71) - 0.855011720422249*std::exp(1.62775981426239*x_71) - 0.00103793681384101*std::exp(1.83247983455658*x_71) + 0.000719633938392895*std::exp(1.8958398103714*x_71) - 0.00925948477130306*std::exp(1.97847986221313*x_71) + 0.129615813686122*std::exp(1.99599981307983*x_71) - 0.00711271346453526*std::exp(1.21479988098145*x_77) - 0.73498882171952*std::exp(1.32791984081268*x_77) - 0.285507540183259*std::exp(0.814639866352081*x_78) + 0.064408898736603*std::exp(1.25415980815887*x_78) - 0.0394102628037811*std::exp(1.2727198600769*x_78) + 0.00185042394534741*std::exp(1.48223996162415*x_78) + 0.702648508670123*std::exp(1.75423991680145*x_78) - 0.418242585650305*std::exp(0.863119900226593*x_87) - 0.00589096189760369*std::exp(0.901039838790894*x_87) + 3.70521387429961*std::sin(0.241679981350899*x_100 + 1.81343984603882) + 4.29844381344658*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.630074654652849*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.0928961041518469*std::sin(0.384559839963913*x_105 + 1.97951984405518) - 0.0331493542718375*std::sin(0.387279838323593*x_105 - 7.41224002838135) - 67.7748514611681*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 23.3044716865467*std::sin(0.502319812774658*x_105 + 2.05711984634399) + 0.603225920562774*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 30.3127977612369*std::sin(0.379999846220016*x_112 + 1.9871199131012) - 61.5381260962656*std::sin(0.4059998691082*x_112 + 1.9936797618866) - 62.7282114718739*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 0.687085207709501*std::sin(0.56199985742569*x_118 + 8.39344024658203) + 126.652746534302*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0194859688381964*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 2.43099863048563*std::sin(0.419839859008789*x_14 - 1.15535986423492) + 0.274542250239393*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0247971674476599*std::sin(0.39727982878685*x_16 + 2.0079197883606) + 60.3876494502*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 2.71005854399779*std::sin(0.330239832401276*x_28 + 8.3089599609375) + 20.4761651803153*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 2.0331722959275*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 56.6479785545808*std::sin(0.312319844961166*x_33 - 1.17319989204407) + 12.6412208740259*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 66.8564223869146*std::sin(0.293199926614761*x_36 + 1.90127992630005) - 91.0828623729862*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0453375102891154*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 42.7240824935624*std::sin(0.370239853858948*x_36 - 1.19343984127045) + 0.484979076330255*std::sin(0.375999838113785*x_36 + 1.98047983646393) - 0.0571740444585608*std::sin(0.388399839401245*x_41 + 2.0033597946167) - 0.0605147902935745*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 18.4028410661165*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 1.36840598036452*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0398937467734438*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 1.69356899689771*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0386405395534248*std::sin(0.249279975891113*x_55 - 7.55600023269653) - 9.91519020861048*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.0613928439776148*std::sin(0.217199996113777*x_64 - 4.36175966262817) - 3.4522596999001*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.0423569288298672*std::sin(0.694319844245911*x_73 + 8.65120029449463) + 239.998673748655*std::sin(0.187120005488396*x_75 - 7.62423992156982) - 0.338301255134379*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 34.1968149161936*std::sin(0.517359852790833*x_79 - 1.05527985095978) + 41.9231431765268*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 26.8438185955417*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 0.624069817797238*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 1.24382986112708*std::sin(0.419279843568802*x_86 + 2.0163197517395) - 81.2807528559734*std::sin(0.425759851932526*x_86 + 1.99495983123779) + 5.39007204079724*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.116246960869068*std::sin(0.347679853439331*x_92 + 5.18296003341675) + 76.6790233054249*std::sin(0.357119828462601*x_92 + 2.00119972229004) + 0.0427146853148283*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.049216509847734*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 2.16848226944791*std::sin(0.365199834108353*x_92 + 1.99327981472015) + 9.61227510527798*std::sin(0.380959838628769*x_92 + 1.98055982589722) - 63.5709018052655*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 3.33229984701794*std::sin(0.31743985414505*x_97 + 5.14344024658203) + 108.474702034236*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.083058623357487*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 0.978647877724643*std::sin(0.469919860363007*x_98 + 2.05343985557556) + 9.44515146913104*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 3.41490061347964*std::sin(0.340399831533432*x_99 - 7.43175983428955) - 5455.29167268469 - 0.199459788757952*std::exp(-2.46455979347229*x_86) + 0.000196827469318677*std::exp(-2.44327998161316*x_86) + 0.361265890858813*std::exp(-2.08607983589172*x_23) + 0.000239628260409085*std::exp(-2.06303977966309*x_23) + 0.00130807186831662*std::exp(-3.40519976615906*x_117) + 9.94158095197084e-5*std::exp(-4.41160011291504*x_111) - 4.79144108607842e-5*std::exp(-4.36687994003296*x_111) - 7.98301857271161e-6*std::exp(-4.15944004058838*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.50201212797474*x_1 + 3.08644700733898*x_10 - 5.17606245066389*x_100 + 279.947267865418*x_101 - 6.55959342110832*x_102 - 5.3540916653397*x_103 - 2.12031873098101*x_104 - 0.177559191657272*x_105 - 8.6674295096087*x_106 + 13.0179291829937*x_107 - 1.77426016295298*x_108 - 12.9787751362671*x_109 - 1.48864351145875*x_11 - 7.4731512875546*x_110 - 13.4710924208147*x_111 + 7.07027132546263*x_112 - 7.69828583856483*x_113 - 0.0304761481905584*x_114 - 5.85488486762908*x_115 - 3.05798580026404*x_116 - 2.10229937223149*x_117 - 9.74664535270141*x_118 - 2.23914524876408*x_119 - 4.41832498725622*x_12 - 15.1334630824906*x_120 - 1.00811740206026*x_13 + 3.85269569414805*x_14 + 0.036483568346647*x_15 + 9.67241413151118*x_16 - 0.097715193101386*x_17 - 5.32828619416496*x_18 - 2.63378020418989*x_19 - 0.0743646533957643*x_2 - 5.77110595819208*x_20 + 1.1848420347317*x_21 - 6.38534069452236*x_22 - 3.2426081381846*x_23 - 9.57122463212692*x_24 - 6.47539703023898*x_25 - 10.6734653314999*x_26 + 2.22154214613849*x_27 - 4.9131345028212*x_28 - 0.581710476887654*x_29 - 3.42993291370863*x_3 - 5.14565216588548*x_30 - 79.301812952563*x_31 - 40.3940254117373*x_32 + 20.4005555520148*x_33 - 3.55224891400722*x_34 - 16.2306571856733*x_35 + 0.72181375852505*x_36 - 1.48620821234775*x_37 - 2.0908448481411*x_38 + 12.4158900959438*x_39 + 33.645438083921*x_4 + 11.5587912324755*x_40 + 5.90704247270569*x_41 - 9.14440936136329*x_42 + 13.3590316323879*x_43 + 7.67345233669064*x_44 - 5.09225883758116*x_45 - 3.5650239703121*x_46 - 1.67492212373312*x_47 + 21.1771168240616*x_48 - 3.72527937751108*x_49 - 4.21396213852874*x_5 + 0.390225968517759*x_50 + 0.879584060548443*x_51 - 10.4377975211456*x_52 - 1.98559979075481*x_53 + 4.92080748871878*x_54 + 7.8279437881598*x_55 + 3.8591381100469*x_56 - 18.8850234343658*x_57 + 6.40524329164968*x_58 - 7.81666902065953*x_59 - 0.831587171077404*x_6 + 1.26126553183312*x_60 + 0.901877709578928*x_61 - 1.14068970602456*x_62 + 12.7706924729238*x_63 + 0.309026186389948*x_64 + 0.158763931977096*x_65 - 1.87018093001794*x_66 + 7.22433675148765*x_67 - 4.49005962289311*x_68 + 3.74370429959911*x_69 + 1.11361612757243*x_7 + 1.67632335501503*x_70 + 0.467624008006565*x_71 - 6.34657410975855*x_72 + 4.32896576850097*x_73 - 1.8200056217787*x_74 + 3.33570638437347*x_75 + 2.20714527089803*x_76 - 1.55919005675573*x_77 - 6.03496234223597*x_78 - 1.66514392368976*x_79 - 10.4699027161495*x_8 + 1.12596251076296*x_80 + 3.11428279588067*x_81 - 1.22431010634748*x_82 - 11.7538911804079*x_83 + 11.7582165426075*x_84 + 3.6044504377714*x_85 - 16.0541467009546*x_86 + 2.32756956938839*x_87 - 17.9580609539284*x_88 + 19.53451983843*x_89 - 52.253150077299*x_9 + 9.6005982649748*x_90 - 12.3576138213303*x_91 - 7.76344974815944*x_92 - 175.552954182822*x_93 - 9.78528534105515*x_94 + 1.06099727332098*x_95 - 8.09619387947488*x_96 + 3.13542311321716*x_97 + 6.93504519089755*x_98 + 1.47941555936337*x_99 + 0.0117838682939287*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.00317625013996946*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.00109404976522406*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00148257425227326*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 3.12218481242251e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) - 1.76188151972392e-6*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.000656607092642208*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 0.000123952519809023*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) + 0.0699610304905364*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.00474301764493341*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.00569925822080791*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 3.33750548013847e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) - 0.000176646987909655*std::exp(0.459359854459763*x_1) - 0.0459060954678301*std::exp(0.553199887275696*x_1) - 0.00833613440147229*std::exp(1.07583975791931*x_1) - 0.00248117023593176*std::exp(1.12799990177155*x_1) + 0.0892005320532374*std::exp(1.14143979549408*x_1) + 0.0733708358495078*std::exp(1.17095983028412*x_1) + 0.588312742703361*std::exp(0.854959905147552*x_108) - 0.0450501924934685*std::exp(1.12103986740112*x_108) + 4.68524254842295*std::exp(0.783599853515625*x_15) + 0.0368696712220793*std::exp(2.65919995307922*x_17) + 0.00320761427124686*std::exp(3.37599992752075*x_17) + 0.049119777616605*std::exp(3.38383984565735*x_17) - 0.00175077464021613*std::exp(3.54839992523193*x_17) - 0.0240928734472927*std::exp(3.8503999710083*x_17) - 1.85323492388487e-6*std::exp(4.05463981628418*x_17) - 0.0787294530027693*std::exp(0.856879889965057*x_29) - 3.48133077950034*std::exp(0.877039849758148*x_29) - 0.513706361392241*std::exp(1.00639986991882*x_29) - 0.0508681750493084*std::exp(1.10455989837646*x_29) + 2.00267453569036e-5*std::exp(1.58135986328125*x_29) - 0.000630379767514304*std::exp(2.08335995674133*x_29) + 0.00326576346590772*std::exp(1.54199981689453*x_38) - 0.0150834814281379*std::exp(1.65999984741211*x_38) - 0.471362084374424*std::exp(1.84159982204437*x_50) - 0.0557737737392136*std::exp(1.84279990196228*x_50) + 0.00018050922908537*std::exp(1.86639988422394*x_50) - 0.000821415760786665*std::exp(1.92463982105255*x_50) + 0.259896269112906*std::exp(1.92519986629486*x_50) - 0.160556122384925*std::exp(1.9385598897934*x_50) - 0.0293425323495888*std::exp(1.95839989185333*x_50) - 1.50789823203689*std::exp(1.97631978988647*x_50) - 6.69524277658015*std::exp(0.794959902763367*x_66) - 0.0250024248749677*std::exp(0.697999835014343*x_67) + 5.07800271647342*std::exp(0.72519987821579*x_7) + 0.277025599101735*std::exp(1.3575998544693*x_71) - 0.781587399722711*std::exp(1.5887998342514*x_71) + 0.0106004826080288*std::exp(1.62775981426239*x_71) - 3.63539799453718e-5*std::exp(1.83247983455658*x_71) + 0.000491838714919262*std::exp(1.8958398103714*x_71) - 0.00494017680856192*std::exp(1.97847986221313*x_71) + 0.0742374236784515*std::exp(1.99599981307983*x_71) - 0.0114588045708214*std::exp(1.21479988098145*x_77) - 0.420964657052181*std::exp(1.32791984081268*x_77) - 0.484262967498371*std::exp(0.814639866352081*x_78) + 0.0343638286214062*std::exp(1.25415980815887*x_78) + 0.373727596777068*std::exp(1.2727198600769*x_78) + 0.00126468484430846*std::exp(1.48223996162415*x_78) - 0.00871147508017389*std::exp(1.75423991680145*x_78) - 0.709401214171801*std::exp(0.863119900226593*x_87) - 0.00402621801832511*std::exp(0.901039838790894*x_87) + 1.97682831223025*std::sin(0.241679981350899*x_100 + 1.81343984603882) + 2.46193257953538*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 1.06869969813004*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.149658538639899*std::sin(0.384559839963913*x_105 + 1.97951984405518) - 0.00116106389553786*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 34.0181500587234*std::sin(0.404239863157272*x_105 + 5.20743989944458) + 23.9246682481086*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 5.72039254668281*std::sin(0.348479837179184*x_112 + 1.95431983470917) + 0.375819743511817*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 30.8877579624772*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 31.4850960903716*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 0.3665778920175*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 63.5706614483977*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0133178180753099*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 4.12333281995918*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 2.60348467876476*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0169477929269591*std::sin(0.39727982878685*x_16 + 2.0079197883606) + 34.5870105636678*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 4.5966596600857*std::sin(0.330239832401276*x_28 + 8.3089599609375) + 11.7277182974146*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 3.44856058382678*std::sin(0.329359829425812*x_3 - 4.26152038574219) + 58.1555382191606*std::sin(0.312319844961166*x_33 - 1.17319989204407) + 7.24025597764253*std::sin(0.409919857978821*x_34 - 1.18663990497589) - 68.6356570265322*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 45.7171120730169*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0309862300936438*std::sin(0.353839844465256*x_36 + 1.97599983215332) - 0.529695538200732*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 4.599057498969*std::sin(0.375999838113785*x_36 + 1.98047983646393) - 0.00200253429488694*std::sin(0.388399839401245*x_41 + 2.0033597946167) - 0.00211954470001867*std::sin(0.307599931955338*x_43 - 7.47824001312256) - 18.8925916558612*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 0.730080307475132*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0272656528542606*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 2.87254321750839*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0264091398471084*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 4.97671955165481*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.0419593572179516*std::sin(0.217199996113777*x_64 - 4.36175966262817) - 1.97728084792301*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.0682383414011676*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 120.462247005501*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 3.2081114428881*std::sin(0.484159857034683*x_75 + 8.49135971069336) - 0.42397400305819*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 21.0424330672204*std::sin(0.388479858636856*x_8 + 8.37639999389648) - 0.332811147915717*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 0.332957536726043*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 0.663615696283722*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 40.7971509775236*std::sin(0.425759851932526*x_86 + 1.99495983123779) + 3.08716236368374*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.187277501503796*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 38.4874103730766*std::sin(0.357119828462601*x_92 + 2.00119972229004) + 0.0014960918551117*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.0336373587526729*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 3.67806628888473*std::sin(0.365199834108353*x_92 + 1.99327981472015) + 5.50542807401868*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 31.9080666406025*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 5.65207283658947*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 54.4465773339274*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.133810048404233*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 0.522134186587494*std::sin(0.469919860363007*x_98 + 2.05343985557556) + 5.40970805475183*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 5.79217593950124*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 2133.22071686653 + 0.00247291349489992*std::exp(-2.46455979347229*x_86) + 6.893928201496e-6*std::exp(-2.44327998161316*x_86) - 0.181329756117206*std::exp(-2.08607983589172*x_23) + 0.000163775566117889*std::exp(-2.06303977966309*x_23) + 0.000697890483908709*std::exp(-3.40519976615906*x_117) + 5.30409292443338e-5*std::exp(-4.41160011291504*x_111) + 0.0004543724489011*std::exp(-4.36687994003296*x_111) - 2.79607094792132e-7*std::exp(-4.15944004058838*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.8135336057678*x_1 - 0.288226964049367*x_10 + 0.157084542263552*x_100 - 1.34767287372919*x_101 - 0.227423304450437*x_102 + 3.50011632490207*x_103 - 6.25701254073422*x_104 + 0.329743619139155*x_105 - 6.43046842037357*x_106 + 0.70204801044126*x_107 - 1.40910663250733*x_108 - 0.525353299851441*x_109 - 3.08178589416947*x_11 - 6.61714851385928*x_110 + 0.977067749514644*x_111 + 0.841631544469775*x_112 - 0.936642212968932*x_113 + 1.58048656905653*x_114 - 3.20066896477336*x_115 - 5.21297349491588*x_116 + 2.54183132693822*x_117 - 6.95739847556338*x_118 - 1.37629365005201*x_119 + 2.25477963078338*x_12 - 4.30869434669264*x_120 + 0.436077023746736*x_13 + 1.5798235167661*x_14 + 0.409936330868309*x_15 + 6.01149531611618*x_16 + 1.48811056392558*x_17 - 1.81118948102231*x_18 + 1.88290014836994*x_19 - 0.4095288342932*x_2 + 1.99275724459703*x_20 - 0.926142539517674*x_21 + 0.0959343525123779*x_22 - 3.39055992394063*x_23 + 2.94377737440266*x_24 - 2.0140598759727*x_25 - 3.95161092385161*x_26 + 0.318854124361954*x_27 - 1.09526995163785*x_28 - 0.202843614237993*x_29 - 1.93922916667106*x_3 - 1.99349531871859*x_30 - 210.342694001995*x_31 - 5.55354202850849*x_32 + 13.6777010643688*x_33 + 0.963063775086655*x_34 + 4.00350878225312*x_35 + 1.55735678940427*x_36 - 6.5883698704786*x_37 - 0.564741423228623*x_38 - 6.57159519659552*x_39 + 5.71077227353795*x_4 + 8.57898969089037*x_40 + 4.90956595692202*x_41 + 9.69547402770536*x_42 + 7.7883738021269*x_43 + 2.16064314795942*x_44 - 1.36911368562855*x_45 - 1.49863230692968*x_46 - 6.32989732278534*x_47 + 22.0707932036894*x_48 + 13.5024929439868*x_49 - 3.63141027138808*x_5 + 0.0156227034261587*x_50 - 6.26301061126626*x_51 - 4.2756425241453*x_52 - 0.289603214693595*x_53 + 6.41061866352855*x_54 + 2.02654393273198*x_55 + 3.9144006020038*x_56 + 1.20540659331106*x_57 + 1.6442397554132*x_58 + 1.48079940504144*x_59 + 0.580555283493473*x_6 + 2.14972780253783*x_60 + 3.31662956024211*x_61 - 6.4893650880513*x_62 + 1.63976824321151*x_63 + 3.46498043789922*x_64 + 3.00197357742429*x_65 - 3.13871781007506*x_66 + 3.86718802804279*x_67 - 2.35919282108462*x_68 - 1.65185836070268*x_69 + 2.17345081478272*x_7 + 0.594987138039996*x_70 + 0.22637395112422*x_71 + 5.09980452828498*x_72 + 1.07562349333617*x_73 - 0.263287656801704*x_74 + 2.71872635550699*x_75 - 1.69259784906844*x_76 + 2.20697077065847*x_77 - 1.25775611641169*x_78 - 0.58576098224523*x_79 + 40.2075271646808*x_8 + 0.782567037270746*x_80 + 3.69090600523528*x_81 + 0.628930331390051*x_82 + 0.789939427534412*x_83 + 4.50049638505834*x_84 + 1.34131006061184*x_85 - 4.17105244818996*x_86 + 2.39315957640254*x_87 - 0.542600892735338*x_88 + 11.9254463065509*x_89 - 57.672784706587*x_9 - 3.07088124386132*x_90 - 1.84320741076752*x_91 + 0.640278963351114*x_92 - 240.853187114917*x_93 - 1.02317769449689*x_94 + 4.19153129058723*x_95 - 6.33009531358839*x_96 - 0.924833404550552*x_97 + 2.55015839113269*x_98 + 0.989664291508944*x_99 + 0.0197963405650353*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.00115436903538203*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) + 0.000234592869487858*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00771924775061039*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 9.1581682140351e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 2.0792267451164e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00341872443497622*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) - 2.65786605203413e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) + 0.0118252839696853*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.0017237914088323*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.00957448385309261*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 9.7897589152182e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.00208464154708632*std::exp(0.459359854459763*x_1) + 1.97431727237355*std::exp(0.553199887275696*x_1) + 0.00178748513261399*std::exp(1.07583975791931*x_1) - 0.0129185892262936*std::exp(1.12799990177155*x_1) + 0.040335221376302*std::exp(1.14143979549408*x_1) + 0.0124016322076754*std::exp(1.17095983028412*x_1) + 0.458004371946719*std::exp(0.854959905147552*x_108) - 0.234560661320371*std::exp(1.12103986740112*x_108) + 2.11860054017974*std::exp(0.783599853515625*x_15) + 0.0619393012402569*std::exp(2.65919995307922*x_17) + 0.00116576794301612*std::exp(3.37599992752075*x_17) + 0.00830255521926194*std::exp(3.38383984565735*x_17) - 0.00136298669280524*std::exp(3.54839992523193*x_17) - 0.0108944572607233*std::exp(3.8503999710083*x_17) - 5.43601298216981e-6*std::exp(4.05463981628418*x_17) - 0.409916840297587*std::exp(0.856879889965057*x_29) - 1.57420863354799*std::exp(0.877039849758148*x_29) - 0.863002354310546*std::exp(1.00639986991882*x_29) + 2.18772508510008*std::exp(1.10455989837646*x_29) - 0.000236339073300651*std::exp(1.58135986328125*x_29) + 0.000135169901067511*std::exp(2.08335995674133*x_29) - 0.000700265058216072*std::exp(1.54199981689453*x_38) - 0.0253395343370943*std::exp(1.65999984741211*x_38) - 0.366957707598489*std::exp(1.84159982204437*x_50) - 0.290394613840983*std::exp(1.84279990196228*x_50) - 0.00213022052080695*std::exp(1.86639988422394*x_50) - 0.00240942294031181*std::exp(1.92463982105255*x_50) + 0.436613421552916*std::exp(1.92519986629486*x_50) - 0.0583521473292869*std::exp(1.9385598897934*x_50) + 1.26195590896137*std::exp(1.95839989185333*x_50) - 0.681850293962848*std::exp(1.97631978988647*x_50) - 1.13167496996423*std::exp(0.794959902763367*x_66) + 0.00536117348772709*std::exp(0.697999835014343*x_67) + 0.85831817656337*std::exp(0.72519987821579*x_7) + 0.465389884565868*std::exp(1.3575998544693*x_71) - 0.13210915968568*std::exp(1.5887998342514*x_71) - 0.45590276618479*std::exp(1.62775981426239*x_71) + 0.000429019582461404*std::exp(1.83247983455658*x_71) + 0.00144268900017822*std::exp(1.8958398103714*x_71) - 0.0257217799773852*std::exp(1.97847986221313*x_71) + 0.0577942004970912*std::exp(1.99599981307983*x_71) + 0.00245706724741086*std::exp(1.21479988098145*x_77) - 0.327723061851417*std::exp(1.32791984081268*x_77) - 0.175999417560895*std::exp(0.814639866352081*x_78) + 0.178920486701706*std::exp(1.25415980815887*x_78) + 0.62784466015823*std::exp(1.2727198600769*x_78) + 0.00370964476408782*std::exp(1.48223996162415*x_78) + 0.374660827573365*std::exp(1.75423991680145*x_78) - 0.257823143397081*std::exp(0.863119900226593*x_87) - 0.011809929294221*std::exp(0.901039838790894*x_87) + 10.2926564919959*std::sin(0.241679981350899*x_100 + 1.81343984603882) + 1.91662665623038*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.388405756876348*std::sin(0.702159821987152*x_100 - 7.1541600227356) - 0.0320907029450377*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.0137019151251988*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 15.3825272321463*std::sin(0.404239863157272*x_105 + 5.20743989944458) + 4.0439083577059*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 9.60998851948874*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 16.1631566212018*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 13.9670081170658*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 14.2371159860496*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 1.90864340456523*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 28.7457556982812*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0390645735295121*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 1.49857458329183*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 4.37373094056328*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0497122200659535*std::sin(0.39727982878685*x_16 + 2.0079197883606) + 26.9261583183395*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 1.67059939990861*std::sin(0.330239832401276*x_28 + 8.3089599609375) + 9.13008653950537*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 1.25333691591648*std::sin(0.329359829425812*x_3 - 4.26152038574219) + 9.8298402557762*std::sin(0.312319844961166*x_33 - 1.17319989204407) + 5.6365749899211*std::sin(0.409919857978821*x_34 - 1.18663990497589) - 11.6012604316121*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 20.6726327041389*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.090890554072039*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 22.7810063023499*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 7.72619875382328*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.0236322523241754*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.0250131122803257*std::sin(0.307599931955338*x_43 - 7.47824001312256) - 3.19335292358345*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 3.80127387387246*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0799771475126292*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 1.0439904909757*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0774647753539411*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 2.25040232634444*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.123077548140602*std::sin(0.217199996113777*x_64 - 4.36175966262817) - 1.53932289270824*std::sin(0.518159866333008*x_73 + 2.1451997756958) + 0.0146320842316652*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 54.471327565106*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 5.38947526481779*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 18.2341623425964*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 9.51509118304127*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 14.3134542607513*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 1.73359392454062*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 3.45521579303921*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 18.4478957504279*std::sin(0.425759851932526*x_86 + 1.99495983123779) + 2.40337112702904*std::sin(0.656639814376831*x_87 + 5.4495997428894) + 0.0401571919896118*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 17.4034636550386*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.0176556378137532*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.0986669938650437*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 1.33674794076888*std::sin(0.365199834108353*x_92 + 1.99327981472015) + 4.2860029102075*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 14.4283772979108*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 2.05417633396641*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 24.6199736637804*std::sin(0.368239849805832*x_97 + 5.15952014923096) + 0.0286923723392322*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 2.71857085009555*std::sin(0.469919860363007*x_98 + 2.05343985557556) + 4.21148440308561*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 2.10509508300545*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 140.867785727902 - 0.106354412770478*std::exp(-2.46455979347229*x_86) - 8.1356434782906e-5*std::exp(-2.44327998161316*x_86) - 0.0819947559363566*std::exp(-2.08607983589172*x_23) + 0.000480395708123599*std::exp(-2.06303977966309*x_23) + 0.00363367267428556*std::exp(-3.40519976615906*x_117) + 0.000276165644406553*std::exp(-4.41160011291504*x_111) + 0.00076332419180632*std::exp(-4.36687994003296*x_111) + 3.29969151221471e-6*std::exp(-4.15944004058838*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.03939108754948*x_1 - 0.569882931962924*x_10 - 2.99543191755232*x_100 + 52.2574396889565*x_101 + 1.41523002397072*x_102 + 1.15694333824133*x_103 - 7.42262207598257*x_104 + 0.405220037665955*x_105 - 5.83806659571923*x_106 + 4.83833606710425*x_107 - 3.63275715678455*x_108 - 5.81790217337515*x_109 + 2.46668679382175*x_11 - 7.51738904000221*x_110 - 4.5771026664664*x_111 + 3.5765162737262*x_112 - 0.147563443099854*x_113 + 1.48213245713311*x_114 - 10.093612496389*x_115 - 1.09803897359721*x_116 + 5.99641129148314*x_117 - 9.16261353915011*x_118 + 4.53855295346284*x_119 - 1.94666129940798*x_12 - 6.80315940740112*x_120 + 1.55338671421006*x_13 + 3.12519240733333*x_14 + 0.0289596984546337*x_15 + 5.22385280438766*x_16 + 1.38613375250102*x_17 - 3.63680559913128*x_18 - 3.96771802203804*x_19 + 0.0326483511906921*x_2 + 1.11190192475269*x_20 - 1.8801301321339*x_21 - 3.00469400303488*x_22 - 6.429086639442*x_23 - 1.84333032841635*x_24 - 9.77673554006587*x_25 - 7.20947071131748*x_26 + 3.03515283543138*x_27 + 0.150962624426254*x_28 - 0.316966752014163*x_29 - 5.35968201998238*x_3 - 10.2620153333326*x_30 - 121.632630009757*x_31 - 11.1412855204634*x_32 + 12.7186565592374*x_33 - 1.70240643645552*x_34 - 2.22095865877595*x_35 - 1.29021400413839*x_36 - 7.03421964222465*x_37 - 2.61855160475508*x_38 - 7.16040352758566*x_39 + 37.9307221039898*x_4 - 1.46202103476941*x_40 + 9.8666197686377*x_41 + 2.9595819922803*x_42 + 8.51568133634087*x_43 + 6.33875025575251*x_44 - 7.61657857227358*x_45 - 2.34739855726906*x_46 - 7.6824716097612*x_47 + 31.7562902296061*x_48 + 14.1783404986928*x_49 - 3.31970963899254*x_5 + 0.191002948333894*x_50 - 4.95401771702325*x_51 - 9.25211400751694*x_52 - 2.92345660469189*x_53 + 8.03531201020039*x_54 + 7.64041290139909*x_55 + 5.94911730567061*x_56 - 4.93663727922629*x_57 - 0.114845162537468*x_58 + 0.993331251286396*x_59 + 2.38519418009053*x_6 - 1.57968794774562*x_60 + 1.08137793735532*x_61 - 3.47614051753338*x_62 + 6.36183755852525*x_63 + 3.78585758005478*x_64 - 1.08651545270488*x_65 - 0.90484139353878*x_66 + 3.10879998958085*x_67 - 1.44580431117366*x_68 - 0.243445831083507*x_69 + 3.67508778750089*x_7 + 5.53789468569727*x_70 + 0.191146159078281*x_71 + 5.32835621037682*x_72 + 3.12011030264397*x_73 - 3.29721253504262*x_74 + 4.64492535010416*x_75 + 8.03640624144717*x_76 - 0.311409546981209*x_77 - 4.60373406837824*x_78 - 2.34274582262009*x_79 + 98.8041185513702*x_8 + 1.58519226414137*x_80 - 1.78980452048834*x_81 - 6.33595517900465*x_82 - 7.48298209014693*x_83 + 15.1337230109481*x_84 + 0.511536409093575*x_85 - 10.7866304246425*x_86 + 5.23915282621082*x_87 - 4.28895108085681*x_88 + 12.905163977018*x_89 - 69.0216854681099*x_9 + 3.58847511837611*x_90 + 0.215484549859456*x_91 - 3.95465717046906*x_92 - 222.401462120765*x_93 - 2.93802108715556*x_94 + 4.12823514086254*x_95 - 6.4337557849754*x_96 - 1.93764429320197*x_97 + 4.77508619712717*x_98 - 0.159121221957409*x_99 + 0.0410430332304398*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.00199928303901809*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 1.82542734930206e-5*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00412636259142718*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) + 2.3446262123584e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 2.76293312769758e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00182749628909998*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 2.06815381590944e-6*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) + 0.0510107515444878*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.0029854810904062*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.0198504293081749*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) + 2.50632275241608e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.00277012846403007*std::exp(0.459359854459763*x_1) + 1.72169683687465*std::exp(0.553199887275696*x_1) - 0.000139088807544224*std::exp(1.07583975791931*x_1) - 0.00690569664811922*std::exp(1.12799990177155*x_1) + 0.0348640770496836*std::exp(1.14143979549408*x_1) + 0.0534969461125493*std::exp(1.17095983028412*x_1) - 0.675806586406328*std::exp(0.854959905147552*x_108) - 0.12538557765765*std::exp(1.12103986740112*x_108) + 1.83122962884553*std::exp(0.783599853515625*x_15) + 0.128416501561108*std::exp(2.65919995307922*x_17) + 0.00201902511628944*std::exp(3.37599992752075*x_17) + 0.0358147493590746*std::exp(3.38383984565735*x_17) + 0.0020111497631929*std::exp(3.54839992523193*x_17) - 0.00941671284778175*std::exp(3.8503999710083*x_17) + 1.39169954414937e-6*std::exp(4.05463981628418*x_17) - 0.219123102411921*std::exp(0.856879889965057*x_29) - 1.3606800513196*std::exp(0.877039849758148*x_29) - 1.78923140817629*std::exp(1.00639986991882*x_29) + 1.90779841298753*std::exp(1.10455989837646*x_29) - 0.00031405379741552*std::exp(1.58135986328125*x_29) - 1.05179170513475e-5*std::exp(2.08335995674133*x_29) + 5.44894221132486e-5*std::exp(1.54199981689453*x_38) - 0.0525355353644561*std::exp(1.65999984741211*x_38) + 0.541463031615942*std::exp(1.84159982204437*x_50) - 0.155231896943665*std::exp(1.84279990196228*x_50) - 0.00283069504567633*std::exp(1.86639988422394*x_50) + 0.000616847829225848*std::exp(1.92463982105255*x_50) + 0.905214734550632*std::exp(1.92519986629486*x_50) - 0.101061666477496*std::exp(1.9385598897934*x_50) + 1.10048446981472*std::exp(1.95839989185333*x_50) - 0.589362853950688*std::exp(1.97631978988647*x_50) - 4.88170862280759*std::exp(0.794959902763367*x_66) - 0.000417166673915323*std::exp(0.697999835014343*x_67) + 3.70252886637081*std::exp(0.72519987821579*x_7) + 0.964875929194916*std::exp(1.3575998544693*x_71) - 0.569879551201731*std::exp(1.5887998342514*x_71) - 0.397568496941276*std::exp(1.62775981426239*x_71) + 0.000570092905738974*std::exp(1.83247983455658*x_71) - 0.000369349674197416*std::exp(1.8958398103714*x_71) - 0.0137497064626809*std::exp(1.97847986221313*x_71) - 0.0852780098714118*std::exp(1.99599981307983*x_71) - 0.000191190711051439*std::exp(1.21479988098145*x_77) + 0.483570501248841*std::exp(1.32791984081268*x_77) - 0.304818164401047*std::exp(0.814639866352081*x_78) + 0.0956428433207737*std::exp(1.25415980815887*x_78) + 1.30168750965729*std::exp(1.2727198600769*x_78) - 0.000949723803837643*std::exp(1.48223996162415*x_78) + 0.326721733512673*std::exp(1.75423991680145*x_78) - 0.446530894246936*std::exp(0.863119900226593*x_87) + 0.00302351618164149*std::exp(0.901039838790894*x_87) + 5.50199113788302*std::sin(0.241679981350899*x_100 + 1.81343984603882) - 2.82807107813615*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.672690463949317*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.00249705998916696*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.018207477996919*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 13.2960126743099*std::sin(0.404239863157272*x_105 + 5.20743989944458) + 17.4442157188301*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 19.9240398423009*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 14.0950271863738*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 12.0724972004996*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 12.3059671365667*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 1.02027490235035*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 24.8466280168992*std::sin(0.289359927177429*x_14 - 7.47560024261475) + 0.0100011073100328*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 2.59542196234276*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 9.06789735935326*std::sin(0.607599854469299*x_15 + 2.18927979469299) + 0.0127270619535617*std::sin(0.39727982878685*x_16 + 2.0079197883606) - 39.7307891643231*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 2.893356407577*std::sin(0.330239832401276*x_28 + 8.3089599609375) - 13.4718640165629*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 2.17068819533762*std::sin(0.329359829425812*x_3 - 4.26152038574219) + 42.4030019316947*std::sin(0.312319844961166*x_33 - 1.17319989204407) - 8.31702650953077*std::sin(0.409919857978821*x_34 - 1.18663990497589) - 50.0443807520347*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 17.8685584167974*std::sin(0.347439825534821*x_36 - 1.21175980567932) + 0.0232693231389323*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 19.8661010772721*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 16.0184470031917*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.0314031805246508*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.0332381048427992*std::sin(0.307599931955338*x_43 - 7.47824001312256) - 13.775173010337*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 2.03199000986547*std::sin(0.413279861211777*x_51 - 1.19959986209869) + 0.020475330007631*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 1.80811544448013*std::sin(0.498479843139648*x_54 + 8.28343963623047) + 0.0198321256592513*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 1.94515357598994*std::sin(0.528079867362976*x_55 - 7.24743986129761) - 0.0315096686126619*std::sin(0.217199996113777*x_64 - 4.36175966262817) + 2.27134196356381*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.00113856004200313*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 47.0827355454699*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 11.173803141134*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 15.9010408649087*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 8.22444654624405*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 12.4820003706186*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 0.926701325059064*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 1.84700292752982*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 15.9455889146385*std::sin(0.425759851932526*x_86 + 1.99495983123779) - 3.54628500667232*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.00312473421246952*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 15.042825528091*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.0234612923870974*std::sin(0.361199855804443*x_92 + 2.00439977645874) + 0.0252602064849669*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 2.31515001139745*std::sin(0.365199834108353*x_92 + 1.99327981472015) - 6.32419508085367*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 12.4712854089308*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 3.55768370232856*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 21.2804747187907*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.00223262715950124*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 1.45322567954781*std::sin(0.469919860363007*x_98 + 2.05343985557556) - 6.21423958477819*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 3.64587126471243*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 185.828703614606 - 0.0927460133266495*std::exp(-2.46455979347229*x_86) - 0.000108108646322975*std::exp(-2.44327998161316*x_86) - 0.0708728349837367*std::exp(-2.08607983589172*x_23) - 0.000122988390609042*std::exp(-2.06303977966309*x_23) + 0.00194239794822979*std::exp(-3.40519976615906*x_117) + 0.000147625729984696*std::exp(-4.41160011291504*x_111) + 0.00158257229749015*std::exp(-4.36687994003296*x_111) + 4.38471995019002e-6*std::exp(-4.15944004058838*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.423531159392911*x_1 + 2.80409903043451*x_10 + 7.29255491862349*x_100 - 12.4657423787082*x_101 + 0.7706372574975*x_102 + 1.03990701256964*x_103 + 2.21618539359672*x_104 + 0.663529266668742*x_105 - 3.68645815216852*x_106 + 17.2485133128673*x_107 + 1.89461173470603*x_108 + 9.64054951149256*x_109 - 1.2347934345257*x_11 - 3.59889994845737*x_110 + 4.13337195866903*x_111 - 9.50058770214118*x_112 - 7.73152641707184*x_113 + 4.38389050910112*x_114 + 10.6509930775779*x_115 + 2.75538463987974*x_116 - 6.81103204476403*x_117 + 7.75041305334612*x_118 - 2.4336862229728*x_119 + 8.55161404563809*x_12 + 3.73689240505807*x_120 + 0.722648362656267*x_13 - 4.28500976960791*x_14 + 0.166980264669795*x_15 - 1.9200945137541*x_16 + 0.560193173440394*x_17 + 11.1532621417679*x_18 + 8.86068779419916*x_19 - 9.8034196239916*x_2 + 17.4080697302885*x_20 - 0.828195542732628*x_21 - 0.927287060784726*x_22 + 3.25006377538428*x_23 + 6.01287179755376*x_24 + 14.8996361616135*x_25 + 5.71256169887936*x_26 - 4.87203688715234*x_27 - 6.35584790868721*x_28 + 0.385144063111421*x_29 + 8.32441646535043*x_3 + 9.2136456668724*x_30 - 165.668933086533*x_31 - 7.87738534380191*x_32 + 17.1337523174506*x_33 + 8.77356022830615*x_34 + 8.28568085961971*x_35 - 0.421245072988012*x_36 + 9.61586711475178*x_37 + 6.27202046588592*x_38 - 25.88629661675*x_39 - 59.4358803525818*x_4 + 22.4271533758036*x_40 - 4.58555579745445*x_41 + 9.19464446459776*x_42 - 3.82814624183945*x_43 - 1.66310198884482*x_44 + 6.58829582422193*x_45 - 3.65157029482403*x_46 - 3.29217855332905*x_47 + 0.698106969929334*x_48 + 12.4478204029102*x_49 + 0.332586205234322*x_5 - 0.272937161680628*x_50 + 1.05888303320088*x_51 + 7.66813394369468*x_52 + 5.16749160606524*x_53 - 6.49812755365533*x_54 - 11.2176433071174*x_55 - 6.2692524631596*x_56 + 12.7927127828523*x_57 + 0.90315137520245*x_58 + 3.63457107517838*x_59 - 1.3821345055989*x_6 + 6.40598084985515*x_60 + 3.07898997822448*x_61 - 8.35639776188013*x_62 - 9.09371093670765*x_63 + 11.5981740316198*x_64 + 6.42698713493382*x_65 - 0.772753180001586*x_66 - 6.18408458645423*x_67 - 3.30634441522145*x_68 + 3.00656400681717*x_69 - 0.0195213852562645*x_7 - 8.4200745200712*x_70 + 0.416342707555231*x_71 - 11.9032496242211*x_72 - 4.83382806718826*x_73 + 10.0117134593865*x_74 - 4.20406116985794*x_75 - 15.717357502451*x_76 + 7.76770906479833*x_77 + 4.59084957920532*x_78 - 7.26211237190738*x_79 + 54.4809801581964*x_8 - 2.4085980240309*x_80 + 15.136985489641*x_81 + 3.9883968076686*x_82 + 8.31469682767783*x_83 - 23.7307340555872*x_84 + 5.11209692069332*x_85 + 19.5390877246316*x_86 - 5.5083483015235*x_87 + 5.37523640755012*x_88 - 2.72816545113235*x_89 - 65.9247405661101*x_9 - 14.4917743761323*x_90 - 11.8161563351197*x_91 + 11.3577726533983*x_92 + 376.831414897211*x_93 - 1.7845502645388*x_94 - 0.103810814532322*x_95 + 1.4398859718595*x_96 - 5.04681065613485*x_97 - 7.64623109045342*x_98 - 0.894458166785364*x_99 + 0.0145726846003841*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) - 0.00158349488103931*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.000709111666899429*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) + 0.00214549279946704*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) + 1.88068143383289e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 0.000159815745550468*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) + 0.000950202519153956*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 8.03402009049927e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.0967248754373656*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) - 0.00236459467310828*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.00704806693662476*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) + 2.01038214228638e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.0160231943839503*std::exp(0.459359854459763*x_1) + 0.549013326025779*std::exp(0.553199887275696*x_1) - 0.00540309074488498*std::exp(1.07583975791931*x_1) + 0.00359060119065277*std::exp(1.12799990177155*x_1) + 0.0784316769053559*std::exp(1.14143979549408*x_1) - 0.101439114154258*std::exp(1.17095983028412*x_1) - 0.238171963532322*std::exp(0.854959905147552*x_108) + 0.0651939445603738*std::exp(1.12103986740112*x_108) + 4.11961029068546*std::exp(0.783599853515625*x_15) + 0.0455953916521658*std::exp(2.65919995307922*x_17) - 0.0015991312255139*std::exp(3.37599992752075*x_17) - 0.0679107259879469*std::exp(3.38383984565735*x_17) + 0.000708781917329851*std::exp(3.54839992523193*x_17) - 0.0211842286412809*std::exp(3.8503999710083*x_17) + 1.11631588880118e-6*std::exp(4.05463981628418*x_17) + 0.113932556338694*std::exp(0.856879889965057*x_29) - 3.06104240202827*std::exp(0.877039849758148*x_29) - 0.635282115774921*std::exp(1.00639986991882*x_29) + 0.60835724946926*std::exp(1.10455989837646*x_29) - 0.00181657461318082*std::exp(1.58135986328125*x_29) - 0.00040858255440528*std::exp(2.08335995674133*x_29) + 0.00211671447553833*std::exp(1.54199981689453*x_38) - 0.0186531970695271*std::exp(1.65999984741211*x_38) + 0.190825771772806*std::exp(1.84159982204437*x_50) + 0.0807124700655674*std::exp(1.84279990196228*x_50) - 0.0163735283570822*std::exp(1.86639988422394*x_50) + 0.000494788573893091*std::exp(1.92463982105255*x_50) + 0.321404335497389*std::exp(1.92519986629486*x_50) + 0.080044009984206*std::exp(1.9385598897934*x_50) + 0.350921617599909*std::exp(1.95839989185333*x_50) - 1.32585517394324*std::exp(1.97631978988647*x_50) + 9.25653208717724*std::exp(0.794959902763367*x_66) - 0.0162053973623267*std::exp(0.697999835014343*x_67) - 7.02061099983276*std::exp(0.72519987821579*x_7) + 0.342587559640493*std::exp(1.3575998544693*x_71) + 1.08058648295382*std::exp(1.5887998342514*x_71) - 0.126776327953893*std::exp(1.62775981426239*x_71) + 0.00329757611034297*std::exp(1.83247983455658*x_71) - 0.00029626431334511*std::exp(1.8958398103714*x_71) + 0.00714912845316976*std::exp(1.97847986221313*x_71) - 0.030054207025723*std::exp(1.99599981307983*x_71) - 0.00742705886713101*std::exp(1.21479988098145*x_77) + 0.170422925886517*std::exp(1.32791984081268*x_77) + 0.241425547837348*std::exp(0.814639866352081*x_78) - 0.049729277812763*std::exp(1.25415980815887*x_78) + 0.462175429871167*std::exp(1.2727198600769*x_78) - 0.000761796449997879*std::exp(1.48223996162415*x_78) + 0.104184768049127*std::exp(1.75423991680145*x_78) + 0.353666475164617*std::exp(0.863119900226593*x_87) + 0.00242523550992241*std::exp(0.901039838790894*x_87) - 2.86074771848315*std::sin(0.241679981350899*x_100 + 1.81343984603882) - 0.996686411818539*std::sin(0.609119892120361*x_100 - 0.991599798202515) - 0.532791948613169*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.0970016348195437*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.105317122644087*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 29.9112627795909*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 33.0771365137571*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 7.07420299462664*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 4.49461112448932*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 27.1587915125661*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 27.6840151852489*std::sin(0.42663985490799*x_116 + 2.02367973327637) + 0.530489603850473*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 55.8960071718488*std::sin(0.289359927177429*x_14 - 7.47560024261475) + 0.00802213023833322*std::sin(0.332639902830124*x_14 - 1.29095983505249) + 2.05565560818505*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 3.2196355338695*std::sin(0.607599854469299*x_15 + 2.18927979469299) + 0.010208684436411*std::sin(0.39727982878685*x_16 + 2.0079197883606) - 14.0021720094129*std::sin(0.128400042653084*x_26 + 1.70263993740082) - 2.29162903451162*std::sin(0.330239832401276*x_28 + 8.3089599609375) - 4.74783816820637*std::sin(0.333119839429855*x_28 - 4.27583980560303) + 1.71925314153505*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 80.4031494504953*std::sin(0.312319844961166*x_33 - 1.17319989204407) - 2.93113824927169*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 94.8924755668242*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 40.1978517461844*std::sin(0.347439825534821*x_36 - 1.21175980567932) + 0.0186648872961412*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 6.33488660372764*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 5.68748841380354*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.181644740435149*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.192258453629791*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 26.1200208428801*std::sin(0.46823987364769*x_46 + 5.2469596862793) + 1.056528561938*std::sin(0.413279861211777*x_51 - 1.19959986209869) + 0.0164237577802302*std::sin(0.321119844913483*x_53 + 5.12696027755737) - 1.43208414956023*std::sin(0.498479843139648*x_54 + 8.28343963623047) + 0.0159078280043955*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 4.37589833759059*std::sin(0.528079867362976*x_55 - 7.24743986129761) - 0.025274667848421*std::sin(0.217199996113777*x_64 - 4.36175966262817) + 0.800480472071184*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.0442288875291924*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 105.919278943199*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 3.96735563008441*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 5.07051133831581*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 18.5020568111164*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 3.98025040887456*std::sin(0.508959829807281*x_84 + 8.29032039642334) - 0.481836236180865*std::sin(0.641439855098724*x_85 - 0.964639782905579) + 0.960344951227176*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 35.8718596231963*std::sin(0.425759851932526*x_86 + 1.99495983123779) - 1.24980383481577*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.121384479468281*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 33.8409655841894*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.135706648012362*std::sin(0.361199855804443*x_92 + 2.00439977645874) + 0.0202618230149687*std::sin(0.362639844417572*x_92 + 1.99015974998474) - 1.83367143137796*std::sin(0.365199834108353*x_92 + 1.99327981472015) - 2.22881219340876*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 28.0559220424456*std::sin(0.336159855127335*x_95 + 5.15320014953613) + 2.81779709078166*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 47.8734404802475*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.0867293879016432*std::sin(0.398559868335724*x_97 - 1.19631993770599) + 0.755601371035123*std::sin(0.469919860363007*x_98 + 2.05343985557556) - 2.19006099309755*std::sin(0.310239940881729*x_99 - 4.28975963592529) + 2.88764440648477*std::sin(0.340399831533432*x_99 - 7.43175983428955) - 907.690441618233 - 0.029574775396885*std::exp(-2.46455979347229*x_86) - 0.000625330513408259*std::exp(-2.44327998161316*x_86) - 0.15943847550846*std::exp(-2.08607983589172*x_23) - 9.86519648958256e-5*std::exp(-2.06303977966309*x_23) - 0.0010099453742346*std::exp(-3.40519976615906*x_117) - 7.67576609375677e-5*std::exp(-4.41160011291504*x_111) + 0.000561906007753952*std::exp(-4.36687994003296*x_111) + 2.53624411262382e-5*std::exp(-4.15944004058838*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.19593377827129*x_1 - 6.07788116754044*x_10 + 5.0462842881595*x_100 - 416.19093892613*x_101 + 8.16329293144278*x_102 + 9.79239462724381*x_103 - 4.53641904355678*x_104 - 0.292272226541954*x_105 + 10.7530769924616*x_106 - 26.720678288957*x_107 - 0.557546645930368*x_108 + 15.1253153760952*x_109 + 1.94457641803918*x_11 + 4.68250587337836*x_110 + 19.5703486262847*x_111 - 8.24574222568894*x_112 + 9.66554082356521*x_113 + 0.756654663010164*x_114 + 1.43205213282028*x_115 - 0.971623518652046*x_116 + 9.15025944685761*x_117 + 7.98797318141751*x_118 + 4.34461770427488*x_119 + 4.57299642728866*x_12 + 17.5544628081879*x_120 + 2.45796323851856*x_13 - 2.45352694570042*x_14 - 0.116573395247809*x_15 - 8.91699565490129*x_16 + 0.757252947273246*x_17 + 3.13842132058195*x_18 + 1.3001302668839*x_19 + 3.47976293884072*x_2 + 2.99816201475337*x_20 - 2.01426313741789*x_21 + 9.92423377242314*x_22 - 1.27075437768342*x_23 + 12.8967961585733*x_24 + 1.12160680612443*x_25 + 10.9400748827737*x_26 + 0.302351323630852*x_27 + 9.60005293015866*x_28 - 0.0943282663651639*x_29 + 0.33437133818767*x_3 + 2.1090373413596*x_30 + 4.75312744662027*x_31 + 57.419637895304*x_32 - 22.977037535361*x_33 + 4.04000403279387*x_34 + 25.4759810796101*x_35 - 0.618685524415073*x_36 - 5.89236569942859*x_37 + 0.908080841335848*x_38 - 12.9223785045157*x_39 - 15.6278161941689*x_4 - 17.2732448129638*x_40 - 3.1453267152368*x_41 + 32.5906339379873*x_42 - 14.9283578521418*x_43 - 5.41083086723346*x_44 + 3.88780571654218*x_45 + 5.10483818738077*x_46 - 2.54276904103595*x_47 - 21.2140017931915*x_48 + 10.9426158566357*x_49 + 1.11591942847702*x_5 - 0.225682140578934*x_50 - 6.90910195016283*x_51 + 8.96576322766284*x_52 + 0.941964158241753*x_53 + 0.0188181096444096*x_54 - 5.80002328076538*x_55 + 1.58574039278256*x_56 + 22.1229244429834*x_57 - 9.76261282718581*x_58 + 13.5182882840294*x_59 + 2.08747523467267*x_6 - 3.67487998942883*x_60 - 0.201431754164453*x_61 - 3.39205555911176*x_62 - 14.4534259447898*x_63 - 1.30176676350349*x_64 - 0.331962485808542*x_65 + 1.11385319831468*x_66 - 7.82405356338437*x_67 + 8.41574366382129*x_68 - 7.05863105357845*x_69 + 3.3818866465326*x_7 + 2.46664921846392*x_70 - 0.716583118245334*x_71 + 18.5948701796791*x_72 - 5.18649031253524*x_73 - 1.00238389282312*x_74 - 1.3595715280666*x_75 + 3.49331066506548*x_76 + 2.11545162547558*x_77 + 6.27035234771272*x_78 + 4.79137549073737*x_79 + 76.4242520895256*x_8 + 0.685994913886019*x_80 - 8.10960090846819*x_81 - 2.35429588893021*x_82 + 14.2655371886535*x_83 - 1.15789174813577*x_84 - 6.05138424279782*x_85 + 13.0239023244077*x_86 + 0.0355615345560305*x_87 + 22.5220798472938*x_88 - 20.5939941990729*x_89 + 41.6505674376825*x_9 - 15.1759098369823*x_90 + 18.4629894167384*x_91 + 8.58288316581813*x_92 - 1.45494534578404*x_93 + 14.5964481365487*x_94 + 1.88918723091529*x_95 + 7.12752630087823*x_96 - 4.56519702216316*x_97 - 7.1112682998158*x_98 - 2.92574700955412*x_99 + 0.0191878048271721*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.00170052936364066*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 3.93451475497089e-5*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.00988650922097423*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 2.37954363343791e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 6.11700351488714e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00437856793075331*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 4.45768587139677e-6*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.0622470292855413*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.0025393594402337*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.00928016604334084*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 2.54364824440537e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.00613293364985691*std::exp(0.459359854459763*x_1) + 1.23509073024668*std::exp(0.553199887275696*x_1) - 0.000299791150682219*std::exp(1.07583975791931*x_1) - 0.016545621495*std::exp(1.12799990177155*x_1) - 0.130299673166937*std::exp(1.14143979549408*x_1) - 0.0652808647300692*std::exp(1.17095983028412*x_1) - 0.688021588286938*std::exp(0.854959905147552*x_108) - 0.300416078864458*std::exp(1.12103986740112*x_108) - 6.84396784094275*std::exp(0.783599853515625*x_15) + 0.0600352989192651*std::exp(2.65919995307922*x_17) + 0.00171732137429849*std::exp(3.37599992752075*x_17) - 0.0437037621424642*std::exp(3.38383984565735*x_17) + 0.00204750069352376*std::exp(3.54839992523193*x_17) + 0.0351936637996846*std::exp(3.8503999710083*x_17) - 1.41242547425417e-6*std::exp(4.05463981628418*x_17) - 0.525005382955127*std::exp(0.856879889965057*x_29) + 5.0853537788784*std::exp(0.877039849758148*x_29) - 0.836473826336764*std::exp(1.00639986991882*x_29) + 1.3685941012342*std::exp(1.10455989837646*x_29) - 0.000695300281934534*std::exp(1.58135986328125*x_29) - 2.26702529935848e-5*std::exp(2.08335995674133*x_29) + 0.000117446161511925*std::exp(1.54199981689453*x_38) - 0.0245606018786292*std::exp(1.65999984741211*x_38) + 0.551249813932818*std::exp(1.84159982204437*x_50) - 0.371926011473476*std::exp(1.84279990196228*x_50) - 0.00626702520245399*std::exp(1.86639988422394*x_50) - 0.000626034255310112*std::exp(1.92463982105255*x_50) + 0.423192008147098*std::exp(1.92519986629486*x_50) - 0.085959980667793*std::exp(1.9385598897934*x_50) + 0.789452671537641*std::exp(1.95839989185333*x_50) + 2.20266227432529*std::exp(1.97631978988647*x_50) + 5.95701593108992*std::exp(0.794959902763367*x_66) - 0.000899158454281694*std::exp(0.697999835014343*x_67) - 4.51809502501734*std::exp(0.72519987821579*x_7) + 0.451083888168808*std::exp(1.3575998544693*x_71) + 0.695408478386131*std::exp(1.5887998342514*x_71) - 0.285203036152193*std::exp(1.62775981426239*x_71) + 0.00126215878091974*std::exp(1.83247983455658*x_71) + 0.000374850226068564*std::exp(1.8958398103714*x_71) - 0.0329434451570984*std::exp(1.97847986221313*x_71) - 0.0868193843887767*std::exp(1.99599981307983*x_71) - 0.000412091269440484*std::exp(1.21479988098145*x_77) + 0.49231089339798*std::exp(1.32791984081268*x_77) - 0.259269062468318*std::exp(0.814639866352081*x_78) + 0.2291543293785*std::exp(1.25415980815887*x_78) + 0.6085448349063*std::exp(1.2727198600769*x_78) + 0.000963867596051957*std::exp(1.48223996162415*x_78) + 0.234379814023558*std::exp(1.75423991680145*x_78) - 0.379805601618355*std::exp(0.863119900226593*x_87) - 0.00306854399336628*std::exp(0.901039838790894*x_87) + 13.1824300247898*std::sin(0.241679981350899*x_100 + 1.81343984603882) - 2.87918761685121*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.572170055095699*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.00538214756954382*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.040310496764428*std::sin(0.387279838323593*x_105 - 7.41224002838135) - 49.6920111614359*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 21.2867008196559*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 9.31457930305543*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 10.1113256687319*std::sin(0.379999846220016*x_112 + 1.9871199131012) - 45.1192910482666*std::sin(0.4059998691082*x_112 + 1.9936797618866) - 45.9918526916023*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 2.44451547980095*std::sin(0.56199985742569*x_118 + 8.39344024658203) + 92.8608408388033*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0101500491214674*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 2.20758700587456*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 4.2392832846247*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0129166001319694*std::sin(0.39727982878685*x_16 + 2.0079197883606) - 40.4489112929355*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 2.46100098612302*std::sin(0.330239832401276*x_28 + 8.3089599609375) - 13.7153639285313*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 1.84632137793392*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 51.7432271260524*std::sin(0.312319844961166*x_33 - 1.17319989204407) - 8.46735427563799*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 61.0677933559146*std::sin(0.293199926614761*x_36 + 1.90127992630005) - 66.7812693952889*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0236158622802225*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 14.2513111258441*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 7.48869687593379*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.0695251592310527*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.073587595050127*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 16.8094680400861*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 4.86852222128987*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0207802595165863*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 1.53792802028709*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0201274762268155*std::sin(0.249279975891113*x_55 - 7.55600023269653) - 7.26974286024558*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.0319789273632571*std::sin(0.217199996113777*x_64 - 4.36175966262817) + 2.31239579007943*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.00245404523296662*std::sin(0.694319844245911*x_73 + 8.65120029449463) + 175.96522187114*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 5.22380382184595*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 11.4069026282078*std::sin(0.517359852790833*x_79 - 1.05527985095978) + 30.7377331523042*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 8.95419136662393*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 2.22031898367824*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 4.4253046283735*std::sin(0.419279843568802*x_86 + 2.0163197517395) - 59.5944364473171*std::sin(0.425759851932526*x_86 + 1.99495983123779) - 3.61038304729076*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.00673503268646893*std::sin(0.347679853439331*x_92 + 5.18296003341675) + 56.2204829637188*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.0519421938073698*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.0256363949203524*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 1.96919620622999*std::sin(0.365199834108353*x_92 + 1.99327981472015) - 6.43850301504645*std::sin(0.380959838628769*x_92 + 1.98055982589722) - 46.6097069037435*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 3.02605758378607*std::sin(0.31743985414505*x_97 + 5.14344024658203) + 79.5328353807914*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.00481219069319029*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 3.48183872906737*std::sin(0.469919860363007*x_98 + 2.05343985557556) - 6.32656010627277*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 3.10106724295635*std::sin(0.340399831533432*x_99 - 7.43175983428955) - 1599.85969589724 - 0.0665330497644516*std::exp(-2.46455979347229*x_86) - 0.000239347439472198*std::exp(-2.44327998161316*x_86) + 0.264877433056241*std::exp(-2.08607983589172*x_23) + 0.000124819999161464*std::exp(-2.06303977966309*x_23) + 0.00465386519010036*std::exp(-3.40519976615906*x_117) + 0.000353702106494221*std::exp(-4.41160011291504*x_111) + 0.000739859751559716*std::exp(-4.36687994003296*x_111) + 9.70756298016487e-6*std::exp(-4.15944004058838*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.97852800254249*x_1 - 4.71280559575127*x_10 - 4.19394744117884*x_100 - 176.572626143865*x_101 + 1.77880259587118*x_102 + 3.04825039382299*x_103 - 2.91005483748834*x_104 - 0.570317872915474*x_105 + 9.90155775372938*x_106 - 26.9826283532966*x_107 - 2.18047150706137*x_108 - 1.95589810521987*x_109 + 3.09067531275721*x_11 + 5.67687652996115*x_110 + 4.69349233349844*x_111 + 4.23811613688238*x_112 + 9.41103908840559*x_113 - 2.99414401478789*x_114 - 7.20522312680099*x_115 - 2.1586804414442*x_116 + 8.57905494787363*x_117 - 0.673764341200603*x_118 + 3.45468523310518*x_119 - 6.75067507293808*x_12 + 5.86483027982252*x_120 - 0.540632091015572*x_13 + 2.62926078847978*x_14 - 0.333545118544072*x_15 - 3.26099607063799*x_16 - 0.794953367176103*x_17 - 7.54127423681821*x_18 - 7.38470604992714*x_19 + 10.1544000772949*x_2 - 15.0027311379834*x_20 + 0.696049400243746*x_21 + 5.70552308780803*x_22 - 3.48954515157445*x_23 - 0.604740929530986*x_24 - 11.7238888422725*x_25 + 0.981868568298942*x_26 + 4.67212148211594*x_27 + 10.3415286817615*x_28 - 0.271021029230746*x_29 - 6.45422722718147*x_3 - 5.20563096787378*x_30 + 195.615630229278*x_31 + 31.5411293431068*x_32 - 27.8982986093597*x_33 - 4.97928692921771*x_34 + 3.37663423730721*x_35 + 0.578272074151682*x_36 - 9.52696414483013*x_37 - 4.87522726921441*x_38 + 21.1122810168465*x_39 + 46.5386595946564*x_4 - 28.8519691672741*x_40 + 0.651048907990003*x_41 + 11.0774061038055*x_42 - 5.75073953144294*x_43 - 0.930375328558568*x_44 - 2.95505850363415*x_45 + 6.19984769275411*x_46 + 3.00189769626486*x_47 - 17.398703819139*x_48 - 10.8933698564331*x_49 + 0.163047171420412*x_5 + 0.114075942384772*x_50 - 2.78321570483729*x_51 - 1.5921303354979*x_52 - 4.15163720332971*x_53 + 3.95665434754639*x_54 + 6.58081586038436*x_55 + 5.80981783962484*x_56 - 2.20165722648412*x_57 - 6.32891064677105*x_58 + 2.97287994357685*x_59 + 1.52020365320507*x_6 - 7.92298942601953*x_60 - 4.26150065549889*x_61 + 5.7459137750706*x_62 + 0.981600030051157*x_63 - 11.9515828379768*x_64 - 6.01482065461466*x_65 + 2.32103057305433*x_66 + 0.560542752234228*x_67 + 8.24018829788611*x_68 - 4.68159148538395*x_69 + 2.04701252810721*x_7 + 8.83132629313549*x_70 - 0.729150813209352*x_71 + 15.0849241696697*x_72 + 1.74318087500095*x_73 - 8.81745054886485*x_74 + 2.12782377519418*x_75 + 15.4658830239202*x_76 - 6.40619541551466*x_77 - 0.66522938432386*x_78 + 9.11108613383379*x_79 - 13.9508670432105*x_8 + 2.52671061614507*x_80 - 18.2995694657876*x_81 - 5.38720717847435*x_82 - 1.99860576846399*x_83 + 21.0900498830068*x_84 - 7.5532300071659*x_85 - 10.6623355988451*x_86 + 3.69009160135743*x_87 + 4.37883171508336*x_88 - 9.90453509373672*x_89 + 87.1654944333274*x_9 + 4.14744345724965*x_90 + 16.2799074877176*x_91 - 5.91512909925814*x_92 - 254.000660699139*x_93 + 8.5829224526358*x_94 + 0.215118009276945*x_95 + 4.01854242882824*x_96 + 2.78114239570422*x_97 + 2.10206371367836*x_98 - 1.59290925076545*x_99 + 0.00195664470711072*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.00137882747011219*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) + 0.000655475978183839*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.0078455810043498*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 2.81071005814921e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 2.41624433567e-6*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00347467529903221*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) - 7.4263440067127e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) + 0.0520673378326436*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.00205896976997029*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.000946329605359429*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 3.00454995003155e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.000242253681176446*std::exp(0.459359854459763*x_1) - 0.596552443866114*std::exp(0.553199887275696*x_1) + 0.00499441252561118*std::exp(1.07583975791931*x_1) - 0.0131300149329697*std::exp(1.12799990177155*x_1) - 0.135175251628267*std::exp(1.14143979549408*x_1) + 0.054605028977618*std::exp(1.17095983028412*x_1) - 0.0162167692292953*std::exp(0.854959905147552*x_108) - 0.23839948247254*std::exp(1.12103986740112*x_108) - 7.10005675800845*std::exp(0.783599853515625*x_15) + 0.00612200045436372*std::exp(2.65919995307922*x_17) + 0.0013924428101754*std::exp(3.37599992752075*x_17) + 0.0365565806777825*std::exp(3.38383984565735*x_17) + 4.82598901095081e-5*std::exp(3.54839992523193*x_17) + 0.0365105471427241*std::exp(3.8503999710083*x_17) - 1.66835288543825e-6*std::exp(4.05463981628418*x_17) - 0.416625541698352*std::exp(0.856879889965057*x_29) + 5.27563853362814*std::exp(0.877039849758148*x_29) - 0.0852980369396271*std::exp(1.00639986991882*x_29) - 0.661034963471021*std::exp(1.10455989837646*x_29) - 2.74646788043421e-5*std::exp(1.58135986328125*x_29) + 0.000377678244512139*std::exp(2.08335995674133*x_29) - 0.0019566107231827*std::exp(1.54199981689453*x_38) - 0.00250452681284418*std::exp(1.65999984741211*x_38) + 0.0129930385505757*std::exp(1.84159982204437*x_50) - 0.295147213785975*std::exp(1.84279990196228*x_50) - 0.000247550358767612*std::exp(1.86639988422394*x_50) - 0.000739469851874013*std::exp(1.92463982105255*x_50) + 0.0431543060965465*std::exp(1.92519986629486*x_50) - 0.0696982864331834*std::exp(1.9385598897934*x_50) - 0.381307954945425*std::exp(1.95839989185333*x_50) + 2.28508191883603*std::exp(1.97631978988647*x_50) - 4.98282351010997*std::exp(0.794959902763367*x_66) + 0.0149796557915545*std::exp(0.697999835014343*x_67) + 3.77921938970679*std::exp(0.72519987821579*x_7) + 0.0459985344961684*std::exp(1.3575998544693*x_71) - 0.581683472952912*std::exp(1.5887998342514*x_71) + 0.137753902647011*std::exp(1.62775981426239*x_71) + 4.98558484998635e-5*std::exp(1.83247983455658*x_71) + 0.000442772002961007*std::exp(1.8958398103714*x_71) - 0.0261427427786187*std::exp(1.97847986221313*x_71) - 0.00204634555838254*std::exp(1.99599981307983*x_71) + 0.00686529203115213*std::exp(1.21479988098145*x_77) + 0.0116038395934368*std::exp(1.32791984081268*x_77) - 0.210221189427865*std::exp(0.814639866352081*x_78) + 0.181848700431325*std::exp(1.25415980815887*x_78) + 0.0620553544808214*std::exp(1.2727198600769*x_78) + 0.00113851761694036*std::exp(1.48223996162415*x_78) - 0.113206137350503*std::exp(1.75423991680145*x_78) - 0.307954927454305*std::exp(0.863119900226593*x_87) - 0.00362455529069961*std::exp(0.901039838790894*x_87) + 10.4611061682163*std::sin(0.241679981350899*x_100 + 1.81343984603882) - 0.0678628722487822*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.463928354552226*std::sin(0.702159821987152*x_100 - 7.1541600227356) - 0.0896646387821872*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.00159228303920453*std::sin(0.387279838323593*x_105 - 7.41224002838135) - 51.5513964801424*std::sin(0.404239863157272*x_105 + 5.20743989944458) + 17.8055379612611*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 0.94983884068267*std::sin(0.348479837179184*x_112 + 1.95431983470917) + 4.88379994334787*std::sin(0.379999846220016*x_112 + 1.9871199131012) - 46.8075734382275*std::sin(0.4059998691082*x_112 + 1.9936797618866) - 47.7127847624951*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 1.93988027366403*std::sin(0.56199985742569*x_118 + 8.39344024658203) + 96.3355258053158*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.0119892086682181*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 1.78996121528059*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 0.432293911446167*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.0152570507209256*std::sin(0.39727982878685*x_16 + 2.0079197883606) - 0.953386741318657*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 1.99543497230469*std::sin(0.330239832401276*x_28 + 8.3089599609375) - 0.323273129086807*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 1.49703891563535*std::sin(0.329359829425812*x_3 - 4.26152038574219) + 43.2812958023231*std::sin(0.312319844961166*x_33 - 1.17319989204407) - 0.199576775799427*std::sin(0.409919857978821*x_34 - 1.18663990497589) - 51.0809505907624*std::sin(0.293199926614761*x_36 + 1.90127992630005) - 69.2801038955627*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0278949882280526*std::sin(0.353839844465256*x_36 + 1.97599983215332) - 6.88342505713784*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 0.763647495762649*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.00274627555419485*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.00290674362508891*std::sin(0.307599931955338*x_43 - 7.47824001312256) - 14.0604983286084*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 3.86348554427816*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0245455824442414*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 1.24698664237544*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0237745167102209*std::sin(0.249279975891113*x_55 - 7.55600023269653) - 7.54176350962518*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.0377734165180522*std::sin(0.217199996113777*x_64 - 4.36175966262817) + 0.0545035061877637*std::sin(0.518159866333008*x_73 + 2.1451997756958) + 0.0408835091431264*std::sin(0.694319844245911*x_73 + 8.65120029449463) + 182.549522697427*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 0.532688767217674*std::sin(0.484159857034683*x_75 + 8.49135971069336) - 5.50956741327096*std::sin(0.517359852790833*x_79 - 1.05527985095978) + 31.8878836174975*std::sin(0.388479858636856*x_8 + 8.37639999389648) - 4.32490068283283*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 1.76196593282767*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 3.51176387487424*std::sin(0.419279843568802*x_86 + 2.0163197517395) - 61.8243526374014*std::sin(0.425759851932526*x_86 + 1.99495983123779) - 0.0850972552373698*std::sin(0.656639814376831*x_87 + 5.4495997428894) + 0.112203217250256*std::sin(0.347679853439331*x_92 + 5.18296003341675) + 58.3241519074797*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.00205174038667601*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.0302816355391702*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 1.59666859111312*std::sin(0.365199834108353*x_92 + 1.99327981472015) - 0.151756455545382*std::sin(0.380959838628769*x_92 + 1.98055982589722) - 48.3537579634698*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 2.45359557551706*std::sin(0.31743985414505*x_97 + 5.14344024658203) + 82.5088104521508*std::sin(0.368239849805832*x_97 + 5.15952014923096) + 0.0801693626346411*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 2.76306299649499*std::sin(0.469919860363007*x_98 + 2.05343985557556) - 0.149117944851323*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 2.51441509489678*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 781.107215035111 + 0.0321356581041801*std::exp(-2.46455979347229*x_86) - 9.45433321191228e-6*std::exp(-2.44327998161316*x_86) + 0.274788668258242*std::exp(-2.08607983589172*x_23) + 0.000147437022028643*std::exp(-2.06303977966309*x_23) + 0.00369314138248062*std::exp(-3.40519976615906*x_117) + 0.000280685372954734*std::exp(-4.41160011291504*x_111) + 7.54459762298367e-5*std::exp(-4.36687994003296*x_111) + 3.83453172895812e-7*std::exp(-4.15944004058838*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.58441985739588*x_1 + 6.27984807714952*x_10 + 9.80642437984361*x_100 + 181.561541023427*x_101 + 1.25827557669757*x_102 - 3.38312732621904*x_103 + 3.21997249818777*x_104 - 0.206023943156289*x_105 - 18.0598826733857*x_106 + 42.7148457758729*x_107 + 4.92686516035351*x_108 + 11.3831169495828*x_109 - 7.97645015920089*x_11 - 10.9986382571368*x_110 - 1.75848547076527*x_111 - 11.5068059887686*x_112 - 9.13717975808508*x_113 + 4.65748533880525*x_114 + 9.89785142184874*x_115 - 1.0652418433644*x_116 - 9.36287275801391*x_117 - 2.10655983069919*x_118 - 4.7404008842931*x_119 + 18.0693591737232*x_12 - 9.57072721761077*x_120 + 4.9907156674268*x_13 - 5.57432063412966*x_14 + 0.530086463675933*x_15 + 5.46434278445904*x_16 + 2.77459610766191*x_17 + 14.399851217381*x_18 + 14.1862936031871*x_19 - 17.817084923674*x_2 + 30.9742347556227*x_20 - 4.47872262171566*x_21 - 7.86320170738693*x_22 + 3.64178570080215*x_23 + 9.15153581816941*x_24 + 19.9565374039455*x_25 - 1.38545131823483*x_26 - 9.21790202886011*x_27 - 17.1436286896248*x_28 + 0.154001972401364*x_29 + 9.52348761706579*x_3 + 7.77878155246067*x_30 - 500.232147635523*x_31 - 42.8767267133498*x_32 + 55.2549821697619*x_33 + 10.1284910245951*x_34 + 5.50391838952552*x_35 - 1.43325622754176*x_36 + 11.5588902438859*x_37 + 8.77015662335993*x_38 - 55.5986345690943*x_39 - 90.3022675462158*x_4 + 52.3186891763615*x_40 + 2.31589234500208*x_41 + 6.85726035753665*x_42 + 10.8558275181811*x_43 - 0.00335157671521724*x_44 + 4.61968826303188*x_45 - 12.2107715481199*x_46 - 9.99876515785417*x_47 + 37.0967694284276*x_48 + 38.2587858029667*x_49 + 0.153169659371682*x_5 - 0.519569593124581*x_50 + 0.738207716631029*x_51 + 0.894100714551236*x_52 + 8.02416734407181*x_53 - 1.58167189789391*x_54 - 11.6201167994448*x_55 - 7.93017171006171*x_56 + 14.9098755549589*x_57 + 11.1604413618992*x_58 - 1.42716511022523*x_59 - 1.07014817679308*x_6 + 16.5853649397698*x_60 + 12.1065998114476*x_61 - 12.8822113291207*x_62 - 5.57940253162156*x_63 + 25.8398588056378*x_64 + 11.4896973205306*x_65 - 7.93448058363793*x_66 - 0.691300654052371*x_67 - 15.0787073843002*x_68 + 3.49711242748596*x_69 - 5.16153134747014*x_7 - 16.2891984667646*x_70 + 1.30128247442143*x_71 - 16.2242428352495*x_72 - 4.41002938501386*x_73 + 16.0815474618929*x_74 - 1.82349673259009*x_75 - 29.0173426199588*x_76 + 14.3862943279449*x_77 + 1.83392838344162*x_78 - 18.0980478888352*x_79 + 49.0874066015686*x_8 - 3.29943724288689*x_80 + 35.5736843322699*x_81 + 12.3119765865995*x_82 + 11.9844283630274*x_83 - 41.9586458095862*x_84 + 13.3594869887007*x_85 + 23.6393428326914*x_86 - 6.14242586538429*x_87 + 2.29511975288*x_88 + 18.2046353659855*x_89 - 182.944193601058*x_9 - 2.87058379176048*x_90 - 18.6766845306099*x_91 + 14.17588007843*x_92 + 321.533951403694*x_93 - 13.2000550687968*x_94 + 2.72453481650203*x_95 - 10.2503253182122*x_96 - 7.01554935814104*x_97 - 2.70485149669208*x_98 + 5.07502262799316*x_99 - 0.0173590086052184*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.000397536881749958*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) + 0.00102083260740332*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) + 0.000545689665905817*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 1.18935490260641e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) + 4.37857222327041e-6*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) + 0.000241676735223158*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) - 0.000115657237918189*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.107278673666124*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.000593632227174019*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) + 0.00839567025280982*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 1.27137845571624e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) + 0.000438997506885025*std::exp(0.459359854459763*x_1) + 3.100074487579*std::exp(0.553199887275696*x_1) + 0.00777825478073818*std::exp(1.07583975791931*x_1) + 0.000913241920278204*std::exp(1.12799990177155*x_1) + 0.233082454282495*std::exp(1.14143979549408*x_1) - 0.112507290137397*std::exp(1.17095983028412*x_1) - 0.649380169747452*std::exp(0.854959905147552*x_108) + 0.0165815806210443*std::exp(1.12103986740112*x_108) + 12.2426156768149*std::exp(0.783599853515625*x_15) - 0.0543133141046221*std::exp(2.65919995307922*x_17) + 0.000401462390887262*std::exp(3.37599992752075*x_17) - 0.0753205685584796*std::exp(3.38383984565735*x_17) + 0.00193250672733829*std::exp(3.54839992523193*x_17) - 0.06295507374845*std::exp(3.8503999710083*x_17) - 7.05965269459393e-7*std::exp(4.05463981628418*x_17) + 0.0289778733443904*std::exp(0.856879889965057*x_29) - 9.09677446509897*std::exp(0.877039849758148*x_29) + 0.756749220674655*std::exp(1.00639986991882*x_29) + 3.43516759796252*std::exp(1.10455989837646*x_29) - 4.97698341009832e-5*std::exp(1.58135986328125*x_29) + 0.000588192824660164*std::exp(2.08335995674133*x_29) - 0.00304720858231009*std::exp(1.54199981689453*x_38) + 0.0222197225373437*std::exp(1.65999984741211*x_38) + 0.520289920896571*std::exp(1.84159982204437*x_50) + 0.0205285987608319*std::exp(1.84279990196228*x_50) - 0.000448595826489516*std::exp(1.86639988422394*x_50) - 0.000312907441700023*std::exp(1.92463982105255*x_50) - 0.382857433523719*std::exp(1.92519986629486*x_50) - 0.0200950735697982*std::exp(1.9385598897934*x_50) + 1.98152413118357*std::exp(1.95839989185333*x_50) - 3.94016282909198*std::exp(1.97631978988647*x_50) + 10.2665263777292*std::exp(0.794959902763367*x_66) + 0.0233291861008643*std::exp(0.697999835014343*x_67) - 7.78664054083552*std::exp(0.72519987821579*x_7) - 0.408090928948215*std::exp(1.3575998544693*x_71) + 1.19849091713634*std::exp(1.5887998342514*x_71) - 0.715858871338866*std::exp(1.62775981426239*x_71) + 9.03457610583696e-5*std::exp(1.83247983455658*x_71) + 0.000187359436428422*std::exp(1.8958398103714*x_71) + 0.00181832608251916*std::exp(1.97847986221313*x_71) - 0.0819433394700987*std::exp(1.99599981307983*x_71) + 0.0106919463077268*std::exp(1.21479988098145*x_77) + 0.464661192273477*std::exp(1.32791984081268*x_77) - 0.0606099587761483*std::exp(0.814639866352081*x_78) - 0.0126482610438614*std::exp(1.25415980815887*x_78) - 0.550544219151127*std::exp(1.2727198600769*x_78) + 0.000481764921104465*std::exp(1.48223996162415*x_78) + 0.588292717339741*std::exp(1.75423991680145*x_78) - 0.0887880784459261*std::exp(0.863119900226593*x_87) - 0.00153373436447593*std::exp(0.901039838790894*x_87) - 0.727609277983913*std::sin(0.241679981350899*x_100 + 1.81343984603882) - 2.71748354295222*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.133757584195124*std::sin(0.702159821987152*x_100 - 7.1541600227356) - 0.139642931314602*std::sin(0.384559839963913*x_105 + 1.97951984405518) + 0.00288543926792582*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 88.8899844353527*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 36.6862331724272*std::sin(0.502319812774658*x_105 + 2.05711984634399) + 8.42680357300459*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 25.3794008598688*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 80.7102185094711*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 82.2710728416296*std::sin(0.42663985490799*x_116 + 2.02367973327637) + 0.13492596887931*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 166.111181735001*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.00507324619505789*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 0.516072978962418*std::sin(0.419839859008789*x_14 - 1.15535986423492) + 3.83523574898715*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.00645603697956534*std::sin(0.39727982878685*x_16 + 2.0079197883606) - 38.1771754385003*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 0.575314180939749*std::sin(0.330239832401276*x_28 + 8.3089599609375) - 12.9450667067489*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 0.431619035216633*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 89.1760593397066*std::sin(0.312319844961166*x_33 - 1.17319989204407) - 7.99180149349101*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 105.246337859551*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 119.459564191018*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0118037934617236*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 35.7707534789418*std::sin(0.370239853858948*x_36 - 1.19343984127045) + 6.77494662271723*std::sin(0.375999838113785*x_36 + 1.98047983646393) + 0.00497663488808959*std::sin(0.388399839401245*x_41 + 2.0033597946167) + 0.00526742544580182*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 28.9700160324342*std::sin(0.46823987364769*x_46 + 5.2469596862793) + 0.268719950086581*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.0103864888990405*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 0.359525170580947*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0100602116267441*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 13.0042498702034*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.0159838607307372*std::sin(0.217199996113777*x_64 - 4.36175966262817) + 2.18252449668603*std::sin(0.518159866333008*x_73 + 2.1451997756958) + 0.0636716228015148*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 314.769828543945*std::sin(0.187120005488396*x_75 - 7.62423992156982) - 4.72592129804153*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 28.6312956238786*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 54.9842229691594*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 22.4749968020786*std::sin(0.508959829807281*x_84 + 8.29032039642334) - 0.122551357342317*std::sin(0.641439855098724*x_85 - 0.964639782905579) + 0.244256385162269*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 106.603625098328*std::sin(0.425759851932526*x_86 + 1.99495983123779) - 3.40761277846011*std::sin(0.656639814376831*x_87 + 5.4495997428894) + 0.174744318078572*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 100.568234989678*std::sin(0.357119828462601*x_92 + 2.00119972229004) - 0.00371804015588953*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.012813705769128*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 0.460343782422293*std::sin(0.365199834108353*x_92 + 1.99327981472015) - 6.07689678930052*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 83.3763018314993*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 0.707408834904616*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 142.269800192441*std::sin(0.368239849805832*x_97 + 5.15952014923096) + 0.124855070538115*std::sin(0.398559868335724*x_97 - 1.19631993770599) + 0.192181423223867*std::sin(0.469919860363007*x_98 + 2.05343985557556) - 5.97124094021231*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 0.724944025207851*std::sin(0.340399831533432*x_99 - 7.43175983428955) - 1137.21910974327 - 0.166997780085683*std::exp(-2.46455979347229*x_86) - 1.71325723065765e-5*std::exp(-2.44327998161316*x_86) - 0.473817628856966*std::exp(-2.08607983589172*x_23) + 6.23881301691156e-5*std::exp(-2.06303977966309*x_23) - 0.00025687187297301*std::exp(-3.40519976615906*x_117) - 1.95227233403618e-5*std::exp(-4.41160011291504*x_111) - 0.000669343466314208*std::exp(-4.36687994003296*x_111) + 6.94870707809006e-7*std::exp(-4.15944004058838*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.78975707383018*x_1 + 1.54892545233257*x_10 + 4.95730654112241*x_100 - 109.3510132391*x_101 - 1.15672127421075*x_102 - 0.469009975590053*x_103 + 6.22012735933535*x_104 - 0.225627891581826*x_105 + 6.43840756274838*x_106 + 2.47181421428915*x_107 + 2.09519202426975*x_108 + 9.81963500944315*x_109 + 0.724608780604761*x_11 + 2.56642433468362*x_110 + 5.57834724347375*x_111 - 8.50649653641263*x_112 - 2.70583508013567*x_113 + 2.05552397943691*x_114 + 10.6382280760564*x_115 + 0.414338853229632*x_116 - 5.9642526406258*x_117 + 12.148908739177*x_118 - 3.62713459088699*x_119 + 3.58278209906028*x_12 + 8.50938752628205*x_120 - 1.08311380400218*x_13 - 3.42425816529859*x_14 - 0.384648380030203*x_15 - 5.99516099983665*x_16 - 1.55816168467826*x_17 + 8.84139815585609*x_18 + 4.68393209512934*x_19 - 3.44720056074041*x_2 + 5.33795256867721*x_20 + 1.0731051049807*x_21 + 3.50009720728993*x_22 + 2.05271143582037*x_23 + 4.56847102368753*x_24 + 11.3565099006244*x_25 + 8.50338845468081*x_26 - 2.84622881144428*x_27 - 0.242010032406745*x_28 + 0.493873532171504*x_29 + 6.01298693586329*x_3 + 12.3607113737498*x_30 + 49.6152571210753*x_31 + 5.56592908979856*x_32 - 3.38543633164018*x_33 + 7.34507793063333*x_34 + 8.37709386919974*x_35 + 1.67804902124918*x_36 + 7.80644587739351*x_37 + 3.92887132032745*x_38 - 4.79422522865857*x_39 - 36.3901001005552*x_4 + 4.39654831304868*x_40 - 9.40122730445466*x_41 + 32.8543929362854*x_42 - 11.8256730259474*x_43 - 4.41792275448868*x_44 + 8.2620094034317*x_45 + 1.06246618152428*x_46 + 2.95497781150727*x_47 - 31.0177778703129*x_48 - 4.36679122903754*x_49 + 1.85176135994114*x_5 - 0.197301605303275*x_50 + 4.02599972389506*x_51 + 8.55125456592468*x_52 + 3.25195025477921*x_53 - 7.553806212089*x_54 - 8.91148273604264*x_55 - 4.59854683812568*x_56 + 10.8389995254103*x_57 - 3.29414089071425*x_58 + 3.41631020307101*x_59 - 2.36065913087823*x_6 + 2.49110057273977*x_60 - 1.09265653685902*x_61 - 3.06786442481698*x_62 - 9.70296908323955*x_63 + 1.79279437372498*x_64 + 2.31368396868204*x_65 + 1.37327454290132*x_66 - 7.41315324283045*x_67 + 4.00227116092356*x_68 + 1.72962492011398*x_69 - 1.31043696307622*x_7 - 4.62984123266467*x_70 - 0.0950251091515426*x_71 - 12.0693487667837*x_72 - 4.10098224342361*x_73 + 6.4934369930073*x_74 - 5.14906629699049*x_75 - 9.4790623050902*x_76 + 2.9366427075808*x_77 + 5.44487297144735*x_78 - 1.36747757424098*x_79 - 9.84877877543984*x_8 - 0.367086429114526*x_80 + 3.63514677690486*x_81 + 3.23750413586388*x_82 + 7.63540032365488*x_83 - 15.2344023482538*x_84 + 0.498449832014632*x_85 + 16.2047888463582*x_86 - 7.47202432057571*x_87 + 6.82424415894216*x_88 - 15.1971028204245*x_89 + 20.3218556577619*x_9 - 8.18129824146337*x_90 - 4.95644934085127*x_91 + 8.4236651279628*x_92 + 386.238617369958*x_93 + 3.12194330830978*x_94 - 2.08521507164472*x_95 + 7.59764507851414*x_96 - 1.05708745651471*x_97 - 8.24453458591307*x_98 - 2.05782640152667*x_99 - 0.00301507465345332*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) - 0.00268704712136182*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.000774732579484114*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.0110304320302682*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) + 0.000131872919616636*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) - 9.71504239530371e-6*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.0048851920198105*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 8.77748512523411e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.0784178952930518*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) - 0.00401250258882608*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) + 0.0014582383794884*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) + 0.000140967501395566*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) - 0.000974034268101019*std::exp(0.459359854459763*x_1) - 1.32439931508801*std::exp(0.553199887275696*x_1) - 0.00590309062079663*std::exp(1.07583975791931*x_1) - 0.0184600397592263*std::exp(1.12799990177155*x_1) - 0.0144129090079785*std::exp(1.14143979549408*x_1) - 0.0822398767266396*std::exp(1.17095983028412*x_1) - 0.0282780174701478*std::exp(0.854959905147552*x_108) - 0.335175850712204*std::exp(1.12103986740112*x_108) - 0.757035557707512*std::exp(0.783599853515625*x_15) - 0.00943364338517961*std::exp(2.65919995307922*x_17) - 0.00271358057903961*std::exp(3.37599992752075*x_17) - 0.0550573590890426*std::exp(3.38383984565735*x_17) + 8.41532611291518e-5*std::exp(3.54839992523193*x_17) + 0.00389289598103881*std::exp(3.8503999710083*x_17) + 7.82757955825774e-6*std::exp(4.05463981628418*x_17) - 0.585751357003314*std::exp(0.856879889965057*x_29) + 0.562509018686871*std::exp(0.877039849758148*x_29) + 0.131439268576133*std::exp(1.00639986991882*x_29) - 1.46755622556252*std::exp(1.10455989837646*x_29) + 0.000110427788704405*std::exp(1.58135986328125*x_29) - 0.00044639262204031*std::exp(2.08335995674133*x_29) + 0.00231259439410374*std::exp(1.54199981689453*x_38) + 0.00385932882186434*std::exp(1.65999984741211*x_38) + 0.0226566319054321*std::exp(1.84159982204437*x_50) - 0.414959870885817*std::exp(1.84279990196228*x_50) + 0.000995330726655641*std::exp(1.86639988422394*x_50) + 0.0034694453115993*std::exp(1.92463982105255*x_50) - 0.0664982528643104*std::exp(1.92519986629486*x_50) + 0.135827421474928*std::exp(1.9385598897934*x_50) - 0.846537466336607*std::exp(1.95839989185333*x_50) + 0.243644286770267*std::exp(1.97631978988647*x_50) + 7.50456137272654*std::exp(0.794959902763367*x_66) - 0.0177050384109123*std::exp(0.697999835014343*x_67) - 5.69182990196392*std::exp(0.72519987821579*x_7) - 0.0708810418934925*std::exp(1.3575998544693*x_71) + 0.876065410187388*std::exp(1.5887998342514*x_71) + 0.30582587699087*std::exp(1.62775981426239*x_71) - 0.000200456416877935*std::exp(1.83247983455658*x_71) - 0.00207739807902571*std::exp(1.8958398103714*x_71) - 0.0367551806736122*std::exp(1.97847986221313*x_71) - 0.00356831836426245*std::exp(1.99599981307983*x_71) - 0.00811435595083622*std::exp(1.21479988098145*x_77) + 0.0202342139858062*std::exp(1.32791984081268*x_77) + 0.409677246896917*std::exp(0.814639866352081*x_78) + 0.25566872979684*std::exp(1.25415980815887*x_78) - 0.0956236590762912*std::exp(1.2727198600769*x_78) - 0.00534169797221147*std::exp(1.48223996162415*x_78) - 0.25132766165386*std::exp(1.75423991680145*x_78) + 0.600139915444206*std::exp(0.863119900226593*x_87) + 0.0170056917507608*std::exp(0.901039838790894*x_87) + 14.7077087708295*std::sin(0.241679981350899*x_100 + 1.81343984603882) - 0.118335992816546*std::sin(0.609119892120361*x_100 - 0.991599798202515) - 0.904099589425973*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.105978127657262*std::sin(0.384559839963913*x_105 + 1.97951984405518) - 0.00640212457110867*std::sin(0.387279838323593*x_105 - 7.41224002838135) - 5.49660960680721*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 26.8166737460358*std::sin(0.502319812774658*x_105 + 2.05711984634399) + 1.46364590515602*std::sin(0.348479837179184*x_112 + 1.95431983470917) + 10.8424688667413*std::sin(0.379999846220016*x_112 + 1.9871199131012) - 4.99080481614112*std::sin(0.4059998691082*x_112 + 1.9936797618866) - 5.08732195439317*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 2.7273591966797*std::sin(0.56199985742569*x_118 + 8.39344024658203) + 10.2716669726356*std::sin(0.289359927177429*x_14 - 7.47560024261475) + 0.0562509799396416*std::sin(0.332639902830124*x_14 - 1.29095983505249) + 3.48826102984275*std::sin(0.419839859008789*x_14 - 1.15535986423492) + 0.666139545164637*std::sin(0.607599854469299*x_15 + 2.18927979469299) + 0.0715830442017353*std::sin(0.39727982878685*x_16 + 2.0079197883606) - 1.66246966615975*std::sin(0.128400042653084*x_26 + 1.70263993740082) - 3.88868652128011*std::sin(0.330239832401276*x_28 + 8.3089599609375) - 0.56370803966502*std::sin(0.333119839429855*x_28 - 4.27583980560303) + 2.91741657025246*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 65.1853592607972*std::sin(0.312319844961166*x_33 - 1.17319989204407) - 0.348012324335037*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 76.9323111500548*std::sin(0.293199926614761*x_36 + 1.90127992630005) - 7.38691307382212*std::sin(0.347439825534821*x_36 - 1.21175980567932) + 0.130877730687286*std::sin(0.353839844465256*x_36 + 1.97599983215332) - 15.281813903991*std::sin(0.370239853858948*x_36 - 1.19343984127045) + 1.17673597065406*std::sin(0.375999838113785*x_36 + 1.98047983646393) - 0.011042005580446*std::sin(0.388399839401245*x_41 + 2.0033597946167) - 0.0116872027936642*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 21.1763215020698*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 5.43183668264421*std::sin(0.413279861211777*x_51 - 1.19959986209869) + 0.115162985638739*std::sin(0.321119844913483*x_53 + 5.12696027755737) - 2.43011684957141*std::sin(0.498479843139648*x_54 + 8.28343963623047) + 0.11154529873906*std::sin(0.249279975891113*x_55 - 7.55600023269653) - 0.804132042770984*std::sin(0.528079867362976*x_55 - 7.24743986129761) - 0.177225349362819*std::sin(0.217199996113777*x_64 - 4.36175966262817) + 0.0950405767245949*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.0483218112501649*std::sin(0.694319844245911*x_73 + 8.65120029449463) + 19.4641373209601*std::sin(0.187120005488396*x_75 - 7.62423992156982) - 0.820842125491932*std::sin(0.484159857034683*x_75 + 8.49135971069336) - 12.231728129849*std::sin(0.517359852790833*x_79 - 1.05527985095978) + 3.40000968742336*std::sin(0.388479858636856*x_8 + 8.37639999389648) - 9.60166295698389*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 2.47722194837173*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 4.93733640716666*std::sin(0.419279843568802*x_86 + 2.0163197517395) - 6.59195199052032*std::sin(0.425759851932526*x_86 + 1.99495983123779) - 0.14838847591892*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.132617351085179*std::sin(0.347679853439331*x_92 + 5.18296003341675) + 6.2187470286479*std::sin(0.357119828462601*x_92 + 2.00119972229004) + 0.00824947400660419*std::sin(0.361199855804443*x_92 + 2.00439977645874) + 0.142075404673607*std::sin(0.362639844417572*x_92 + 1.99015974998474) - 3.11157402540743*std::sin(0.365199834108353*x_92 + 1.99327981472015) - 0.264625563849533*std::sin(0.380959838628769*x_92 + 1.98055982589722) - 5.15566500026081*std::sin(0.336159855127335*x_95 + 5.15320014953613) + 4.78154596647452*std::sin(0.31743985414505*x_97 + 5.14344024658203) + 8.7974090159172*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.0947552910811831*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 3.88470637946244*std::sin(0.469919860363007*x_98 + 2.05343985557556) - 0.260024656575907*std::sin(0.310239940881729*x_99 - 4.28975963592529) + 4.90007052303748*std::sin(0.340399831533432*x_99 - 7.43175983428955) + 1869.42858917928 + 0.071344010104551*std::exp(-2.46455979347229*x_86) + 3.80132284707817e-5*std::exp(-2.44327998161316*x_86) + 0.0292990323622333*std::exp(-2.08607983589172*x_23) - 0.00069174515166115*std::exp(-2.06303977966309*x_23) + 0.00519234266716989*std::exp(-3.40519976615906*x_117) + 0.000394627361128655*std::exp(-4.41160011291504*x_111) - 0.000116257821263587*std::exp(-4.36687994003296*x_111) - 1.54175791591191e-6*std::exp(-4.15944004058838*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.07064109699449*x_1 + 0.475932450194309*x_10 + 10.2981391013264*x_100 - 169.381643211009*x_101 + 2.38110635017804*x_102 + 8.27694732412442*x_103 - 4.81106550464131*x_104 + 0.575453612698767*x_105 - 6.58789411090009*x_106 + 6.38018784663013*x_107 + 1.55768441805115*x_108 + 16.3099743326843*x_109 - 6.51656858051139*x_11 - 7.88917696288409*x_110 + 13.9567638266645*x_111 - 12.4789963837423*x_112 - 5.41631896944925*x_113 + 5.75795382050658*x_114 + 10.709134890856*x_115 - 5.05405674823738*x_116 - 2.40373865994399*x_117 + 4.10053854379316*x_118 - 4.92426701615654*x_119 + 14.2399463219596*x_12 + 5.85636057882627*x_120 + 1.80534367181259*x_13 - 4.15110471339388*x_14 + 0.673943333452982*x_15 + 1.55343852297263*x_16 + 2.30789832893929*x_17 + 10.7354443619012*x_18 + 13.5238349223986*x_19 - 8.75895744828441*x_2 + 19.8961415207069*x_20 - 2.03483184290076*x_21 + 3.74220589206829*x_22 + 0.99812567859038*x_23 + 15.0574482239131*x_24 + 16.2783195469295*x_25 + 6.65367666006265*x_26 - 5.57230194084101*x_27 - 4.78800028133134*x_28 + 0.0596014086533506*x_29 + 7.80174705461244*x_3 + 11.2442740977787*x_30 - 409.15340446142*x_31 + 8.20058400866507*x_32 + 23.4503803759101*x_33 + 11.6319133698394*x_34 + 23.0693275324695*x_35 + 1.99613637860073*x_36 + 1.26568380230185*x_37 + 6.82350024922783*x_38 - 35.4797092942537*x_39 - 72.7259720952229*x_4 + 29.7975956187138*x_40 - 2.86797392701254*x_41 + 32.2049385942656*x_42 - 1.22614509204231*x_43 - 3.05381882299926*x_44 + 9.14038052958659*x_45 - 3.1315659643813*x_46 - 9.41511074167147*x_47 + 9.83678900562001*x_48 + 28.5804786505512*x_49 - 3.02190586372576*x_5 - 0.40163611921492*x_50 - 7.77034950168083*x_51 + 8.3776254467285*x_52 + 6.42482149009609*x_53 - 0.692119396166069*x_54 - 13.3203341992072*x_55 - 2.60532611927439*x_56 + 23.340709724036*x_57 + 0.60854425484617*x_58 + 9.42584728142855*x_59 - 0.916434224118835*x_6 + 8.99253638783947*x_60 + 7.58507314091055*x_61 - 16.7230879929634*x_62 - 13.9214285760808*x_63 + 14.0720877285292*x_64 + 10.877759168655*x_65 - 4.76645537777671*x_66 - 4.27914161844421*x_67 - 3.35756556265699*x_68 - 1.86537865821319*x_69 + 2.37621295348013*x_7 - 9.32016043886652*x_70 + 0.410410314664438*x_71 + 0.300679240550257*x_72 - 6.49103276146858*x_73 + 10.4690250910109*x_74 - 2.67393364316697*x_75 - 20.2606659143845*x_76 + 11.6922849106815*x_77 + 6.7361834053599*x_78 - 5.27609945911243*x_79 + 85.8061600763172*x_8 - 1.64256046814118*x_80 + 18.5097744423663*x_81 + 7.289082228782*x_82 + 17.847328212527*x_83 - 24.4057275953489*x_84 + 4.82516100730683*x_85 + 22.1028762134031*x_86 - 4.32254417170267*x_87 + 13.6757181440613*x_88 + 2.00118188002628*x_89 - 101.019427950672*x_9 - 24.2783795364987*x_90 - 7.65384134235476*x_91 + 16.4735554032384*x_92 + 114.07895553234*x_93 + 2.72139918643332*x_94 + 4.52399073775009*x_95 - 2.74653451111418*x_96 - 6.7602319688975*x_97 - 8.03036984137905*x_98 - 0.128150176203604*x_99 + 0.0267082908610302*std::pow(-3.73047995567322*x_106 - 5.30263996124268, 2) + 0.000747650803673036*std::pow(-8.33975982666016*x_109 - 9.5576000213623, 2) - 0.000352381109495719*std::pow(-3.2992799282074*x_117 - 3.91872000694275, 2) - 0.0104103183193325*std::pow(-5.51624011993408*x_13 - 7.14991998672485, 2) - 1.35010738987302e-5*std::pow(-6.87463998794556*x_26 - 7.6625599861145, 2) - 1.66808423597758e-5*std::pow(-6.60712051391602*x_27 - 9.20576000213623, 2) - 0.00461055413221689*std::pow(-8.26775932312012*x_44 - 8.07015991210938, 2) + 3.99237108251181e-5*std::pow(-8.16024017333984*x_44 - 7.74696016311646, 2) - 0.119931166616846*std::pow(-6.06623983383179*x_69 - 8.49248027801514, 2) + 0.00111644889344388*std::pow(-5.278480052948*x_71 - 7.31360006332397, 2) - 0.0129174429361096*std::pow(-6.68567991256714*x_73 - 8.10919952392578, 2) - 1.44321719667211e-5*std::pow(-6.69040012359619*x_85 - 9.95376014709473, 2) - 0.00167242832486937*std::exp(0.459359854459763*x_1) + 3.00714293690193*std::exp(0.553199887275696*x_1) - 0.00268497501911592*std::exp(1.07583975791931*x_1) - 0.0174222450719737*std::exp(1.12799990177155*x_1) + 0.0760231551483894*std::exp(1.14143979549408*x_1) - 0.12577644836542*std::exp(1.17095983028412*x_1) + 0.491629340246792*std::exp(0.854959905147552*x_108) - 0.316332786357988*std::exp(1.12103986740112*x_108) + 3.99310310115651*std::exp(0.783599853515625*x_15) + 0.083565589701745*std::exp(2.65919995307922*x_17) + 0.000755033540209107*std::exp(3.37599992752075*x_17) - 0.0842039088363103*std::exp(3.38383984565735*x_17) - 0.00146305207895908*std::exp(3.54839992523193*x_17) - 0.0205336920519811*std::exp(3.8503999710083*x_17) - 8.01383107096202e-7*std::exp(4.05463981628418*x_17) - 0.552821327909244*std::exp(0.856879889965057*x_29) - 2.96704227969022*std::exp(0.877039849758148*x_29) - 1.16432215423643*std::exp(1.00639986991882*x_29) + 3.33219089434028*std::exp(1.10455989837646*x_29) + 0.000189605815452463*std::exp(1.58135986328125*x_29) - 0.000203038224531634*std::exp(2.08335995674133*x_29) + 0.00105186563723769*std::exp(1.54199981689453*x_38) - 0.0341869069758029*std::exp(1.65999984741211*x_38) - 0.39389837026732*std::exp(1.84159982204437*x_50) - 0.391631473165922*std::exp(1.84279990196228*x_50) + 0.00170899459535141*std::exp(1.86639988422394*x_50) - 0.000355199821735015*std::exp(1.92463982105255*x_50) + 0.589058276622151*std::exp(1.92519986629486*x_50) - 0.0377929661222684*std::exp(1.9385598897934*x_50) + 1.92212358743769*std::exp(1.95839989185333*x_50) - 1.28514010626871*std::exp(1.97631978988647*x_50) + 11.4773649179865*std::exp(0.794959902763367*x_66) - 0.00805299950475299*std::exp(0.697999835014343*x_67) - 8.7050002780126*std::exp(0.72519987821579*x_7) + 0.627882125988486*std::exp(1.3575998544693*x_71) + 1.33984145179867*std::exp(1.5887998342514*x_71) - 0.694399427300987*std::exp(1.62775981426239*x_71) - 0.000344186031711268*std::exp(1.83247983455658*x_71) + 0.000212682824218506*std::exp(1.8958398103714*x_71) - 0.0346888616553653*std::exp(1.97847986221313*x_71) + 0.0620372345785843*std::exp(1.99599981307983*x_71) - 0.00369075191687803*std::exp(1.21479988098145*x_77) - 0.35178326354582*std::exp(1.32791984081268*x_77) - 0.113989635854917*std::exp(0.814639866352081*x_78) + 0.241295431963222*std::exp(1.25415980815887*x_78) + 0.847058462343683*std::exp(1.2727198600769*x_78) + 0.00054687997564002*std::exp(1.48223996162415*x_78) + 0.570657349320857*std::exp(1.75423991680145*x_78) - 0.166984451642488*std::exp(0.863119900226593*x_87) - 0.00174103297093518*std::exp(0.901039838790894*x_87) + 13.8808642882007*std::sin(0.241679981350899*x_100 + 1.81343984603882) + 2.05733821818534*std::sin(0.609119892120361*x_100 - 0.991599798202515) + 0.251558961977642*std::sin(0.702159821987152*x_100 - 7.1541600227356) + 0.0482033300200337*std::sin(0.384559839963913*x_105 + 1.97951984405518) - 0.0109925233872304*std::sin(0.387279838323593*x_105 - 7.41224002838135) + 28.9927317724072*std::sin(0.404239863157272*x_105 + 5.20743989944458) - 41.0130233045208*std::sin(0.502319812774658*x_105 + 2.05711984634399) - 12.9653441607787*std::sin(0.348479837179184*x_112 + 1.95431983470917) - 24.6185975028487*std::sin(0.379999846220016*x_112 + 1.9871199131012) + 26.3247848607656*std::sin(0.4059998691082*x_112 + 1.9936797618866) + 26.8338796848398*std::sin(0.42663985490799*x_116 + 2.02367973327637) - 2.5740313099871*std::sin(0.56199985742569*x_118 + 8.39344024658203) - 54.1795227778787*std::sin(0.289359927177429*x_14 - 7.47560024261475) - 0.00575894307374753*std::sin(0.332639902830124*x_14 - 1.29095983505249) - 0.970582592932536*std::sin(0.419839859008789*x_14 - 1.15535986423492) - 5.90083191005373*std::sin(0.607599854469299*x_15 + 2.18927979469299) - 0.00732863102199625*std::sin(0.39727982878685*x_16 + 2.0079197883606) + 28.9029761728254*std::sin(0.128400042653084*x_26 + 1.70263993740082) + 1.08199799689188*std::sin(0.330239832401276*x_28 + 8.3089599609375) + 9.80038335165786*std::sin(0.333119839429855*x_28 - 4.27583980560303) - 0.811749383201298*std::sin(0.329359829425812*x_3 - 4.26152038574219) - 99.6935221644274*std::sin(0.312319844961166*x_33 - 1.17319989204407) + 6.05039124794391*std::sin(0.409919857978821*x_34 - 1.18663990497589) + 117.659136250418*std::sin(0.293199926614761*x_36 + 1.90127992630005) + 38.9634346798398*std::sin(0.347439825534821*x_36 - 1.21175980567932) - 0.0133991870267522*std::sin(0.353839844465256*x_36 + 1.97599983215332) + 34.6984464737378*std::sin(0.370239853858948*x_36 - 1.19343984127045) - 10.4238236804082*std::sin(0.375999838113785*x_36 + 1.98047983646393) - 0.0189592537972065*std::sin(0.388399839401245*x_41 + 2.0033597946167) - 0.0200670650209497*std::sin(0.307599931955338*x_43 - 7.47824001312256) + 32.3867521935602*std::sin(0.46823987364769*x_46 + 5.2469596862793) - 5.12646728340148*std::sin(0.413279861211777*x_51 - 1.19959986209869) - 0.011790320439003*std::sin(0.321119844913483*x_53 + 5.12696027755737) + 0.676161873439957*std::sin(0.498479843139648*x_54 + 8.28343963623047) - 0.0114199437284772*std::sin(0.249279975891113*x_55 - 7.55600023269653) + 4.24152091805539*std::sin(0.528079867362976*x_55 - 7.24743986129761) + 0.0181442296525438*std::sin(0.217199996113777*x_64 - 4.36175966262817) - 1.6523342232571*std::sin(0.518159866333008*x_73 + 2.1451997756958) - 0.0219788013465425*std::sin(0.694319844245911*x_73 + 8.65120029449463) - 102.666653245488*std::sin(0.187120005488396*x_75 - 7.62423992156982) + 7.27122634045394*std::sin(0.484159857034683*x_75 + 8.49135971069336) + 27.7730095695011*std::sin(0.517359852790833*x_79 - 1.05527985095978) - 17.9338857846065*std::sin(0.388479858636856*x_8 + 8.37639999389648) + 21.8012593442698*std::sin(0.508959829807281*x_84 + 8.29032039642334) + 2.33795638823767*std::sin(0.641439855098724*x_85 - 0.964639782905579) - 4.65976704332088*std::sin(0.419279843568802*x_86 + 2.0163197517395) + 34.7702874297371*std::sin(0.425759851932526*x_86 + 1.99495983123779) + 2.57981764786937*std::sin(0.656639814376831*x_87 + 5.4495997428894) - 0.060319974338625*std::sin(0.347679853439331*x_92 + 5.18296003341675) - 32.8017591678249*std::sin(0.357119828462601*x_92 + 2.00119972229004) + 0.0141644441533011*std::sin(0.361199855804443*x_92 + 2.00439977645874) - 0.0145455984690915*std::sin(0.362639844417572*x_92 + 1.99015974998474) + 0.865772245782196*std::sin(0.365199834108353*x_92 + 1.99327981472015) + 4.60066521654573*std::sin(0.380959838628769*x_92 + 1.98055982589722) + 27.1943658279518*std::sin(0.336159855127335*x_95 + 5.15320014953613) - 1.33042947264074*std::sin(0.31743985414505*x_97 + 5.14344024658203) - 46.4033173421607*std::sin(0.368239849805832*x_97 + 5.15952014923096) - 0.0430987097819109*std::sin(0.398559868335724*x_97 - 1.19631993770599) - 3.66631423650255*std::sin(0.469919860363007*x_98 + 2.05343985557556) + 4.5206758392898*std::sin(0.310239940881729*x_99 - 4.28975963592529) - 1.36340804576096*std::sin(0.340399831533432*x_99 - 7.43175983428955) - 1228.81122723192 - 0.16199165435381*std::exp(-2.46455979347229*x_86) + 6.52691615647269e-5*std::exp(-2.44327998161316*x_86) - 0.154542353784286*std::exp(-2.08607983589172*x_23) + 7.08204720030126e-5*std::exp(-2.06303977966309*x_23) + 0.00490043724851062*std::exp(-3.40519976615906*x_117) + 0.000372442025443279*std::exp(-4.41160011291504*x_111) + 0.00102984106931521*std::exp(-4.36687994003296*x_111) - 2.64721652318215e-6*std::exp(-4.15944004058838*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
