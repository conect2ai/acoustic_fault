
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.647112588538857*x_1 + 3.52980289871025*x_10 - 4.99999390369698*x_100 - 2.44526522646584*x_101 - 21.0951837010217*x_102 - 0.504451175749236*x_103 - 95.0388415761809*x_104 - 14.3237728994395*x_105 + 4.86877481204536*x_106 - 5.13502458581709*x_107 - 12.5663291136776*x_108 - 2.26738354588178*x_109 - 4.4384135714324*x_110 - 1.4109039026344*x_111 - 4.93325159938824*x_112 + 5.44115506240683*x_113 + 20.0862635002062*x_114 + 16.6923001131714*x_115 - 6.87287750869353*x_116 + 3.3850481217421*x_117 - 24.051010519649*x_118 - 14.5120561718786*x_119 + 9.54518133059166*x_12 + 7.84513499094815*x_120 - 5.57413148533828*x_13 - 4.91176103146869*x_14 + 6.20544168078976*x_15 - 2.98240960225313*x_16 + 3.71410851591712*x_17 + 57.1238972691666*x_18 + 1.98391262274062*x_19 + 0.997841937281113*x_2 - 0.321481506009282*x_20 - 4.71433851260677*x_21 - 0.00706638487769949*x_22 - 0.15986552488347*x_23 - 5.62216550783691*x_24 + 0.126484405032745*x_25 + 0.199203960631484*x_26 + 23.2747858295402*x_27 + 0.431997687092978*x_28 - 1.06070890652807*x_29 - 0.939898407951189*x_3 - 0.00701443001915036*x_30 - 3.02532329057662*x_31 - 3.30124662154877*x_32 + 34.1328530765996*x_33 - 37.2852699132894*x_34 - 30.2205939287832*x_35 + 75.8851358324969*x_36 - 334.698296308267*x_37 - 24.0213227169585*x_38 - 33.9849437238015*x_39 + 0.141205337263654*x_4 - 2969.2052563273*x_40 - 12.1612052167847*x_41 - 0.667094557912904*x_42 - 4.59916083195525*x_43 - 10.6696676960912*x_44 + 21.7578478282027*x_45 - 37.6229802662672*x_46 + 131.850590903898*x_47 - 95.3174390745163*x_48 + 22.0736719610393*x_5 + 0.139373517648222*x_50 - 11.292981957838*x_52 - 0.562618451510232*x_53 - 1.24956067248542*x_54 - 8.34119298884353*x_56 - 0.717430987483126*x_58 - 13.4533173320858*x_59 + 10.7123857489208*x_6 - 0.0924217245030481*x_60 + 9.56312847183164*x_61 + 4.7328208695408*x_62 + 2.04477106042987*x_63 + 8.66453790804863*x_64 - 4.8683061726025*x_65 + 1.5052436023189*x_66 + 2.39873795592722*x_67 + 4.12049369157429*x_68 + 17.0624635534079*x_69 + 18.6840639510164*x_7 - 4.20383061068608*x_70 - 4.10311663150411*x_71 + 4.21657572547983*x_72 + 17.3721028848378*x_73 - 4.94159046437703*x_74 - 5.05905000548849*x_75 + 4.20409074116623*x_76 + 1.84540974291302*x_77 - 3.08505991717491*x_78 + 10.6561089027587*x_79 - 0.787251942947199*x_8 - 6.98747449241801*x_80 - 5.09935700981779*x_81 - 4.55779048210859*x_82 + 17.1144256050942*x_83 + 4.57234292529148*x_84 + 0.295294405869223*x_85 + 291.889557835789*x_86 + 14.1401140949243*x_87 + 33.848984395444*x_88 - 3.06362790072757*x_89 + 1.37653883481469*x_9 + 0.877715317443076*x_90 + 6.71328117407932*x_91 - 10.4483450215532*x_92 - 8.38959773464283*x_93 + 7.37827910293977*x_94 + 1.8737615049717*x_95 - 0.855026247619347*x_96 - 3.70446743816846*x_97 - 23.8031748324902*x_98 - 42.8394587802432*x_99 + 0.000889750753833588*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) - 0.00165167126612719*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) - 0.000392634807825599*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) - 0.000726510376438304*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) - 0.0321748888616259*std::exp(1.10463988780975*x_1) + 0.0197939849414828*std::exp(1.27999985218048*x_1) + 0.0161617613991843*std::exp(1.32983994483948*x_1) - 0.621697986763758*std::exp(1.33063983917236*x_1) - 0.133045337933984*std::exp(1.79583990573883*x_1) - 0.039648082006436*std::exp(1.89927983283997*x_1) + 0.0226836960746642*std::exp(0.68343985080719*x_10) + 0.387116153657382*std::exp(0.712479829788208*x_10) + 0.0543775875795509*std::exp(0.782719850540161*x_10) - 0.0289852770335396*std::exp(0.806639909744263*x_10) - 3.03151062262862*std::exp(0.807519853115082*x_10) - 0.0225662681574032*std::exp(0.83463990688324*x_10) - 0.00251328358132502*std::exp(0.860239923000336*x_10) + 0.00976192489470501*std::exp(0.939199805259705*x_10) - 0.0580924378288401*std::exp(1.05287981033325*x_10) - 0.0141966653491101*std::exp(0.837359845638275*x_11) - 0.00953501345131947*std::exp(0.884399890899658*x_11) - 0.0291317578589743*std::exp(0.896239876747131*x_11) - 4.1281521831621*std::exp(0.927199840545654*x_11) - 0.0066777051098388*std::exp(0.931759834289551*x_11) - 1.07209015841826*std::exp(0.933759808540344*x_11) - 0.0287674460936682*std::exp(0.951039850711823*x_11) - 0.144820736492947*std::exp(0.958639860153198*x_11) + 0.00771383991059676*std::exp(0.975439846515656*x_11) + 0.243378730050059*std::exp(1.01423990726471*x_11) + 0.0362819467222379*std::exp(0.427279859781265*x_12) - 0.0606665302022246*std::exp(0.519439876079559*x_12) + 0.0110104735704088*std::exp(0.88239985704422*x_12) - 0.044892445474863*std::exp(0.905999839305878*x_12) + 0.000236966795420409*std::exp(0.997519791126251*x_12) + 0.0462243216169612*std::exp(1.23287987709045*x_12) - 0.0269755260973469*std::exp(0.619519829750061*x_13) + 0.00181235120804861*std::exp(1.07167983055115*x_13) - 0.000134285695058256*std::exp(1.30135977268219*x_13) + 39.1777135028737*std::exp(0.264079838991165*x_14) + 0.110798812580723*std::exp(0.453439861536026*x_14) + 0.576475466396318*std::exp(0.619439840316772*x_14) + 0.00407852408747362*std::exp(0.899199843406677*x_14) - 0.185589803710251*std::exp(0.827359914779663*x_15) - 1.45196873417413*std::exp(0.876239895820618*x_15) + 0.0146762589760946*std::exp(0.927279829978943*x_15) - 0.00523834088142386*std::exp(0.928959846496582*x_15) - 1.90210818784716*std::exp(0.932479858398438*x_15) - 0.00470568086141912*std::exp(1.01999986171722*x_15) + 0.000228894680743786*std::exp(1.1373598575592*x_15) - 0.0808529276008988*std::exp(0.38351982831955*x_16) + 0.155079163304651*std::exp(0.547599852085114*x_16) - 7.61279453966214*std::exp(0.600879848003387*x_16) + 0.07902909022236*std::exp(0.678639829158783*x_16) - 0.00164954990921574*std::exp(0.935519814491272*x_16) + 0.10423744102934*std::exp(0.628639817237854*x_17) - 0.100365291817345*std::exp(0.667199850082397*x_17) + 6.30765684721712*std::exp(0.677199840545654*x_17) - 1.38261958347669*std::exp(0.695839881896973*x_17) + 0.10824447763625*std::exp(0.7151198387146*x_17) - 0.0669775287566347*std::exp(0.693999886512756*x_19) - 15.4904158199479*std::exp(0.714319825172424*x_19) - 0.0504774901445616*std::exp(0.71535986661911*x_19) - 0.0944305673309481*std::exp(0.717759847640991*x_19) + 0.136872751854891*std::exp(0.728159844875336*x_19) - 14.1131556011813*std::exp(0.751519858837128*x_19) + 10.4095593340841*std::exp(0.766079843044281*x_19) + 0.0472744676871645*std::exp(0.825519859790802*x_19) - 0.00432271779013514*std::exp(0.880719900131226*x_19) - 0.0675950854356871*std::exp(0.594239830970764*x_2) + 0.0658875927607688*std::exp(0.739439845085144*x_2) - 0.115454486106679*std::exp(0.749919831752777*x_2) + 4.25845008369273*std::exp(0.779519855976105*x_2) + 5.6565838158669*std::exp(0.884239912033081*x_2) + 0.0347353721848145*std::exp(0.947919845581055*x_2) + 0.000909101663096581*std::exp(1.33703982830048*x_2) + 4.41537805570215*std::exp(0.395839840173721*x_20) + 8.19605488451441*std::exp(0.457199841737747*x_20) - 0.0296236414166126*std::exp(0.519039869308472*x_20) - 0.00679564543574767*std::exp(0.855199873447418*x_20) + 1.11557795815276*std::exp(0.866639912128448*x_20) + 8.4668512567935e-5*std::exp(1.17951989173889*x_20) - 1.87587110550654e-5*std::exp(1.35351979732513*x_20) - 0.0198552529363744*std::exp(1.0551198720932*x_21) + 0.166981913280455*std::exp(0.538959860801697*x_22) - 0.822881280390911*std::exp(0.831119894981384*x_22) - 0.0914988581039586*std::exp(1.05791985988617*x_22) - 0.000398694934989468*std::exp(1.28927981853485*x_22) - 0.000273030599717749*std::exp(1.33255982398987*x_22) + 2.80930405657849*std::exp(0.619919836521149*x_23) - 0.12655184013038*std::exp(0.693919837474823*x_23) - 3.93516160137057*std::exp(0.69735985994339*x_23) + 0.0257408159298135*std::exp(0.720719873905182*x_23) - 0.0116630974312178*std::exp(0.722399830818176*x_23) - 0.0538294604355905*std::exp(0.726079881191254*x_23) - 3.46625128317024*std::exp(0.748559832572937*x_23) + 0.049488699393177*std::exp(0.811039865016937*x_23) - 0.224830669142048*std::exp(0.972799837589264*x_23) + 18.2528280837625*std::exp(0.312959849834442*x_24) - 2.83879314130493*std::exp(0.446319848299026*x_24) - 0.197241644651612*std::exp(0.608799874782562*x_24) - 0.0558148007779014*std::exp(0.626559853553772*x_24) - 0.0569655955370962*std::exp(0.689279854297638*x_24) - 0.0603293326387067*std::exp(0.733279824256897*x_24) - 0.14670846753964*std::exp(0.44327986240387*x_25) - 0.0314682603844882*std::exp(0.543599843978882*x_25) - 13.374550417523*std::exp(0.614479839801788*x_25) - 0.0155537835495705*std::exp(0.783199846744537*x_25) - 0.14103563469333*std::exp(0.797279894351959*x_25) - 0.00763034160925556*std::exp(0.822319865226746*x_25) + 1.14409332962194*std::exp(0.882079899311066*x_25) + 0.00720404412877231*std::exp(0.994239807128906*x_25) + 0.00357571583422161*std::exp(0.997759819030762*x_25) + 0.250033445268114*std::exp(0.439359873533249*x_26) + 0.0484420025029271*std::exp(0.595519840717316*x_26) + 1.13333515440981*std::exp(0.669679820537567*x_26) + 1.16313988602183*std::exp(0.748879849910736*x_26) - 0.00955304720061557*std::exp(0.816239893436432*x_26) + 0.00457249211750204*std::exp(0.825599908828735*x_26) - 0.00813914408129025*std::exp(0.871999859809875*x_26) + 0.000574779384121354*std::exp(1.1651998758316*x_26) + 0.101710746901151*std::exp(1.19079983234406*x_27) - 0.00150485539905297*std::exp(1.22255980968475*x_27) - 0.000579283233847884*std::exp(1.22495996952057*x_27) - 0.0500194654637708*std::exp(1.26967978477478*x_27) + 0.00035629942431685*std::exp(1.42463982105255*x_27) - 10.1472106974698*std::exp(0.559919834136963*x_28) - 4.4835551266833*std::exp(0.587999820709229*x_28) + 0.0520173998160228*std::exp(0.67631983757019*x_28) + 0.0188357209996322*std::exp(0.690719842910767*x_28) - 0.0246598948058221*std::exp(0.717759847640991*x_28) - 0.00982703852946174*std::exp(0.782079875469208*x_28) - 0.0102934306857853*std::exp(0.911999821662903*x_28) - 0.141263446626517*std::exp(1.1043199300766*x_29) + 0.0022707751886391*std::exp(1.13167989253998*x_29) - 0.00222887454639422*std::exp(1.13919985294342*x_29) + 0.239267919079281*std::exp(1.14943981170654*x_29) - 0.178149312977062*std::exp(1.15047979354858*x_29) - 8.45661310880535e-5*std::exp(1.30935978889465*x_29) + 0.00014130062209327*std::exp(1.35751986503601*x_29) + 5.4321703272766*std::exp(0.411679863929749*x_3) + 11.6477616981944*std::exp(0.555839836597443*x_3) - 0.0246184295114243*std::exp(0.65151983499527*x_3) - 0.0749213869734437*std::exp(0.657999873161316*x_3) - 0.0181380952198384*std::exp(0.949759840965271*x_3) - 0.657623244505294*std::exp(0.983039796352386*x_3) - 0.00833134547990875*std::exp(0.6422398686409*x_30) - 3.38639655634321*std::exp(0.799999833106995*x_30) - 4.66494391085824*std::exp(0.843599855899811*x_30) + 1.79523911269983*std::exp(0.844959855079651*x_30) + 0.0265513207792129*std::exp(0.928399801254272*x_30) + 0.0151649295922987*std::exp(0.962799787521362*x_30) + 0.00661061048619065*std::exp(1.03063988685608*x_30) + 0.00157984385752814*std::exp(1.09807980060577*x_30) - 0.00478457490872489*std::exp(1.10879981517792*x_30) + 0.00949348877077757*std::exp(0.816479861736298*x_32) + 2.90738305596819*std::exp(0.830799877643585*x_32) + 0.00669067892135203*std::exp(0.873279869556427*x_32) + 5.23764027239133*std::exp(0.337679862976074*x_33) + 0.0669011293739094*std::exp(0.393599838018417*x_33) - 14.030562515582*std::exp(0.417359858751297*x_33) + 0.183197354381061*std::exp(0.425519853830338*x_33) - 16.2567730769892*std::exp(0.358959853649139*x_34) + 0.219409833772966*std::exp(0.365919858217239*x_34) - 6.79619238787334*std::exp(0.429999858140945*x_36) + 0.198624753038326*std::exp(0.381999850273132*x_4) + 1.43329858407363*std::exp(0.475839853286743*x_4) - 5.08116124788684*std::exp(0.60919988155365*x_4) + 0.0294025688588206*std::exp(0.61959981918335*x_4) - 0.0522502298457846*std::exp(0.755119860172272*x_4) - 0.000564059970663599*std::exp(0.894799828529358*x_4) - 0.158529481936327*std::exp(1.16215980052948*x_4) - 0.126766828822666*std::exp(1.17103981971741*x_4) - 0.00279749145909377*std::exp(1.17639982700348*x_4) + 3.31781157659118*std::exp(0.683199822902679*x_41) - 0.0220524694047766*std::exp(0.767599880695343*x_41) - 0.0741459272350028*std::exp(0.7704798579216*x_41) - 0.00529181711769637*std::exp(0.784719884395599*x_41) - 0.0771410907250757*std::exp(0.803359866142273*x_41) + 0.75786586100592*std::exp(0.804319858551025*x_41) - 1.12350222912018*std::exp(0.808079898357391*x_41) + 0.0143143348186663*std::exp(0.808239877223969*x_41) - 0.655008840305656*std::exp(0.633279860019684*x_42) - 0.0136527699658451*std::exp(0.719839870929718*x_42) - 0.0160479031173104*std::exp(0.733519852161407*x_42) + 0.230638581975582*std::exp(0.816239893436432*x_42) + 0.00133305405497838*std::exp(0.75087982416153*x_43) - 0.00335317470109232*std::exp(0.821199893951416*x_43) - 0.000514716450916436*std::exp(0.844239890575409*x_44) + 0.0213460237505641*std::exp(0.897199809551239*x_44) + 0.00019458011291393*std::exp(0.97439980506897*x_44) - 3.04408056925577*std::exp(0.521199882030487*x_45) - 0.0145550231760062*std::exp(0.675519824028015*x_46) - 0.0142628909418807*std::exp(0.691119849681854*x_46) + 0.0504296415727062*std::exp(0.763439834117889*x_46) - 0.546420159131058*std::exp(0.766159892082214*x_46) - 2.92406926684208*std::exp(0.79447990655899*x_46) + 0.0300261014177167*std::exp(0.795199871063232*x_46) + 0.176112367882624*std::exp(0.484159857034683*x_47) + 1.26555110758511*std::exp(0.519519865512848*x_47) - 0.0366488529875904*std::exp(0.598719835281372*x_48) - 0.0153809500667143*std::exp(0.655999839305878*x_49) - 0.0791849488067312*std::exp(0.690879821777344*x_49) + 17.3065619465461*std::exp(0.702399849891663*x_49) + 5.06344079711432*std::exp(0.70719987154007*x_49) - 5.74480138087383*std::exp(0.710559844970703*x_49) - 0.0433082076685432*std::exp(0.714879810810089*x_49) + 0.0744707462117356*std::exp(0.715039849281311*x_49) + 15.2823008886058*std::exp(0.717039823532104*x_49) - 0.109857914242595*std::exp(0.718959867954254*x_49) - 0.0402174239422895*std::exp(0.719279825687408*x_49) + 0.00128606070851498*std::exp(1.92919981479645*x_5) + 0.0472354982348947*std::exp(0.479759842157364*x_50) + 9.93480107012634*std::exp(0.541039824485779*x_50) + 12.5795080208816*std::exp(0.549919843673706*x_50) + 0.0745959005420669*std::exp(0.552239894866943*x_50) - 2.20496681030418*std::exp(0.554079830646515*x_50) - 0.0167370404827313*std::exp(0.58679986000061*x_50) + 1.94852982064763*std::exp(0.61983984708786*x_50) + 0.0102412268066103*std::exp(0.667119860649109*x_50) + 0.203855741750437*std::exp(0.485599845647812*x_51) + 84.6199048674773*std::exp(0.495279848575592*x_51) + 28.336486392825*std::exp(0.495439857244492*x_51) + 0.298247464364974*std::exp(0.495919853448868*x_51) - 55.2986768043058*std::exp(0.495999842882156*x_51) - 0.358146904245985*std::exp(0.496239870786667*x_51) + 1.03600017941345*std::exp(0.497919857501984*x_51) + 0.240100702453886*std::exp(0.498719841241837*x_51) + 0.477192521926194*std::exp(0.504399836063385*x_51) - 5.06618947097984*std::exp(0.503519833087921*x_52) - 0.0544857469399198*std::exp(0.579199850559235*x_52) + 0.0673949759444131*std::exp(0.628959834575653*x_52) + 0.0160604599335612*std::exp(0.709119856357574*x_52) - 1.13309303274863*std::exp(0.72111988067627*x_52) - 0.00848542443234671*std::exp(0.745919823646545*x_52) - 0.000970582214664576*std::exp(0.87967985868454*x_52) - 0.139820648861408*std::exp(0.467919856309891*x_54) + 0.298662161292226*std::exp(0.488959848880768*x_54) - 24.1906385539978*std::exp(0.515999853610992*x_54) + 0.178427742175614*std::exp(0.532239854335785*x_54) + 10.66301029025*std::exp(0.533839821815491*x_54) + 0.0828698440679907*std::exp(0.533999860286713*x_54) + 5.32540472960613*std::exp(0.535999834537506*x_54) - 0.0996547445094538*std::exp(0.537439823150635*x_54) - 0.0383791102727884*std::exp(0.61959981918335*x_55) - 12.5424237791938*std::exp(0.635919868946075*x_55) - 12.2961923656624*std::exp(0.65015983581543*x_55) - 0.871809135940863*std::exp(0.651679813861847*x_55) + 0.40392340963962*std::exp(0.652799844741821*x_55) + 1.9604721577638*std::exp(0.655679821968079*x_55) + 105.004926408558*std::exp(0.656159818172455*x_55) + 0.0722596757735309*std::exp(0.656319856643677*x_55) - 13.7243687924324*std::exp(0.657199859619141*x_55) - 0.376632368630595*std::exp(0.659119844436646*x_55) + 28.6467765480152*std::exp(0.402799874544144*x_56) - 23.4016102718211*std::exp(0.458079844713211*x_56) + 13.0508522608393*std::exp(0.521679878234863*x_56) + 0.147774817132847*std::exp(0.548719882965088*x_56) - 0.140356374431973*std::exp(0.656559824943542*x_56) + 0.0052584250884802*std::exp(0.671279847621918*x_56) + 0.0126431613833015*std::exp(0.737839818000793*x_56) + 0.00701652369596497*std::exp(0.840079843997955*x_56) - 10.1514433170666*std::exp(0.612879812717438*x_57) - 0.236213621436061*std::exp(0.620399832725525*x_57) - 0.265703438848743*std::exp(0.626639842987061*x_57) + 0.375861397907401*std::exp(0.628719866275787*x_57) + 0.0358744792235413*std::exp(0.631839871406555*x_57) - 61.0300726023149*std::exp(0.63351982831955*x_57) + 0.216158104479514*std::exp(0.639759838581085*x_57) + 5.63603512069838*std::exp(0.640399813652039*x_57) - 12.9051560512757*std::exp(0.644639849662781*x_57) + 0.0553668061020439*std::exp(0.655679821968079*x_57) + 0.231688507282567*std::exp(0.401999861001968*x_58) - 1.4507868761717*std::exp(0.521199882030487*x_58) - 7.74547241304079*std::exp(0.560399830341339*x_58) + 0.0596017839102301*std::exp(0.562319815158844*x_58) + 0.0342652238954655*std::exp(0.610559821128845*x_58) - 0.0236903855820137*std::exp(0.612719833850861*x_58) - 3.21062173643591*std::exp(0.66023987531662*x_58) - 0.0323996156010787*std::exp(0.671919822692871*x_58) + 0.610674454079488*std::exp(0.683759808540344*x_58) - 11.3189317212097*std::exp(0.516079843044281*x_59) - 0.757668444823971*std::exp(0.642879843711853*x_59) - 0.00604118325835235*std::exp(0.651439845561981*x_59) + 0.0323112889378511*std::exp(0.696319878101349*x_59) + 0.504783233477741*std::exp(0.784239888191223*x_59) - 0.00144957148902363*std::exp(0.914319813251495*x_59) + 0.000136002837810106*std::exp(1.11175990104675*x_59) - 0.0171732413398716*std::exp(0.776479840278625*x_60) + 0.0460835162941412*std::exp(0.789359867572784*x_60) - 6.6460219642628*std::exp(0.82287985086441*x_60) - 0.0169728078447294*std::exp(0.827119886875153*x_60) + 0.357350708673892*std::exp(0.83383983373642*x_60) - 0.0205474700647049*std::exp(0.855439901351929*x_60) - 1.66236819055573*std::exp(0.855599880218506*x_60) - 0.00468350229159115*std::exp(0.87527984380722*x_60) - 0.194379857937874*std::exp(0.97055983543396*x_60) + 0.799638533075524*std::exp(1.06751978397369*x_61) + 0.0148954050085031*std::exp(1.41151988506317*x_61) + 0.00597665818085202*std::exp(1.48039984703064*x_61) + 0.299056261523887*std::exp(1.54959976673126*x_61) - 0.153132128422566*std::exp(0.620399832725525*x_66) - 0.623113923818168*std::exp(0.898959815502167*x_66) - 6.52382859497807*std::exp(0.940879821777344*x_66) - 4.19274764237028e-5*std::exp(1.60559988021851*x_7) + 0.000831126243233753*std::exp(1.86407995223999*x_7) + 0.0802205446995197*std::exp(0.557119846343994*x_8) - 0.555712962516747*std::exp(0.561599850654602*x_8) + 0.814285575288342*std::exp(0.82727986574173*x_8) + 0.273916736736911*std::exp(0.832399845123291*x_8) + 0.000715268478216719*std::exp(0.850879848003387*x_8) - 2.09488517706305e-6*std::exp(1.72775983810425*x_9) - 0.105649229742666*std::log(4.17511987686157 - 0.624479830265045*x_5) - 0.241183817826306*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 13.8752198019312*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 52.6300666366149*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 9.1345750545095*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 39.6843120023612*std::sin(0.24415996670723*x_108 - 1.1950398683548) + 1.32572474836845*std::sin(0.285119920969009*x_113 - 7.42575979232788) - 0.715229576359299*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 29.0581845806069*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 57.7278642148643*std::sin(0.221279993653297*x_116 + 5.17928028106689) + 0.369025467772068*std::sin(0.239519983530045*x_117 - 7.43887996673584) + 1.26623184099871*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 54.149941111155*std::sin(0.258879989385605*x_120 + 8.34255981445313) - 0.809992656744971*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 83.1895006674554*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 1.34407585753571*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.587719945869551*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.793544125526114*std::sin(0.245119974017143*x_20 - 4.37967967987061) - 0.499629935670079*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 22.2902676274753*std::sin(0.416879862546921*x_22 + 2.00263977050781) + 2.27988375373554*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.0751487758753754*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.689284879861024*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 41.070287430917*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.64505488287306*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 18.9084250974712*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 51.7246849536652*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.175609628265061*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.124631983818739*std::sin(0.57287985086441*x_64 + 5.36984014511108) - 0.239913276374861*std::sin(0.576239883899689*x_65 + 2.18959999084473) - 0.498614221398005*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 54.2388717281025*std::sin(0.219119995832443*x_9 - 7.589439868927) - 0.750777489179343*std::sin(0.327599853277206*x_9 - 4.33911991119385) + 0.356219619082038*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.0816871550005689*std::sin(0.474319845438004*x_9 - 1.12655985355377) + 0.47168810236247*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 43.2950831135166*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.131414918235053*std::sin(0.381119847297668*x_91 - 1.19447994232178) + 0.494418600745976*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 29.9996164748705*std::sin(0.390719830989838*x_91 - 4.39071989059448) - 0.741832444053491*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 38.3622861028201*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 47.5780910529387*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.204961446357892*std::sin(0.279199957847595*x_95 - 1.19967985153198) + 1.16853902768722*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 56.6256878516038*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.303345680060225*std::sin(0.315439909696579*x_97 + 1.92727982997894) - 0.543600592044091*std::sin(0.236799985170364*x_98 + 5.18336009979248) - 1.0898595335057*std::sin(0.26079997420311*x_98 + 1.96743977069855) - 0.510763716193678*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.101476753976698*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 22.0478521007211);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.59382582967761*x_1 + 5.6254731629476*x_10 + 0.163963068760682*x_100 - 5.74578929309818*x_101 - 29.4989942584664*x_102 - 0.573870825936124*x_103 - 186.879410317787*x_104 - 18.9335503987531*x_105 + 4.91805238562426*x_106 - 10.1684578407429*x_107 - 18.2031129243613*x_108 - 5.07626506174136*x_109 - 6.00526000562046*x_110 - 7.24945801530919*x_111 - 15.7760712901572*x_112 + 8.62816950357842*x_113 + 33.5890981312757*x_114 + 20.5372780207736*x_115 - 16.8822875245152*x_116 + 4.84242598089594*x_117 - 30.1569890521308*x_118 - 27.4978432536879*x_119 + 8.59417671148345*x_12 + 10.5837590938157*x_120 - 6.4819195195606*x_13 - 9.04746834616538*x_14 + 10.4641375604181*x_15 - 4.3952407238234*x_16 + 9.14335443747829*x_17 + 65.729829804843*x_18 + 6.34626398231366*x_19 + 1.90719950355976*x_2 - 0.74672182434613*x_20 - 8.53677171628662*x_21 - 0.0797275807626377*x_22 - 0.106068638123973*x_23 - 9.78630265947691*x_24 + 0.220156371479488*x_25 + 2.50888950925535*x_26 + 41.9174337148054*x_27 - 0.262586702226727*x_28 - 3.05373915484475*x_29 - 3.2513515372971*x_3 - 0.0224381981730118*x_30 - 5.37194377479483*x_31 - 1.94144789067961*x_32 + 47.27176032261*x_33 - 72.9279739085852*x_34 - 3.20170420722622*x_35 + 107.921060503316*x_36 - 590.486390495974*x_37 - 121.582760930308*x_38 - 102.706623039949*x_39 + 2.48904585657693*x_4 - 4261.52049873952*x_40 - 11.5514765050875*x_41 - 8.95394781684159*x_42 - 14.3823068028949*x_43 - 28.5550716860268*x_44 + 67.7376163732302*x_45 - 47.7696383906839*x_46 + 176.957610156669*x_47 - 142.689405399322*x_48 + 31.9413408256873*x_5 + 0.155209813827125*x_50 - 19.6715771839663*x_52 - 2.06095519667825*x_53 - 2.98103536336075*x_54 - 26.6823306771942*x_56 - 0.476005867091989*x_58 - 23.3930981198135*x_59 + 13.860336895423*x_6 - 1.62913042020841*x_60 + 15.9342363280338*x_61 + 5.54755135053246*x_62 + 1.96624217256912*x_63 + 15.2995639590536*x_64 - 7.93302089996333*x_65 + 1.40172616604672*x_66 + 1.48513253876403*x_67 + 6.77854803225125*x_68 + 27.845947195448*x_69 + 29.4025230817128*x_7 - 4.73368576511331*x_70 - 5.01920611328424*x_71 + 3.69004369587169*x_72 + 27.4068765992888*x_73 - 11.2576217228859*x_74 - 3.07017681967539*x_75 + 6.08975786384305*x_76 - 0.782200385555099*x_77 - 6.22757837795723*x_78 + 9.26305115604034*x_79 - 0.928195082641321*x_8 - 11.1799030758065*x_80 - 4.91876852099675*x_81 - 10.6084381792917*x_82 + 17.5538724674959*x_83 + 8.66268423584036*x_84 - 2.7854785355566*x_85 + 408.992483340099*x_86 + 16.2584846846378*x_87 + 46.4662520750127*x_88 - 1.54353847161575*x_89 + 0.132750743792789*x_9 - 2.38922999383242*x_90 + 6.32072739694149*x_91 - 16.9569038045399*x_92 - 5.59179722985602*x_93 + 11.1685678971801*x_94 + 1.81919681429412*x_95 - 7.2329060124288*x_96 - 6.01030604543127*x_97 - 40.8303940766089*x_98 - 72.1878106463197*x_99 + 0.0156837586321585*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) - 0.00109586179981149*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) - 0.00692102763609727*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.000672983876189627*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) - 0.0213476085343008*std::exp(1.10463988780975*x_1) - 0.0183356399897056*std::exp(1.27999985218048*x_1) - 0.00295630679052196*std::exp(1.32983994483948*x_1) - 0.590527793861246*std::exp(1.33063983917236*x_1) - 0.212035345734571*std::exp(1.79583990573883*x_1) - 0.0690107042713955*std::exp(1.89927983283997*x_1) + 0.00773818499724804*std::exp(0.68343985080719*x_10) + 1.23833140369551*std::exp(0.712479829788208*x_10) - 0.00994673955660193*std::exp(0.782719850540161*x_10) - 0.0192313437361472*std::exp(0.806639909744263*x_10) - 2.87951918481614*std::exp(0.807519853115082*x_10) + 0.0209036720028093*std::exp(0.83463990688324*x_10) - 0.0158818771791616*std::exp(0.860239923000336*x_10) + 0.172074789680311*std::exp(0.939199805259705*x_10) - 0.101114602385047*std::exp(1.05287981033325*x_10) - 0.250246568218828*std::exp(0.837359845638275*x_11) - 0.00325271938905798*std::exp(0.884399890899658*x_11) - 0.01932853180516*std::exp(0.896239876747131*x_11) - 3.9211782140973*std::exp(0.927199840545654*x_11) - 0.0421975829473278*std::exp(0.931759834289551*x_11) - 1.70859806836406*std::exp(0.933759808540344*x_11) + 0.00526213660331465*std::exp(0.951039850711823*x_11) - 0.463261644370054*std::exp(0.958639860153198*x_11) - 0.00714551374859889*std::exp(0.975439846515656*x_11) + 0.423620430433583*std::exp(1.01423990726471*x_11) + 0.639546853593162*std::exp(0.427279859781265*x_12) - 0.0206954295411445*std::exp(0.519439876079559*x_12) + 0.00730530198780846*std::exp(0.88239985704422*x_12) - 0.143604766928463*std::exp(0.905999839305878*x_12) + 0.00149743449898412*std::exp(0.997519791126251*x_12) + 0.0736680455519731*std::exp(1.23287987709045*x_12) + 0.0249880727158322*std::exp(0.619519829750061*x_13) - 0.000331514990899147*std::exp(1.07167983055115*x_13) - 8.90967630747325e-5*std::exp(1.30135977268219*x_13) + 62.4378137307879*std::exp(0.264079838991165*x_14) - 0.0202673009410157*std::exp(0.453439861536026*x_14) + 1.84406583593613*std::exp(0.619439840316772*x_14) + 0.00270604619619822*std::exp(0.899199843406677*x_14) - 0.593676290614042*std::exp(0.827359914779663*x_15) - 1.37917109529449*std::exp(0.876239895820618*x_15) + 0.00973750158756113*std::exp(0.927279829978943*x_15) + 0.00485240000076254*std::exp(0.928959846496582*x_15) - 3.03140398226394*std::exp(0.932479858398438*x_15) + 0.000860762384806934*std::exp(1.01999986171722*x_15) + 0.00144642539884801*std::exp(1.1373598575592*x_15) + 0.0748959937570183*std::exp(0.38351982831955*x_16) + 0.102892951217091*std::exp(0.547599852085114*x_16) - 7.23111037889514*std::exp(0.600879848003387*x_16) - 0.0144559884472077*std::exp(0.678639829158783*x_16) - 0.000562717923820275*std::exp(0.935519814491272*x_16) + 0.0355589582786591*std::exp(0.628639817237854*x_17) + 0.0929707617574212*std::exp(0.667199850082397*x_17) + 10.0525596848673*std::exp(0.677199840545654*x_17) - 4.42281013956068*std::exp(0.695839881896973*x_17) + 0.071818763524449*std::exp(0.7151198387146*x_17) - 0.0228483271187988*std::exp(0.693999886512756*x_19) - 24.68719103547*std::exp(0.714319825172424*x_19) + 0.00923333436233033*std::exp(0.71535986661911*x_19) - 0.0626534187490942*std::exp(0.717759847640991*x_19) + 2.41267477904597*std::exp(0.728159844875336*x_19) - 13.4055615733448*std::exp(0.751519858837128*x_19) + 18.1186827822695*std::exp(0.766079843044281*x_19) - 0.0437914660832254*std::exp(0.825519859790802*x_19) - 0.0273160074466841*std::exp(0.880719900131226*x_19) - 1.19150784658029*std::exp(0.594239830970764*x_2) - 0.0610332474345759*std::exp(0.739439845085144*x_2) - 0.0766025077362052*std::exp(0.749919831752777*x_2) + 7.41217795434627*std::exp(0.779519855976105*x_2) + 9.01493974684817*std::exp(0.884239912033081*x_2) - 0.00635378868212083*std::exp(0.947919845581055*x_2) + 0.00574477192464667*std::exp(1.33703982830048*x_2) + 7.68532382471887*std::exp(0.395839840173721*x_20) + 7.78512768637477*std::exp(0.457199841737747*x_20) - 0.52217999229778*std::exp(0.519039869308472*x_20) + 0.00629496832375689*std::exp(0.855199873447418*x_20) + 1.77790489861552*std::exp(0.866639912128448*x_20) + 0.000535035094144573*std::exp(1.17951989173889*x_20) - 6.39923828886721e-6*std::exp(1.35351979732513*x_20) - 0.063514226950062*std::exp(1.0551198720932*x_21) + 0.110790266668837*std::exp(0.538959860801697*x_22) - 0.781624321559232*std::exp(0.831119894981384*x_22) - 0.145822411470126*std::exp(1.05791985988617*x_22) + 0.000369320620142815*std::exp(1.28927981853485*x_22) + 4.99427132989725e-5*std::exp(1.33255982398987*x_22) + 8.98657780855437*std::exp(0.619919836521149*x_23) + 0.0231488422016534*std::exp(0.693919837474823*x_23) - 6.27149634571967*std::exp(0.69735985994339*x_23) + 0.00878107319853759*std::exp(0.720719873905182*x_23) - 0.073701146304207*std::exp(0.722399830818176*x_23) + 0.0498635120873821*std::exp(0.726079881191254*x_23) - 6.03329165315931*std::exp(0.748559832572937*x_23) + 0.872344095195009*std::exp(0.811039865016937*x_23) - 0.213558290146519*std::exp(0.972799837589264*x_23) + 17.3376824913682*std::exp(0.312959849834442*x_24) - 9.08090934015795*std::exp(0.446319848299026*x_24) - 0.130867193816672*std::exp(0.608799874782562*x_24) + 0.0517025801619142*std::exp(0.626559853553772*x_24) - 0.019432914075974*std::exp(0.689279854297638*x_24) - 1.06343342499898*std::exp(0.733279824256897*x_24) + 0.0268358892389289*std::exp(0.44327986240387*x_25) - 0.198853424333768*std::exp(0.543599843978882*x_25) - 21.3151205886754*std::exp(0.614479839801788*x_25) - 0.274168676966276*std::exp(0.783199846744537*x_25) - 0.451153623610996*std::exp(0.797279894351959*x_25) - 0.00260297064333212*std::exp(0.822319865226746*x_25) + 1.08673169979195*std::exp(0.882079899311066*x_25) + 0.00477978695081925*std::exp(0.994239807128906*x_25) - 0.00331227079517349*std::exp(0.997759819030762*x_25) - 0.0457360775132488*std::exp(0.439359873533249*x_26) + 0.853893825479608*std::exp(0.595519840717316*x_26) + 1.97266180918048*std::exp(0.669679820537567*x_26) + 1.85370469721144*std::exp(0.748879849910736*x_26) - 0.00633831907937579*std::exp(0.816239893436432*x_26) + 0.0288943749732237*std::exp(0.825599908828735*x_26) - 0.0027765405784389*std::exp(0.871999859809875*x_26) - 0.00053243184189087*std::exp(1.1651998758316*x_26) + 0.0966112553977757*std::exp(1.19079983234406*x_27) + 0.00139398342047708*std::exp(1.22255980968475*x_27) - 0.0102111050540629*std::exp(1.22495996952057*x_27) - 0.0870629388421166*std::exp(1.26967978477478*x_27) + 0.000236399903789084*std::exp(1.42463982105255*x_27) - 16.1716852457253*std::exp(0.559919834136963*x_28) - 7.80399154949825*std::exp(0.587999820709229*x_28) - 0.00951501439126338*std::exp(0.67631983757019*x_28) + 0.0124972490220791*std::exp(0.690719842910767*x_28) + 0.0228430482634132*std::exp(0.717759847640991*x_28) - 0.00335233913669799*std::exp(0.782079875469208*x_28) - 0.181443715194541*std::exp(0.911999821662903*x_28) - 0.225132606750739*std::exp(1.1043199300766*x_29) + 0.00150662897407195*std::exp(1.13167989253998*x_29) + 0.00206465961178211*std::exp(1.13919985294342*x_29) + 0.227271696875143*std::exp(1.14943981170654*x_29) - 0.310083336490693*std::exp(1.15047979354858*x_29) - 0.000534388127721452*std::exp(1.30935978889465*x_29) + 0.00249072545534384*std::exp(1.35751986503601*x_29) + 8.65729029907605*std::exp(0.411679863929749*x_3) + 11.0637756040699*std::exp(0.555839836597443*x_3) - 0.155568148675908*std::exp(0.65151983499527*x_3) - 0.0255582490059218*std::exp(0.657999873161316*x_3) + 0.00331781745449158*std::exp(0.949759840965271*x_3) - 1.14464662480226*std::exp(0.983039796352386*x_3) - 0.0526472247828536*std::exp(0.6422398686409*x_30) - 5.89429802070974*std::exp(0.799999833106995*x_30) - 7.43455584638381*std::exp(0.843599855899811*x_30) + 1.70523086007499*std::exp(0.844959855079651*x_30) + 0.468023774829053*std::exp(0.928399801254272*x_30) - 0.0140476356982007*std::exp(0.962799787521362*x_30) - 0.00120921180477317*std::exp(1.03063988685608*x_30) + 0.000538938804156047*std::exp(1.09807980060577*x_30) - 0.00317450147516486*std::exp(1.10879981517792*x_30) - 0.0017365474359874*std::exp(0.816479861736298*x_32) + 4.63351802496782*std::exp(0.830799877643585*x_32) + 0.00228241954398415*std::exp(0.873279869556427*x_32) + 16.75449182186*std::exp(0.337679862976074*x_33) - 0.0619721105543504*std::exp(0.393599838018417*x_33) - 24.4213326729646*std::exp(0.417359858751297*x_33) + 0.0624948868359427*std::exp(0.425519853830338*x_33) - 28.2962328175464*std::exp(0.358959853649139*x_34) - 0.203244558089518*std::exp(0.365919858217239*x_34) - 11.8293243787909*std::exp(0.429999858140945*x_36) + 0.131784867737072*std::exp(0.381999850273132*x_4) + 4.58492530151962*std::exp(0.475839853286743*x_4) - 4.82640607795321*std::exp(0.60919988155365*x_4) + 0.0100302224326661*std::exp(0.61959981918335*x_4) + 0.0484006331551704*std::exp(0.755119860172272*x_4) - 0.00356439330695738*std::exp(0.894799828529358*x_4) - 0.275933428366837*std::exp(1.16215980052948*x_4) - 0.202029239013444*std::exp(1.17103981971741*x_4) + 0.000511716686855895*std::exp(1.17639982700348*x_4) + 5.28762101437739*std::exp(0.683199822902679*x_41) - 0.388721904305647*std::exp(0.767599880695343*x_41) - 0.0491948312807817*std::exp(0.7704798579216*x_41) - 0.0334399150745774*std::exp(0.784719884395599*x_41) + 0.00598511682945333*std::exp(0.803359866142273*x_41) + 2.42430879364177*std::exp(0.804319858551025*x_41) - 1.95554680474784*std::exp(0.808079898357391*x_41) + 0.00488310946217914*std::exp(0.808239877223969*x_41) - 2.09528331221889*std::exp(0.633279860019684*x_42) + 0.0126468861978051*std::exp(0.719839870929718*x_42) - 0.282878590391433*std::exp(0.733519852161407*x_42) + 0.401445168815661*std::exp(0.816239893436432*x_42) + 0.00842380101141956*std::exp(0.75087982416153*x_43) - 0.0011438826406304*std::exp(0.821199893951416*x_43) + 0.000476794115418567*std::exp(0.844239890575409*x_44) + 0.0371544866200902*std::exp(0.897199809551239*x_44) + 0.00122958566147048*std::exp(0.97439980506897*x_44) - 2.89145890958399*std::exp(0.521199882030487*x_45) + 0.0134826648492478*std::exp(0.675519824028015*x_46) - 0.251413935830277*std::exp(0.691119849681854*x_46) + 0.0334593928653225*std::exp(0.763439834117889*x_46) - 1.74792303620365*std::exp(0.766159892082214*x_46) - 4.66011096348477*std::exp(0.79447990655899*x_46) - 0.0054923696323457*std::exp(0.795199871063232*x_46) + 0.116848201209825*std::exp(0.484159857034683*x_47) + 4.04832416497741*std::exp(0.519519865512848*x_47) - 0.012502177926448*std::exp(0.598719835281372*x_48) + 0.00281348090742149*std::exp(0.655999839305878*x_49) - 0.0525381547145249*std::exp(0.690879821777344*x_49) + 27.5815966406392*std::exp(0.702399849891663*x_49) + 8.81332961802925*std::exp(0.70719987154007*x_49) - 18.3768305474167*std::exp(0.710559844970703*x_49) - 0.273672115694484*std::exp(0.714879810810089*x_49) + 0.0254045200205783*std::exp(0.715039849281311*x_49) + 14.5160891960576*std::exp(0.717039823532104*x_49) - 1.93648052939495*std::exp(0.718959867954254*x_49) + 0.0372543582759715*std::exp(0.719279825687408*x_49) + 0.00122158123259224*std::exp(1.92919981479645*x_5) + 0.0161136449093519*std::exp(0.479759842157364*x_50) + 17.2923274960523*std::exp(0.541039824485779*x_50) + 20.0480556011811*std::exp(0.549919843673706*x_50) + 1.31491217513382*std::exp(0.552239894866943*x_50) - 7.05338596570842*std::exp(0.554079830646515*x_50) - 0.105764277164957*std::exp(0.58679986000061*x_50) + 1.85083600197847*std::exp(0.61983984708786*x_50) - 0.00187332355699705*std::exp(0.667119860649109*x_50) + 0.0695421697250658*std::exp(0.485599845647812*x_51) + 47.6791230086481*std::exp(0.495279848575592*x_51) + 90.6445278480482*std::exp(0.495439857244492*x_51) + 0.197883204600743*std::exp(0.495919853448868*x_51) - 88.1299129826202*std::exp(0.495999842882156*x_51) - 2.26319273622633*std::exp(0.496239870786667*x_51) - 0.189504985857329*std::exp(0.497919857501984*x_51) - 0.222411002861968*std::exp(0.498719841241837*x_51) + 8.41153806581796*std::exp(0.504399836063385*x_51) - 8.81811390795382*std::exp(0.503519833087921*x_52) - 0.0185869528557675*std::exp(0.579199850559235*x_52) - 0.0123278781384304*std::exp(0.628959834575653*x_52) + 0.0106559004140461*std::exp(0.709119856357574*x_52) - 1.07628292694289*std::exp(0.72111988067627*x_52) - 0.149573740865004*std::exp(0.745919823646545*x_52) + 0.000899073436759302*std::exp(0.87967985868454*x_52) + 0.129519199303673*std::exp(0.467919856309891*x_54) - 0.0546312344114135*std::exp(0.488959848880768*x_54) - 42.1057695329415*std::exp(0.515999853610992*x_54) + 0.118384421093279*std::exp(0.532239854335785*x_54) + 10.1283968690313*std::exp(0.533839821815491*x_54) + 0.0282697397276208*std::exp(0.533999860286713*x_54) + 17.0352382657131*std::exp(0.535999834537506*x_54) - 0.629735706857823*std::exp(0.537439823150635*x_54) - 0.0130924278981293*std::exp(0.61959981918335*x_55) - 11.9135818382738*std::exp(0.635919868946075*x_55) - 21.4025206786338*std::exp(0.65015983581543*x_55) + 0.159471186646223*std::exp(0.651679813861847*x_55) + 7.12001336932967*std::exp(0.652799844741821*x_55) + 1.30074706229219*std::exp(0.655679821968079*x_55) + 167.347133094731*std::exp(0.656159818172455*x_55) + 0.456621490773525*std::exp(0.656319856643677*x_55) - 43.9023706735046*std::exp(0.657199859619141*x_55) + 0.348883539120412*std::exp(0.659119844436646*x_55) + 45.6545810913972*std::exp(0.402799874544144*x_56) - 40.7324017762307*std::exp(0.458079844713211*x_56) + 12.3965191422295*std::exp(0.521679878234863*x_56) + 2.60484697971541*std::exp(0.548719882965088*x_56) - 0.0931245776653191*std::exp(0.656559824943542*x_56) + 0.0332289050195583*std::exp(0.671279847621918*x_56) + 0.00431301501360368*std::exp(0.737839818000793*x_56) - 0.00128346138368844*std::exp(0.840079843997955*x_56) - 17.6694109079021*std::exp(0.612879812717438*x_57) + 0.0432081575650816*std::exp(0.620399832725525*x_57) - 0.176290678832009*std::exp(0.626639842987061*x_57) - 0.348169370565426*std::exp(0.628719866275787*x_57) + 0.226697089468228*std::exp(0.631839871406555*x_57) - 97.264081142466*std::exp(0.63351982831955*x_57) + 0.0737389266551312*std::exp(0.639759838581085*x_57) + 18.0289022205688*std::exp(0.640399813652039*x_57) - 12.2581277318674*std::exp(0.644639849662781*x_57) + 0.975958288764081*std::exp(0.655679821968079*x_57) - 0.0423804244133883*std::exp(0.401999861001968*x_58) - 4.64086794585891*std::exp(0.521199882030487*x_58) - 12.3440170582422*std::exp(0.560399830341339*x_58) - 0.0552105528903337*std::exp(0.562319815158844*x_58) + 0.0116890404721737*std::exp(0.610559821128845*x_58) - 0.149703677267553*std::exp(0.612719833850861*x_58) - 3.04965016986764*std::exp(0.66023987531662*x_58) - 0.571112470175077*std::exp(0.671919822692871*x_58) + 1.06292844505655*std::exp(0.683759808540344*x_58) - 18.039065766014*std::exp(0.516079843044281*x_59) - 2.42367728639157*std::exp(0.642879843711853*x_59) - 0.0381752903806327*std::exp(0.651439845561981*x_59) - 0.0299307169990912*std::exp(0.696319878101349*x_59) + 0.479474818304388*std::exp(0.784239888191223*x_59) - 0.0255517955516758*std::exp(0.914319813251495*x_59) + 4.63952221746077e-5*std::exp(1.11175990104675*x_59) + 0.0159079827328911*std::exp(0.776479840278625*x_60) + 0.0305757968570551*std::exp(0.789359867572784*x_60) - 10.5918146914043*std::exp(0.82287985086441*x_60) - 0.00579000558784391*std::exp(0.827119886875153*x_60) + 1.14311583358875*std::exp(0.83383983373642*x_60) + 0.00375853991282159*std::exp(0.855439901351929*x_60) - 2.89348674092213*std::exp(0.855599880218506*x_60) - 0.0295958676195853*std::exp(0.87527984380722*x_60) - 0.184634197187345*std::exp(0.97055983543396*x_60) + 0.759546900387454*std::exp(1.06751978397369*x_61) - 0.0137979686528098*std::exp(1.41151988506317*x_61) - 0.00109324935124789*std::exp(1.48039984703064*x_61) + 0.520531692332152*std::exp(1.54959976673126*x_61) + 0.0280109042524016*std::exp(0.620399832725525*x_66) - 1.99325585526172*std::exp(0.898959815502167*x_66) - 10.3970742089109*std::exp(0.940879821777344*x_66) - 2.78183199753593e-5*std::exp(1.60559988021851*x_7) + 0.00144664267428346*std::exp(1.86407995223999*x_7) + 0.0532252587419562*std::exp(0.557119846343994*x_8) - 1.7776494378331*std::exp(0.561599850654602*x_8) + 1.41733012506292*std::exp(0.82727986574173*x_8) + 0.260183320021569*std::exp(0.832399845123291*x_8) + 0.0045199062316616*std::exp(0.850879848003387*x_8) - 7.14637023646798e-7*std::exp(1.72775983810425*x_9) - 0.667615904275094*std::log(4.17511987686157 - 0.624479830265045*x_5) - 1.52408259886822*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 13.1795552075479*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 91.6069020401462*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 29.2202509312597*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 69.0737655194564*std::sin(0.24415996670723*x_108 - 1.1950398683548) + 0.879600643660902*std::sin(0.285119920969009*x_113 - 7.42575979232788) - 12.6074498884867*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 50.5781284055648*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 54.8335510568082*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 0.341837085564361*std::sin(0.239519983530045*x_117 - 7.43887996673584) + 0.840127895128383*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 94.2523669046282*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 0.750315502021817*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 132.579726651246*std::sin(0.269279956817627*x_120 + 5.15327978134155) - 0.245858139250217*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.200491386092534*std::sin(0.280559957027435*x_120 - 7.44615983963013) - 0.145154963554286*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 0.462819116797815*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 38.7980197155629*std::sin(0.416879862546921*x_22 + 2.00263977050781) + 1.51267238521858*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.474878218075108*std::sin(0.343199849128723*x_31 - 4.24496030807495) + 0.126083879139566*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 71.4861682281665*std::sin(0.32151985168457*x_37 + 5.08903980255127) + 0.117993335218599*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 32.9116483472667*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 90.0310117470258*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.0599064537957189*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.0425162347524402*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.222237385618151*std::sin(0.576239883899689*x_65 + 2.18959999084473) - 0.330823868695157*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 94.4071578603632*std::sin(0.219119995832443*x_9 - 7.589439868927) - 0.498130825075862*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 0.32997472272852*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.516195375831883*std::sin(0.474319845438004*x_9 - 1.12655985355377) + 8.31451090683482*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 68.9996963376242*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.830433782493553*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 0.457991733058936*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 52.2167670170402*std::sin(0.390719830989838*x_91 - 4.39071989059448) - 13.0763822878595*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 36.4389087017917*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 82.8135285565361*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.0699193634053474*std::sin(0.279199957847595*x_95 - 1.19967985153198) + 0.775310019792205*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 98.5616050193054*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.103481592360243*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 0.503550183723874*std::sin(0.236799985170364*x_98 + 5.18336009979248) - 0.723107227462842*std::sin(0.26079997420311*x_98 + 1.96743977069855) - 9.00330211391338*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.641249302376073*std::sin(0.275039941072464*x_98 + 1.95935988426208) - 97.2459740394863);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.45851163579295*x_1 + 7.69574811152607*x_10 - 14.5791295639587*x_100 - 18.6292433292604*x_101 - 26.0253078441596*x_102 + 2.63343490846964*x_103 - 159.053010320978*x_104 - 28.9671763415821*x_105 - 11.9435425524745*x_106 - 1.51715084522931*x_107 - 20.4368086476191*x_108 + 6.9638047567213*x_109 - 24.0702125794619*x_110 - 16.8580826750839*x_111 + 3.07611206189817*x_112 + 14.3400515022997*x_113 + 39.4582253619732*x_114 + 22.2966437557408*x_115 + 3.00093068603638*x_116 - 24.0906987041193*x_117 - 40.8808354694265*x_118 - 13.2248789038623*x_119 + 10.4037755315405*x_12 + 6.50494602765454*x_120 + 3.77615317648908*x_13 + 2.87791475238538*x_14 - 0.981566057757202*x_15 - 11.6385226217683*x_16 - 3.2561661377866*x_17 + 112.124893203875*x_18 + 0.111127040160641*x_19 + 0.60948634646495*x_2 + 0.0526320438064403*x_20 + 6.10398014750293*x_21 + 0.0852373698968599*x_22 + 0.0927005954481016*x_23 - 6.85386447917343*x_24 - 0.026163640119284*x_25 - 0.798587360638605*x_26 + 44.8769013526519*x_27 + 0.702687570444977*x_28 - 0.136514882597562*x_29 + 0.411634609495898*x_3 - 0.000392906843530899*x_30 - 4.24534010279493*x_31 + 0.156393029514341*x_32 + 62.9897722613912*x_33 - 77.8856296008573*x_34 - 137.901776372071*x_35 + 113.420734674033*x_36 - 537.352093413143*x_37 + 17.4900283926296*x_38 - 51.5770555010464*x_39 - 1.86743286830848*x_4 - 4612.13657627564*x_40 - 12.5139812745868*x_41 - 16.4293249323546*x_42 - 5.18507713489185*x_43 - 38.8489127429744*x_44 + 20.0168095471446*x_45 - 19.6842098557102*x_46 + 107.021621617908*x_47 - 174.012185045676*x_48 + 51.760856523543*x_5 - 0.0458743211099041*x_50 - 22.3908476357901*x_52 + 0.38453389674232*x_53 - 1.77349355298505*x_54 - 0.467224250520864*x_56 + 0.416013895310345*x_58 + 2.72742882501373*x_59 + 9.74855964566829*x_6 + 1.22227225561939*x_60 + 20.0656673275225*x_61 + 15.6175400233373*x_62 + 9.50692222216426*x_63 + 22.0398303716822*x_64 - 3.59100752623074*x_65 + 1.89235750451343*x_66 + 9.15809321074001*x_67 + 6.9161327322269*x_68 + 24.9916499332093*x_69 + 42.4325492976244*x_7 - 8.2664766499161*x_70 - 16.1653858284915*x_71 + 1.2235045194807*x_72 + 27.8386491587744*x_73 - 11.0268507099179*x_74 - 15.2743002145142*x_75 + 2.74498681988531*x_76 + 0.82668337335189*x_77 - 7.02372665441448*x_78 - 14.2958156979289*x_79 - 2.85455069630451*x_8 - 10.0982823583505*x_80 - 8.60861608158753*x_81 - 14.3323497201677*x_82 + 29.8478865896177*x_83 + 6.58898637942703*x_84 - 3.14351464890888*x_85 + 408.031647939308*x_86 + 79.9855867739737*x_87 + 51.571503273435*x_88 - 2.81016729498798*x_89 + 4.15593475655942*x_9 - 0.190882694022002*x_90 + 7.16609550183789*x_91 - 23.1752457487311*x_92 - 30.4138044134185*x_93 + 13.5817111809988*x_94 - 1.49858280686922*x_95 - 19.55247567943*x_96 - 9.88704440092921*x_97 - 32.6124856082761*x_98 - 52.5534072262857*x_99 - 0.0117669050937409*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) + 0.000957748144674196*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.0051925738756352*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.00106460210260579*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) + 0.0186571267202439*std::exp(1.10463988780975*x_1) - 0.0290053916242166*std::exp(1.27999985218048*x_1) + 0.00529266766847894*std::exp(1.32983994483948*x_1) - 0.639732397087775*std::exp(1.33063983917236*x_1) - 0.290068153246437*std::exp(1.79583990573883*x_1) + 0.00820131263429434*std::exp(1.89927983283997*x_1) + 0.0353423766080026*std::exp(0.68343985080719*x_10) + 0.0216839551607314*std::exp(0.712479829788208*x_10) + 0.0178076196377145*std::exp(0.782719850540161*x_10) + 0.0168075790086442*std::exp(0.806639909744263*x_10) - 3.11944963422924*std::exp(0.807519853115082*x_10) + 0.0330677954609748*std::exp(0.83463990688324*x_10) + 0.00763264159880812*std::exp(0.860239923000336*x_10) - 0.129100923234176*std::exp(0.939199805259705*x_10) + 0.0120165773528537*std::exp(1.05287981033325*x_10) + 0.187750123380982*std::exp(0.837359845638275*x_11) - 0.0148560461773817*std::exp(0.884399890899658*x_11) + 0.0168925182708737*std::exp(0.896239876747131*x_11) - 4.24790291733879*std::exp(0.927199840545654*x_11) + 0.0202796573314095*std::exp(0.931759834289551*x_11) - 2.33739278049992*std::exp(0.933759808540344*x_11) - 0.00942078824727312*std::exp(0.951039850711823*x_11) - 0.0081120003047883*std::exp(0.958639860153198*x_11) - 0.011303582790167*std::exp(0.975439846515656*x_11) - 0.05034354633735*std::exp(1.01423990726471*x_11) - 0.479826762559379*std::exp(0.427279859781265*x_12) - 0.0945216048941234*std::exp(0.519439876079559*x_12) - 0.00638460016245827*std::exp(0.88239985704422*x_12) - 0.00251460902764099*std::exp(0.905999839305878*x_12) - 0.00071964924042058*std::exp(0.997519791126251*x_12) + 0.100779206657766*std::exp(1.23287987709045*x_12) + 0.0395289630176009*std::exp(0.619519829750061*x_13) + 0.000593510348646264*std::exp(1.07167983055115*x_13) + 7.78677197672007e-5*std::exp(1.30135977268219*x_13) + 85.4160482484206*std::exp(0.264079838991165*x_14) + 0.0362844914342966*std::exp(0.453439861536026*x_14) + 0.0322907428339011*std::exp(0.619439840316772*x_14) - 0.00236499778006436*std::exp(0.899199843406677*x_14) - 0.0103956420932611*std::exp(0.827359914779663*x_15) - 1.49408789892492*std::exp(0.876239895820618*x_15) - 0.00851026478051608*std::exp(0.927279829978943*x_15) + 0.00767607579656271*std::exp(0.928959846496582*x_15) - 4.14701497919094*std::exp(0.932479858398438*x_15) - 0.00154102045799723*std::exp(1.01999986171722*x_15) - 0.000695134872551809*std::exp(1.1373598575592*x_15) + 0.11847896398636*std::exp(0.38351982831955*x_16) - 0.0899251467157382*std::exp(0.547599852085114*x_16) - 7.83362887299395*std::exp(0.600879848003387*x_16) + 0.0258805151467154*std::exp(0.678639829158783*x_16) - 0.00257008443127196*std::exp(0.935519814491272*x_16) + 0.162407346906227*std::exp(0.628639817237854*x_17) + 0.147071678757314*std::exp(0.667199850082397*x_17) + 13.7520818196003*std::exp(0.677199840545654*x_17) - 0.0774461638172612*std::exp(0.695839881896973*x_17) - 0.062767301068591*std::exp(0.7151198387146*x_17) - 0.10435446841638*std::exp(0.693999886512756*x_19) - 33.7725198017928*std::exp(0.714319825172424*x_19) - 0.0165304123403015*std::exp(0.71535986661911*x_19) + 0.0547570830325161*std::exp(0.717759847640991*x_19) - 1.81013466305742*std::exp(0.728159844875336*x_19) - 14.5225544483664*std::exp(0.751519858837128*x_19) - 2.15324540718519*std::exp(0.766079843044281*x_19) - 0.0692742999020317*std::exp(0.825519859790802*x_19) + 0.0131277488422134*std::exp(0.880719900131226*x_19) + 0.893941310752516*std::exp(0.594239830970764*x_2) - 0.0965493020658948*std::exp(0.739439845085144*x_2) + 0.0669481404264311*std::exp(0.749919831752777*x_2) - 0.880871878448789*std::exp(0.779519855976105*x_2) + 12.3325991472647*std::exp(0.884239912033081*x_2) + 0.0113751698700631*std::exp(0.947919845581055*x_2) - 0.00276086917642552*std::exp(1.33703982830048*x_2) - 0.913332852457726*std::exp(0.395839840173721*x_20) + 8.43380861698977*std::exp(0.457199841737747*x_20) + 0.391771038775076*std::exp(0.519039869308472*x_20) + 0.00995809372321444*std::exp(0.855199873447418*x_20) + 2.4322057664611*std::exp(0.866639912128448*x_20) - 0.00025713151350574*std::exp(1.17951989173889*x_20) - 2.9227046095425e-5*std::exp(1.35351979732513*x_20) - 0.00111217372437104*std::exp(1.0551198720932*x_21) - 0.0968271477008235*std::exp(0.538959860801697*x_22) - 0.846751678839155*std::exp(0.831119894981384*x_22) - 0.199487672446986*std::exp(1.05791985988617*x_22) + 0.000584233178015887*std::exp(1.28927981853485*x_22) - 8.94122980744212e-5*std::exp(1.33255982398987*x_22) + 0.157360581882675*std::exp(0.619919836521149*x_23) - 0.0414433065865198*std::exp(0.693919837474823*x_23) - 8.57951940414659*std::exp(0.69735985994339*x_23) + 0.0401055281200336*std::exp(0.720719873905182*x_23) + 0.0354198958231101*std::exp(0.722399830818176*x_23) + 0.0788797498568578*std::exp(0.726079881191254*x_23) + 0.717003421191683*std::exp(0.748559832572937*x_23) - 0.6544853448712*std::exp(0.811039865016937*x_23) - 0.231352627757094*std::exp(0.972799837589264*x_23) + 18.7823118495856*std::exp(0.312959849834442*x_24) - 0.159012385830658*std::exp(0.446319848299026*x_24) + 0.11437373955201*std::exp(0.608799874782562*x_24) + 0.0817889959892725*std::exp(0.626559853553772*x_24) - 0.0887553564703195*std::exp(0.689279854297638*x_24) + 0.797852127092615*std::exp(0.733279824256897*x_24) - 0.0480442164477401*std::exp(0.44327986240387*x_25) + 0.0955665946483214*std::exp(0.543599843978882*x_25) - 29.1594669934038*std::exp(0.614479839801788*x_25) + 0.205697937414296*std::exp(0.783199846744537*x_25) - 0.00789998131016287*std::exp(0.797279894351959*x_25) - 0.0118884685244583*std::exp(0.822319865226746*x_25) + 1.17728154800878*std::exp(0.882079899311066*x_25) - 0.00417738083841643*std::exp(0.994239807128906*x_25) - 0.00523972501823782*std::exp(0.997759819030762*x_25) + 0.0818811699494422*std::exp(0.439359873533249*x_26) - 0.640642835700606*std::exp(0.595519840717316*x_26) - 0.23443343159052*std::exp(0.669679820537567*x_26) + 2.53590124949012*std::exp(0.748879849910736*x_26) + 0.0055394880446325*std::exp(0.816239893436432*x_26) - 0.0138862935347187*std::exp(0.825599908828735*x_26) - 0.0126812092015747*std::exp(0.871999859809875*x_26) - 0.000842260978941463*std::exp(1.1651998758316*x_26) + 0.104661204169842*std::exp(1.19079983234406*x_27) + 0.00220516082619988*std::exp(1.22255980968475*x_27) + 0.0076609891092694*std::exp(1.22495996952057*x_27) + 0.010346661258471*std::exp(1.26967978477478*x_27) - 0.000206605950945731*std::exp(1.42463982105255*x_27) - 22.1231552591346*std::exp(0.559919834136963*x_28) + 0.927435463361227*std::exp(0.587999820709229*x_28) + 0.0170347032977792*std::exp(0.67631983757019*x_28) - 0.0109221957243939*std::exp(0.690719842910767*x_28) + 0.0361357204408014*std::exp(0.717759847640991*x_28) - 0.015311036416041*std::exp(0.782079875469208*x_28) + 0.136130058273925*std::exp(0.911999821662903*x_28) - 0.307985441057036*std::exp(1.1043199300766*x_29) - 0.0013167455101346*std::exp(1.13167989253998*x_29) + 0.00326611237153793*std::exp(1.13919985294342*x_29) + 0.246208677971732*std::exp(1.14943981170654*x_29) + 0.0368506655901404*std::exp(1.15047979354858*x_29) + 0.000256820589124545*std::exp(1.30935978889465*x_29) - 0.00186869300497275*std::exp(1.35751986503601*x_29) + 11.8433282926086*std::exp(0.411679863929749*x_3) + 11.9856436252617*std::exp(0.555839836597443*x_3) + 0.0747642051149511*std::exp(0.65151983499527*x_3) - 0.116731412098526*std::exp(0.657999873161316*x_3) - 0.00593987918561129*std::exp(0.949759840965271*x_3) + 0.13603114074702*std::exp(0.983039796352386*x_3) + 0.0253016311237223*std::exp(0.6422398686409*x_30) + 0.700485255699382*std::exp(0.799999833106995*x_30) - 10.1706056464172*std::exp(0.843599855899811*x_30) + 1.84731597232855*std::exp(0.844959855079651*x_30) - 0.351139766250654*std::exp(0.928399801254272*x_30) - 0.0222221408715159*std::exp(0.962799787521362*x_30) + 0.00216484846700774*std::exp(1.03063988685608*x_30) + 0.00246147878241777*std::exp(1.09807980060577*x_30) + 0.00277441270297737*std::exp(1.10879981517792*x_30) + 0.00310893595302664*std::exp(0.816479861736298*x_32) + 6.33873570408859*std::exp(0.830799877643585*x_32) + 0.0104244252534206*std::exp(0.873279869556427*x_32) + 0.293381600694174*std::exp(0.337679862976074*x_33) - 0.0980345020635978*std::exp(0.393599838018417*x_33) + 2.90225967567914*std::exp(0.417359858751297*x_33) + 0.285430992851151*std::exp(0.425519853830338*x_33) + 3.36275733104882*std::exp(0.358959853649139*x_34) - 0.32151525696333*std::exp(0.365919858217239*x_34) + 1.40581071454384*std::exp(0.429999858140945*x_36) - 0.115175757192218*std::exp(0.381999850273132*x_4) + 0.0802849014058435*std::exp(0.475839853286743*x_4) - 5.22855716812119*std::exp(0.60919988155365*x_4) + 0.0458107293639778*std::exp(0.61959981918335*x_4) + 0.0765656023086164*std::exp(0.755119860172272*x_4) + 0.00171300510149344*std::exp(0.894799828529358*x_4) + 0.03279225065418*std::exp(1.16215980052948*x_4) - 0.276379619913803*std::exp(1.17103981971741*x_4) - 0.000916124934200478*std::exp(1.17639982700348*x_4) + 7.23356031700251*std::exp(0.683199822902679*x_41) + 0.291642702690156*std::exp(0.767599880695343*x_41) + 0.0429947082696318*std::exp(0.7704798579216*x_41) + 0.0160708261359508*std::exp(0.784719884395599*x_41) - 0.0448582986109462*std::exp(0.803359866142273*x_41) + 0.0424511588902745*std::exp(0.804319858551025*x_41) + 0.232399464489743*std::exp(0.808079898357391*x_41) + 0.0223024770914383*std::exp(0.808239877223969*x_41) - 0.0366897175147102*std::exp(0.633279860019684*x_42) + 0.0200062766939245*std::exp(0.719839870929718*x_42) + 0.212232641693561*std::exp(0.733519852161407*x_42) - 0.0477082123671208*std::exp(0.816239893436432*x_42) - 0.00404837874607195*std::exp(0.75087982416153*x_43) - 0.00522442033821799*std::exp(0.821199893951416*x_43) + 0.000754246922910898*std::exp(0.844239890575409*x_44) - 0.00441548255093476*std::exp(0.897199809551239*x_44) - 0.000590924269415176*std::exp(0.97439980506897*x_44) - 3.13238421381332*std::exp(0.521199882030487*x_45) + 0.0213284060065563*std::exp(0.675519824028015*x_46) + 0.188625953226084*std::exp(0.691119849681854*x_46) - 0.0292424386397994*std::exp(0.763439834117889*x_46) - 0.0306072224513889*std::exp(0.766159892082214*x_46) - 6.37511532060151*std::exp(0.79447990655899*x_46) + 0.00983297378663437*std::exp(0.795199871063232*x_46) - 0.102121588631411*std::exp(0.484159857034683*x_47) + 0.0708886808551452*std::exp(0.519519865512848*x_47) - 0.0571008163870365*std::exp(0.598719835281372*x_48) - 0.00503696689475298*std::exp(0.655999839305878*x_49) + 0.0459166659619833*std::exp(0.690879821777344*x_49) + 37.7321185457142*std::exp(0.702399849891663*x_49) - 1.04738637736963*std::exp(0.70719987154007*x_49) - 0.321789763545819*std::exp(0.710559844970703*x_49) + 0.131523569356416*std::exp(0.714879810810089*x_49) + 0.116029290386845*std::exp(0.715039849281311*x_49) + 15.7256146692325*std::exp(0.717039823532104*x_49) + 1.45286491202087*std::exp(0.718959867954254*x_49) + 0.0589331625244666*std::exp(0.719279825687408*x_49) + 0.00132336716118614*std::exp(1.92919981479645*x_5) + 0.0735953595211888*std::exp(0.479759842157364*x_50) - 2.05504038057634*std::exp(0.541039824485779*x_50) + 27.4260993810728*std::exp(0.549919843673706*x_50) - 0.986526707933315*std::exp(0.552239894866943*x_50) - 0.123509187084591*std::exp(0.554079830646515*x_50) + 0.050829055813145*std::exp(0.58679986000061*x_50) + 2.00505338524379*std::exp(0.61983984708786*x_50) + 0.00335380585482729*std::exp(0.667119860649109*x_50) + 0.317617833307808*std::exp(0.485599845647812*x_51) + 138.180522988281*std::exp(0.495279848575592*x_51) + 1.58724221283339*std::exp(0.495439857244492*x_51) - 0.172943588417032*std::exp(0.495919853448868*x_51) - 120.563300501035*std::exp(0.495999842882156*x_51) + 1.08766355700739*std::exp(0.496239870786667*x_51) + 0.339270239096382*std::exp(0.497919857501984*x_51) - 0.351834909671441*std::exp(0.498719841241837*x_51) - 6.31084502345765*std::exp(0.504399836063385*x_51) + 1.04795494796775*std::exp(0.503519833087921*x_52) - 0.0848916235599616*std::exp(0.579199850559235*x_52) + 0.0220705652922777*std::exp(0.628959834575653*x_52) - 0.0093129159654449*std::exp(0.709119856357574*x_52) - 1.16596215107126*std::exp(0.72111988067627*x_52) + 0.112219274381428*std::exp(0.745919823646545*x_52) + 0.00142225617141126*std::exp(0.87967985868454*x_52) + 0.204888135934562*std::exp(0.467919856309891*x_54) + 0.0978061441340908*std::exp(0.488959848880768*x_54) + 5.00389879067403*std::exp(0.515999853610992*x_54) - 0.103464195649415*std::exp(0.532239854335785*x_54) + 10.972326239405*std::exp(0.533839821815491*x_54) + 0.12911552107104*std::exp(0.533999860286713*x_54) + 0.298297646012799*std::exp(0.535999834537506*x_54) + 0.302643503547834*std::exp(0.537439823150635*x_54) - 0.0597966471017898*std::exp(0.61959981918335*x_55) - 12.9062583447022*std::exp(0.635919868946075*x_55) + 2.54350053517974*std::exp(0.65015983581543*x_55) - 0.285500813488784*std::exp(0.651679813861847*x_55) - 5.34186501769302*std::exp(0.652799844741821*x_55) - 1.13681130760745*std::exp(0.655679821968079*x_55) + 228.933877414193*std::exp(0.656159818172455*x_55) - 0.219446866769673*std::exp(0.656319856643677*x_55) - 0.76875789008752*std::exp(0.657199859619141*x_55) + 0.55190348900348*std::exp(0.659119844436646*x_55) + 62.4562851940685*std::exp(0.402799874544144*x_56) + 4.84068616368286*std::exp(0.458079844713211*x_56) + 13.4294354793169*std::exp(0.521679878234863*x_56) - 1.95431388055035*std::exp(0.548719882965088*x_56) + 0.081387900826427*std::exp(0.656559824943542*x_56) - 0.0159694172089369*std::exp(0.671279847621918*x_56) + 0.0196987020833646*std::exp(0.737839818000793*x_56) + 0.0022977772777059*std::exp(0.840079843997955*x_56) + 2.09985341331433*std::exp(0.612879812717438*x_57) - 0.0773554420307219*std::exp(0.620399832725525*x_57) + 0.15407241187142*std::exp(0.626639842987061*x_57) - 0.550773736312289*std::exp(0.628719866275787*x_57) - 0.108947929510135*std::exp(0.631839871406555*x_57) - 133.059006254195*std::exp(0.63351982831955*x_57) + 0.336785553387823*std::exp(0.639759838581085*x_57) + 0.315697321558155*std::exp(0.640399813652039*x_57) - 13.2795128683787*std::exp(0.644639849662781*x_57) - 0.732222984851953*std::exp(0.655679821968079*x_57) + 0.0758735537151585*std::exp(0.401999861001968*x_58) - 0.0812644919967029*std::exp(0.521199882030487*x_58) - 16.8868365758654*std::exp(0.560399830341339*x_58) - 0.0873383044863855*std::exp(0.562319815158844*x_58) + 0.0533869984629037*std::exp(0.610559821128845*x_58) + 0.0719458097879077*std::exp(0.612719833850861*x_58) - 3.30375645944104*std::exp(0.66023987531662*x_58) + 0.428483145655064*std::exp(0.671919822692871*x_58) - 0.126319656897146*std::exp(0.683759808540344*x_58) - 24.6777652797044*std::exp(0.516079843044281*x_59) - 0.0424401008044856*std::exp(0.642879843711853*x_59) + 0.0183465912825538*std::exp(0.651439845561981*x_59) - 0.0473477974392851*std::exp(0.696319878101349*x_59) + 0.519426143943978*std::exp(0.784239888191223*x_59) + 0.019170503721904*std::exp(0.914319813251495*x_59) + 0.000211899484890847*std::exp(1.11175990104675*x_59) + 0.0251650484726926*std::exp(0.776479840278625*x_60) - 0.0267222680057074*std::exp(0.789359867572784*x_60) - 14.4897923335392*std::exp(0.82287985086441*x_60) - 0.026444516139223*std::exp(0.827119886875153*x_60) + 0.0200166711472297*std::exp(0.83383983373642*x_60) - 0.00672890335368958*std::exp(0.855439901351929*x_60) + 0.343865341123956*std::exp(0.855599880218506*x_60) + 0.0142234225713858*std::exp(0.87527984380722*x_60) - 0.200018489864323*std::exp(0.97055983543396*x_60) + 0.822834698614756*std::exp(1.06751978397369*x_61) - 0.0218271892673564*std::exp(1.41151988506317*x_61) + 0.00195724121511546*std::exp(1.48039984703064*x_61) - 0.0618605938012979*std::exp(1.54959976673126*x_61) - 0.0501478424962012*std::exp(0.620399832725525*x_66) - 0.0349031531142433*std::exp(0.898959815502167*x_66) - 14.2233838631802*std::exp(0.940879821777344*x_66) + 2.43123214523369e-5*std::exp(1.60559988021851*x_7) - 0.000171920703710714*std::exp(1.86407995223999*x_7) - 0.0465171728941381*std::exp(0.557119846343994*x_8) - 0.0311277502827104*std::exp(0.561599850654602*x_8) - 0.168437166152245*std::exp(0.82727986574173*x_8) + 0.281862599406733*std::exp(0.832399845123291*x_8) - 0.00217221326782188*std::exp(0.850879848003387*x_8) - 3.26393990796672e-6*std::exp(1.72775983810425*x_9) + 0.320848276655983*std::log(4.17511987686157 - 0.624479830265045*x_5) + 0.732456000818618*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 14.277716532774*std::sin(0.217600002884865*x_101 + 8.20775985717773) - 10.8866711479399*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 0.511664816936636*std::sin(0.270719945430756*x_107 - 7.4443998336792) - 8.2088069066093*std::sin(0.24415996670723*x_108 - 1.1950398683548) - 0.768742814710187*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 9.45887205938849*std::sin(0.304159939289093*x_113 - 1.22191989421844) + 6.010763806731*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 59.4024522182764*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 0.540756610843249*std::sin(0.239519983530045*x_117 - 7.43887996673584) - 0.734244895648937*std::sin(0.269199967384338*x_117 + 1.93663990497589) - 11.2010612798147*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 1.18693402521441*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 181.371442267864*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 0.440159129902845*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.915698200089912*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.259870519861494*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 0.732139687593758*std::sin(0.412479877471924*x_21 - 7.41631984710693) - 4.61080194207982*std::sin(0.416879862546921*x_22 + 2.00263977050781) - 1.32202725808327*std::sin(0.16056002676487*x_3 + 1.77247989177704) - 0.22822083313953*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.225727611483978*std::sin(0.3504798412323*x_35 + 1.83119988441467) + 8.49549965989787*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.21124313363202*std::sin(0.282319933176041*x_42 + 5.11696004867554) - 3.91125869900404*std::sin(0.476879835128784*x_5 - 4.28232002258301) - 10.6993905063687*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.273608921478508*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.194183103803977*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.351560262255129*std::sin(0.576239883899689*x_65 + 2.18959999084473) + 0.289129474639256*std::sin(0.582639873027802*x_65 - 7.20071983337402) + 11.2194568176425*std::sin(0.219119995832443*x_9 - 7.589439868927) + 0.435350400573776*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 0.52199138204102*std::sin(0.390079855918884*x_9 + 1.9851998090744) - 0.24807736857809*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 6.23804937554906*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 94.3928212623294*std::sin(0.359999865293503*x_91 + 2.00431990623474) + 0.399096615709408*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 0.724503185353031*std::sin(0.383759826421738*x_91 + 8.19527912139893) + 6.20550153168573*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 9.81069353077265*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 39.4751113383448*std::sin(0.311039924621582*x_92 + 8.22056007385254) + 9.84165638087439*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.31934057851323*std::sin(0.279199957847595*x_95 - 1.19967985153198) - 0.677596146823469*std::sin(0.301439940929413*x_97 - 7.45655965805054) - 11.713176166443*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.472628324405808*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 0.796572701555955*std::sin(0.236799985170364*x_98 + 5.18336009979248) + 0.631972576854281*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 6.75482223294805*std::sin(0.271759957075119*x_98 - 1.21863985061646) - 0.308176800847208*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 1549.59898889392);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.783472490512642*x_1 + 10.750200970749*x_10 - 16.6379128842719*x_100 - 18.4018455760183*x_101 - 39.8853361987226*x_102 - 1.62981666977727*x_103 - 238.525586892051*x_104 - 37.4442062315136*x_105 - 17.6523954896741*x_106 - 5.21606782309313*x_107 - 25.9594811693352*x_108 + 10.1882980133654*x_109 - 29.1488859857509*x_110 - 29.9391907534566*x_111 - 6.4643273501157*x_112 + 18.4318539320211*x_113 + 49.9607773315045*x_114 + 24.5855807592239*x_115 - 2.95807207205917*x_116 - 35.3233492748616*x_117 - 51.7459243544833*x_118 - 22.5686846828107*x_119 + 8.16931079282415*x_12 + 5.39122530850166*x_120 + 7.59698889840724*x_13 + 1.56608929462852*x_14 + 0.756283561470451*x_15 - 14.372990430027*x_16 + 2.34034899891417*x_17 + 137.546316189502*x_18 - 0.69251235339574*x_19 + 0.333887779811216*x_2 + 0.14800949725671*x_20 + 3.38928089605485*x_21 - 0.189098809413985*x_22 + 0.107310375357144*x_23 - 11.0147290088624*x_24 + 0.0222042008903939*x_25 - 1.04625615226186*x_26 + 61.3186315414909*x_27 + 0.843883984298627*x_28 + 0.377557021756616*x_29 - 0.279081805425399*x_3 + 0.00244848456762232*x_30 - 8.05458191470222*x_31 - 8.2244541981674*x_32 + 80.8226964266326*x_33 - 146.728009634776*x_34 - 80.1007429280786*x_35 + 136.265269208385*x_36 - 708.420682840401*x_37 - 16.0928264467594*x_38 - 102.149171606859*x_39 + 2.5655729778723*x_4 - 6309.09599612968*x_40 - 10.0277533546936*x_41 - 30.103688869175*x_42 - 10.0571967717619*x_43 - 61.3444286429771*x_44 + 48.4299833096214*x_45 - 20.7062451920243*x_46 + 130.496572257837*x_47 - 274.536072354883*x_48 + 71.6571710952306*x_5 - 0.154678514591163*x_50 - 30.6746649171701*x_52 - 4.86886888026445*x_53 - 4.73904480582873*x_54 + 2.91160967505336*x_56 + 0.481578430470101*x_58 - 2.38681929752945*x_59 + 12.8377065270926*x_6 - 1.67921895551756*x_60 + 30.0353016235439*x_61 + 18.5641384400213*x_62 + 12.2581443637146*x_63 + 32.624811629743*x_64 - 7.31083809723495*x_65 + 1.44497122521107*x_66 + 8.28837378415396*x_67 + 10.7222172852722*x_68 + 35.8027397414916*x_69 + 54.4853172241422*x_7 - 14.258790235033*x_70 - 20.2808731257748*x_71 - 4.59738516056606*x_72 + 37.4718377106818*x_73 - 20.2577639382078*x_74 - 17.51526718451*x_75 + 1.82306671749573*x_76 - 0.196416169035847*x_77 - 7.6583934588602*x_78 - 28.1566896994665*x_79 - 2.39614244363285*x_8 - 15.8508657042319*x_80 - 8.74135065814793*x_81 - 21.3240237029029*x_82 + 36.6061501441863*x_83 + 14.876233223013*x_84 - 6.93717068648257*x_85 + 601.382748284777*x_86 + 127.692834689324*x_87 + 72.9656037793486*x_88 - 2.48327666042408*x_89 + 5.64367325993468*x_9 - 6.16355728708884*x_90 + 5.78980098646888*x_91 - 32.1840349171698*x_92 - 33.7804399117026*x_93 + 16.313107605172*x_94 - 5.67560075395292*x_95 - 30.0003314800074*x_96 - 8.57973586551566*x_97 - 47.7771063613522*x_98 - 71.1407526786656*x_99 + 0.0161659646534092*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) + 0.00110869096801147*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) - 0.0071338185414945*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) - 0.000637629001469867*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) + 0.0215975233142493*std::exp(1.10463988780975*x_1) + 0.0173723862214088*std::exp(1.27999985218048*x_1) - 0.00830286262337316*std::exp(1.32983994483948*x_1) - 0.512632914357221*std::exp(1.33063983917236*x_1) - 0.405196596539184*std::exp(1.79583990573883*x_1) - 0.00696017803587571*std::exp(1.89927983283997*x_1) - 0.00573590178593997*std::exp(0.68343985080719*x_10) - 0.13512828918667*std::exp(0.712479829788208*x_10) - 0.0279356703958171*std::exp(0.782719850540161*x_10) + 0.0194564835699704*std::exp(0.806639909744263*x_10) - 2.49968981478062*std::exp(0.807519853115082*x_10) - 0.0198055079442189*std::exp(0.83463990688324*x_10) - 0.0131664674092228*std::exp(0.860239923000336*x_10) + 0.177365326319861*std::exp(0.939199805259705*x_10) - 0.0101980648083086*std::exp(1.05287981033325*x_10) - 0.257940540360495*std::exp(0.837359845638275*x_11) + 0.0024110665433166*std::exp(0.884399890899658*x_11) + 0.0195548094120898*std::exp(0.896239876747131*x_11) - 3.40394649752769*std::exp(0.927199840545654*x_11) - 0.0349828357414169*std::exp(0.931759834289551*x_11) - 3.26510714407584*std::exp(0.933759808540344*x_11) + 0.0147788441520411*std::exp(0.951039850711823*x_11) + 0.0505516966320281*std::exp(0.958639860153198*x_11) + 0.00677012772178886*std::exp(0.975439846515656*x_11) + 0.0427248735769556*std::exp(1.01423990726471*x_11) + 0.659210082982719*std::exp(0.427279859781265*x_12) + 0.0153404126817932*std::exp(0.519439876079559*x_12) - 0.00739082458561173*std::exp(0.88239985704422*x_12) + 0.0156703338187046*std::exp(0.905999839305878*x_12) + 0.00124141008684976*std::exp(0.997519791126251*x_12) + 0.140778610414887*std::exp(1.23287987709045*x_12) - 0.0236753366881008*std::exp(0.619519829750061*x_13) - 0.000931068262552832*std::exp(1.07167983055115*x_13) + 9.01398118969072e-5*std::exp(1.30135977268219*x_13) + 119.317793603776*std::exp(0.264079838991165*x_14) - 0.0569212288789908*std::exp(0.453439861536026*x_14) - 0.201226796650719*std::exp(0.619439840316772*x_14) - 0.0027377256669252*std::exp(0.899199843406677*x_14) + 0.0647827077969263*std::exp(0.827359914779663*x_15) - 1.19724847048297*std::exp(0.876239895820618*x_15) - 0.00985149775545009*std::exp(0.927279829978943*x_15) - 0.00459748156930107*std::exp(0.928959846496582*x_15) - 5.79297084688087*std::exp(0.932479858398438*x_15) + 0.00241747299547257*std::exp(1.01999986171722*x_15) + 0.00119912228629952*std::exp(1.1373598575592*x_15) - 0.0709613698083975*std::exp(0.38351982831955*x_16) - 0.104097510932544*std::exp(0.547599852085114*x_16) - 6.27727471273395*std::exp(0.600879848003387*x_16) - 0.0406000103057785*std::exp(0.678639829158783*x_16) + 0.00041711263627957*std::exp(0.935519814491272*x_16) - 0.0263579498770399*std::exp(0.628639817237854*x_17) - 0.0880865888212956*std::exp(0.667199850082397*x_17) + 19.2103017386272*std::exp(0.677199840545654*x_17) + 0.48262263702007*std::exp(0.695839881896973*x_17) - 0.0726595401600872*std::exp(0.7151198387146*x_17) + 0.0169362402647477*std::exp(0.693999886512756*x_19) - 47.1768786993052*std::exp(0.714319825172424*x_19) + 0.0259320538084493*std::exp(0.71535986661911*x_19) + 0.0633868974117998*std::exp(0.717759847640991*x_19) + 2.48685382840919*std::exp(0.728159844875336*x_19) - 11.6372712163209*std::exp(0.751519858837128*x_19) + 1.82738691441558*std::exp(0.766079843044281*x_19) + 0.0414909030950999*std::exp(0.825519859790802*x_19) - 0.0226456430647098*std::exp(0.880719900131226*x_19) - 1.2281414285847*std::exp(0.594239830970764*x_2) + 0.0578268960001151*std::exp(0.739439845085144*x_2) + 0.0774992872903946*std::exp(0.749919831752777*x_2) + 0.747566319464832*std::exp(0.779519855976105*x_2) + 17.2274244691324*std::exp(0.884239912033081*x_2) - 0.0178447767108359*std::exp(0.947919845581055*x_2) + 0.00476255743990532*std::exp(1.33703982830048*x_2) + 0.775114855704673*std::exp(0.395839840173721*x_20) + 6.75821313746177*std::exp(0.457199841737747*x_20) - 0.538234711218686*std::exp(0.519039869308472*x_20) - 0.00596426527970866*std::exp(0.855199873447418*x_20) + 3.39755153271077*std::exp(0.866639912128448*x_20) + 0.000443557272882579*std::exp(1.17951989173889*x_20) + 4.74341235610451e-6*std::exp(1.35351979732513*x_20) + 0.00693075278650214*std::exp(1.0551198720932*x_21) - 0.112087279637315*std::exp(0.538959860801697*x_22) - 0.678522430372756*std::exp(0.831119894981384*x_22) - 0.278664600103028*std::exp(1.05791985988617*x_22) - 0.000349918544226074*std::exp(1.28927981853485*x_22) + 0.00014026537735844*std::exp(1.33255982398987*x_22) - 0.980626737954742*std::exp(0.619919836521149*x_23) + 0.0650141106148651*std::exp(0.693919837474823*x_23) - 11.984742287612*std::exp(0.69735985994339*x_23) - 0.00650893891266153*std::exp(0.720719873905182*x_23) - 0.0611000658102262*std::exp(0.722399830818176*x_23) - 0.0472439571688927*std::exp(0.726079881191254*x_23) - 0.608496674417471*std::exp(0.748559832572937*x_23) + 0.899164807319654*std::exp(0.811039865016937*x_23) - 0.18538840982763*std::exp(0.972799837589264*x_23) + 15.0507169961226*std::exp(0.312959849834442*x_24) + 0.99092031400709*std::exp(0.446319848299026*x_24) + 0.1323992457977*std::exp(0.608799874782562*x_24) - 0.0489864107127107*std::exp(0.626559853553772*x_24) + 0.0144045776359751*std::exp(0.689279854297638*x_24) - 1.09612928654344*std::exp(0.733279824256897*x_24) + 0.0753692757602957*std::exp(0.44327986240387*x_25) - 0.164854387247007*std::exp(0.543599843978882*x_25) - 40.7328989769718*std::exp(0.614479839801788*x_25) - 0.282598147858566*std::exp(0.783199846744537*x_25) + 0.0492304540908751*std::exp(0.797279894351959*x_25) + 0.00192944262345082*std::exp(0.822319865226746*x_25) + 0.943383942601733*std::exp(0.882079899311066*x_25) - 0.0048357435420269*std::exp(0.994239807128906*x_25) + 0.00313826228896036*std::exp(0.997759819030762*x_25) - 0.128450934030904*std::exp(0.439359873533249*x_26) + 0.880147273636532*std::exp(0.595519840717316*x_26) + 0.198955764057603*std::exp(0.669679820537567*x_26) + 3.5424038935425*std::exp(0.748879849910736*x_26) + 0.00641252128405931*std::exp(0.816239893436432*x_26) + 0.0239541486250744*std::exp(0.825599908828735*x_26) + 0.00205810071331537*std::exp(0.871999859809875*x_26) + 0.000504460798701184*std::exp(1.1651998758316*x_26) + 0.0838675332966775*std::exp(1.19079983234406*x_27) - 0.00132075119168813*std::exp(1.22255980968475*x_27) - 0.0105250512487332*std::exp(1.22495996952057*x_27) - 0.00878086321630053*std::exp(1.26967978477478*x_27) - 0.000239167418934417*std::exp(1.42463982105255*x_27) - 30.903865575665*std::exp(0.559919834136963*x_28) - 0.787083266986619*std::exp(0.587999820709229*x_28) - 0.0267231593159957*std::exp(0.67631983757019*x_28) - 0.0126435533368831*std::exp(0.690719842910767*x_28) - 0.0216430000332192*std::exp(0.717759847640991*x_28) + 0.00248490932280642*std::exp(0.782079875469208*x_28) - 0.187022304742936*std::exp(0.911999821662903*x_28) - 0.43022528017375*std::exp(1.1043199300766*x_29) - 0.00152426696138628*std::exp(1.13167989253998*x_29) - 0.00195619374135621*std::exp(1.13919985294342*x_29) + 0.197292919200668*std::exp(1.14943981170654*x_29) - 0.0312739197595489*std::exp(1.15047979354858*x_29) - 0.000443020921780704*std::exp(1.30935978889465*x_29) + 0.00256730421685236*std::exp(1.35751986503601*x_29) + 16.5439613489185*std::exp(0.411679863929749*x_3) + 9.60438372362425*std::exp(0.555839836597443*x_3) - 0.128969827454779*std::exp(0.65151983499527*x_3) + 0.0189449601128302*std::exp(0.657999873161316*x_3) + 0.00931817449474163*std::exp(0.949759840965271*x_3) - 0.115445051327932*std::exp(0.983039796352386*x_3) - 0.0436458462352913*std::exp(0.6422398686409*x_30) - 0.594478263246103*std::exp(0.799999833106995*x_30) - 14.2073328166062*std::exp(0.843599855899811*x_30) + 1.48029859820199*std::exp(0.844959855079651*x_30) + 0.482413430242922*std::exp(0.928399801254272*x_30) + 0.0133096501122299*std::exp(0.962799787521362*x_30) - 0.00339610203169074*std::exp(1.03063988685608*x_30) - 0.000399486449389669*std::exp(1.09807980060577*x_30) + 0.00321166511512656*std::exp(1.10879981517792*x_30) - 0.00487713753058376*std::exp(0.816479861736298*x_32) + 8.85458849898632*std::exp(0.830799877643585*x_32) - 0.00169183527445503*std::exp(0.873279869556427*x_32) - 1.82827134103488*std::exp(0.337679862976074*x_33) + 0.0587164364107535*std::exp(0.393599838018417*x_33) - 2.46305011768495*std::exp(0.417359858751297*x_33) - 0.046324110000198*std::exp(0.425519853830338*x_33) - 2.85385898077764*std::exp(0.358959853649139*x_34) + 0.192567205863172*std::exp(0.365919858217239*x_34) - 1.19306424401521*std::exp(0.429999858140945*x_36) - 0.133327662854761*std::exp(0.381999850273132*x_4) - 0.500312848559047*std::exp(0.475839853286743*x_4) - 4.18976827057509*std::exp(0.60919988155365*x_4) - 0.00743486628781367*std::exp(0.61959981918335*x_4) - 0.0458579298570665*std::exp(0.755119860172272*x_4) - 0.00295496985528153*std::exp(0.894799828529358*x_4) - 0.027829679580285*std::exp(1.16215980052948*x_4) - 0.386075065768158*std::exp(1.17103981971741*x_4) + 0.00143716929740638*std::exp(1.17639982700348*x_4) + 10.104570213953*std::exp(0.683199822902679*x_41) - 0.400673378900767*std::exp(0.767599880695343*x_41) + 0.0497707513148402*std::exp(0.7704798579216*x_41) - 0.0277225133420812*std::exp(0.784719884395599*x_41) + 0.0548382371238113*std::exp(0.803359866142273*x_41) - 0.264543642168315*std::exp(0.804319858551025*x_41) - 0.197229604627792*std::exp(0.808079898357391*x_41) - 0.00361958731860439*std::exp(0.808239877223969*x_41) + 0.228639965437827*std::exp(0.633279860019684*x_42) - 0.0119824882932816*std::exp(0.719839870929718*x_42) - 0.291575852493514*std::exp(0.733519852161407*x_42) + 0.0404883543226979*std::exp(0.816239893436432*x_42) + 0.00698353854695209*std::exp(0.75087982416153*x_43) + 0.000847898891488251*std::exp(0.821199893951416*x_43) - 0.000451745972641083*std::exp(0.844239890575409*x_44) + 0.00374727144778*std::exp(0.897199809551239*x_44) + 0.00101935680247172*std::exp(0.97439980506897*x_44) - 2.51005460364915*std::exp(0.521199882030487*x_45) - 0.0127743597270916*std::exp(0.675519824028015*x_46) - 0.259143799348778*std::exp(0.691119849681854*x_46) - 0.0338510993551485*std::exp(0.763439834117889*x_46) + 0.190735572728999*std::exp(0.766159892082214*x_46) - 8.90540723461605*std::exp(0.79447990655899*x_46) - 0.0154254594551404*std::exp(0.795199871063232*x_46) - 0.118216133943172*std::exp(0.484159857034683*x_47) - 0.441758253771106*std::exp(0.519519865512848*x_47) + 0.00926719440307451*std::exp(0.598719835281372*x_48) + 0.00790173250715955*std::exp(0.655999839305878*x_49) + 0.0531532147739824*std::exp(0.690879821777344*x_49) + 52.7080475530424*std::exp(0.702399849891663*x_49) + 0.888881571025585*std::exp(0.70719987154007*x_49) + 2.00530299492941*std::exp(0.710559844970703*x_49) - 0.226880925438229*std::exp(0.714879810810089*x_49) - 0.0188310090555867*std::exp(0.715039849281311*x_49) + 12.6013122278083*std::exp(0.717039823532104*x_49) - 1.99601871747918*std::exp(0.718959867954254*x_49) - 0.0352972190097688*std::exp(0.719279825687408*x_49) + 0.00106044584843874*std::exp(1.92919981479645*x_5) - 0.0119441813094962*std::exp(0.479759842157364*x_50) + 1.74404361320336*std::exp(0.541039824485779*x_50) + 38.3115554092377*std::exp(0.549919843673706*x_50) + 1.3553398929492*std::exp(0.552239894866943*x_50) + 0.769674398690937*std::exp(0.554079830646515*x_50) - 0.0876811911239022*std::exp(0.58679986000061*x_50) + 1.6066973706481*std::exp(0.61983984708786*x_50) - 0.00526127673648141*std::exp(0.667119860649109*x_50) - 0.0515478830844705*std::exp(0.485599845647812*x_51) + 96.6135559856631*std::exp(0.495279848575592*x_51) - 9.89124553870395*std::exp(0.495439857244492*x_51) - 0.200199807767503*std::exp(0.495919853448868*x_51) - 168.415037927471*std::exp(0.495999842882156*x_51) - 1.87624252890028*std::exp(0.496239870786667*x_51) - 0.532229560565963*std::exp(0.497919857501984*x_51) + 0.210726750949422*std::exp(0.498719841241837*x_51) + 8.6701555565896*std::exp(0.504399836063385*x_51) - 0.889364097758239*std::exp(0.503519833087921*x_52) + 0.0137775119254055*std::exp(0.579199850559235*x_52) - 0.034623158512923*std::exp(0.628959834575653*x_52) - 0.0107806482050153*std::exp(0.709119856357574*x_52) - 0.934313438329532*std::exp(0.72111988067627*x_52) - 0.154172470044514*std::exp(0.745919823646545*x_52) - 0.000851841058919193*std::exp(0.87967985868454*x_52) - 0.122714972297356*std::exp(0.467919856309891*x_54) - 0.153433207851603*std::exp(0.488959848880768*x_54) - 4.24664050861306*std::exp(0.515999853610992*x_54) - 0.119770338232396*std::exp(0.532239854335785*x_54) + 8.79238819698645*std::exp(0.533839821815491*x_54) - 0.0209548428538973*std::exp(0.533999860286713*x_54) - 1.85890674811564*std::exp(0.535999834537506*x_54) - 0.522066413638209*std::exp(0.537439823150635*x_54) + 0.00970471507076622*std::exp(0.61959981918335*x_55) - 10.342094380104*std::exp(0.635919868946075*x_55) - 2.15858330838029*std::exp(0.65015983581543*x_55) + 0.447878873517088*std::exp(0.651679813861847*x_55) + 7.33892220353199*std::exp(0.652799844741821*x_55) - 1.31597480620173*std::exp(0.655679821968079*x_55) + 319.79804374436*std::exp(0.656159818172455*x_55) + 0.378550464079192*std::exp(0.656319856643677*x_55) + 4.79068222177496*std::exp(0.657199859619141*x_55) - 0.330555115136131*std::exp(0.659119844436646*x_55) + 87.2452694647134*std::exp(0.402799874544144*x_56) - 4.1081274446419*std::exp(0.458079844713211*x_56) + 10.7613287669562*std::exp(0.521679878234863*x_56) + 2.68493447197508*std::exp(0.548719882965088*x_56) + 0.0942147797972176*std::exp(0.656559824943542*x_56) + 0.0275475808085345*std::exp(0.671279847621918*x_56) - 0.00319700685989199*std::exp(0.737839818000793*x_56) - 0.00360463385780338*std::exp(0.840079843997955*x_56) - 1.78207492600562*std::exp(0.612879812717438*x_57) + 0.121351206722559*std::exp(0.620399832725525*x_57) + 0.178354499991953*std::exp(0.626639842987061*x_57) + 0.329878465072573*std::exp(0.628719866275787*x_57) + 0.187937471532988*std::exp(0.631839871406555*x_57) - 185.870306235516*std::exp(0.63351982831955*x_57) - 0.0546587140582556*std::exp(0.639759838581085*x_57) - 1.96733661579518*std::exp(0.640399813652039*x_57) - 10.6411921827794*std::exp(0.644639849662781*x_57) + 1.00596467781719*std::exp(0.655679821968079*x_57) - 0.119026497166245*std::exp(0.401999861001968*x_58) + 0.50641738067346*std::exp(0.521199882030487*x_58) - 23.5892449076986*std::exp(0.560399830341339*x_58) + 0.0523100938307523*std::exp(0.562319815158844*x_58) - 0.0086644591908968*std::exp(0.610559821128845*x_58) - 0.124108036194252*std::exp(0.612719833850861*x_58) - 2.6473792945918*std::exp(0.66023987531662*x_58) - 0.588671645777608*std::exp(0.671919822692871*x_58) + 0.107203241802831*std::exp(0.683759808540344*x_58) - 34.4724037768937*std::exp(0.516079843044281*x_59) + 0.264474731298354*std::exp(0.642879843711853*x_59) - 0.0316482561201088*std::exp(0.651439845561981*x_59) + 0.0283583216012001*std::exp(0.696319878101349*x_59) + 0.416228628056804*std::exp(0.784239888191223*x_59) - 0.0263373999439495*std::exp(0.914319813251495*x_59) - 3.43902914992411e-5*std::exp(1.11175990104675*x_59) - 0.0150722647365702*std::exp(0.776479840278625*x_60) - 0.03093374531442*std::exp(0.789359867572784*x_60) - 20.2408105557233*std::exp(0.82287985086441*x_60) + 0.00429182080859106*std::exp(0.827119886875153*x_60) - 0.124738245734599*std::exp(0.83383983373642*x_60) + 0.0105559547001929*std::exp(0.855439901351929*x_60) - 0.291826942992254*std::exp(0.855599880218506*x_60) - 0.0245357033091924*std::exp(0.87527984380722*x_60) - 0.160279613555994*std::exp(0.97055983543396*x_60) + 0.659357180448145*std::exp(1.06751978397369*x_61) + 0.0130730992014505*std::exp(1.41151988506317*x_61) - 0.00307041853897051*std::exp(1.48039984703064*x_61) + 0.052499004179112*std::exp(1.54959976673126*x_61) + 0.0786693352360386*std::exp(0.620399832725525*x_66) + 0.217506600276009*std::exp(0.898959815502167*x_66) - 19.868664202287*std::exp(0.940879821777344*x_66) + 2.8143986866993e-5*std::exp(1.60559988021851*x_7) + 0.000145903315632177*std::exp(1.86407995223999*x_7) - 0.0538483626744097*std::exp(0.557119846343994*x_8) + 0.193979355276931*std::exp(0.561599850654602*x_8) + 0.142946954536977*std::exp(0.82727986574173*x_8) + 0.225863261638679*std::exp(0.832399845123291*x_8) + 0.00374711360757779*std::exp(0.850879848003387*x_8) + 5.29722122395919e-7*std::exp(1.72775983810425*x_9) - 0.553470030422491*std::log(4.17511987686157 - 0.624479830265045*x_5) - 1.26350201809213*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 11.4410767218938*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 9.23915143666669*std::sin(0.298079937696457*x_103 - 7.48615980148315) - 3.18855074349483*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 6.96653817258643*std::sin(0.24415996670723*x_108 - 1.1950398683548) - 0.889898059455739*std::sin(0.285119920969009*x_113 - 7.42575979232788) - 12.9950730591455*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 5.10113296394845*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 47.6006097850356*std::sin(0.221279993653297*x_116 + 5.17928028106689) + 0.323878843528722*std::sin(0.239519983530045*x_117 - 7.43887996673584) - 0.849963206549907*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 9.5059637614915*std::sin(0.258879989385605*x_120 + 8.34255981445313) - 0.710898048628326*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 253.358013604151*std::sin(0.269279956817627*x_120 + 5.15327978134155) - 0.690498821562524*std::sin(0.271759957075119*x_120 - 7.44655990600586) + 0.148613518539906*std::sin(0.280559957027435*x_120 - 7.44615983963013) - 0.407671397757464*std::sin(0.245119974017143*x_20 - 4.37967967987061) - 0.438505143653403*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 3.91303244200717*std::sin(0.416879862546921*x_22 + 2.00263977050781) - 1.53038112227354*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.393685740740994*std::sin(0.343199849128723*x_31 - 4.24496030807495) + 0.354109773340868*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 7.20984466429847*std::sin(0.32151985168457*x_37 + 5.08903980255127) + 0.331387275479848*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 3.31935363317339*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 9.08021265867667*std::sin(0.294399946928024*x_53 - 4.27839994430542) - 0.0444054433227425*std::sin(0.455759853124619*x_6 + 1.95391988754272) - 0.0315150060297981*std::sin(0.57287985086441*x_64 + 5.36984014511108) - 0.210562254601546*std::sin(0.576239883899689*x_65 + 2.18959999084473) + 0.334696797796973*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 9.52157543538519*std::sin(0.219119995832443*x_9 - 7.589439868927) + 0.503962403603001*std::sin(0.327599853277206*x_9 - 4.33911991119385) + 0.312639664051027*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.427938682311406*std::sin(0.474319845438004*x_9 - 1.12655985355377) + 8.57014524277835*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 131.857459997454*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.688450062254932*std::sin(0.381119847297668*x_91 - 1.19447994232178) + 0.433931364129054*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 5.26640031765456*std::sin(0.390719830989838*x_91 - 4.39071989059448) - 13.4784230501072*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 31.6323535623208*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 8.35228257149495*std::sin(0.313199937343597*x_92 - 4.37519979476929) + 0.051827476542774*std::sin(0.279199957847595*x_95 - 1.19967985153198) - 0.784386513427403*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 9.94057843169081*std::sin(0.303759932518005*x_97 + 1.957359790802) - 0.0767053579931365*std::sin(0.315439909696579*x_97 + 1.92727982997894) - 0.477096424145757*std::sin(0.236799985170364*x_98 + 5.18336009979248) + 0.731572587099741*std::sin(0.26079997420311*x_98 + 1.96743977069855) - 9.28011372471989*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.531611467944064*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 1844.19933796911);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.41576404284356*x_1 + 12.7741111750001*x_10 - 3.29989362176848*x_100 - 34.749737646509*x_101 - 32.5872930869786*x_102 + 8.30689603705895*x_103 - 349.398312634008*x_104 - 41.7872549896216*x_105 - 21.8169938387843*x_106 - 10.2399491017339*x_107 - 31.3473179048154*x_108 + 7.53785598135774*x_109 - 33.8437631571609*x_110 - 34.2997312625011*x_111 - 16.2243259675908*x_112 + 23.6679071474643*x_113 + 75.5015363799551*x_114 + 24.6611074563372*x_115 - 9.61941260152695*x_116 - 32.5785229115816*x_117 - 50.6146962682868*x_118 - 38.1925045903658*x_119 + 3.88633718556037*x_12 + 8.70910450819704*x_120 + 7.88890409852108*x_13 - 3.59646719969919*x_14 + 3.6845647252896*x_15 - 17.8265730798935*x_16 + 1.90038061072376*x_17 + 125.175668429468*x_18 + 9.87324861504144*x_19 + 2.35017575316577*x_2 - 0.919998764911074*x_20 + 7.3912344918648*x_21 + 0.18394104368817*x_22 + 0.18283433603878*x_23 - 13.7146201868655*x_24 + 0.0737685275477896*x_25 + 4.78745870749765*x_26 + 88.5163975258117*x_27 - 1.36340334992885*x_28 - 4.7925272567378*x_29 - 4.24176149768918*x_3 - 0.0349083980201762*x_30 - 7.13543403965607*x_31 + 14.1767236289564*x_32 + 90.8016220668744*x_33 - 138.485785386474*x_34 - 120.984442739685*x_35 + 167.720358178461*x_36 - 1087.36428954873*x_37 - 162.256464718535*x_38 - 219.776824596207*x_39 - 0.517914384462552*x_4 - 6971.07474064786*x_40 - 5.05000834848046*x_41 - 43.022910965672*x_42 - 17.7154129660231*x_43 - 90.4473022900551*x_44 + 103.246641013158*x_45 - 18.1591944248247*x_46 + 153.755258410251*x_47 - 258.788583064305*x_48 + 77.2516323036144*x_5 - 0.244526439576137*x_50 - 42.3682542576715*x_52 + 1.00974465485337*x_53 - 4.07232737594314*x_54 - 41.5112395480029*x_56 + 0.820508476394376*x_58 - 7.96376698000198*x_59 + 12.6105653459476*x_6 + 0.338985349169832*x_60 + 33.8760007938338*x_61 + 21.2352233026125*x_62 + 10.1623724433227*x_63 + 38.7007306122179*x_64 - 7.93606484258987*x_65 + 0.555309803728066*x_66 + 9.42410005120533*x_67 + 13.1677990670393*x_68 + 44.8617156913373*x_69 + 73.6007880200979*x_7 - 8.90463847913525*x_70 - 21.4229614972073*x_71 - 1.01849087598348*x_72 + 48.0173603684736*x_73 - 25.234570879939*x_74 - 12.7006252243713*x_75 + 5.69384970395437*x_76 - 8.81265790693658*x_77 - 15.8821151023499*x_78 - 31.6775887302438*x_79 - 3.82430299184884*x_8 - 17.9718621454867*x_80 - 7.29192661341768*x_81 - 31.757437945004*x_82 + 27.8212145005504*x_83 + 14.7786100762193*x_84 - 12.6422602165559*x_85 + 574.332350902949*x_86 + 87.6857353427839*x_87 + 67.2305204399631*x_88 + 2.24285902848913*x_89 + 2.04525983415112*x_9 - 8.88642994754549*x_90 + 2.84914484523423*x_91 - 38.2553817308451*x_92 - 29.1889199494737*x_93 + 19.8824560440343*x_94 - 3.12981645778598*x_95 - 42.8961024368889*x_96 - 21.1831220893378*x_97 - 66.0953678650508*x_98 - 111.933290512846*x_99 - 0.00326343694173823*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) + 0.0018889764976959*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.00144010997568652*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) - 0.000736346025449231*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) + 0.0367976425588001*std::exp(1.10463988780975*x_1) + 0.0200619600382274*std::exp(1.27999985218048*x_1) + 0.00694447962843186*std::exp(1.32983994483948*x_1) - 0.258163559238132*std::exp(1.33063983917236*x_1) - 0.481481824014919*std::exp(1.79583990573883*x_1) - 0.0231236461835088*std::exp(1.89927983283997*x_1) + 0.00835022862194452*std::exp(0.68343985080719*x_10) + 1.92654353026797*std::exp(0.712479829788208*x_10) + 0.023365278069785*std::exp(0.782719850540161*x_10) + 0.0331497606203103*std::exp(0.806639909744263*x_10) - 1.25885170753079*std::exp(0.807519853115082*x_10) - 0.0228717750025646*std::exp(0.83463990688324*x_10) - 0.00476823232024407*std::exp(0.860239923000336*x_10) - 0.0358048882640371*std::exp(0.939199805259705*x_10) - 0.0338808060897755*std::exp(1.05287981033325*x_10) + 0.052070674793096*std::exp(0.837359845638275*x_11) - 0.00350998981690476*std::exp(0.884399890899658*x_11) + 0.0333172871991665*std::exp(0.896239876747131*x_11) - 1.7142382368479*std::exp(0.927199840545654*x_11) - 0.0126690237291112*std::exp(0.931759834289551*x_11) - 3.87981971408724*std::exp(0.933759808540344*x_11) - 0.0123609635376483*std::exp(0.951039850711823*x_11) - 0.720722838102135*std::exp(0.958639860153198*x_11) + 0.00781827148425035*std::exp(0.975439846515656*x_11) + 0.141943906425428*std::exp(1.01423990726471*x_11) - 0.133075296358417*std::exp(0.427279859781265*x_12) - 0.0223323128303806*std::exp(0.519439876079559*x_12) - 0.0125924124428054*std::exp(0.88239985704422*x_12) - 0.223414211911319*std::exp(0.905999839305878*x_12) + 0.00044957629976342*std::exp(0.997519791126251*x_12) + 0.167282604799201*std::exp(1.23287987709045*x_12) - 0.0273407263961773*std::exp(0.619519829750061*x_13) + 0.000778741606994187*std::exp(1.07167983055115*x_13) + 0.000153579303063489*std::exp(1.30135977268219*x_13) + 141.781420161129*std::exp(0.264079838991165*x_14) + 0.0476086781518814*std::exp(0.453439861536026*x_14) + 2.86891949522464*std::exp(0.619439840316772*x_14) - 0.00466450939997828*std::exp(0.899199843406677*x_14) - 0.923616419112634*std::exp(0.827359914779663*x_15) - 0.602938121559847*std::exp(0.876239895820618*x_15) - 0.0167848825904357*std::exp(0.927279829978943*x_15) - 0.00530925863288375*std::exp(0.928959846496582*x_15) - 6.88359723068831*std::exp(0.932479858398438*x_15) - 0.0020219643189186*std::exp(1.01999986171722*x_15) + 0.000434261785165946*std::exp(1.1373598575592*x_15) - 0.0819475313989712*std::exp(0.38351982831955*x_16) - 0.177360290012016*std::exp(0.547599852085114*x_16) - 3.16125542618915*std::exp(0.600879848003387*x_16) + 0.0339576790887644*std::exp(0.678639829158783*x_16) - 0.000607225507691573*std::exp(0.935519814491272*x_16) + 0.0383714567809618*std::exp(0.628639817237854*x_17) - 0.101724058072046*std::exp(0.667199850082397*x_17) + 22.8269714010215*std::exp(0.677199840545654*x_17) - 6.88082062244893*std::exp(0.695839881896973*x_17) - 0.123796592247855*std::exp(0.7151198387146*x_17) - 0.0246554915834651*std::exp(0.693999886512756*x_19) - 56.0587374165554*std::exp(0.714319825172424*x_19) - 0.0216894615224903*std::exp(0.71535986661911*x_19) + 0.107997956984811*std::exp(0.717759847640991*x_19) - 0.502023283257777*std::exp(0.728159844875336*x_19) - 5.86056664112548*std::exp(0.751519858837128*x_19) + 6.07108729568627*std::exp(0.766079843044281*x_19) + 0.0479144792911679*std::exp(0.825519859790802*x_19) - 0.00820111301063358*std::exp(0.880719900131226*x_19) + 0.247925947733482*std::exp(0.594239830970764*x_2) + 0.0667795927343231*std::exp(0.739439845085144*x_2) + 0.132042504632565*std::exp(0.749919831752777*x_2) + 2.48362311724081*std::exp(0.779519855976105*x_2) + 20.4707833859482*std::exp(0.884239912033081*x_2) + 0.0149252967275966*std::exp(0.947919845581055*x_2) + 0.00172475878351913*std::exp(1.33703982830048*x_2) + 2.57514701240558*std::exp(0.395839840173721*x_20) + 3.40345754006979*std::exp(0.457199841737747*x_20) + 0.108653895859313*std::exp(0.519039869308472*x_20) - 0.00688764630108479*std::exp(0.855199873447418*x_20) + 4.03719903653256*std::exp(0.866639912128448*x_20) + 0.000160634136606493*std::exp(1.17951989173889*x_20) - 6.90537932827214e-6*std::exp(1.35351979732513*x_20) - 0.0988127432167592*std::exp(1.0551198720932*x_21) - 0.19097317740877*std::exp(0.538959860801697*x_22) - 0.341706044894874*std::exp(0.831119894981384*x_22) - 0.331128003275365*std::exp(1.05791985988617*x_22) - 0.000404092550178691*std::exp(1.28927981853485*x_22) - 0.000117317375925011*std::exp(1.33255982398987*x_22) + 13.9809369968761*std::exp(0.619919836521149*x_23) - 0.0543775306428136*std::exp(0.693919837474823*x_23) - 14.2410761252041*std::exp(0.69735985994339*x_23) + 0.00947560297148426*std::exp(0.720719873905182*x_23) - 0.0221273709576256*std::exp(0.722399830818176*x_23) - 0.054558214898655*std::exp(0.726079881191254*x_23) - 2.02159509865195*std::exp(0.748559832572937*x_23) - 0.181515159276255*std::exp(0.811039865016937*x_23) - 0.0933621903357684*std::exp(0.972799837589264*x_23) + 7.57958874661192*std::exp(0.312959849834442*x_24) - 14.1276939969561*std::exp(0.446319848299026*x_24) + 0.225580500644909*std::exp(0.608799874782562*x_24) - 0.0565704331926201*std::exp(0.626559853553772*x_24) - 0.0209699400289209*std::exp(0.689279854297638*x_24) + 0.221276545094552*std::exp(0.733279824256897*x_24) - 0.0630385475310198*std::exp(0.44327986240387*x_25) - 0.0597019681114004*std::exp(0.543599843978882*x_25) - 48.4015676941927*std::exp(0.614479839801788*x_25) + 0.0570483268497035*std::exp(0.783199846744537*x_25) - 0.701885692417142*std::exp(0.797279894351959*x_25) - 0.00280884987574774*std::exp(0.822319865226746*x_25) + 0.475091141300484*std::exp(0.882079899311066*x_25) - 0.00823909111134657*std::exp(0.994239807128906*x_25) + 0.00362412462100404*std::exp(0.997759819030762*x_25) + 0.107435824858711*std::exp(0.439359873533249*x_26) - 0.177676073685457*std::exp(0.595519840717316*x_26) + 0.660986352723208*std::exp(0.669679820537567*x_26) + 4.20932234532097*std::exp(0.748879849910736*x_26) + 0.0109255891371503*std::exp(0.816239893436432*x_26) + 0.00867498791650081*std::exp(0.825599908828735*x_26) - 0.0029961481427901*std::exp(0.871999859809875*x_26) + 0.000582560867310418*std::exp(1.1651998758316*x_26) + 0.042235955386402*std::exp(1.19079983234406*x_27) - 0.00152522844532637*std::exp(1.22255980968475*x_27) + 0.00212470098724113*std::exp(1.22495996952057*x_27) - 0.0291724684559701*std::exp(1.26967978477478*x_27) - 0.000407491038004945*std::exp(1.42463982105255*x_27) - 36.7220497249269*std::exp(0.559919834136963*x_28) - 2.61490940159102*std::exp(0.587999820709229*x_28) + 0.0223511388656311*std::exp(0.67631983757019*x_28) - 0.021541958751205*std::exp(0.690719842910767*x_28) - 0.0249937456052361*std::exp(0.717759847640991*x_28) - 0.00361748888397932*std::exp(0.782079875469208*x_28) + 0.0377543506566068*std::exp(0.911999821662903*x_28) - 0.511222587762666*std::exp(1.1043199300766*x_29) - 0.00259703068695265*std::exp(1.13167989253998*x_29) - 0.00225904951489942*std::exp(1.13919985294342*x_29) + 0.0993573389589907*std::exp(1.14943981170654*x_29) - 0.103900654776895*std::exp(1.15047979354858*x_29) - 0.000160439897211865*std::exp(1.30935978889465*x_29) - 0.000518263871138023*std::exp(1.35751986503601*x_29) + 19.6586465798196*std::exp(0.411679863929749*x_3) + 4.83679806141324*std::exp(0.555839836597443*x_3) - 0.0467063852810979*std::exp(0.65151983499527*x_3) - 0.0275797518994352*std::exp(0.657999873161316*x_3) - 0.00779368223806854*std::exp(0.949759840965271*x_3) - 0.383540551230776*std::exp(0.983039796352386*x_3) - 0.0158063304450015*std::exp(0.6422398686409*x_30) - 1.97502203998724*std::exp(0.799999833106995*x_30) - 16.8821075432332*std::exp(0.843599855899811*x_30) + 0.745483062331695*std::exp(0.844959855079651*x_30) - 0.097385206710408*std::exp(0.928399801254272*x_30) + 0.015370235572203*std::exp(0.962799787521362*x_30) + 0.00284048555840985*std::exp(1.03063988685608*x_30) + 0.000581565603502736*std::exp(1.09807980060577*x_30) + 0.00547200265537032*std::exp(1.10879981517792*x_30) + 0.0040792174654143*std::exp(0.816479861736298*x_32) + 10.5216170565272*std::exp(0.830799877643585*x_32) + 0.00246294512346757*std::exp(0.873279869556427*x_32) + 26.0659284953972*std::exp(0.337679862976074*x_33) + 0.0678068508175346*std::exp(0.393599838018417*x_33) - 8.18293715477214*std::exp(0.417359858751297*x_33) + 0.0674378543506337*std::exp(0.425519853830338*x_33) - 9.48131283265775*std::exp(0.358959853649139*x_34) + 0.222380249866837*std::exp(0.365919858217239*x_34) - 3.96369105942447*std::exp(0.429999858140945*x_36) - 0.227162328269964*std::exp(0.381999850273132*x_4) + 7.13303252267071*std::exp(0.475839853286743*x_4) - 2.10998057054318*std::exp(0.60919988155365*x_4) + 0.0108235523538795*std::exp(0.61959981918335*x_4) - 0.0529576043557302*std::exp(0.755119860172272*x_4) - 0.00107014146857878*std::exp(0.894799828529358*x_4) - 0.0924579314922599*std::exp(1.16215980052948*x_4) - 0.458760336242747*std::exp(1.17103981971741*x_4) - 0.00120204239925045*std::exp(1.17639982700348*x_4) + 12.0069293253071*std::exp(0.683199822902679*x_41) + 0.0808842734912256*std::exp(0.767599880695343*x_41) + 0.0847989044909651*std::exp(0.7704798579216*x_41) - 0.0100397000962851*std::exp(0.784719884395599*x_41) - 0.0267648367646299*std::exp(0.803359866142273*x_41) + 3.77163690416327*std::exp(0.804319858551025*x_41) - 0.655251571269983*std::exp(0.808079898357391*x_41) + 0.00526933388251604*std::exp(0.808239877223969*x_41) - 3.25975300084233*std::exp(0.633279860019684*x_42) - 0.0138376040133219*std::exp(0.719839870929718*x_42) + 0.0588606636688074*std::exp(0.733519852161407*x_42) + 0.134513567768645*std::exp(0.816239893436432*x_42) + 0.00252908644166179*std::exp(0.75087982416153*x_43) - 0.00123435683811311*std::exp(0.821199893951416*x_43) - 0.000521684789587913*std::exp(0.844239890575409*x_44) + 0.0124494773934511*std::exp(0.897199809551239*x_44) + 0.00036915976779023*std::exp(0.97439980506897*x_44) - 1.26407144803147*std::exp(0.521199882030487*x_45) - 0.0147520721156331*std::exp(0.675519824028015*x_46) + 0.0523135777015849*std::exp(0.691119849681854*x_46) - 0.0576751619233743*std::exp(0.763439834117889*x_46) - 2.71934460093244*std::exp(0.766159892082214*x_46) - 10.5820032930705*std::exp(0.79447990655899*x_46) + 0.0129017898771285*std::exp(0.795199871063232*x_46) - 0.201415457607309*std::exp(0.484159857034683*x_47) + 6.29821121001179*std::exp(0.519519865512848*x_47) - 0.0134910245742633*std::exp(0.598719835281372*x_48) - 0.00660897607420538*std::exp(0.655999839305878*x_49) + 0.0905619116435304*std::exp(0.690879821777344*x_49) + 62.6312439266746*std::exp(0.702399849891663*x_49) + 2.95311166488731*std::exp(0.70719987154007*x_49) - 28.5898943467816*std::exp(0.710559844970703*x_49) - 0.082164860770753*std::exp(0.714879810810089*x_49) + 0.0274138638812638*std::exp(0.715039849281311*x_49) + 6.34606074774015*std::exp(0.717039823532104*x_49) + 0.402937984752354*std::exp(0.718959867954254*x_49) - 0.0407618958161246*std::exp(0.719279825687408*x_49) + 0.000534043887828619*std::exp(1.92919981479645*x_5) + 0.0173881367496089*std::exp(0.479759842157364*x_50) + 5.79419768179086*std::exp(0.541039824485779*x_50) + 45.5243645599195*std::exp(0.549919843673706*x_50) - 0.273603609193168*std::exp(0.552239894866943*x_50) - 10.9733590363341*std::exp(0.554079830646515*x_50) - 0.0317537177133503*std::exp(0.58679986000061*x_50) + 0.809137884455117*std::exp(0.61983984708786*x_50) + 0.00440050989320042*std::exp(0.667119860649109*x_50) + 0.0750425346869946*std::exp(0.485599845647812*x_51) + 28.1930441736115*std::exp(0.495279848575592*x_51) + 141.020915853953*std::exp(0.495439857244492*x_51) - 0.341098414821881*std::exp(0.495919853448868*x_51) - 200.122065055447*std::exp(0.495999842882156*x_51) - 0.679480682924263*std::exp(0.496239870786667*x_51) + 0.445154582058831*std::exp(0.497919857501984*x_51) + 0.243351235843638*std::exp(0.498719841241837*x_51) - 1.7502516268353*std::exp(0.504399836063385*x_51) - 2.95471475282306*std::exp(0.503519833087921*x_52) - 0.0200570683934487*std::exp(0.579199850559235*x_52) + 0.0289586652063959*std::exp(0.628959834575653*x_52) - 0.018367959762247*std::exp(0.709119856357574*x_52) - 0.470523206621666*std::exp(0.72111988067627*x_52) + 0.0311229267741959*std::exp(0.745919823646545*x_52) - 0.000983722159129637*std::exp(0.87967985868454*x_52) - 0.141713569969325*std::exp(0.467919856309891*x_54) + 0.128330894365386*std::exp(0.488959848880768*x_54) - 14.1085202251395*std::exp(0.515999853610992*x_54) - 0.204063495211719*std::exp(0.532239854335785*x_54) + 4.42787454251453*std::exp(0.533839821815491*x_54) + 0.0305057051353065*std::exp(0.533999860286713*x_54) + 26.5027019176303*std::exp(0.535999834537506*x_54) - 0.189066198962365*std::exp(0.537439823150635*x_54) - 0.0141279597482593*std::exp(0.61959981918335*x_55) - 5.20831148443154*std::exp(0.635919868946075*x_55) - 7.17141378041395*std::exp(0.65015983581543*x_55) - 0.374604019629175*std::exp(0.651679813861847*x_55) - 1.48151442521547*std::exp(0.652799844741821*x_55) - 2.24214461215784*std::exp(0.655679821968079*x_55) + 380.005525055162*std::exp(0.656159818172455*x_55) + 0.137091939816858*std::exp(0.656319856643677*x_55) - 68.3014481681218*std::exp(0.657199859619141*x_55) - 0.381731296194666*std::exp(0.659119844436646*x_55) + 103.670691800791*std::exp(0.402799874544144*x_56) - 13.6483413236008*std::exp(0.458079844713211*x_56) + 5.4194392494142*std::exp(0.521679878234863*x_56) - 0.54200999011476*std::exp(0.548719882965088*x_56) + 0.160522192303723*std::exp(0.656559824943542*x_56) + 0.00997634833043978*std::exp(0.671279847621918*x_56) + 0.00465414841158203*std::exp(0.737839818000793*x_56) + 0.00301490070701682*std::exp(0.840079843997955*x_56) - 5.92054827463503*std::exp(0.612879812717438*x_57) - 0.10149764258391*std::exp(0.620399832725525*x_57) + 0.303878599595137*std::exp(0.626639842987061*x_57) + 0.380949887909013*std::exp(0.628719866275787*x_57) + 0.0680615003323386*std::exp(0.631839871406555*x_57) - 220.863587801221*std::exp(0.63351982831955*x_57) + 0.0795712297038803*std::exp(0.639759838581085*x_57) + 28.0486021974544*std::exp(0.640399813652039*x_57) - 5.35893808513631*std::exp(0.644639849662781*x_57) - 0.203074939359098*std::exp(0.655679821968079*x_57) + 0.0995532652181569*std::exp(0.401999861001968*x_58) - 7.22006571846652*std::exp(0.521199882030487*x_58) - 28.0303259264791*std::exp(0.560399830341339*x_58) + 0.060408685292479*std::exp(0.562319815158844*x_58) + 0.0126135728660564*std::exp(0.610559821128845*x_58) - 0.0449456889984725*std::exp(0.612719833850861*x_58) - 1.3332285973134*std::exp(0.66023987531662*x_58) + 0.118835642448305*std::exp(0.671919822692871*x_58) + 0.356158968979866*std::exp(0.683759808540344*x_58) - 40.9624266107884*std::exp(0.516079843044281*x_59) - 3.77065443194012*std::exp(0.642879843711853*x_59) - 0.0114614066948253*std::exp(0.651439845561981*x_59) + 0.0327487259069435*std::exp(0.696319878101349*x_59) + 0.209614055333698*std::exp(0.784239888191223*x_59) + 0.00531675317676098*std::exp(0.914319813251495*x_59) + 5.00648036020928e-5*std::exp(1.11175990104675*x_59) - 0.0174057362631059*std::exp(0.776479840278625*x_60) - 0.0527046035104394*std::exp(0.789359867572784*x_60) - 24.0514912246249*std::exp(0.82287985086441*x_60) - 0.00624796000587051*std::exp(0.827119886875153*x_60) + 1.77841118054112*std::exp(0.83383983373642*x_60) - 0.00882895643338465*std::exp(0.855439901351929*x_60) - 0.969530224914546*std::exp(0.855599880218506*x_60) - 0.00888559777521344*std::exp(0.87527984380722*x_60) - 0.0807173210109057*std::exp(0.97055983543396*x_60) + 0.332054364334272*std::exp(1.06751978397369*x_61) + 0.0150970621083748*std::exp(1.41151988506317*x_61) + 0.00256808524503537*std::exp(1.48039984703064*x_61) + 0.174416285239691*std::exp(1.54959976673126*x_61) - 0.0657987034966739*std::exp(0.620399832725525*x_66) - 3.10102300617052*std::exp(0.898959815502167*x_66) - 23.609281920343*std::exp(0.940879821777344*x_66) + 4.79514411834388e-5*std::exp(1.60559988021851*x_7) + 0.000484731371854164*std::exp(1.86407995223999*x_7) - 0.0917462976304435*std::exp(0.557119846343994*x_8) - 2.76559167709191*std::exp(0.561599850654602*x_8) + 0.474909518504475*std::exp(0.82727986574173*x_8) + 0.113745453896358*std::exp(0.832399845123291*x_8) + 0.00135701609672183*std::exp(0.850879848003387*x_8) - 7.71160489349755e-7*std::exp(1.72775983810425*x_9) - 0.200439009593293*std::log(4.17511987686157 - 0.624479830265045*x_5) - 0.457576886199586*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 5.76176247236129*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 30.6950293162231*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 45.4596283486217*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 23.1447763256142*std::sin(0.24415996670723*x_108 - 1.1950398683548) - 1.5161993451359*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 2.62332637680605*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 16.9473816884249*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 23.9718178443903*std::sin(0.221279993653297*x_116 + 5.17928028106689) + 0.374021411525678*std::sin(0.239519983530045*x_117 - 7.43887996673584) - 1.44815874522611*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 31.5814540261727*std::sin(0.258879989385605*x_120 + 8.34255981445313) - 0.820958506279329*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 301.057016669997*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 0.577530331081047*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.216349041952162*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.340974654795732*std::sin(0.245119974017143*x_20 - 4.37967967987061) - 0.506394029951422*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 13.0001814935156*std::sin(0.416879862546921*x_22 + 2.00263977050781) - 2.60744793265266*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.142573175831925*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.296175935787702*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 23.9531081239534*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.277170933457695*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 11.0278154633136*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 30.166990514897*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.0646446919144616*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.0458790117389796*std::sin(0.57287985086441*x_64 + 5.36984014511108) - 0.243161272351262*std::sin(0.576239883899689*x_65 + 2.18959999084473) + 0.570253030947409*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 31.6333203464865*std::sin(0.219119995832443*x_9 - 7.589439868927) + 0.858646064228201*std::sin(0.327599853277206*x_9 - 4.33911991119385) + 0.361042194585052*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.154977868600546*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 1.73006246029659*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 156.681894398412*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.249321988631405*std::sin(0.381119847297668*x_91 - 1.19447994232178) + 0.501112142888143*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 17.4964457774593*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 2.72090064781997*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 15.9301534373135*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 27.7486044196621*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.0754495621057272*std::sin(0.279199957847595*x_95 - 1.19967985153198) - 1.33642983637859*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 33.0253647721406*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.11166636035171*std::sin(0.315439909696579*x_97 + 1.92727982997894) - 0.550959970242776*std::sin(0.236799985170364*x_98 + 5.18336009979248) + 1.24644600097049*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 1.87338439753399*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.192522937586712*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 1618.90713679162);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.15256110261826*x_1 + 2.33353702125649*x_10 - 17.3567252344175*x_100 + 8.30485155481848*x_101 - 22.1613191628995*x_102 - 10.3096543280162*x_103 - 3.71206335984241*x_104 - 9.94535827694802*x_105 - 3.48084218099758*x_106 + 2.63768709108272*x_107 - 4.83359986667186*x_108 + 6.26918160302535*x_109 - 6.34933222192185*x_110 - 8.26911025037024*x_111 + 5.19917395405972*x_112 + 2.31954947067249*x_113 - 4.20362258964038*x_114 + 8.76909987334393*x_115 + 4.0074045218643*x_116 - 16.2639929464753*x_117 - 19.5091875860979*x_118 + 4.67115734014951*x_119 + 5.9788787511762*x_12 - 1.45177295754944*x_120 + 3.43193061283533*x_13 + 5.25990398343944*x_14 - 1.99104067639471*x_15 - 2.36761988537491*x_16 + 1.81939061206189*x_17 + 62.3725380931196*x_18 - 9.69920875457443*x_19 - 1.74703156109325*x_2 + 1.02634051662053*x_20 - 2.63236998157115*x_21 - 0.476644668804699*x_22 - 0.00324038711240466*x_23 - 1.59441912775862*x_24 - 0.0310560922925914*x_25 - 5.53036597934733*x_26 - 0.709093936621052*x_27 + 2.17282107207676*x_28 + 4.57713244104182*x_29 + 3.39837214516857*x_3 + 0.0342930531668822*x_30 - 4.25247819994041*x_31 - 24.1888480267693*x_32 + 21.4634385006086*x_33 - 67.2698278998157*x_34 + 23.0285247859387*x_35 + 19.8969837820036*x_36 + 66.4313328040989*x_37 + 111.872904190661*x_38 + 61.546762923508*x_39 + 4.3701403744633*x_4 - 1784.7407331581*x_40 - 7.12828261564051*x_41 - 1.28718194618958*x_42 + 2.05996176190687*x_43 + 1.80201287804143*x_44 - 27.4659494185041*x_45 - 8.98816529781877*x_46 + 26.3480724052752*x_47 - 122.313968840505*x_48 + 22.4233841506437*x_5 + 0.0838203025562019*x_50 - 1.41307699162681*x_52 - 7.43276116516615*x_53 - 2.69547202385358*x_54 + 40.7795036604106*x_56 - 0.0145419353395589*x_58 + 3.29036717746115*x_59 + 4.80766564802946*x_6 - 2.86034449940198*x_60 + 8.38173586422644*x_61 + 4.35486521743939*x_62 + 6.42175199154407*x_63 + 7.68133697903935*x_64 - 2.70111214721552*x_65 + 1.27439289736356*x_66 + 1.84896353316494*x_67 + 2.15773603861254*x_68 + 5.51975912163564*x_69 + 3.19843432930359*x_7 - 10.1923395303109*x_70 - 6.45485526251609*x_71 - 5.71345742127511*x_72 + 4.82359209422504*x_73 - 3.88311826086246*x_74 - 10.3009359285391*x_75 - 3.03832501195965*x_76 + 7.27875188082138*x_77 + 4.71083649118018*x_78 - 8.90151816704437*x_79 + 0.701847654347531*x_8 - 4.43144265840651*x_80 - 4.42554017780947*x_81 + 0.886437506716785*x_82 + 21.4163933927536*x_83 + 6.42891191888344*x_84 + 1.58646267589392*x_85 + 261.448736568403*x_86 + 86.4898218885313*x_87 + 33.2718629925418*x_88 - 4.89878184107746*x_89 + 5.62293728825374*x_9 - 1.07620588443298*x_90 + 4.21020168069645*x_91 - 7.07338315071879*x_92 - 15.8323911188238*x_93 + 2.84086815171206*x_94 - 4.98639380040811*x_95 - 0.669930419418793*x_96 + 8.34898195242295*x_97 - 2.23609223287973*x_98 + 9.76725727435049*x_99 + 0.0275367473205148*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) - 3.3478476917327e-5*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) - 0.0121515890216987*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.00147642188626731*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) - 0.00065216747191905*std::exp(1.10463988780975*x_1) - 0.040225540517841*std::exp(1.27999985218048*x_1) + 0.00586094030840262*std::exp(1.32983994483948*x_1) - 0.364407875060799*std::exp(1.33063983917236*x_1) - 0.0879556820829776*std::exp(1.79583990573883*x_1) + 0.00973491153867817*std::exp(1.89927983283997*x_1) + 0.037046403333574*std::exp(0.68343985080719*x_10) - 1.89258354604549*std::exp(0.712479829788208*x_10) + 0.0197196200987578*std::exp(0.782719850540161*x_10) - 0.000587515777510026*std::exp(0.806639909744263*x_10) - 1.77691800156354*std::exp(0.807519853115082*x_10) + 0.0458594030856167*std::exp(0.83463990688324*x_10) - 0.00600779077340358*std::exp(0.860239923000336*x_10) + 0.302120181443096*std::exp(0.939199805259705*x_10) + 0.0142636091006399*std::exp(1.05287981033325*x_10) - 0.439370222309998*std::exp(0.837359845638275*x_11) - 0.0155723279374728*std::exp(0.884399890899658*x_11) - 0.000590484864055102*std::exp(0.896239876747131*x_11) - 2.41971374690222*std::exp(0.927199840545654*x_11) - 0.0159624864637236*std::exp(0.931759834289551*x_11) - 0.708754042812948*std::exp(0.933759808540344*x_11) - 0.010432296345415*std::exp(0.951039850711823*x_11) + 0.708018356824555*std::exp(0.958639860153198*x_11) - 0.0156761450910048*std::exp(0.975439846515656*x_11) - 0.0597575037059438*std::exp(1.01423990726471*x_11) + 1.12288390302787*std::exp(0.427279859781265*x_12) - 0.0990789481274311*std::exp(0.519439876079559*x_12) + 0.000223176301989009*std::exp(0.88239985704422*x_12) + 0.219475996660854*std::exp(0.905999839305878*x_12) + 0.000566448982402213*std::exp(0.997519791126251*x_12) + 0.0305586937488942*std::exp(1.23287987709045*x_12) + 0.0548199425849223*std::exp(0.619519829750061*x_13) + 0.000657235432814295*std::exp(1.07167983055115*x_13) - 2.72189789489795e-6*std::exp(1.30135977268219*x_13) + 25.9002124171128*std::exp(0.264079838991165*x_14) + 0.0401803498231498*std::exp(0.453439861536026*x_14) - 2.81834785785299*std::exp(0.619439840316772*x_14) + 8.26694617261285e-5*std::exp(0.899199843406677*x_14) + 0.907335448281765*std::exp(0.827359914779663*x_15) - 0.851070539619056*std::exp(0.876239895820618*x_15) + 0.000297479775449493*std::exp(0.927279829978943*x_15) + 0.0106454104110374*std::exp(0.928959846496582*x_15) - 1.25747527614028*std::exp(0.932479858398438*x_15) - 0.00170647950789336*std::exp(1.01999986171722*x_15) + 0.000547153278393154*std::exp(1.1373598575592*x_15) + 0.164310154059983*std::exp(0.38351982831955*x_16) + 0.00314337017028021*std::exp(0.547599852085114*x_16) - 4.46223462281679*std::exp(0.600879848003387*x_16) + 0.0286593007395836*std::exp(0.678639829158783*x_16) - 0.0026940006185289*std::exp(0.935519814491272*x_16) + 0.1702377897377*std::exp(0.628639817237854*x_17) + 0.203963382033426*std::exp(0.667199850082397*x_17) + 4.16996393077397*std::exp(0.677199840545654*x_17) + 6.75952953501443*std::exp(0.695839881896973*x_17) + 0.00219405660211701*std::exp(0.7151198387146*x_17) - 0.109385901505519*std::exp(0.693999886512756*x_19) - 10.2406451090268*std::exp(0.714319825172424*x_19) - 0.0183052793162871*std::exp(0.71535986661911*x_19) - 0.0019140561645127*std::exp(0.717759847640991*x_19) + 4.23605191302438*std::exp(0.728159844875336*x_19) - 8.27241707794557*std::exp(0.751519858837128*x_19) - 2.55589007451812*std::exp(0.766079843044281*x_19) - 0.0960716612158311*std::exp(0.825519859790802*x_19) - 0.0103330894486287*std::exp(0.880719900131226*x_19) - 2.09198899774044*std::exp(0.594239830970764*x_2) - 0.133897446120961*std::exp(0.739439845085144*x_2) - 0.00234019954660072*std::exp(0.749919831752777*x_2) - 1.04558991907593*std::exp(0.779519855976105*x_2) + 3.73954244102093*std::exp(0.884239912033081*x_2) + 0.0125965195214193*std::exp(0.947919845581055*x_2) + 0.00217313025247952*std::exp(1.33703982830048*x_2) - 1.08412091094605*std::exp(0.395839840173721*x_20) + 4.80411229879455*std::exp(0.457199841737747*x_20) - 0.916817125344485*std::exp(0.519039869308472*x_20) + 0.0138101808013233*std::exp(0.855199873447418*x_20) + 0.737503634097636*std::exp(0.866639912128448*x_20) + 0.000202392882515578*std::exp(1.17951989173889*x_20) - 3.0636223192045e-5*std::exp(1.35351979732513*x_20) + 0.0970709298873948*std::exp(1.0551198720932*x_21) + 0.00338463242899348*std::exp(0.538959860801697*x_22) - 0.482331333217761*std::exp(0.831119894981384*x_22) - 0.0604894887661569*std::exp(1.05791985988617*x_22) + 0.000810231962340546*std::exp(1.28927981853485*x_22) - 9.90124781444835e-5*std::exp(1.33255982398987*x_22) - 13.7344892045631*std::exp(0.619919836521149*x_23) - 0.045893065898133*std::exp(0.693919837474823*x_23) - 2.60151785947609*std::exp(0.69735985994339*x_23) + 0.0420392093921702*std::exp(0.720719873905182*x_23) - 0.0278796430523118*std::exp(0.722399830818176*x_23) + 0.109392785141886*std::exp(0.726079881191254*x_23) + 0.851078990580538*std::exp(0.748559832572937*x_23) + 1.53161748336738*std::exp(0.811039865016937*x_23) - 0.131784352104849*std::exp(0.972799837589264*x_23) + 10.6988834409423*std::exp(0.312959849834442*x_24) + 13.8786592579539*std::exp(0.446319848299026*x_24) - 0.00399798070174584*std::exp(0.608799874782562*x_24) + 0.11342741427884*std::exp(0.626559853553772*x_24) - 0.0930346810086925*std::exp(0.689279854297638*x_24) - 1.86712242920793*std::exp(0.733279824256897*x_24) - 0.0532027140946683*std::exp(0.44327986240387*x_25) - 0.0752222016638959*std::exp(0.543599843978882*x_25) - 8.84185588757805*std::exp(0.614479839801788*x_25) - 0.481371446595715*std::exp(0.783199846744537*x_25) + 0.689513261342534*std::exp(0.797279894351959*x_25) - 0.0124616690286712*std::exp(0.822319865226746*x_25) + 0.670609569268547*std::exp(0.882079899311066*x_25) + 0.000146022050527055*std::exp(0.994239807128906*x_25) - 0.00726660662797251*std::exp(0.997759819030762*x_25) + 0.090672734340369*std::exp(0.439359873533249*x_26) + 1.49922343631117*std::exp(0.595519840717316*x_26) - 0.278271152437153*std::exp(0.669679820537567*x_26) + 0.768946613399788*std::exp(0.748879849910736*x_26) - 0.000193635063317324*std::exp(0.816239893436432*x_26) + 0.0109301537475157*std::exp(0.825599908828735*x_26) - 0.0132926315637922*std::exp(0.871999859809875*x_26) - 0.00116807259746562*std::exp(1.1651998758316*x_26) + 0.0596176888749994*std::exp(1.19079983234406*x_27) + 0.00305818267554781*std::exp(1.22255980968475*x_27) - 0.0179281399523977*std::exp(1.22495996952057*x_27) + 0.0122814281765946*std::exp(1.26967978477478*x_27) + 7.22199525854681e-6*std::exp(1.42463982105255*x_27) - 6.70827593055908*std::exp(0.559919834136963*x_28) + 1.10086063002906*std::exp(0.587999820709229*x_28) + 0.0188637158902376*std::exp(0.67631983757019*x_28) + 0.000381789805053641*std::exp(0.690719842910767*x_28) + 0.0501140927716087*std::exp(0.717759847640991*x_28) - 0.016049255453728*std::exp(0.782079875469208*x_28) - 0.318569665307321*std::exp(0.911999821662903*x_28) - 0.0933886372447923*std::exp(1.1043199300766*x_29) + 4.60273762075842e-5*std::exp(1.13167989253998*x_29) + 0.00452954186032885*std::exp(1.13919985294342*x_29) + 0.140246736869412*std::exp(1.14943981170654*x_29) + 0.0437415308570657*std::exp(1.15047979354858*x_29) - 0.000202148148290291*std::exp(1.30935978889465*x_29) + 0.00437308932872415*std::exp(1.35751986503601*x_29) + 3.591183680285*std::exp(0.411679863929749*x_3) + 6.82732802746952*std::exp(0.555839836597443*x_3) - 0.0588482631937803*std::exp(0.65151983499527*x_3) - 0.122359597439196*std::exp(0.657999873161316*x_3) - 0.00657764279312778*std::exp(0.949759840965271*x_3) + 0.161468191828254*std::exp(0.983039796352386*x_3) - 0.019915373209833*std::exp(0.6422398686409*x_30) + 0.831472021913548*std::exp(0.799999833106995*x_30) - 3.08397370347514*std::exp(0.843599855899811*x_30) + 1.05227825119783*std::exp(0.844959855079651*x_30) + 0.821732387607359*std::exp(0.928399801254272*x_30) - 0.0308183264546588*std::exp(0.962799787521362*x_30) + 0.00239728780203494*std::exp(1.03063988685608*x_30) + 0.00258015856663798*std::exp(1.09807980060577*x_30) - 9.69807272948183e-5*std::exp(1.10879981517792*x_30) + 0.00344274176741812*std::exp(0.816479861736298*x_32) + 1.92205802724978*std::exp(0.830799877643585*x_32) + 0.0109270371583181*std::exp(0.873279869556427*x_32) - 25.6064535307568*std::exp(0.337679862976074*x_33) - 0.13595716568823*std::exp(0.393599838018417*x_33) + 3.44496575912329*std::exp(0.417359858751297*x_33) + 0.29919300001664*std::exp(0.425519853830338*x_33) + 3.99157386183687*std::exp(0.358959853649139*x_34) - 0.445886929010971*std::exp(0.365919858217239*x_34) + 1.66868933748284*std::exp(0.429999858140945*x_36) + 0.0040260155553807*std::exp(0.381999850273132*x_4) - 7.00729559115447*std::exp(0.475839853286743*x_4) - 2.97831939720809*std::exp(0.60919988155365*x_4) + 0.0480194859515714*std::exp(0.61959981918335*x_4) + 0.106183456435966*std::exp(0.755119860172272*x_4) - 0.00134833741507693*std::exp(0.894799828529358*x_4) + 0.0389242153673942*std::exp(1.16215980052948*x_4) - 0.083804987590968*std::exp(1.17103981971741*x_4) - 0.00101448908012231*std::exp(1.17639982700348*x_4) + 2.19339049961056*std::exp(0.683199822902679*x_41) - 0.682498188595291*std::exp(0.767599880695343*x_41) - 0.001502897558587*std::exp(0.7704798579216*x_41) - 0.0126496390182417*std::exp(0.784719884395599*x_41) - 0.0541507378588011*std::exp(0.803359866142273*x_41) - 3.70515269150678*std::exp(0.804319858551025*x_41) + 0.275856845035208*std::exp(0.808079898357391*x_41) + 0.0233777872617694*std::exp(0.808239877223969*x_41) + 3.20229197868603*std::exp(0.633279860019684*x_42) + 0.0277453000527909*std::exp(0.719839870929718*x_42) - 0.496663870484485*std::exp(0.733519852161407*x_42) - 0.0566293772438727*std::exp(0.816239893436432*x_42) + 0.00318655240954746*std::exp(0.75087982416153*x_43) - 0.0054763148834175*std::exp(0.821199893951416*x_43) + 0.00104601208461803*std::exp(0.844239890575409*x_44) - 0.00524115272160032*std::exp(0.897199809551239*x_44) + 0.000465127220715712*std::exp(0.97439980506897*x_44) - 1.78428586769397*std::exp(0.521199882030487*x_45) + 0.0295788683398226*std::exp(0.675519824028015*x_46) - 0.441419827108219*std::exp(0.691119849681854*x_46) + 0.00102218136621074*std::exp(0.763439834117889*x_46) + 2.67140958244349*std::exp(0.766159892082214*x_46) - 1.93308920715871*std::exp(0.79447990655899*x_46) + 0.0108887381614335*std::exp(0.795199871063232*x_46) + 0.00356970177052181*std::exp(0.484159857034683*x_47) - 6.18719002104747*std::exp(0.519519865512848*x_47) - 0.0598539226157055*std::exp(0.598719835281372*x_48) - 0.0055777849951481*std::exp(0.655999839305878*x_49) - 0.00160503578114661*std::exp(0.690879821777344*x_49) + 11.441291248214*std::exp(0.702399849891663*x_49) - 1.2432416840048*std::exp(0.70719987154007*x_49) + 28.0859283861453*std::exp(0.710559844970703*x_49) - 0.103524589257273*std::exp(0.714879810810089*x_49) + 0.12162362304764*std::exp(0.715039849281311*x_49) + 8.95771083616651*std::exp(0.717039823532104*x_49) - 3.39997422044659*std::exp(0.718959867954254*x_49) + 0.0817302640724634*std::exp(0.719279825687408*x_49) + 0.000753823657092226*std::exp(1.92919981479645*x_5) + 0.0771437473642901*std::exp(0.479759842157364*x_50) - 2.43932126543588*std::exp(0.541039824485779*x_50) + 8.3162568897674*std::exp(0.549919843673706*x_50) + 2.30865605398221*std::exp(0.552239894866943*x_50) + 10.7799270718408*std::exp(0.554079830646515*x_50) - 0.0400084726345219*std::exp(0.58679986000061*x_50) + 1.14212950106371*std::exp(0.61983984708786*x_50) + 0.00371390330025445*std::exp(0.667119860649109*x_50) + 0.3329317235557*std::exp(0.485599845647812*x_51) + 83.9920430632111*std::exp(0.495279848575592*x_51) - 138.535081507519*std::exp(0.495439857244492*x_51) + 0.00604531365058282*std::exp(0.495919853448868*x_51) - 36.5577096660256*std::exp(0.495999842882156*x_51) - 0.856119732305618*std::exp(0.496239870786667*x_51) + 0.375697614948274*std::exp(0.497919857501984*x_51) - 0.487935125922015*std::exp(0.498719841241837*x_51) + 14.7685515779608*std::exp(0.504399836063385*x_51) + 1.24391657407704*std::exp(0.503519833087921*x_52) - 0.0889846588679089*std::exp(0.579199850559235*x_52) + 0.024440277352218*std::exp(0.628959834575653*x_52) + 0.000325536774898388*std::exp(0.709119856357574*x_52) - 0.66416175233173*std::exp(0.72111988067627*x_52) - 0.2626139820552*std::exp(0.745919823646545*x_52) + 0.00197242719529729*std::exp(0.87967985868454*x_52) + 0.284144965889018*std::exp(0.467919856309891*x_54) + 0.108307569730648*std::exp(0.488959848880768*x_54) + 5.93959945777652*std::exp(0.515999853610992*x_54) + 0.00361663314628196*std::exp(0.532239854335785*x_54) + 6.25011662310237*std::exp(0.533839821815491*x_54) + 0.135340804136507*std::exp(0.533999860286713*x_54) - 26.0355277661847*std::exp(0.535999834537506*x_54) - 0.238216196150116*std::exp(0.537439823150635*x_54) - 0.0626797323535593*std::exp(0.61959981918335*x_55) - 7.35173363079398*std::exp(0.635919868946075*x_55) + 3.01912069599891*std::exp(0.65015983581543*x_55) - 0.316154977162782*std::exp(0.651679813861847*x_55) + 12.5009580718684*std::exp(0.652799844741821*x_55) + 0.0397377027903708*std::exp(0.655679821968079*x_55) + 69.4182905448392*std::exp(0.656159818172455*x_55) + 0.172730612903014*std::exp(0.656319856643677*x_55) + 67.0974701288405*std::exp(0.657199859619141*x_55) + 0.765396187249269*std::exp(0.659119844436646*x_55) + 18.9382567618382*std::exp(0.402799874544144*x_56) + 5.74586699608369*std::exp(0.458079844713211*x_56) + 7.64974865828552*std::exp(0.521679878234863*x_56) + 4.57345810856549*std::exp(0.548719882965088*x_56) - 0.00284494725917128*std::exp(0.656559824943542*x_56) + 0.012569818210705*std::exp(0.671279847621918*x_56) + 0.0206484716809621*std::exp(0.737839818000793*x_56) + 0.00254448915182095*std::exp(0.840079843997955*x_56) + 2.4925140808957*std::exp(0.612879812717438*x_57) - 0.0856610799450509*std::exp(0.620399832725525*x_57) - 0.00538566397973957*std::exp(0.626639842987061*x_57) - 0.763829412587393*std::exp(0.628719866275787*x_57) + 0.0857548932724189*std::exp(0.631839871406555*x_57) - 40.3467099762171*std::exp(0.63351982831955*x_57) + 0.353023612025602*std::exp(0.639759838581085*x_57) - 27.5541778187041*std::exp(0.640399813652039*x_57) - 7.56434891876274*std::exp(0.644639849662781*x_57) + 1.71353802512324*std::exp(0.655679821968079*x_57) + 0.0840200815855728*std::exp(0.401999861001968*x_58) + 7.09279461660343*std::exp(0.521199882030487*x_58) - 5.12049741631627*std::exp(0.560399830341339*x_58) - 0.121123360490794*std::exp(0.562319815158844*x_58) + 0.0559610435869159*std::exp(0.610559821128845*x_58) - 0.0566298530637593*std::exp(0.612719833850861*x_58) - 1.88190386571608*std::exp(0.66023987531662*x_58) - 1.00273028625675*std::exp(0.671919822692871*x_58) - 0.14994071562981*std::exp(0.683759808540344*x_58) - 7.48289549599731*std::exp(0.516079843044281*x_59) + 3.7041875377302*std::exp(0.642879843711853*x_59) - 0.0144409350817606*std::exp(0.651439845561981*x_59) - 0.0656633349068229*std::exp(0.696319878101349*x_59) + 0.295878367622641*std::exp(0.784239888191223*x_59) - 0.0448625456559397*std::exp(0.914319813251495*x_59) + 0.00022211618280547*std::exp(1.11175990104675*x_59) + 0.0348996383185042*std::exp(0.776479840278625*x_60) + 0.000934087774100602*std::exp(0.789359867572784*x_60) - 4.39365560704756*std::exp(0.82287985086441*x_60) - 0.027719534023443*std::exp(0.827119886875153*x_60) - 1.7470623868682*std::exp(0.83383983373642*x_60) - 0.00745138432398852*std::exp(0.855439901351929*x_60) + 0.408166207816699*std::exp(0.855599880218506*x_60) - 0.0111955141328706*std::exp(0.87527984380722*x_60) - 0.113935628703712*std::exp(0.97055983543396*x_60) + 0.468707611828756*std::exp(1.06751978397369*x_61) - 0.0302705958133514*std::exp(1.41151988506317*x_61) + 0.00216738980217018*std::exp(1.48039984703064*x_61) - 0.0734281736642459*std::exp(1.54959976673126*x_61) - 0.0555322060396585*std::exp(0.620399832725525*x_66) + 3.0463599836597*std::exp(0.898959815502167*x_66) - 4.31287411324738*std::exp(0.940879821777344*x_66) - 8.49847109675767e-7*std::exp(1.60559988021851*x_7) - 0.000204068899323834*std::exp(1.86407995223999*x_7) + 0.00162602674581581*std::exp(0.557119846343994*x_8) + 2.71684144215338*std::exp(0.561599850654602*x_8) - 0.19993396001771*std::exp(0.82727986574173*x_8) + 0.160556119053054*std::exp(0.832399845123291*x_8) + 0.00170978849974077*std::exp(0.850879848003387*x_8) - 3.4213102199727e-6*std::exp(1.72775983810425*x_9) - 0.252545503572087*std::log(4.17511987686157 - 0.624479830265045*x_5) - 0.57652941601887*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 8.13295116225723*std::sin(0.217600002884865*x_101 + 8.20775985717773) - 12.9224168497991*std::sin(0.298079937696457*x_103 - 7.48615980148315) - 44.6582925691678*std::sin(0.270719945430756*x_107 - 7.4443998336792) - 9.74380719737161*std::sin(0.24415996670723*x_108 - 1.1950398683548) + 0.0268717185418207*std::sin(0.285119920969009*x_113 - 7.42575979232788) - 22.1355205775397*std::sin(0.304159939289093*x_113 - 1.22191989421844) + 7.13474251593988*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 33.8371504785503*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 0.749937364803741*std::sin(0.239519983530045*x_117 - 7.43887996673584) + 0.0256658297145646*std::sin(0.269199967384338*x_117 + 1.93663990497589) - 13.2955961515656*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 1.64607543803697*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 54.9962094649194*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 0.487418925228004*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.959848434320554*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.287772764175743*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 1.01535311260661*std::sin(0.412479877471924*x_21 - 7.41631984710693) - 5.47299573007616*std::sin(0.416879862546921*x_22 + 2.00263977050781) + 0.0462120018607543*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.179636761124517*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.249963938742087*std::sin(0.3504798412323*x_35 + 1.83119988441467) + 10.0841098679921*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.233924265479718*std::sin(0.282319933176041*x_42 + 5.11696004867554) - 4.64264187179909*std::sin(0.476879835128784*x_5 - 4.28232002258301) - 12.700115791432*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.286800929467257*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.203545609393413*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.487554236709549*std::sin(0.576239883899689*x_65 + 2.18959999084473) - 0.0101066386780859*std::sin(0.582639873027802*x_65 - 7.20071983337402) + 13.317431550537*std::sin(0.219119995832443*x_9 - 7.589439868927) - 0.0152178507654706*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 0.723913186909849*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.19526620066458*std::sin(0.474319845438004*x_9 - 1.12655985355377) + 14.5981962171822*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 28.622187182373*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.314136191843462*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 1.00476258398081*std::sin(0.383759826421738*x_91 + 8.19527912139893) + 7.36589508994987*std::sin(0.390719830989838*x_91 - 4.39071989059448) - 22.9588482820005*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 22.4860293242597*std::sin(0.311039924621582*x_92 + 8.22056007385254) + 11.6819902537618*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.334737530630558*std::sin(0.279199957847595*x_95 - 1.19967985153198) + 0.0236856496009356*std::sin(0.301439940929413*x_97 - 7.45655965805054) - 13.903473614756*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.495416019330297*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 1.10471073436887*std::sin(0.236799985170364*x_98 + 5.18336009979248) - 0.0220908591097266*std::sin(0.26079997420311*x_98 + 1.96743977069855) - 15.8075408564846*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.242571554911737*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 488.891691542541);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.65790373796822*x_1 + 0.251251881992078*x_10 + 10.2402249941302*x_100 - 7.32003020777285*x_101 + 4.98434886966423*x_102 + 3.69301012575123*x_103 - 59.5831748369933*x_104 + 1.77801467068118*x_105 + 2.18318407940547*x_106 - 2.48984932848568*x_107 - 2.7734502204177*x_108 - 7.00017390055593*x_109 + 1.38353168597163*x_110 + 1.24853515450575*x_111 - 5.78482035000833*x_112 + 1.63793687032715*x_113 + 11.1391907930446*x_114 + 1.00362579490681*x_115 - 7.53281833793956*x_116 + 9.53162990579432*x_117 + 4.0174897506475*x_118 - 9.48804314402794*x_119 - 0.838318338761777*x_12 + 4.27936522047732*x_120 - 2.82287774976769*x_13 - 3.1646441507916*x_14 + 2.69646569212578*x_15 - 0.300785086795872*x_16 + 1.56572378944343*x_17 - 16.14309688581*x_18 + 7.72419875667718*x_19 + 1.60691071834539*x_2 - 0.811786966945448*x_20 - 1.22842124879575*x_21 + 0.149128277100146*x_22 + 0.0105876246879855*x_23 - 1.07584618332101*x_24 + 0.053616979465901*x_25 + 4.06878198475198*x_26 + 12.7677489774853*x_27 - 1.41942089323084*x_28 - 3.80465724157146*x_29 - 3.29900111951586*x_3 - 0.027310099755237*x_30 + 0.0564220260719991*x_31 + 12.4968268237656*x_32 + 1.21900069532158*x_33 + 9.3571163648841*x_34 - 40.3709456988053*x_35 + 19.7727130438746*x_36 - 223.203140513659*x_37 - 117.981884020608*x_38 - 61.5170558645546*x_39 - 0.293815858094885*x_4 - 74.5589861546373*x_40 + 0.774739765008232*x_41 - 1.77935972448028*x_42 - 10.9148231975022*x_43 - 8.09475389380957*x_44 + 45.1511917693599*x_45 - 5.25450211415057*x_46 + 21.8374301675464*x_47 + 30.3825893385164*x_48 - 4.56871271490996*x_5 - 0.00537906741867043*x_50 - 4.97936221734764*x_52 + 2.48080270324253*x_53 + 0.0438768720210547*x_54 - 32.4757410054813*x_56 + 0.0475142469931461*x_58 - 5.75699426089858*x_59 - 0.76862485759665*x_6 + 0.192308370332838*x_60 + 0.244109249045422*x_61 - 1.31369901669717*x_62 - 1.95253534518835*x_63 + 0.138360095630721*x_64 - 0.00650542995677234*x_65 - 0.214490678764749*x_66 - 0.202436276578571*x_67 + 0.178214660706533*x_68 + 5.37492636977258*x_69 + 4.94984365568897*x_7 + 5.19630325230847*x_70 + 1.53738634269269*x_71 + 3.70289273704979*x_72 + 4.69674932307598*x_73 - 1.40563634895461*x_74 + 4.9060956904231*x_75 + 3.34929426907449*x_76 - 4.16192782610536*x_77 - 5.58272461874786*x_78 + 4.21577986660492*x_79 - 0.0439998398408571*x_8 - 0.0156450446049189*x_80 + 1.25934983271809*x_81 - 4.06133320517666*x_82 - 7.30151427686116*x_83 - 2.41869400413642*x_84 - 2.32293508997644*x_85 - 60.8485580716207*x_86 - 33.998245358563*x_87 - 4.27001789324467*x_88 + 3.09873633365293*x_89 - 3.17709685924357*x_9 - 0.161071196995444*x_90 - 0.571788211537146*x_91 - 0.75827951714663*x_92 + 6.29595529285766*x_93 + 2.66250238142928*x_94 + 3.95340665076431*x_95 - 1.55178543215971*x_96 - 5.12379454314982*x_97 - 9.04729731848579*x_98 - 21.2656938370958*x_99 - 0.00185136685548979*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) + 0.000109387408488674*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.000816982808261685*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.000119021125541984*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) + 0.00213088874473*std::exp(1.10463988780975*x_1) - 0.00324276492545931*std::exp(1.27999985218048*x_1) + 0.0124837572616368*std::exp(1.32983994483948*x_1) + 0.0396057910038945*std::exp(1.33063983917236*x_1) - 0.00947018643970167*std::exp(1.79583990573883*x_1) - 0.016806897247539*std::exp(1.89927983283997*x_1) + 0.0215625443888893*std::exp(0.68343985080719*x_10) + 1.50720454040931*std::exp(0.712479829788208*x_10) + 0.0420026374013152*std::exp(0.782719850540161*x_10) + 0.00191964612090129*std::exp(0.806639909744263*x_10) + 0.193124923519399*std::exp(0.807519853115082*x_10) + 0.00369693637211863*std::exp(0.83463990688324*x_10) + 0.00403560025239797*std::exp(0.860239923000336*x_10) - 0.0203123224318366*std::exp(0.939199805259705*x_10) - 0.0246254947033723*std::exp(1.05287981033325*x_10) + 0.0295399982215003*std::exp(0.837359845638275*x_11) - 0.00906374120496042*std::exp(0.884399890899658*x_11) + 0.00192934729946884*std::exp(0.896239876747131*x_11) + 0.262987392720507*std::exp(0.927199840545654*x_11) + 0.01072244637531*std::exp(0.931759834289551*x_11) - 0.0763115328808293*std::exp(0.933759808540344*x_11) - 0.0222207100575498*std::exp(0.951039850711823*x_11) - 0.563847490024335*std::exp(0.958639860153198*x_11) - 0.00126372580239103*std::exp(0.975439846515656*x_11) + 0.103168705803319*std::exp(1.01423990726471*x_11) - 0.0754943935981883*std::exp(0.427279859781265*x_12) - 0.0576680601829448*std::exp(0.519439876079559*x_12) - 0.000729205135913111*std::exp(0.88239985704422*x_12) - 0.174785001892934*std::exp(0.905999839305878*x_12) - 0.000380499545102814*std::exp(0.997519791126251*x_12) + 0.00329025391313271*std::exp(1.23287987709045*x_12) + 0.00441928647176871*std::exp(0.619519829750061*x_13) + 0.00139990635892292*std::exp(1.07167983055115*x_13) + 8.89351560493382e-6*std::exp(1.30135977268219*x_13) + 2.78867532613228*std::exp(0.264079838991165*x_14) + 0.0855838325397592*std::exp(0.453439861536026*x_14) + 2.24445927192203*std::exp(0.619439840316772*x_14) - 0.000270113786887795*std::exp(0.899199843406677*x_14) - 0.722578461691709*std::exp(0.827359914779663*x_15) + 0.0924988844330003*std::exp(0.876239895820618*x_15) - 0.000971983934471379*std::exp(0.927279829978943*x_15) + 0.000858175255164579*std::exp(0.928959846496582*x_15) - 0.135392336530677*std::exp(0.932479858398438*x_15) - 0.00363478807623352*std::exp(1.01999986171722*x_15) - 0.000367538083742694*std::exp(1.1373598575592*x_15) + 0.0132457935337428*std::exp(0.38351982831955*x_16) - 0.0102706320152096*std::exp(0.547599852085114*x_16) + 0.484979452905999*std::exp(0.600879848003387*x_16) + 0.0610440876199132*std::exp(0.678639829158783*x_16) - 0.00156802017722676*std::exp(0.935519814491272*x_16) + 0.0990854595204081*std::exp(0.628639817237854*x_17) + 0.0164424217256373*std::exp(0.667199850082397*x_17) + 0.448979928710068*std::exp(0.677199840545654*x_17) - 5.38311432934738*std::exp(0.695839881896973*x_17) - 0.00716884959777937*std::exp(0.7151198387146*x_17) - 0.0636671348496026*std::exp(0.693999886512756*x_19) - 1.10261004347406*std::exp(0.714319825172424*x_19) - 0.038990102537535*std::exp(0.71535986661911*x_19) + 0.00625397756459622*std::exp(0.717759847640991*x_19) - 0.284800743480142*std::exp(0.728159844875336*x_19) + 0.899090399271685*std::exp(0.751519858837128*x_19) + 4.41263196771313*std::exp(0.766079843044281*x_19) - 0.00774477631153599*std::exp(0.825519859790802*x_19) + 0.0069410237406308*std::exp(0.880719900131226*x_19) + 0.140649839553873*std::exp(0.594239830970764*x_2) - 0.0107940859538495*std::exp(0.739439845085144*x_2) + 0.00764635632562289*std::exp(0.749919831752777*x_2) + 1.80516507655476*std::exp(0.779519855976105*x_2) + 0.402636455962396*std::exp(0.884239912033081*x_2) + 0.026830488585837*std::exp(0.947919845581055*x_2) - 0.00145975206630434*std::exp(1.33703982830048*x_2) + 1.87168714186927*std::exp(0.395839840173721*x_20) - 0.522136541735139*std::exp(0.457199841737747*x_20) + 0.061639990324626*std::exp(0.519039869308472*x_20) + 0.00111330188085155*std::exp(0.855199873447418*x_20) + 0.0794070007696959*std::exp(0.866639912128448*x_20) - 0.000135952931546698*std::exp(1.17951989173889*x_20) - 1.78315534854557e-5*std::exp(1.35351979732513*x_20) - 0.0773047755665727*std::exp(1.0551198720932*x_21) - 0.0110589311159106*std::exp(0.538959860801697*x_22) + 0.0524223412429417*std::exp(0.831119894981384*x_22) - 0.00651290198303869*std::exp(1.05791985988617*x_22) + 6.53165067551715e-5*std::exp(1.28927981853485*x_22) - 0.000210895808178899*std::exp(1.33255982398987*x_22) + 10.9377916407303*std::exp(0.619919836521149*x_23) - 0.097751873337325*std::exp(0.693919837474823*x_23) - 0.28010537320613*std::exp(0.69735985994339*x_23) + 0.0244685647464993*std::exp(0.720719873905182*x_23) + 0.018727532096617*std::exp(0.722399830818176*x_23) + 0.00881865307935592*std::exp(0.726079881191254*x_23) - 1.46935050076156*std::exp(0.748559832572937*x_23) - 0.102974611016696*std::exp(0.811039865016937*x_23) + 0.0143230261041354*std::exp(0.972799837589264*x_23) - 1.16281170231651*std::exp(0.312959849834442*x_24) - 11.0526049389414*std::exp(0.446319848299026*x_24) + 0.013062982202914*std::exp(0.608799874782562*x_24) + 0.00914390299978264*std::exp(0.626559853553772*x_24) - 0.0541500458463684*std::exp(0.689279854297638*x_24) + 0.12553147764122*std::exp(0.733279824256897*x_24) - 0.113321367130443*std::exp(0.44327986240387*x_25) + 0.0505288462049371*std::exp(0.543599843978882*x_25) - 0.952002437424601*std::exp(0.614479839801788*x_25) + 0.0323638493331615*std::exp(0.783199846744537*x_25) - 0.549110511046848*std::exp(0.797279894351959*x_25) - 0.00725320860896775*std::exp(0.822319865226746*x_25) - 0.0728854238982362*std::exp(0.882079899311066*x_25) - 0.000477111719532552*std::exp(0.994239807128906*x_25) - 0.000585794418097333*std::exp(0.997759819030762*x_25) + 0.193132218755279*std::exp(0.439359873533249*x_26) - 0.100796675317284*std::exp(0.595519840717316*x_26) + 0.480422923966346*std::exp(0.669679820537567*x_26) + 0.0827924656897467*std::exp(0.748879849910736*x_26) + 0.000632682240029264*std::exp(0.816239893436432*x_26) - 0.00734208844580544*std::exp(0.825599908828735*x_26) - 0.00773686329435556*std::exp(0.871999859809875*x_26) - 9.41636781181768e-5*std::exp(1.1651998758316*x_26) - 0.00647956832800193*std::exp(1.19079983234406*x_27) + 0.000246534102171115*std::exp(1.22255980968475*x_27) + 0.00120535529131735*std::exp(1.22495996952057*x_27) - 0.0212033463886085*std::exp(1.26967978477478*x_27) - 2.35971112843864e-5*std::exp(1.42463982105255*x_27) - 0.722279928332824*std::exp(0.559919834136963*x_28) - 1.90058753171492*std::exp(0.587999820709229*x_28) + 0.0401795680956851*std::exp(0.67631983757019*x_28) - 0.00124745810466064*std::exp(0.690719842910767*x_28) + 0.00403992638057678*std::exp(0.717759847640991*x_28) - 0.00934133281478386*std::exp(0.782079875469208*x_28) + 0.0214182638439311*std::exp(0.911999821662903*x_28) - 0.0100551526076905*std::exp(1.1043199300766*x_29) - 0.000150389619435617*std::exp(1.13167989253998*x_29) + 0.00036514710017531*std::exp(1.13919985294342*x_29) - 0.0152427632045586*std::exp(1.14943981170654*x_29) - 0.0755178320464307*std::exp(1.15047979354858*x_29) + 0.000135788536756901*std::exp(1.30935978889465*x_29) - 0.00029401412392902*std::exp(1.35751986503601*x_29) + 0.386662671314726*std::exp(0.411679863929749*x_3) - 0.742030415577256*std::exp(0.555839836597443*x_3) + 0.0395300160666977*std::exp(0.65151983499527*x_3) - 0.0712183643694825*std::exp(0.657999873161316*x_3) - 0.0140103279785052*std::exp(0.949759840965271*x_3) - 0.278767742061256*std::exp(0.983039796352386*x_3) + 0.0133777104069604*std::exp(0.6422398686409*x_30) - 1.43549993042895*std::exp(0.799999833106995*x_30) - 0.332051383780913*std::exp(0.843599855899811*x_30) - 0.11436721143288*std::exp(0.844959855079651*x_30) - 0.055247197092351*std::exp(0.928399801254272*x_30) - 0.00248440634487429*std::exp(0.962799787521362*x_30) + 0.00510620436860305*std::exp(1.03063988685608*x_30) + 0.00150175937789578*std::exp(1.09807980060577*x_30) + 0.000316874344622187*std::exp(1.10879981517792*x_30) + 0.00733301318174661*std::exp(0.816479861736298*x_32) + 0.206947947362953*std::exp(0.830799877643585*x_32) + 0.00635998916396146*std::exp(0.873279869556427*x_32) + 20.3923166858225*std::exp(0.337679862976074*x_33) - 0.0109601293750947*std::exp(0.393599838018417*x_33) - 5.94758209202351*std::exp(0.417359858751297*x_33) + 0.174142744320259*std::exp(0.425519853830338*x_33) - 6.89127697620185*std::exp(0.358959853649139*x_34) - 0.0359449860835616*std::exp(0.365919858217239*x_34) - 2.8809188580409*std::exp(0.429999858140945*x_36) - 0.0131545831438423*std::exp(0.381999850273132*x_4) + 5.58042880222962*std::exp(0.475839853286743*x_4) + 0.323699633464256*std::exp(0.60919988155365*x_4) + 0.0279493339215478*std::exp(0.61959981918335*x_4) + 0.00855993440391111*std::exp(0.755119860172272*x_4) + 0.000905715764385617*std::exp(0.894799828529358*x_4) - 0.0672009484135178*std::exp(1.16215980052948*x_4) - 0.00902328125105802*std::exp(1.17103981971741*x_4) - 0.00216085384842963*std::exp(1.17639982700348*x_4) + 0.236162308954482*std::exp(0.683199822902679*x_41) + 0.0458861212106847*std::exp(0.767599880695343*x_41) + 0.0049105599864581*std::exp(0.7704798579216*x_41) + 0.00849711455344825*std::exp(0.784719884395599*x_41) - 0.0698191182772764*std::exp(0.803359866142273*x_41) + 2.95068768362554*std::exp(0.804319858551025*x_41) - 0.476254728265005*std::exp(0.808079898357391*x_41) + 0.0136068425052501*std::exp(0.808239877223969*x_41) - 2.55022243011505*std::exp(0.633279860019684*x_42) + 0.00223667562198772*std::exp(0.719839870929718*x_42) + 0.0333919986057764*std::exp(0.733519852161407*x_42) + 0.0977681328431591*std::exp(0.816239893436432*x_42) - 0.00214049593157915*std::exp(0.75087982416153*x_43) - 0.00318744256218281*std::exp(0.821199893951416*x_43) + 8.43238215307884e-5*std::exp(0.844239890575409*x_44) + 0.00904862000035766*std::exp(0.897199809551239*x_44) - 0.000312438898109976*std::exp(0.97439980506897*x_44) + 0.193925702498332*std::exp(0.521199882030487*x_45) + 0.00238448795348352*std::exp(0.675519824028015*x_46) + 0.0296777984615254*std::exp(0.691119849681854*x_46) - 0.00333987029730542*std::exp(0.763439834117889*x_46) - 2.12744143335957*std::exp(0.766159892082214*x_46) - 0.208135674271702*std::exp(0.79447990655899*x_46) + 0.0231929275747743*std::exp(0.795199871063232*x_46) - 0.0116636257592925*std::exp(0.484159857034683*x_47) + 4.92731795728808*std::exp(0.519519865512848*x_47) - 0.0348374672604361*std::exp(0.598719835281372*x_48) - 0.0118806386472151*std::exp(0.655999839305878*x_49) + 0.00524428590538285*std::exp(0.690879821777344*x_49) + 1.23188358802442*std::exp(0.702399849891663*x_49) + 2.14640216851556*std::exp(0.70719987154007*x_49) - 22.3669062714081*std::exp(0.710559844970703*x_49) + 0.0695403475742815*std::exp(0.714879810810089*x_49) + 0.0707899967262294*std::exp(0.715039849281311*x_49) - 0.973571779126178*std::exp(0.717039823532104*x_49) + 0.22858907437354*std::exp(0.718959867954254*x_49) + 0.00658865065008046*std::exp(0.719279825687408*x_49) - 8.19295746877176e-5*std::exp(1.92919981479645*x_5) + 0.0449008628959202*std::exp(0.479759842157364*x_50) + 4.21138103813569*std::exp(0.541039824485779*x_50) + 0.895411204386451*std::exp(0.549919843673706*x_50) - 0.155216927014625*std::exp(0.552239894866943*x_50) - 8.58485484665054*std::exp(0.554079830646515*x_50) + 0.0268748044583556*std::exp(0.58679986000061*x_50) - 0.124132724384632*std::exp(0.61983984708786*x_50) + 0.00791058513718335*std::exp(0.667119860649109*x_50) + 0.193780081780118*std::exp(0.485599845647812*x_51) - 25.5545788590728*std::exp(0.495279848575592*x_51) + 110.325752482838*std::exp(0.495439857244492*x_51) - 0.0197524276678253*std::exp(0.495919853448868*x_51) - 3.93616783073927*std::exp(0.495999842882156*x_51) + 0.575079449016516*std::exp(0.496239870786667*x_51) + 0.800232997095382*std::exp(0.497919857501984*x_51) - 0.0393346836828136*std::exp(0.498719841241837*x_51) - 0.992927980083482*std::exp(0.504399836063385*x_51) - 2.14756733658642*std::exp(0.503519833087921*x_52) - 0.0517927648601333*std::exp(0.579199850559235*x_52) + 0.0520576006267713*std::exp(0.628959834575653*x_52) - 0.00106365723452209*std::exp(0.709119856357574*x_52) + 0.0721846407716686*std::exp(0.72111988067627*x_52) + 0.0176562183073443*std::exp(0.745919823646545*x_52) + 0.000159006383620757*std::exp(0.87967985868454*x_52) + 0.0229062261754337*std::exp(0.467919856309891*x_54) + 0.230694280946144*std::exp(0.488959848880768*x_54) - 10.2544576169762*std::exp(0.515999853610992*x_54) - 0.0118169691023569*std::exp(0.532239854335785*x_54) - 0.679296002270146*std::exp(0.533839821815491*x_54) + 0.0787739654655393*std::exp(0.533999860286713*x_54) + 20.7340202989395*std::exp(0.535999834537506*x_54) + 0.160016448236606*std::exp(0.537439823150635*x_54) - 0.0364822058159818*std::exp(0.61959981918335*x_55) + 0.799025612849199*std::exp(0.635919868946075*x_55) - 5.21237929219662*std::exp(0.65015983581543*x_55) - 0.673407641825003*std::exp(0.651679813861847*x_55) - 0.840471794534812*std::exp(0.652799844741821*x_55) - 0.129838771885172*std::exp(0.655679821968079*x_55) + 7.47426588272955*std::exp(0.656159818172455*x_55) - 0.116027959581114*std::exp(0.656319856643677*x_55) - 53.4346881750474*std::exp(0.657199859619141*x_55) + 0.0617020897206188*std::exp(0.659119844436646*x_55) + 2.03908170717556*std::exp(0.402799874544144*x_56) - 9.91998702993007*std::exp(0.458079844713211*x_56) - 0.831415475150831*std::exp(0.521679878234863*x_56) - 0.307485436047167*std::exp(0.548719882965088*x_56) + 0.00929556648398895*std::exp(0.656559824943542*x_56) - 0.00844349669570464*std::exp(0.671279847621918*x_56) + 0.0120182675541938*std::exp(0.737839818000793*x_56) + 0.00541974209849245*std::exp(0.840079843997955*x_56) - 4.30321609798071*std::exp(0.612879812717438*x_57) - 0.182457433881482*std::exp(0.620399832725525*x_57) + 0.0175970916236517*std::exp(0.626639842987061*x_57) - 0.0615757848443082*std::exp(0.628719866275787*x_57) - 0.0576039482710672*std::exp(0.631839871406555*x_57) - 4.3441294144349*std::exp(0.63351982831955*x_57) + 0.205474394803921*std::exp(0.639759838581085*x_57) + 21.9434338855855*std::exp(0.640399813652039*x_57) + 0.82213377608008*std::exp(0.644639849662781*x_57) - 0.115205600298739*std::exp(0.655679821968079*x_57) + 0.178962120141961*std::exp(0.401999861001968*x_58) - 5.64851801267769*std::exp(0.521199882030487*x_58) - 0.551323849103668*std::exp(0.560399830341339*x_58) - 0.00976430844674676*std::exp(0.562319815158844*x_58) + 0.0325716500877666*std::exp(0.610559821128845*x_58) + 0.038039848246562*std::exp(0.612719833850861*x_58) + 0.204535347054552*std::exp(0.66023987531662*x_58) + 0.0674161546882666*std::exp(0.671919822692871*x_58) + 0.258866060651934*std::exp(0.683759808540344*x_58) - 0.805683200649217*std::exp(0.516079843044281*x_59) - 2.94991906014401*std::exp(0.642879843711853*x_59) + 0.00970037796902168*std::exp(0.651439845561981*x_59) - 0.00529342195489189*std::exp(0.696319878101349*x_59) - 0.0321576387137095*std::exp(0.784239888191223*x_59) + 0.00301622515954987*std::exp(0.914319813251495*x_59) + 0.000129280837551459*std::exp(1.11175990104675*x_59) + 0.00281341957357333*std::exp(0.776479840278625*x_60) - 0.00305203373385652*std::exp(0.789359867572784*x_60) - 0.473064806789028*std::exp(0.82287985086441*x_60) - 0.016133919329171*std::exp(0.827119886875153*x_60) + 1.39131525652754*std::exp(0.83383983373642*x_60) - 0.0158713906419551*std::exp(0.855439901351929*x_60) - 0.704681032532975*std::exp(0.855599880218506*x_60) + 0.00752033840132243*std::exp(0.87527984380722*x_60) + 0.0123831316696535*std::exp(0.97055983543396*x_60) - 0.0509416425562346*std::exp(1.06751978397369*x_61) - 0.00244025127102406*std::exp(1.41151988506317*x_61) + 0.00461652341738557*std::exp(1.48039984703064*x_61) + 0.126770517117303*std::exp(1.54959976673126*x_61) - 0.118283166850959*std::exp(0.620399832725525*x_66) - 2.42604222608134*std::exp(0.898959815502167*x_66) - 0.464367065050825*std::exp(0.940879821777344*x_66) + 2.77678620710815e-6*std::exp(1.60559988021851*x_7) + 0.000352315992675138*std::exp(1.86407995223999*x_7) - 0.00531287167863981*std::exp(0.557119846343994*x_8) - 2.16362219028154*std::exp(0.561599850654602*x_8) + 0.345177201555494*std::exp(0.82727986574173*x_8) - 0.0174500951565625*std::exp(0.832399845123291*x_8) - 0.00114851251672201*std::exp(0.850879848003387*x_8) - 1.99134455299375e-6*std::exp(1.72775983810425*x_9) + 0.169641842800078*std::log(4.17511987686157 - 0.624479830265045*x_5) + 0.387270852889988*std::sin(0.14544004201889*x_1 + 4.92015981674194) - 0.883932499876681*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 22.3099851828678*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 35.5647080773886*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 16.8222552116063*std::sin(0.24415996670723*x_108 - 1.1950398683548) - 0.087800519127126*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 1.48822838984104*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 12.3178196203035*std::sin(0.292639940977097*x_114 + 8.10760021209717) - 3.67760194479112*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 0.0604558832913222*std::sin(0.239519983530045*x_117 - 7.43887996673584) - 0.0838604039879359*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 22.9542628586103*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 0.132697674820774*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 5.92144071622712*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 1.03819851885383*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.558671628262655*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.612953748962402*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 0.0818522614769175*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 9.44888677273994*std::sin(0.416879862546921*x_22 + 2.00263977050781) - 0.15099286437387*std::sin(0.16056002676487*x_3 + 1.77247989177704) - 0.120667011531654*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.532421244922959*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 17.4097728275044*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.498256865654957*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 8.01531730272345*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 21.9261921682985*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.166930044914992*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.118471993035054*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.0393039784601424*std::sin(0.576239883899689*x_65 + 2.18959999084473) + 0.0330223808047562*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 22.9919607159985*std::sin(0.219119995832443*x_9 - 7.589439868927) + 0.0497227296842965*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 0.0583579552037979*std::sin(0.390079855918884*x_9 + 1.9851998090744) - 0.131165741020029*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 0.981474547877799*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 3.08175029185033*std::sin(0.359999865293503*x_91 + 2.00431990623474) + 0.211014022109929*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 0.0809985104936435*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 12.716894387902*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 1.54358284421806*std::sin(0.3018399477005*x_92 - 1.18935990333557) + 2.44390156984255*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 20.1684431400992*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.194831136449549*std::sin(0.279199957847595*x_95 - 1.19967985153198) - 0.077390373361824*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 24.0037366029114*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.288352685997326*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 0.0890557883392749*std::sin(0.236799985170364*x_98 + 5.18336009979248) + 0.0721795628656796*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 1.06278192074971*std::sin(0.271759957075119*x_98 - 1.21863985061646) - 0.162942063921408*std::sin(0.275039941072464*x_98 + 1.95935988426208) - 626.947726605265);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.76708836544201*x_1 + 7.90930119331109*x_10 + 2.93636358710437*x_100 - 16.2201198815137*x_101 - 26.7696044977058*x_102 + 10.2756326063443*x_103 - 238.974406452484*x_104 - 29.1347170989826*x_105 - 2.17598944906901*x_106 - 14.9588166561575*x_107 - 21.1558335884454*x_108 + 3.55903049525762*x_109 - 13.4213546725888*x_110 - 11.8878191683891*x_111 - 21.2487728116377*x_112 + 12.8447389844966*x_113 + 53.0891933528481*x_114 + 19.7263647275656*x_115 - 13.6944770559444*x_116 - 2.86610272344241*x_117 - 35.9021484258209*x_118 - 35.6176322725434*x_119 + 4.5872570762751*x_12 + 8.81524570290794*x_120 - 3.55583140449666*x_13 - 14.1261128929477*x_14 + 12.1295010779905*x_15 - 8.15757521494612*x_16 + 5.52072866720176*x_17 + 72.9582490157206*x_18 + 9.13056186781513*x_19 + 2.28796770636731*x_2 - 1.10082494470324*x_20 - 0.523696347882535*x_21 + 0.346071978722104*x_22 - 0.190730445829017*x_23 - 12.1862483664881*x_24 + 0.240778083867806*x_25 + 4.28610158732592*x_26 + 59.017995442013*x_27 - 1.07188536450969*x_28 - 4.37492616298279*x_29 - 3.27693545843361*x_3 - 0.0322825141204242*x_30 - 3.11669847797768*x_31 + 12.1778493975208*x_32 + 59.1750694097289*x_33 - 60.3474373647537*x_34 + 20.5003045958669*x_35 + 121.56813997095*x_36 - 759.733981278479*x_37 - 123.008151945903*x_38 - 171.39747280103*x_39 - 3.44953836622075*x_4 - 5167.25478277191*x_40 - 6.73398763072268*x_41 - 22.5990552065902*x_42 - 1.9376514070244*x_43 - 55.5741575190713*x_44 + 62.2172752067996*x_45 - 41.653234677011*x_46 + 196.192248317624*x_47 - 161.997042882084*x_48 + 46.4784123246765*x_5 + 0.192719783021912*x_50 - 27.8293597748513*x_52 + 4.3846584037039*x_53 - 1.15381656214692*x_54 - 38.3886758736444*x_56 - 0.855943970371043*x_58 - 25.5948872935857*x_59 + 16.9434339190198*x_6 + 2.25779202630473*x_60 + 19.755354498196*x_61 + 11.6549114669457*x_62 + 0.66873727481517*x_63 + 22.7080167539126*x_64 - 9.45931945947321*x_65 + 0.496135102953025*x_66 + 3.24283531985494*x_67 + 10.3052591689048*x_68 + 31.2878089049118*x_69 + 49.744648363433*x_7 - 5.53663678692484*x_70 - 7.87126554244019*x_71 + 4.63681324613838*x_72 + 35.1531951897504*x_73 - 14.8243142538194*x_74 - 3.75981892742529*x_75 + 6.99777175998471*x_76 - 6.5525903020548*x_77 - 8.06083507381549*x_78 + 3.75408423386513*x_79 - 3.35980592975603*x_8 - 14.4652235524232*x_80 - 5.26548850540094*x_81 - 18.0377418210258*x_82 + 16.8757750535947*x_83 + 12.7352833362275*x_84 - 6.45018676778835*x_85 + 487.584108117759*x_86 - 3.74025057128035*x_87 + 43.0213550466508*x_88 - 0.661223742568588*x_89 + 0.17936440232338*x_9 - 5.46568721193697*x_90 + 3.49341025062434*x_91 - 23.7104967855076*x_92 - 7.3515148371472*x_93 + 10.8201239408057*x_94 - 0.538249482546144*x_95 - 21.3791561631974*x_96 - 17.7421515667261*x_97 - 53.368648961717*x_98 - 101.597082936253*x_99 - 0.0217359302502286*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) - 0.00197055617326527*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.00959176798663922*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) - 0.000380050224526687*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) - 0.0383868310666116*std::exp(1.10463988780975*x_1) + 0.0103545780834794*std::exp(1.27999985218048*x_1) + 0.0103793881533946*std::exp(1.32983994483948*x_1) - 0.344250958542679*std::exp(1.33063983917236*x_1) - 0.298117396433164*std::exp(1.79583990573883*x_1) - 0.0754748319531718*std::exp(1.89927983283997*x_1) - 0.0348657435644692*std::exp(0.68343985080719*x_10) + 1.78162483089431*std::exp(0.712479829788208*x_10) + 0.0349223128836597*std::exp(0.782719850540161*x_10) - 0.0345814071865358*std::exp(0.806639909744263*x_10) - 1.67862926998472*std::exp(0.807519853115082*x_10) - 0.0118048076917988*std::exp(0.83463990688324*x_10) - 0.0124360224183946*std::exp(0.860239923000336*x_10) - 0.238476357232695*std::exp(0.939199805259705*x_10) - 0.110585853362845*std::exp(1.05287981033325*x_10) + 0.34681367392447*std::exp(0.837359845638275*x_11) + 0.0146556951205489*std::exp(0.884399890899658*x_11) - 0.0347561687754459*std::exp(0.896239876747131*x_11) - 2.28586930683374*std::exp(0.927199840545654*x_11) - 0.0330420693734856*std::exp(0.931759834289551*x_11) - 2.40225423703203*std::exp(0.933759808540344*x_11) - 0.0184749967415747*std::exp(0.951039850711823*x_11) - 0.666508534264355*std::exp(0.958639860153198*x_11) + 0.00403524393465312*std::exp(0.975439846515656*x_11) + 0.463300311690305*std::exp(1.01423990726471*x_11) - 0.886340202465928*std::exp(0.427279859781265*x_12) + 0.0932468711454558*std::exp(0.519439876079559*x_12) + 0.0131362439425476*std::exp(0.88239985704422*x_12) - 0.206608520006047*std::exp(0.905999839305878*x_12) + 0.00117253954235825*std::exp(0.997519791126251*x_12) + 0.103575778199574*std::exp(1.23287987709045*x_12) - 0.0141113672736274*std::exp(0.619519829750061*x_13) + 0.00116392614604244*std::exp(1.07167983055115*x_13) - 0.000160211968813101*std::exp(1.30135977268219*x_13) + 87.7862999865236*std::exp(0.264079838991165*x_14) + 0.0711570882842377*std::exp(0.453439861536026*x_14) + 2.65311327266923*std::exp(0.619439840316772*x_14) + 0.00486595667261754*std::exp(0.899199843406677*x_14) - 0.854140028844232*std::exp(0.827359914779663*x_15) - 0.803994285256357*std::exp(0.876239895820618*x_15) + 0.0175097752917837*std::exp(0.927279829978943*x_15) - 0.00274026730064402*std::exp(0.928959846496582*x_15) - 4.2620925280115*std::exp(0.932479858398438*x_15) - 0.00302207704842953*std::exp(1.01999986171722*x_15) + 0.00113259777063449*std::exp(1.1373598575592*x_15) - 0.0422955738622834*std::exp(0.38351982831955*x_16) + 0.185019990879505*std::exp(0.547599852085114*x_16) - 4.21540985054375*std::exp(0.600879848003387*x_16) + 0.0507539730705909*std::exp(0.678639829158783*x_16) + 0.00253542385430506*std::exp(0.935519814491272*x_16) - 0.160217094991177*std::exp(0.628639817237854*x_17) - 0.0525028312422289*std::exp(0.667199850082397*x_17) + 14.1336950703169*std::exp(0.677199840545654*x_17) - 6.36323066947752*std::exp(0.695839881896973*x_17) + 0.129143025008925*std::exp(0.7151198387146*x_17) + 0.102947127069778*std::exp(0.693999886512756*x_19) - 34.7096899870431*std::exp(0.714319825172424*x_19) - 0.032417596713561*std::exp(0.71535986661911*x_19) - 0.112662090341537*std::exp(0.717759847640991*x_19) - 3.34369661914463*std::exp(0.728159844875336*x_19) - 7.8148352531417*std::exp(0.751519858837128*x_19) + 19.8158322341805*std::exp(0.766079843044281*x_19) + 0.0247300969698019*std::exp(0.825519859790802*x_19) - 0.0213893154540772*std::exp(0.880719900131226*x_19) + 1.65129622645212*std::exp(0.594239830970764*x_2) + 0.0344669467007669*std::exp(0.739439845085144*x_2) - 0.137745055565534*std::exp(0.749919831752777*x_2) + 8.10646538703954*std::exp(0.779519855976105*x_2) + 12.6748224784017*std::exp(0.884239912033081*x_2) + 0.0223077114959148*std::exp(0.947919845581055*x_2) + 0.00449834182934045*std::exp(1.33703982830048*x_2) + 8.40519641554783*std::exp(0.395839840173721*x_20) + 4.53837684910285*std::exp(0.457199841737747*x_20) + 0.723682897502443*std::exp(0.519039869308472*x_20) - 0.00355492042153782*std::exp(0.855199873447418*x_20) + 2.49969823495615*std::exp(0.866639912128448*x_20) + 0.000418949746956867*std::exp(1.17951989173889*x_20) + 2.88328853945627e-5*std::exp(1.35351979732513*x_20) - 0.0913798386373726*std::exp(1.0551198720932*x_21) + 0.199220781269623*std::exp(0.538959860801697*x_22) - 0.455651579339989*std::exp(0.831119894981384*x_22) - 0.205023353528513*std::exp(1.05791985988617*x_22) - 0.000208564260710553*std::exp(1.28927981853485*x_22) - 0.000175345403401863*std::exp(1.33255982398987*x_22) + 12.9292611983383*std::exp(0.619919836521149*x_23) - 0.0812739798463952*std::exp(0.693919837474823*x_23) - 8.81759668817902*std::exp(0.69735985994339*x_23) - 0.0395646584399217*std::exp(0.720719873905182*x_23) - 0.0577103762584874*std::exp(0.722399830818176*x_23) - 0.028159127781479*std::exp(0.726079881191254*x_23) - 6.59842090374693*std::exp(0.748559832572937*x_23) - 1.20897106695322*std::exp(0.811039865016937*x_23) - 0.124494811001138*std::exp(0.972799837589264*x_23) + 10.1070836607642*std::exp(0.312959849834442*x_24) - 13.0649788249282*std::exp(0.446319848299026*x_24) - 0.235322699174025*std::exp(0.608799874782562*x_24) - 0.0291976938740325*std::exp(0.626559853553772*x_24) + 0.0875583872864544*std::exp(0.689279854297638*x_24) + 1.47379944397667*std::exp(0.733279824256897*x_24) - 0.0942189463371527*std::exp(0.44327986240387*x_25) - 0.155708649241665*std::exp(0.543599843978882*x_25) - 29.9686273179632*std::exp(0.614479839801788*x_25) + 0.379967033356229*std::exp(0.783199846744537*x_25) - 0.649088358717693*std::exp(0.797279894351959*x_25) + 0.0117281387028786*std::exp(0.822319865226746*x_25) + 0.633515362394606*std::exp(0.882079899311066*x_25) + 0.00859491469129579*std::exp(0.994239807128906*x_25) + 0.00187051919657607*std::exp(0.997759819030762*x_25) + 0.160576196843203*std::exp(0.439359873533249*x_26) - 1.1834010626553*std::exp(0.595519840717316*x_26) + 2.15743803979767*std::exp(0.669679820537567*x_26) + 2.60627121470767*std::exp(0.748879849910736*x_26) - 0.0113974351438635*std::exp(0.816239893436432*x_26) + 0.0226252281691225*std::exp(0.825599908828735*x_26) + 0.0125101883501908*std::exp(0.871999859809875*x_26) + 0.000300677101212996*std::exp(1.1651998758316*x_26) + 0.0563199863282141*std::exp(1.19079983234406*x_27) - 0.000787216054771446*std::exp(1.22255980968475*x_27) + 0.0141514462469334*std::exp(1.22495996952057*x_27) - 0.0952179918729172*std::exp(1.26967978477478*x_27) + 0.000425089450011879*std::exp(1.42463982105255*x_27) - 22.7370615247673*std::exp(0.559919834136963*x_28) - 8.53497956557578*std::exp(0.587999820709229*x_28) + 0.03340655576366*std::exp(0.67631983757019*x_28) + 0.0224722964278228*std::exp(0.690719842910767*x_28) - 0.0129000202360538*std::exp(0.717759847640991*x_28) + 0.0151045492867918*std::exp(0.782079875469208*x_28) + 0.251460637102913*std::exp(0.911999821662903*x_28) - 0.316531879834592*std::exp(1.1043199300766*x_29) + 0.00270918926655579*std::exp(1.13167989253998*x_29) - 0.0011659630739918*std::exp(1.13919985294342*x_29) + 0.132489106037357*std::exp(1.14943981170654*x_29) - 0.339128370883972*std::exp(1.15047979354858*x_29) - 0.000418443151366741*std::exp(1.30935978889465*x_29) - 0.00345186610171466*std::exp(1.35751986503601*x_29) + 12.1719746072781*std::exp(0.411679863929749*x_3) + 6.4496800936301*std::exp(0.555839836597443*x_3) - 0.121814881370583*std::exp(0.65151983499527*x_3) + 0.115157153274861*std::exp(0.657999873161316*x_3) - 0.0116486270277097*std::exp(0.949759840965271*x_3) - 1.25186393277434*std::exp(0.983039796352386*x_3) - 0.0412244761925801*std::exp(0.6422398686409*x_30) - 6.44640794919951*std::exp(0.799999833106995*x_30) - 10.4528347614995*std::exp(0.843599855899811*x_30) + 0.994072360724995*std::exp(0.844959855079651*x_30) - 0.648628454678845*std::exp(0.928399801254272*x_30) + 0.00793303865078927*std::exp(0.962799787521362*x_30) + 0.00424545880070574*std::exp(1.03063988685608*x_30) - 0.00242828287890881*std::exp(1.09807980060577*x_30) - 0.00570832333055307*std::exp(1.10879981517792*x_30) + 0.00609689763683596*std::exp(0.816479861736298*x_32) + 6.51463238425688*std::exp(0.830799877643585*x_32) - 0.0102838397576932*std::exp(0.873279869556427*x_32) + 24.1051939486961*std::exp(0.337679862976074*x_33) + 0.0349971453460753*std::exp(0.393599838018417*x_33) - 26.7088417517933*std::exp(0.417359858751297*x_33) - 0.28158162402261*std::exp(0.425519853830338*x_33) - 30.9466978979571*std::exp(0.358959853649139*x_34) + 0.114777103387814*std::exp(0.365919858217239*x_34) - 12.9373591971713*std::exp(0.429999858140945*x_36) + 0.236972841563512*std::exp(0.381999850273132*x_4) + 6.59647065446746*std::exp(0.475839853286743*x_4) - 2.81357615327077*std::exp(0.60919988155365*x_4) - 0.0451929184112675*std::exp(0.61959981918335*x_4) - 0.0273330047697506*std::exp(0.755119860172272*x_4) - 0.00279103500003503*std::exp(0.894799828529358*x_4) - 0.301779692819072*std::exp(1.16215980052948*x_4) - 0.284049013287888*std::exp(1.17103981971741*x_4) - 0.00179660180549417*std::exp(1.17639982700348*x_4) + 7.43428792341417*std::exp(0.683199822902679*x_41) + 0.538724957256036*std::exp(0.767599880695343*x_41) - 0.0884611348709877*std::exp(0.7704798579216*x_41) - 0.0261845327756533*std::exp(0.784719884395599*x_41) - 0.0508432613281991*std::exp(0.803359866142273*x_41) + 3.48792635930732*std::exp(0.804319858551025*x_41) - 2.13871989893721*std::exp(0.808079898357391*x_41) - 0.02200170225526*std::exp(0.808239877223969*x_41) - 3.01454745124556*std::exp(0.633279860019684*x_42) - 0.0071420016275174*std::exp(0.719839870929718*x_42) + 0.39203799639098*std::exp(0.733519852161407*x_42) + 0.439047927052289*std::exp(0.816239893436432*x_42) + 0.00659610806986729*std::exp(0.75087982416153*x_43) + 0.00515396295516983*std::exp(0.821199893951416*x_43) - 0.000269257135317713*std::exp(0.844239890575409*x_44) + 0.0406346908579516*std::exp(0.897199809551239*x_44) + 0.00096280525777185*std::exp(0.97439980506897*x_44) - 1.68558958876869*std::exp(0.521199882030487*x_45) - 0.0076139859875794*std::exp(0.675519824028015*x_46) + 0.348431514492788*std::exp(0.691119849681854*x_46) + 0.0601659928065847*std::exp(0.763439834117889*x_46) - 2.51478971985945*std::exp(0.766159892082214*x_46) - 6.55202151655799*std::exp(0.79447990655899*x_46) + 0.0192833289423146*std::exp(0.795199871063232*x_46) + 0.210114034697232*std::exp(0.484159857034683*x_47) + 5.82444637542818*std::exp(0.519519865512848*x_47) + 0.0563307454830716*std::exp(0.598719835281372*x_48) - 0.00987793638127006*std::exp(0.655999839305878*x_49) - 0.0944730303789051*std::exp(0.690879821777344*x_49) + 38.7791655749233*std::exp(0.702399849891663*x_49) + 9.63886079546045*std::exp(0.70719987154007*x_49) - 26.4393017238421*std::exp(0.710559844970703*x_49) - 0.214294099348132*std::exp(0.714879810810089*x_49) - 0.114464500490866*std::exp(0.715039849281311*x_49) + 8.46222256087074*std::exp(0.717039823532104*x_49) + 2.68374480282738*std::exp(0.718959867954254*x_49) - 0.0210384345425107*std::exp(0.719279825687408*x_49) + 0.000712126532619115*std::exp(1.92919981479645*x_5) - 0.0726028405237377*std::exp(0.479759842157364*x_50) + 18.9120735054538*std::exp(0.541039824485779*x_50) + 28.187159639191*std::exp(0.549919843673706*x_50) - 1.8223207838255*std::exp(0.552239894866943*x_50) - 10.1479196448429*std::exp(0.554079830646515*x_50) - 0.0828168425590442*std::exp(0.58679986000061*x_50) + 1.07895356393013*std::exp(0.61983984708786*x_50) + 0.00657710911374567*std::exp(0.667119860649109*x_50) - 0.313334387509891*std::exp(0.485599845647812*x_51) - 8.96506718854265*std::exp(0.495279848575592*x_51) + 130.41302281185*std::exp(0.495439857244492*x_51) + 0.355829512880717*std::exp(0.495919853448868*x_51) - 123.908870548163*std::exp(0.495999842882156*x_51) - 1.77215295694311*std::exp(0.496239870786667*x_51) + 0.665338865209417*std::exp(0.497919857501984*x_51) + 0.125600856967752*std::exp(0.498719841241837*x_51) - 11.6574482548383*std::exp(0.504399836063385*x_51) - 9.64409322254382*std::exp(0.503519833087921*x_52) + 0.0837467613070166*std::exp(0.579199850559235*x_52) + 0.0432823253380699*std::exp(0.628959834575653*x_52) + 0.0191612211924993*std::exp(0.709119856357574*x_52) - 0.627424201053384*std::exp(0.72111988067627*x_52) + 0.207292427469603*std::exp(0.745919823646545*x_52) - 0.000507728451743878*std::exp(0.87967985868454*x_52) - 0.073142615324721*std::exp(0.467919856309891*x_54) + 0.191806475929054*std::exp(0.488959848880768*x_54) - 46.0497529087668*std::exp(0.515999853610992*x_54) + 0.212876433729074*std::exp(0.532239854335785*x_54) + 5.90439665484051*std::exp(0.533839821815491*x_54) - 0.127374248138038*std::exp(0.533999860286713*x_54) + 24.509112345711*std::exp(0.535999834537506*x_54) - 0.493103383170785*std::exp(0.537439823150635*x_54) + 0.0589902197860116*std::exp(0.61959981918335*x_55) - 6.9450786400514*std::exp(0.635919868946075*x_55) - 23.4072622305309*std::exp(0.65015983581543*x_55) - 0.559892278700666*std::exp(0.651679813861847*x_55) - 9.86753989309165*std::exp(0.652799844741821*x_55) + 2.33897664276412*std::exp(0.655679821968079*x_55) + 235.286675652687*std::exp(0.656159818172455*x_55) + 0.357549364720632*std::exp(0.656319856643677*x_55) - 63.1636680565637*std::exp(0.657199859619141*x_55) - 0.197022948197673*std::exp(0.659119844436646*x_55) + 64.1894152272697*std::exp(0.402799874544144*x_56) - 44.5477438836159*std::exp(0.458079844713211*x_56) + 7.22660921580246*std::exp(0.521679878234863*x_56) - 3.61002573372429*std::exp(0.548719882965088*x_56) - 0.167454702255962*std::exp(0.656559824943542*x_56) + 0.0260193050922301*std::exp(0.671279847621918*x_56) - 0.0194330421807557*std::exp(0.737839818000793*x_56) + 0.0045061439238663*std::exp(0.840079843997955*x_56) - 19.3244777468272*std::exp(0.612879812717438*x_57) - 0.151700845189289*std::exp(0.620399832725525*x_57) - 0.317002276675123*std::exp(0.626639842987061*x_57) + 0.196619639991822*std::exp(0.628719866275787*x_57) + 0.177511137695407*std::exp(0.631839871406555*x_57) - 136.751325757516*std::exp(0.63351982831955*x_57) - 0.33224360859702*std::exp(0.639759838581085*x_57) + 25.9387267205484*std::exp(0.640399813652039*x_57) - 7.1459332913727*std::exp(0.644639849662781*x_57) - 1.35256871705561*std::exp(0.655679821968079*x_57) + 0.148794731488099*std::exp(0.401999861001968*x_58) - 6.67695702827928*std::exp(0.521199882030487*x_58) - 17.3554376709265*std::exp(0.560399830341339*x_58) + 0.0311787306718498*std::exp(0.562319815158844*x_58) - 0.0526670127119534*std::exp(0.610559821128845*x_58) - 0.117222810982202*std::exp(0.612719833850861*x_58) - 1.7778079289583*std::exp(0.66023987531662*x_58) + 0.791497823188111*std::exp(0.671919822692871*x_58) + 1.1624913354513*std::exp(0.683759808540344*x_58) - 25.3625606694021*std::exp(0.516079843044281*x_59) - 3.48701779073311*std::exp(0.642879843711853*x_59) - 0.029892484474391*std::exp(0.651439845561981*x_59) + 0.0169025976969233*std::exp(0.696319878101349*x_59) + 0.279512103433942*std::exp(0.784239888191223*x_59) + 0.0354119225439067*std::exp(0.914319813251495*x_59) - 0.000209041773947214*std::exp(1.11175990104675*x_59) - 0.00898362148530642*std::exp(0.776479840278625*x_60) + 0.0549807697097745*std::exp(0.789359867572784*x_60) - 14.8918766744518*std::exp(0.82287985086441*x_60) + 0.026087881090256*std::exp(0.827119886875153*x_60) + 1.64463531138142*std::exp(0.83383983373642*x_60) - 0.0131959730195368*std::exp(0.855439901351929*x_60) - 3.16451524202671*std::exp(0.855599880218506*x_60) - 0.0231745195518778*std::exp(0.87527984380722*x_60) - 0.107633374791561*std::exp(0.97055983543396*x_60) + 0.442781442693515*std::exp(1.06751978397369*x_61) + 0.00779204564930019*std::exp(1.41151988506317*x_61) + 0.00383832266712929*std::exp(1.48039984703064*x_61) + 0.569289104057927*std::exp(1.54959976673126*x_61) - 0.0983443425747828*std::exp(0.620399832725525*x_66) - 2.86775746416664*std::exp(0.898959815502167*x_66) - 14.6180755050291*std::exp(0.940879821777344*x_66) - 5.00223314351703e-5*std::exp(1.60559988021851*x_7) + 0.00158214749277798*std::exp(1.86407995223999*x_7) + 0.0957085667240566*std::exp(0.557119846343994*x_8) - 2.55755799264823*std::exp(0.561599850654602*x_8) + 1.55008928166571*std::exp(0.82727986574173*x_8) + 0.151675091749004*std::exp(0.832399845123291*x_8) + 0.00353923245922952*std::exp(0.850879848003387*x_8) + 3.21992188310384e-6*std::exp(1.72775983810425*x_9) - 0.522764800330748*std::log(4.17511987686157 - 0.624479830265045*x_5) - 1.19340586463413*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 7.68308377781551*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 100.187581190887*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 42.0400584760552*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 75.5438000524023*std::sin(0.24415996670723*x_108 - 1.1950398683548) + 1.58167980549395*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 17.4725113945269*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 55.3157047478246*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 31.9654768290897*std::sin(0.221279993653297*x_116 + 5.17928028106689) + 0.193043645942682*std::sin(0.239519983530045*x_117 - 7.43887996673584) + 1.51070072007471*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 103.080842724628*std::sin(0.258879989385605*x_120 + 8.34255981445313) - 0.42372125855939*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 186.404407209386*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 0.86319087928584*std::sin(0.271759957075119*x_120 - 7.44655990600586) + 0.903348945117397*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.509629012101201*std::sin(0.245119974017143*x_20 - 4.37967967987061) - 0.261365116576271*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 42.4321711981384*std::sin(0.416879862546921*x_22 + 2.00263977050781) + 2.72005640431405*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.3718449714331*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.442671757096019*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 78.1821688528021*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.414266418381842*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 35.994432378825*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 98.4640796514423*std::sin(0.294399946928024*x_53 - 4.27839994430542) - 0.26991898702875*std::sin(0.455759853124619*x_6 + 1.95391988754272) - 0.191564318859336*std::sin(0.57287985086441*x_64 + 5.36984014511108) - 0.125502811123225*std::sin(0.576239883899689*x_65 + 2.18959999084473) - 0.594880683707452*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 103.2501327137*std::sin(0.219119995832443*x_9 - 7.589439868927) - 0.895728615246751*std::sin(0.327599853277206*x_9 - 4.33911991119385) + 0.186344683577188*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.404197639466686*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 11.5229794958183*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 97.0121738693569*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.650256453917953*std::sin(0.381119847297668*x_91 - 1.19447994232178) + 0.258638976562003*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 57.1078321451441*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 18.1223991009049*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 21.2422334380224*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 90.5705457905968*std::sin(0.313199937343597*x_92 - 4.37519979476929) + 0.315033899493065*std::sin(0.279199957847595*x_95 - 1.19967985153198) + 1.39414654836837*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 107.793720617779*std::sin(0.303759932518005*x_97 + 1.957359790802) - 0.46625438189424*std::sin(0.315439909696579*x_97 + 1.92727982997894) - 0.284366932337602*std::sin(0.236799985170364*x_98 + 5.18336009979248) - 1.30027655974024*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 12.4775668485803*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.502118900062527*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 5.49022925003737);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.258554038562227*x_1 + 3.59520947438037*x_10 - 7.88283357304582*x_100 - 9.13241079236776*x_101 - 9.94645490214604*x_102 + 0.915254222753677*x_103 - 63.7888754148754*x_104 - 13.2818008008263*x_105 - 9.42697090820442*x_106 + 0.365383619051143*x_107 - 7.85080963021424*x_108 + 5.65825091576883*x_109 - 13.0281927935554*x_110 - 10.2954018175045*x_111 + 2.9795427128568*x_112 + 6.79845927229591*x_113 + 16.6757060596074*x_114 + 7.94657626267692*x_115 + 3.61216604866456*x_116 - 16.4062057082211*x_117 - 17.2943469755561*x_118 - 3.09877044704285*x_119 + 2.9910818875716*x_12 + 1.06269397421593*x_120 + 4.43154978764839*x_13 + 3.33745874717505*x_14 - 2.40864063479417*x_15 - 6.01321521995455*x_16 - 2.50202620585802*x_17 + 50.5446282893323*x_18 - 1.14225820625876*x_19 - 0.0899275071610322*x_2 - 0.0123809766219586*x_20 + 4.81298496901742*x_21 + 0.00931571876468245*x_22 - 0.192139622902168*x_23 - 2.49943164526116*x_24 - 0.0514082766561609*x_25 - 0.826065741393667*x_26 + 19.2909215223402*x_27 + 0.349334239525911*x_28 + 0.520053477750089*x_29 + 0.64089710218303*x_3 + 0.00403863061294198*x_30 - 2.12734239727013*x_31 - 0.100865818449363*x_32 + 28.0171142660645*x_33 - 41.6581263353745*x_34 - 62.9549723715347*x_35 + 42.18210950588*x_36 - 208.510958713263*x_37 + 21.0565388142664*x_38 - 17.1252097930781*x_39 - 0.513010277944071*x_4 - 1903.55629511993*x_40 - 3.39331330168975*x_41 - 10.0660383538823*x_42 - 1.82483291836134*x_43 - 20.6218076435315*x_44 + 4.56625001909293*x_45 + 0.000200190486161933*x_46 + 22.7544830302613*x_47 - 84.1587740186472*x_48 + 25.3360062484348*x_5 + 0.245212245697449*x_50 - 9.83254668941536*x_52 - 0.168626311474362*x_53 - 0.985612238545874*x_54 + 4.8025281115116*x_56 - 0.862267956107595*x_58 + 5.56964397902127*x_59 + 2.74174668727177*x_6 + 0.335775513122783*x_60 + 9.60215456655364*x_61 + 7.81579606719221*x_62 + 5.40393115912139*x_63 + 10.9869480571857*x_64 - 0.997463827805563*x_65 + 0.601964935283239*x_66 + 4.37842364365392*x_67 + 2.78414637047116*x_68 + 10.0706028816632*x_69 + 19.188069872613*x_7 - 4.61866518255016*x_70 - 8.50914146734721*x_71 - 1.37757995255515*x_72 + 11.4460995966826*x_73 - 5.65104097209482*x_74 - 7.7912470116477*x_75 + 0.172136831772472*x_76 + 0.215645250898819*x_77 - 2.57273655009934*x_78 - 12.9670876916446*x_79 - 1.25555350444593*x_8 - 4.06540051640014*x_80 - 3.35049394024929*x_81 - 7.30387402222065*x_82 + 12.8666345307438*x_83 + 3.2455110322986*x_84 - 2.58789121310171*x_85 + 164.835089647462*x_86 + 49.0409961151374*x_87 + 21.6843357635764*x_88 - 0.783998628290345*x_89 + 2.33960973759263*x_9 - 1.15253853828568*x_90 + 1.7536028073665*x_91 - 10.8293307171409*x_92 - 15.2581721342164*x_93 + 5.68274187974351*x_94 - 1.82252364453093*x_95 - 11.1900391347182*x_96 - 3.88928576379266*x_97 - 12.2703884423737*x_98 - 17.1422566442117*x_99 - 0.00323253561352886*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) - 0.00198511526774362*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.00142647364325211*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.000557330181803159*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) - 0.0386704451588185*std::exp(1.10463988780975*x_1) - 0.015184621698218*std::exp(1.27999985218048*x_1) - 0.00189451890978314*std::exp(1.32983994483948*x_1) - 0.173470968585214*std::exp(1.33063983917236*x_1) - 0.135510642715255*std::exp(1.79583990573883*x_1) + 0.0161145523682967*std::exp(1.89927983283997*x_1) + 0.0215808451091113*std::exp(0.68343985080719*x_10) - 0.222886128260843*std::exp(0.712479829788208*x_10) - 0.00637426610833688*std::exp(0.782719850540161*x_10) - 0.0348369055992447*std::exp(0.806639909744263*x_10) - 0.845875481632506*std::exp(0.807519853115082*x_10) + 0.0173113320093817*std::exp(0.83463990688324*x_10) + 0.00801045798148065*std::exp(0.860239923000336*x_10) - 0.0354658534907292*std::exp(0.939199805259705*x_10) + 0.0236110697975984*std::exp(1.05287981033325*x_10) + 0.0515776200656443*std::exp(0.837359845638275*x_11) - 0.00907143384962076*std::exp(0.884399890899658*x_11) - 0.0350129583822443*std::exp(0.896239876747131*x_11) - 1.1518688702983*std::exp(0.927199840545654*x_11) + 0.0212835020260154*std::exp(0.931759834289551*x_11) - 1.09195578493735*std::exp(0.933759808540344*x_11) + 0.00337218631462855*std::exp(0.951039850711823*x_11) + 0.0833820364865604*std::exp(0.958639860153198*x_11) - 0.00591754218411834*std::exp(0.975439846515656*x_11) - 0.0989187645971019*std::exp(1.01423990726471*x_11) - 0.13181521274634*std::exp(0.427279859781265*x_12) - 0.057717004640339*std::exp(0.519439876079559*x_12) + 0.0132332986823438*std::exp(0.88239985704422*x_12) + 0.0258472896713811*std::exp(0.905999839305878*x_12) - 0.000755271936611528*std::exp(0.997519791126251*x_12) + 0.0470808494958249*std::exp(1.23287987709045*x_12) + 0.0206938198705094*std::exp(0.619519829750061*x_13) - 0.000212447984474619*std::exp(1.07167983055115*x_13) - 0.00016139566569125*std::exp(1.30135977268219*x_13) + 39.9036690749948*std::exp(0.264079838991165*x_14) - 0.0129880921040136*std::exp(0.453439861536026*x_14) - 0.331911710551242*std::exp(0.619439840316772*x_14) + 0.00490190790500834*std::exp(0.899199843406677*x_14) + 0.106855248490297*std::exp(0.827359914779663*x_15) - 0.405139517957527*std::exp(0.876239895820618*x_15) + 0.0176391430693819*std::exp(0.927279829978943*x_15) + 0.00401850485619156*std::exp(0.928959846496582*x_15) - 1.93735389042353*std::exp(0.932479858398438*x_15) + 0.00055161075300945*std::exp(1.01999986171722*x_15) - 0.000729544105530606*std::exp(1.1373598575592*x_15) + 0.0620249597260271*std::exp(0.38351982831955*x_16) + 0.186386977298945*std::exp(0.547599852085114*x_16) - 2.12418066416748*std::exp(0.600879848003387*x_16) - 0.00926397204804516*std::exp(0.678639829158783*x_16) - 0.00156935099876842*std::exp(0.935519814491272*x_16) + 0.0991695560555872*std::exp(0.628639817237854*x_17) + 0.0769935408349095*std::exp(0.667199850082397*x_17) + 6.42453652767446*std::exp(0.677199840545654*x_17) + 0.796057521514545*std::exp(0.695839881896973*x_17) + 0.130097174668719*std::exp(0.7151198387146*x_17) - 0.0637211708854806*std::exp(0.693999886512756*x_19) - 15.7774502758545*std::exp(0.714319825172424*x_19) + 0.00591708770073108*std::exp(0.71535986661911*x_19) - 0.113494473624827*std::exp(0.717759847640991*x_19) - 0.497269648816037*std::exp(0.728159844875336*x_19) - 3.93796155698518*std::exp(0.751519858837128*x_19) - 4.23085759842708*std::exp(0.766079843044281*x_19) - 0.0362658105447891*std::exp(0.825519859790802*x_19) + 0.0137775734823449*std::exp(0.880719900131226*x_19) + 0.245578348800423*std::exp(0.594239830970764*x_2) - 0.0505445555120027*std::exp(0.739439845085144*x_2) - 0.138762759757432*std::exp(0.749919831752777*x_2) - 1.730802939479*std::exp(0.779519855976105*x_2) + 5.76139923701181*std::exp(0.884239912033081*x_2) - 0.00407176036182588*std::exp(0.947919845581055*x_2) - 0.0028975324262016*std::exp(1.33703982830048*x_2) - 1.79458468868407*std::exp(0.395839840173721*x_20) + 2.28692646536518*std::exp(0.457199841737747*x_20) + 0.107625057319725*std::exp(0.519039869308472*x_20) + 0.0052131647792049*std::exp(0.855199873447418*x_20) + 1.13624940532123*std::exp(0.866639912128448*x_20) - 0.000269859544430056*std::exp(1.17951989173889*x_20) - 1.78466876118174e-5*std::exp(1.35351979732513*x_20) + 0.0114318671820267*std::exp(1.0551198720932*x_21) + 0.20069268763591*std::exp(0.538959860801697*x_22) - 0.229606683275774*std::exp(0.831119894981384*x_22) - 0.0931943145240586*std::exp(1.05791985988617*x_22) + 0.000305852094901977*std::exp(1.28927981853485*x_22) + 3.20052759930494e-5*std::exp(1.33255982398987*x_22) - 1.61748585886302*std::exp(0.619919836521149*x_23) + 0.014834698290185*std::exp(0.693919837474823*x_23) - 4.0080793966243*std::exp(0.69735985994339*x_23) + 0.0244893318855522*std::exp(0.720719873905182*x_23) + 0.0371731835599029*std::exp(0.722399830818176*x_23) + 0.0412943626738156*std::exp(0.726079881191254*x_23) + 1.40882194037168*std::exp(0.748559832572937*x_23) - 0.179796400920599*std::exp(0.811039865016937*x_23) - 0.062733987843125*std::exp(0.972799837589264*x_23) + 5.093044910105*std::exp(0.312959849834442*x_24) + 1.63446450431229*std::exp(0.446319848299026*x_24) - 0.237061337968826*std::exp(0.608799874782562*x_24) + 0.0428173830322388*std::exp(0.626559853553772*x_24) - 0.0541960044689303*std::exp(0.689279854297638*x_24) + 0.219181288079608*std::exp(0.733279824256897*x_24) + 0.0171975045983033*std::exp(0.44327986240387*x_25) + 0.100297148890512*std::exp(0.543599843978882*x_25) - 13.6223782903646*std::exp(0.614479839801788*x_25) + 0.0565081389731641*std::exp(0.783199846744537*x_25) + 0.081202724987365*std::exp(0.797279894351959*x_25) - 0.00725936460517443*std::exp(0.822319865226746*x_25) + 0.319233747361028*std::exp(0.882079899311066*x_25) + 0.00865841664912964*std::exp(0.994239807128906*x_25) - 0.00274305009342479*std::exp(0.997759819030762*x_25) - 0.0293094965603549*std::exp(0.439359873533249*x_26) - 0.175993667447517*std::exp(0.595519840717316*x_26) - 0.460632337614817*std::exp(0.669679820537567*x_26) + 1.18469264665836*std::exp(0.748879849910736*x_26) - 0.0114816430123433*std::exp(0.816239893436432*x_26) - 0.0145736661990968*std::exp(0.825599908828735*x_26) - 0.00774342978150068*std::exp(0.871999859809875*x_26) - 0.000440932310175016*std::exp(1.1651998758316*x_26) + 0.0283801172854254*std::exp(1.19079983234406*x_27) + 0.00115442443816614*std::exp(1.22255980968475*x_27) + 0.00210458229528365*std::exp(1.22495996952057*x_27) + 0.0203298937769373*std::exp(1.26967978477478*x_27) + 0.000428230145795352*std::exp(1.42463982105255*x_27) - 10.3352365797555*std::exp(0.559919834136963*x_28) + 1.82229455319819*std::exp(0.587999820709229*x_28) - 0.00609759946055006*std::exp(0.67631983757019*x_28) + 0.0226383288867179*std::exp(0.690719842910767*x_28) + 0.0189174223811554*std::exp(0.717759847640991*x_28) - 0.00934926105902353*std::exp(0.782079875469208*x_28) + 0.0373968565172072*std::exp(0.911999821662903*x_28) - 0.143881031397206*std::exp(1.1043199300766*x_29) + 0.00272920561677541*std::exp(1.13167989253998*x_29) + 0.0017098435155851*std::exp(1.13919985294342*x_29) + 0.0667623807021008*std::exp(1.14943981170654*x_29) + 0.0724069434904553*std::exp(1.15047979354858*x_29) + 0.000269533229266591*std::exp(1.30935978889465*x_29) - 0.000513356455346939*std::exp(1.35751986503601*x_29) + 5.53282740920426*std::exp(0.411679863929749*x_3) + 3.25004832998332*std::exp(0.555839836597443*x_3) + 0.0784650393758351*std::exp(0.65151983499527*x_3) - 0.0712788093400522*std::exp(0.657999873161316*x_3) + 0.00212618931394231*std::exp(0.949759840965271*x_3) + 0.2672841579189*std::exp(0.983039796352386*x_3) + 0.0265540639313065*std::exp(0.6422398686409*x_30) + 1.37636581356329*std::exp(0.799999833106995*x_30) - 4.75138443336273*std::exp(0.843599855899811*x_30) + 0.500921467259696*std::exp(0.844959855079651*x_30) - 0.0964630708490384*std::exp(0.928399801254272*x_30) - 0.0116335199617423*std::exp(0.962799787521362*x_30) - 0.000774910992803728*std::exp(1.03063988685608*x_30) + 0.0015030339620877*std::exp(1.09807980060577*x_30) - 0.0057504982351866*std::exp(1.10879981517792*x_30) - 0.00111284862780858*std::exp(0.816479861736298*x_32) + 2.96125631045548*std::exp(0.830799877643585*x_32) + 0.00636538706043441*std::exp(0.873279869556427*x_32) - 3.01562554418635*std::exp(0.337679862976074*x_33) - 0.0513220730302452*std::exp(0.393599838018417*x_33) + 5.70257684538952*std::exp(0.417359858751297*x_33) + 0.174290544022605*std::exp(0.425519853830338*x_33) + 6.60739707525154*std::exp(0.358959853649139*x_34) - 0.168316553365115*std::exp(0.365919858217239*x_34) + 2.76224202022248*std::exp(0.429999858140945*x_36) + 0.238723672134056*std::exp(0.381999850273132*x_4) - 0.825236480130612*std::exp(0.475839853286743*x_4) - 1.41778481187768*std::exp(0.60919988155365*x_4) + 0.0279730552844475*std::exp(0.61959981918335*x_4) + 0.0400828825624915*std::exp(0.755119860172272*x_4) + 0.00179779899395748*std::exp(0.894799828529358*x_4) + 0.0644326663309261*std::exp(1.16215980052948*x_4) - 0.129115794025477*std::exp(1.17103981971741*x_4) + 0.000327928394579409*std::exp(1.17639982700348*x_4) + 3.37928999342369*std::exp(0.683199822902679*x_41) + 0.0801183841767542*std::exp(0.767599880695343*x_41) - 0.0891147138136851*std::exp(0.7704798579216*x_41) + 0.0168663333425504*std::exp(0.784719884395599*x_41) + 0.00193903188642249*std::exp(0.803359866142273*x_41) - 0.436349105829824*std::exp(0.804319858551025*x_41) + 0.456635846952604*std::exp(0.808079898357391*x_41) + 0.0136183910040405*std::exp(0.808239877223969*x_41) + 0.377128112616978*std::exp(0.633279860019684*x_42) + 0.0104734922087205*std::exp(0.719839870929718*x_42) + 0.0583033148616685*std::exp(0.733519852161407*x_42) - 0.0937406633388193*std::exp(0.816239893436432*x_42) - 0.00424877382472572*std::exp(0.75087982416153*x_43) - 0.00319014783172346*std::exp(0.821199893951416*x_43) + 0.000394856044001314*std::exp(0.844239890575409*x_44) - 0.00867587031139446*std::exp(0.897199809551239*x_44) - 0.000620175069025459*std::exp(0.97439980506897*x_44) - 0.849382845115903*std::exp(0.521199882030487*x_45) + 0.0111656405412973*std::exp(0.675519824028015*x_46) + 0.0518182229381183*std::exp(0.691119849681854*x_46) + 0.0606105182586063*std::exp(0.763439834117889*x_46) + 0.314607056620492*std::exp(0.766159892082214*x_46) - 2.97825171363996*std::exp(0.79447990655899*x_46) - 0.00351972879180122*std::exp(0.795199871063232*x_46) + 0.211666423877447*std::exp(0.484159857034683*x_47) - 0.728654136028426*std::exp(0.519519865512848*x_47) - 0.0348670347701918*std::exp(0.598719835281372*x_48) + 0.00180299040631123*std::exp(0.655999839305878*x_49) - 0.0951710271138387*std::exp(0.690879821777344*x_49) + 17.6272492444006*std::exp(0.702399849891663*x_49) - 2.05798307912155*std::exp(0.70719987154007*x_49) + 3.30762879645618*std::exp(0.710559844970703*x_49) + 0.138033996784082*std::exp(0.714879810810089*x_49) + 0.070850078129483*std::exp(0.715039849281311*x_49) + 4.26418549488486*std::exp(0.717039823532104*x_49) + 0.399122584259822*std::exp(0.718959867954254*x_49) + 0.0308521184615378*std::exp(0.719279825687408*x_49) + 0.000358846580679464*std::exp(1.92919981479645*x_5) + 0.0449389714843485*std::exp(0.479759842157364*x_50) - 4.03789701825105*std::exp(0.541039824485779*x_50) + 12.8126039094824*std::exp(0.549919843673706*x_50) - 0.27101286971271*std::exp(0.552239894866943*x_50) + 1.26953244045539*std::exp(0.554079830646515*x_50) + 0.0533450982282613*std::exp(0.58679986000061*x_50) + 0.543693823208988*std::exp(0.61983984708786*x_50) - 0.00120050020324396*std::exp(0.667119860649109*x_50) + 0.193944548226994*std::exp(0.485599845647812*x_51) + 51.9570848904958*std::exp(0.495279848575592*x_51) - 16.3150250407857*std::exp(0.495439857244492*x_51) + 0.358458494265008*std::exp(0.495919853448868*x_51) - 56.3233507571148*std::exp(0.495999842882156*x_51) + 1.14150299193349*std::exp(0.496239870786667*x_51) - 0.121442328095288*std::exp(0.497919857501984*x_51) - 0.184189204297008*std::exp(0.498719841241837*x_51) - 1.73367857794991*std::exp(0.504399836063385*x_51) + 2.05910024915116*std::exp(0.503519833087921*x_52) - 0.0518367227939529*std::exp(0.579199850559235*x_52) - 0.007900194366037*std::exp(0.628959834575653*x_52) + 0.0193027903765941*std::exp(0.709119856357574*x_52) - 0.316164359661591*std::exp(0.72111988067627*x_52) + 0.0308282252701512*std::exp(0.745919823646545*x_52) + 0.000744565775929916*std::exp(0.87967985868454*x_52) + 0.107261052528658*std::exp(0.467919856309891*x_54) - 0.0350098666988971*std::exp(0.488959848880768*x_54) + 9.83203454173789*std::exp(0.515999853610992*x_54) + 0.214449232390145*std::exp(0.532239854335785*x_54) + 2.97527539491078*std::exp(0.533839821815491*x_54) + 0.0788408230810767*std::exp(0.533999860286713*x_54) - 3.06615683791489*std::exp(0.535999834537506*x_54) + 0.317624381697233*std::exp(0.537439823150635*x_54) - 0.0365131692602618*std::exp(0.61959981918335*x_55) - 3.49968384602432*std::exp(0.635919868946075*x_55) + 4.99766005767823*std::exp(0.65015983581543*x_55) + 0.102195475664244*std::exp(0.651679813861847*x_55) - 1.46748603603014*std::exp(0.652799844741821*x_55) + 2.35625774461073*std::exp(0.655679821968079*x_55) + 106.950647702907*std::exp(0.656159818172455*x_55) - 0.230309504601991*std::exp(0.656319856643677*x_55) + 7.90194724262669*std::exp(0.657199859619141*x_55) + 0.288927169231793*std::exp(0.659119844436646*x_55) + 29.1775958633592*std::exp(0.402799874544144*x_56) + 9.51134216698089*std::exp(0.458079844713211*x_56) + 3.64154948343208*std::exp(0.521679878234863*x_56) - 0.536877723459602*std::exp(0.548719882965088*x_56) - 0.168691910747688*std::exp(0.656559824943542*x_56) - 0.0167599046653649*std::exp(0.671279847621918*x_56) + 0.0120284677860447*std::exp(0.737839818000793*x_56) - 0.000822493074524538*std::exp(0.840079843997955*x_56) + 4.12594901614941*std::exp(0.612879812717438*x_57) + 0.0276895049682864*std::exp(0.620399832725525*x_57) - 0.319344390114253*std::exp(0.626639842987061*x_57) - 0.288335732044855*std::exp(0.628719866275787*x_57) - 0.114340860921144*std::exp(0.631839871406555*x_57) - 62.1609482280543*std::exp(0.63351982831955*x_57) + 0.205648786533592*std::exp(0.639759838581085*x_57) - 3.24500549751378*std::exp(0.640399813652039*x_57) - 3.60089620301252*std::exp(0.644639849662781*x_57) - 0.201152032477714*std::exp(0.655679821968079*x_57) - 0.0271590606608265*std::exp(0.401999861001968*x_58) + 0.835305545135543*std::exp(0.521199882030487*x_58) - 7.88899454218558*std::exp(0.560399830341339*x_58) - 0.0457225032701265*std::exp(0.562319815158844*x_58) + 0.0325992945366161*std::exp(0.610559821128845*x_58) + 0.0755071332498606*std::exp(0.612719833850861*x_58) - 0.895852446425756*std::exp(0.66023987531662*x_58) + 0.117710393437577*std::exp(0.671919822692871*x_58) - 0.248202308213736*std::exp(0.683759808540344*x_58) - 11.52866937098*std::exp(0.516079843044281*x_59) + 0.436235441421778*std::exp(0.642879843711853*x_59) + 0.0192547490498238*std::exp(0.651439845561981*x_59) - 0.0247870603394695*std::exp(0.696319878101349*x_59) + 0.140848512141369*std::exp(0.784239888191223*x_59) + 0.00526640909539632*std::exp(0.914319813251495*x_59) + 0.000129390561728505*std::exp(1.11175990104675*x_59) + 0.0131741624462717*std::exp(0.776479840278625*x_60) + 0.0553869850877256*std::exp(0.789359867572784*x_60) - 6.76917148591729*std::exp(0.82287985086441*x_60) - 0.0161476126270677*std::exp(0.827119886875153*x_60) - 0.205748365536007*std::exp(0.83383983373642*x_60) + 0.00240862178473635*std::exp(0.855439901351929*x_60) + 0.675652336921428*std::exp(0.855599880218506*x_60) + 0.01492748315062*std::exp(0.87527984380722*x_60) - 0.0542373675769236*std::exp(0.97055983543396*x_60) + 0.223121312605089*std::exp(1.06751978397369*x_61) - 0.0114267587231436*std::exp(1.41151988506317*x_61) - 0.000700597642872373*std::exp(1.48039984703064*x_61) - 0.121548320713507*std::exp(1.54959976673126*x_61) + 0.0179505009278588*std::exp(0.620399832725525*x_66) + 0.358764284654916*std::exp(0.898959815502167*x_66) - 6.64471389676424*std::exp(0.940879821777344*x_66) - 5.03919122973008e-5*std::exp(1.60559988021851*x_7) - 0.000337802655096454*std::exp(1.86407995223999*x_7) + 0.0964156919936772*std::exp(0.557119846343994*x_8) + 0.319957484257668*std::exp(0.561599850654602*x_8) - 0.330957939998272*std::exp(0.82727986574173*x_8) + 0.0764303611160145*std::exp(0.832399845123291*x_8) - 0.00227973800203315*std::exp(0.850879848003387*x_8) - 1.99303466149266e-6*std::exp(1.72775983810425*x_9) + 0.336730292561434*std::log(4.17511987686157 - 0.624479830265045*x_5) + 0.768712632695489*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 3.87157087463497*std::sin(0.217600002884865*x_101 + 8.20775985717773) - 21.390945590382*std::sin(0.298079937696457*x_103 - 7.48615980148315) - 5.25932603941307*std::sin(0.270719945430756*x_107 - 7.4443998336792) - 16.1292776749722*std::sin(0.24415996670723*x_108 - 1.1950398683548) + 1.59336575793474*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 2.59848622489958*std::sin(0.304159939289093*x_113 - 1.22191989421844) + 11.8103982199141*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 16.107674036129*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 0.283091663537814*std::sin(0.239519983530045*x_117 - 7.43887996673584) + 1.52186225650309*std::sin(0.269199967384338*x_117 + 1.93663990497589) - 22.0086828319777*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 0.621372205110184*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 84.7309862762845*std::sin(0.269279956817627*x_120 + 5.15327978134155) - 0.157555668926835*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.559145788128967*std::sin(0.280559957027435*x_120 - 7.44615983963013) - 0.0930210708117756*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 0.383282678282507*std::sin(0.412479877471924*x_21 - 7.41631984710693) - 9.0596484573451*std::sin(0.416879862546921*x_22 + 2.00263977050781) + 2.74015304439675*std::sin(0.16056002676487*x_3 + 1.77247989177704) - 0.239517783023925*std::sin(0.343199849128723*x_31 - 4.24496030807495) + 0.0807995618095325*std::sin(0.3504798412323*x_35 + 1.83119988441467) + 16.6925930358769*std::sin(0.32151985168457*x_37 + 5.08903980255127) + 0.0756148196515658*std::sin(0.282319933176041*x_42 + 5.11696004867554) - 7.68513358062953*std::sin(0.476879835128784*x_5 - 4.28232002258301) - 21.0229625807418*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.167071723002399*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.118572543450607*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.184045423541653*std::sin(0.576239883899689*x_65 + 2.18959999084473) - 0.599275851018562*std::sin(0.582639873027802*x_65 - 7.20071983337402) + 22.044827760343*std::sin(0.219119995832443*x_9 - 7.589439868927) - 0.902346542567609*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 0.273267872701476*std::sin(0.390079855918884*x_9 + 1.9851998090744) - 0.260357218588829*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 1.71368058166288*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 44.0973327606124*std::sin(0.359999865293503*x_91 + 2.00431990623474) + 0.418851930790325*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 0.379284890590986*std::sin(0.383759826421738*x_91 + 8.19527912139893) + 12.1930334646363*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 2.69513656981129*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 10.7041410284124*std::sin(0.311039924621582*x_92 + 8.22056007385254) + 19.337622428538*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.194996494955224*std::sin(0.279199957847595*x_95 - 1.19967985153198) + 1.40444694558097*std::sin(0.301439940929413*x_97 - 7.45655965805054) - 23.0149244578179*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.288597418795855*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 0.41701402570121*std::sin(0.236799985170364*x_98 + 5.18336009979248) - 1.30988341568176*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 1.85564541033613*std::sin(0.271759957075119*x_98 - 1.21863985061646) - 0.323431577664957*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 907.136624772185);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.992688385477422*x_1 + 6.05387895791448*x_10 - 11.5897483568552*x_100 - 8.84247095850093*x_101 - 17.2480657192791*x_102 + 5.61683059203536*x_103 - 104.558432683066*x_104 - 24.6839840423124*x_105 - 17.1753727762858*x_106 - 3.5811039717682*x_107 - 9.09571719044082*x_108 + 19.7161334865672*x_109 - 18.7241131499616*x_110 - 18.7415543452964*x_111 - 4.28629740182024*x_112 + 9.27974170711049*x_113 + 25.3940930762347*x_114 + 5.45553628694464*x_115 + 8.54193635051813*x_116 - 31.85120062526*x_117 - 26.0695357422832*x_118 - 8.00171753208363*x_119 - 2.76050143633672*x_12 - 5.77689563640708*x_120 + 10.5051449417531*x_13 - 1.30624513797327*x_14 - 0.495734904550274*x_15 - 8.53761716166147*x_16 - 3.45562810957549*x_17 + 70.2114586604899*x_18 - 5.4180432765719*x_19 - 1.32803824687949*x_2 + 0.765143806006532*x_20 + 10.3135998711108*x_21 + 0.0291120028688217*x_22 + 0.274236967166715*x_23 - 4.93833413243003*x_24 - 0.0201565736070153*x_25 - 2.57997818617284*x_26 + 26.7044352542298*x_27 + 0.835339803621248*x_28 + 2.42679796253793*x_29 + 3.34283666644681*x_3 + 0.0191563302580037*x_30 - 1.08109478450167*x_31 - 3.62500848888283*x_32 + 37.2303578957241*x_33 - 55.531992353397*x_34 + 73.0916796339867*x_35 + 33.8585742644038*x_36 - 194.532654252108*x_37 + 90.0914196242492*x_38 - 55.8488322532616*x_39 - 3.79830801181761*x_4 - 2999.9324394728*x_40 + 3.46078922780637*x_41 - 26.1905470952075*x_42 + 18.8822134166606*x_43 - 43.8165664588721*x_44 - 27.9153266043111*x_45 + 9.10091266194205*x_46 + 32.6999419436376*x_47 - 154.254305387098*x_48 + 45.5322517420687*x_5 - 0.150259949845442*x_50 - 14.4794561922377*x_52 + 1.32813928708018*x_53 - 0.376987111854261*x_54 + 22.7797051512086*x_56 + 1.23069747715905*x_58 + 1.89441405327667*x_59 + 7.43358447212893*x_6 + 2.48606875241879*x_60 + 15.1525073748621*x_61 + 13.8538026210749*x_62 + 4.88150395935309*x_63 + 20.7630701505187*x_64 - 4.86272090433423*x_65 - 0.292056967791252*x_66 + 4.49970233009841*x_67 + 8.04110884443864*x_68 + 10.2387367518326*x_69 + 34.6411234621975*x_7 - 10.8979244339809*x_70 - 11.3338642939897*x_71 - 6.40430626278513*x_72 + 16.1451985261735*x_73 - 10.700591081095*x_74 - 10.6182211975768*x_75 - 2.76767911211602*x_76 - 2.49970718879348*x_77 + 1.69459165991975*x_78 - 23.6777680766048*x_79 - 2.83184569833365*x_8 - 9.63707077087398*x_80 - 4.46910799715393*x_81 - 11.7791268428741*x_82 + 19.0318247582628*x_83 + 13.3430212243409*x_84 - 5.16335892186091*x_85 + 377.121418799296*x_86 + 65.3469507536938*x_87 + 27.3677110708698*x_88 - 2.53411319876377*x_89 + 5.84106001225325*x_9 - 7.28429964926042*x_90 - 1.56406402340361*x_91 - 18.3674841588234*x_92 - 18.4816359009731*x_93 + 2.30840092144566*x_94 - 10.0921587649558*x_95 - 26.4445899677403*x_96 - 9.30092174012905*x_97 - 21.1219622144116*x_98 - 32.7887248528515*x_99 - 0.0239335671179106*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) + 0.00283331455677698*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.0105615550033908*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.00288155983079956*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) + 0.0551935381112977*std::exp(1.10463988780975*x_1) - 0.0785089294642333*std::exp(1.27999985218048*x_1) + 0.0390332067248557*std::exp(1.32983994483948*x_1) + 0.17692043322905*std::exp(1.33063983917236*x_1) - 0.22818281781724*std::exp(1.79583990573883*x_1) + 0.00631832424821714*std::exp(1.89927983283997*x_1) + 0.00984842581855554*std::exp(0.68343985080719*x_10) - 1.05720990407246*std::exp(0.712479829788208*x_10) + 0.131330463602728*std::exp(0.782719850540161*x_10) + 0.0497220052413367*std::exp(0.806639909744263*x_10) + 0.862695688441607*std::exp(0.807519853115082*x_10) + 0.089504642964926*std::exp(0.83463990688324*x_10) - 0.0146690939173222*std::exp(0.860239923000336*x_10) - 0.262587790637739*std::exp(0.939199805259705*x_10) + 0.00925761953661276*std::exp(1.05287981033325*x_10) + 0.381878679528482*std::exp(0.837359845638275*x_11) - 0.00413975184401862*std::exp(0.884399890899658*x_11) + 0.049973281789827*std::exp(0.896239876747131*x_11) + 1.17477374582205*std::exp(0.927199840545654*x_11) - 0.0389752609439976*std::exp(0.931759834289551*x_11) - 1.83871571225889*std::exp(0.933759808540344*x_11) - 0.0694779264825035*std::exp(0.951039850711823*x_11) + 0.395503818398955*std::exp(0.958639860153198*x_11) - 0.0305954215500206*std::exp(0.975439846515656*x_11) - 0.038784870635759*std::exp(1.01423990726471*x_11) - 0.975954674164345*std::exp(0.427279859781265*x_12) - 0.0263391741980308*std::exp(0.519439876079559*x_12) - 0.0188876174598567*std::exp(0.88239985704422*x_12) + 0.122600768595317*std::exp(0.905999839305878*x_12) + 0.00138308633499934*std::exp(0.997519791126251*x_12) + 0.0792782078804007*std::exp(1.23287987709045*x_12) + 0.106993093199683*std::exp(0.619519829750061*x_13) + 0.00437711445024635*std::exp(1.07167983055115*x_13) + 0.000230356743728793*std::exp(1.30135977268219*x_13) + 67.1927419746045*std::exp(0.264079838991165*x_14) + 0.267596634395937*std::exp(0.453439861536026*x_14) - 1.57434807814395*std::exp(0.619439840316772*x_14) - 0.00699639323162671*std::exp(0.899199843406677*x_14) + 0.50684368689764*std::exp(0.827359914779663*x_15) + 0.413195704271656*std::exp(0.876239895820618*x_15) - 0.0251759893441142*std::exp(0.927279829978943*x_15) + 0.0207768438737888*std::exp(0.928959846496582*x_15) - 3.26225941349083*std::exp(0.932479858398438*x_15) - 0.011364962599574*std::exp(1.01999986171722*x_15) + 0.001335972428243*std::exp(1.1373598575592*x_15) + 0.320687158687926*std::exp(0.38351982831955*x_16) - 0.266026333359987*std::exp(0.547599852085114*x_16) + 2.16641992851196*std::exp(0.600879848003387*x_16) + 0.190867736488322*std::exp(0.678639829158783*x_16) - 0.000716173848452375*std::exp(0.935519814491272*x_16) + 0.0452560597759072*std::exp(0.628639817237854*x_17) + 0.39807909520188*std::exp(0.667199850082397*x_17) + 10.8181085904444*std::exp(0.677199840545654*x_17) + 3.77591868333604*std::exp(0.695839881896973*x_17) - 0.18568504548525*std::exp(0.7151198387146*x_17) - 0.0290791774540936*std::exp(0.693999886512756*x_19) - 26.5672347926263*std::exp(0.714319825172424*x_19) - 0.121911112229635*std::exp(0.71535986661911*x_19) + 0.161988348717136*std::exp(0.717759847640991*x_19) - 3.68176501005229*std::exp(0.728159844875336*x_19) + 4.01626779618122*std::exp(0.751519858837128*x_19) - 1.65886892443175*std::exp(0.766079843044281*x_19) - 0.187504833416971*std::exp(0.825519859790802*x_19) - 0.0252300829531307*std::exp(0.880719900131226*x_19) + 1.81825247929882*std::exp(0.594239830970764*x_2) - 0.261330115583882*std::exp(0.739439845085144*x_2) + 0.198053258441846*std::exp(0.749919831752777*x_2) - 0.678627238998608*std::exp(0.779519855976105*x_2) + 9.70146909592845*std::exp(0.884239912033081*x_2) + 0.0838914106987802*std::exp(0.947919845581055*x_2) + 0.00530608554301175*std::exp(1.33703982830048*x_2) - 0.703635303969058*std::exp(0.395839840173721*x_20) - 2.33240192474416*std::exp(0.457199841737747*x_20) + 0.796851710511751*std::exp(0.519039869308472*x_20) + 0.0269535846246372*std::exp(0.855199873447418*x_20) + 1.91330057812629*std::exp(0.866639912128448*x_20) + 0.000494178361696937*std::exp(1.17951989173889*x_20) - 8.14434180697177e-6*std::exp(1.35351979732513*x_20) + 0.0542244746282974*std::exp(1.0551198720932*x_21) - 0.286444582114291*std::exp(0.538959860801697*x_22) + 0.234172404804902*std::exp(0.831119894981384*x_22) - 0.156927462423229*std::exp(1.05791985988617*x_22) + 0.00158134466714868*std::exp(1.28927981853485*x_22) - 0.000659412026806192*std::exp(1.33255982398987*x_22) - 7.67217808945876*std::exp(0.619919836521149*x_23) - 0.305642684309726*std::exp(0.693919837474823*x_23) - 6.74909979342897*std::exp(0.69735985994339*x_23) + 0.0111757147230079*std::exp(0.720719873905182*x_23) - 0.0680731266685054*std::exp(0.722399830818176*x_23) + 0.213503916716576*std::exp(0.726079881191254*x_23) + 0.552382320267425*std::exp(0.748559832572937*x_23) - 1.33120551278143*std::exp(0.811039865016937*x_23) + 0.0639814511783248*std::exp(0.972799837589264*x_23) - 5.19431994471254*std::exp(0.312959849834442*x_24) + 7.75271245140744*std::exp(0.446319848299026*x_24) + 0.338352815390694*std::exp(0.608799874782562*x_24) + 0.221378376829472*std::exp(0.626559853553772*x_24) - 0.0247323646027662*std::exp(0.689279854297638*x_24) + 1.62280967525575*std::exp(0.733279824256897*x_24) - 0.354324123486351*std::exp(0.44327986240387*x_25) - 0.183668436950295*std::exp(0.543599843978882*x_25) - 22.938365588003*std::exp(0.614479839801788*x_25) + 0.418384048473336*std::exp(0.783199846744537*x_25) + 0.385166747541356*std::exp(0.797279894351959*x_25) - 0.00331281344370171*std::exp(0.822319865226746*x_25) - 0.325581700183463*std::exp(0.882079899311066*x_25) - 0.0123579815888996*std::exp(0.994239807128906*x_25) - 0.0141823702020062*std::exp(0.997759819030762*x_25) + 0.603870266131435*std::exp(0.439359873533249*x_26) - 1.30305022303656*std::exp(0.595519840717316*x_26) - 0.180608458848073*std::exp(0.669679820537567*x_26) + 1.9948728819027*std::exp(0.748879849910736*x_26) + 0.0163875150280645*std::exp(0.816239893436432*x_26) + 0.0266879220499624*std::exp(0.825599908828735*x_26) - 0.00353371674736252*std::exp(0.871999859809875*x_26) - 0.00227974883576416*std::exp(1.1651998758316*x_26) - 0.0289444550069611*std::exp(1.19079983234406*x_27) + 0.00596871154178364*std::exp(1.22255980968475*x_27) + 0.0155822449127947*std::exp(1.22495996952057*x_27) + 0.00797110945924951*std::exp(1.26967978477478*x_27) - 0.000611204157989179*std::exp(1.42463982105255*x_27) - 17.4032338591435*std::exp(0.559919834136963*x_28) + 0.714500012145426*std::exp(0.587999820709229*x_28) + 0.125630237333584*std::exp(0.67631983757019*x_28) - 0.0323112253570792*std::exp(0.690719842910767*x_28) + 0.09780859931081*std::exp(0.717759847640991*x_28) - 0.00426653838311594*std::exp(0.782079875469208*x_28) + 0.27688486144051*std::exp(0.911999821662903*x_28) - 0.24227749582483*std::exp(1.1043199300766*x_29) - 0.00389533954430598*std::exp(1.13167989253998*x_29) + 0.00884039040470141*std::exp(1.13919985294342*x_29) - 0.0680899485000349*std::exp(1.14943981170654*x_29) + 0.0283899010248082*std::exp(1.15047979354858*x_29) - 0.000493580799386446*std::exp(1.30935978889465*x_29) - 0.00380087109575443*std::exp(1.35751986503601*x_29) + 9.31658298884713*std::exp(0.411679863929749*x_3) - 3.31467543673476*std::exp(0.555839836597443*x_3) - 0.143688542464304*std::exp(0.65151983499527*x_3) - 0.0325281082678312*std::exp(0.657999873161316*x_3) - 0.0438063650875826*std::exp(0.949759840965271*x_3) + 0.104798938099314*std::exp(0.983039796352386*x_3) - 0.0486269397574336*std::exp(0.6422398686409*x_30) + 0.539656659117812*std::exp(0.799999833106995*x_30) - 8.0007316533495*std::exp(0.843599855899811*x_30) - 0.510882274562168*std::exp(0.844959855079651*x_30) - 0.714208799712151*std::exp(0.928399801254272*x_30) - 0.060148696243408*std::exp(0.962799787521362*x_30) + 0.0159656685500877*std::exp(1.03063988685608*x_30) + 0.000685910046782219*std::exp(1.09807980060577*x_30) + 0.0082075689121035*std::exp(1.10879981517792*x_30) + 0.0229282749928828*std::exp(0.816479861736298*x_32) + 4.9863818491265*std::exp(0.830799877643585*x_32) + 0.00290484649484902*std::exp(0.873279869556427*x_32) - 14.3039372488746*std::exp(0.337679862976074*x_33) - 0.265350108258712*std::exp(0.393599838018417*x_33) + 2.2359125302439*std::exp(0.417359858751297*x_33) + 0.0795375475336515*std::exp(0.425519853830338*x_33) + 2.59068177657196*std::exp(0.358959853649139*x_34) - 0.870245744571657*std::exp(0.365919858217239*x_34) + 1.08304223021125*std::exp(0.429999858140945*x_36) - 0.340725431059468*std::exp(0.381999850273132*x_4) - 3.91432246952109*std::exp(0.475839853286743*x_4) + 1.4459774173668*std::exp(0.60919988155365*x_4) + 0.0127655130507806*std::exp(0.61959981918335*x_4) + 0.207240210679143*std::exp(0.755119860172272*x_4) - 0.00329220655645396*std::exp(0.894799828529358*x_4) + 0.0252632818307075*std::exp(1.16215980052948*x_4) - 0.217414699798534*std::exp(1.17103981971741*x_4) - 0.00675638377134662*std::exp(1.17639982700348*x_4) + 5.690297805917*std::exp(0.683199822902679*x_41) + 0.593193379540094*std::exp(0.767599880695343*x_41) + 0.127191614499203*std::exp(0.7704798579216*x_41) - 0.0308863523677085*std::exp(0.784719884395599*x_41) - 0.256058254417864*std::exp(0.803359866142273*x_41) - 2.06972322555928*std::exp(0.804319858551025*x_41) + 0.179041482410768*std::exp(0.808079898357391*x_41) + 0.00621475724853576*std::exp(0.808239877223969*x_41) + 1.78882184761279*std::exp(0.633279860019684*x_42) + 0.054151013927145*std::exp(0.719839870929718*x_42) + 0.43167546046464*std::exp(0.733519852161407*x_42) - 0.0367545987428644*std::exp(0.816239893436432*x_42) + 0.00778053669496204*std::exp(0.75087982416153*x_43) - 0.00145582502038763*std::exp(0.821199893951416*x_43) + 0.00204152108120436*std::exp(0.844239890575409*x_44) - 0.00340170552119809*std::exp(0.897199809551239*x_44) + 0.0011356911619471*std::exp(0.97439980506897*x_44) + 0.866272795735325*std::exp(0.521199882030487*x_45) + 0.0577296229765518*std::exp(0.675519824028015*x_46) + 0.383660093775867*std::exp(0.691119849681854*x_46) - 0.0865081572170374*std::exp(0.763439834117889*x_46) + 1.49226736874814*std::exp(0.766159892082214*x_46) - 5.01499996288398*std::exp(0.79447990655899*x_46) + 0.0725177779099232*std::exp(0.795199871063232*x_46) - 0.302107172161629*std::exp(0.484159857034683*x_47) - 3.45620597954434*std::exp(0.519519865512848*x_47) - 0.0159115828741227*std::exp(0.598719835281372*x_48) - 0.0371474240183402*std::exp(0.655999839305878*x_49) + 0.135835667019756*std::exp(0.690879821777344*x_49) + 29.6820627690915*std::exp(0.702399849891663*x_49) - 0.806910678872839*std::exp(0.70719987154007*x_49) + 15.6889885875552*std::exp(0.710559844970703*x_49) - 0.252773769900578*std::exp(0.714879810810089*x_49) + 0.0323324566377842*std::exp(0.715039849281311*x_49) - 4.34897868661789*std::exp(0.717039823532104*x_49) + 2.95508798686623*std::exp(0.718959867954254*x_49) + 0.159514464058284*std::exp(0.719279825687408*x_49) - 0.000365982233421305*std::exp(1.92919981479645*x_5) + 0.0205079145319909*std::exp(0.479759842157364*x_50) - 1.58321137684298*std::exp(0.541039824485779*x_50) + 21.5748077424825*std::exp(0.549919843673706*x_50) - 2.00656867628624*std::exp(0.552239894866943*x_50) + 6.02173980078288*std::exp(0.554079830646515*x_50) - 0.0976878298030221*std::exp(0.58679986000061*x_50) - 0.554505157436996*std::exp(0.61983984708786*x_50) + 0.0247341804636918*std::exp(0.667119860649109*x_50) + 0.088506658866682*std::exp(0.485599845647812*x_51) - 29.2588036953468*std::exp(0.495279848575592*x_51) - 77.3866287368187*std::exp(0.495439857244492*x_51) - 0.511620501995241*std::exp(0.495919853448868*x_51) - 94.8414133912185*std::exp(0.495999842882156*x_51) - 2.09036919415705*std::exp(0.496239870786667*x_51) + 2.50210408205096*std::exp(0.497919857501984*x_51) - 0.952311986140821*std::exp(0.498719841241837*x_51) - 12.8360883117854*std::exp(0.504399836063385*x_51) + 0.807348707949054*std::exp(0.503519833087921*x_52) - 0.0236557056284018*std::exp(0.579199850559235*x_52) + 0.162769512757917*std::exp(0.628959834575653*x_52) - 0.0275504792336735*std::exp(0.709119856357574*x_52) + 0.322451277808115*std::exp(0.72111988067627*x_52) + 0.228250972871345*std::exp(0.745919823646545*x_52) + 0.00384962254218185*std::exp(0.87967985868454*x_52) + 0.554570971512583*std::exp(0.467919856309891*x_54) + 0.721316296823935*std::exp(0.488959848880768*x_54) + 3.85502375955462*std::exp(0.515999853610992*x_54) - 0.306079018026635*std::exp(0.532239854335785*x_54) - 3.03443865066545*std::exp(0.533839821815491*x_54) + 0.0359790357449917*std::exp(0.533999860286713*x_54) - 14.543621004038*std::exp(0.535999834537506*x_54) - 0.581647378504429*std::exp(0.537439823150635*x_54) - 0.0166627968942806*std::exp(0.61959981918335*x_55) + 3.56927494700173*std::exp(0.635919868946075*x_55) + 1.95952304507682*std::exp(0.65015983581543*x_55) - 2.10555677610207*std::exp(0.651679813861847*x_55) - 10.8652091537461*std::exp(0.652799844741821*x_55) - 3.36303864858809*std::exp(0.655679821968079*x_55) + 180.091391135296*std::exp(0.656159818172455*x_55) + 0.421752633977874*std::exp(0.656319856643677*x_55) + 37.4810983148593*std::exp(0.657199859619141*x_55) + 1.49383785782305*std::exp(0.659119844436646*x_55) + 49.1313885598185*std::exp(0.402799874544144*x_56) + 3.72928409509879*std::exp(0.458079844713211*x_56) - 3.71396157805703*std::exp(0.521679878234863*x_56) - 3.97502164392372*std::exp(0.548719882965088*x_56) + 0.240770525570144*std::exp(0.656559824943542*x_56) + 0.0306914556133981*std::exp(0.671279847621918*x_56) + 0.00548919526102028*std::exp(0.737839818000793*x_56) + 0.0169460130705971*std::exp(0.840079843997955*x_56) + 1.61773551755195*std::exp(0.612879812717438*x_57) - 0.570493208568585*std::exp(0.620399832725525*x_57) + 0.45579373844836*std::exp(0.626639842987061*x_57) - 1.49077995481337*std::exp(0.628719866275787*x_57) + 0.209385884217534*std::exp(0.631839871406555*x_57) - 104.671190695137*std::exp(0.63351982831955*x_57) + 0.0938478918972903*std::exp(0.639759838581085*x_57) - 15.3919491424171*std::exp(0.640399813652039*x_57) + 3.67249990846085*std::exp(0.644639849662781*x_57) - 1.4893217726854*std::exp(0.655679821968079*x_57) + 0.559564343091346*std::exp(0.401999861001968*x_58) + 3.96208280046239*std::exp(0.521199882030487*x_58) - 13.2840710390792*std::exp(0.560399830341339*x_58) - 0.236398697017509*std::exp(0.562319815158844*x_58) + 0.0148766988668836*std::exp(0.610559821128845*x_58) - 0.138271898015153*std::exp(0.612719833850861*x_58) + 0.913666443576069*std::exp(0.66023987531662*x_58) + 0.871523144253446*std::exp(0.671919822692871*x_58) - 0.0973171718710342*std::exp(0.683759808540344*x_58) - 19.4128240412912*std::exp(0.516079843044281*x_59) + 2.06918408416513*std::exp(0.642879843711853*x_59) - 0.0352601215585089*std::exp(0.651439845561981*x_59) - 0.128156342021051*std::exp(0.696319878101349*x_59) - 0.143649280285636*std::exp(0.784239888191223*x_59) + 0.03899228674466*std::exp(0.914319813251495*x_59) + 5.90474257315537e-5*std::exp(1.11175990104675*x_59) + 0.0681142678955294*std::exp(0.776479840278625*x_60) - 0.0790527147994866*std::exp(0.789359867572784*x_60) - 11.3984303593804*std::exp(0.82287985086441*x_60) - 0.0073689683745196*std::exp(0.827119886875153*x_60) - 0.975920805339781*std::exp(0.83383983373642*x_60) - 0.0496253859278536*std::exp(0.855439901351929*x_60) + 0.264915242208894*std::exp(0.855599880218506*x_60) - 0.0273358468132448*std::exp(0.87527984380722*x_60) + 0.0553158758907766*std::exp(0.97055983543396*x_60) - 0.227558072746538*std::exp(1.06751978397369*x_61) - 0.0590796802468491*std::exp(1.41151988506317*x_61) + 0.0144345735922553*std::exp(1.48039984703064*x_61) - 0.0476576503362966*std::exp(1.54959976673126*x_61) - 0.369838279213603*std::exp(0.620399832725525*x_66) + 1.70171718592001*std::exp(0.898959815502167*x_66) - 11.188859488616*std::exp(0.940879821777344*x_66) + 7.19233492259913e-5*std::exp(1.60559988021851*x_7) - 0.000132448401794089*std::exp(1.86407995223999*x_7) - 0.137612151831323*std::exp(0.557119846343994*x_8) + 1.51764591129443*std::exp(0.561599850654602*x_8) - 0.129764670444401*std::exp(0.82727986574173*x_8) - 0.077950176394245*std::exp(0.832399845123291*x_8) + 0.00417475391994146*std::exp(0.850879848003387*x_8) - 9.09522028367347e-7*std::exp(1.72775983810425*x_9) - 0.616634941199458*std::log(4.17511987686157 - 0.624479830265045*x_5) - 1.40769951362479*std::sin(0.14544004201889*x_1 + 4.92015981674194) - 3.94855693724287*std::sin(0.217600002884865*x_101 + 8.20775985717773) - 8.38713525061384*std::sin(0.298079937696457*x_103 - 7.48615980148315) - 24.9464227361273*std::sin(0.270719945430756*x_107 - 7.4443998336792) - 6.32409786575884*std::sin(0.24415996670723*x_108 - 1.1950398683548) - 2.2741784669048*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 19.2390902696686*std::sin(0.304159939289093*x_113 - 1.22191989421844) + 4.63071661865042*std::sin(0.292639940977097*x_114 + 8.10760021209717) - 16.4279746174609*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 1.46366658888913*std::sin(0.239519983530045*x_117 - 7.43887996673584) - 2.17212297684901*std::sin(0.269199967384338*x_117 + 1.93663990497589) - 8.62934267303528*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 3.21267579736645*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 142.676285917873*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 3.24615550899835*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.255166365742601*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 1.91653441304479*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 1.98168339996742*std::sin(0.412479877471924*x_21 - 7.41631984710693) - 3.55218036592703*std::sin(0.416879862546921*x_22 + 2.00263977050781) - 3.91096458459599*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.438615228014381*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 1.66473186575385*std::sin(0.3504798412323*x_35 + 1.83119988441467) + 6.54496711628792*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 1.55790943636456*std::sin(0.282319933176041*x_42 + 5.11696004867554) - 3.01324943712425*std::sin(0.476879835128784*x_5 - 4.28232002258301) - 8.24285349089733*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.0762432361683885*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.0541106195047819*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.951568597638636*std::sin(0.576239883899689*x_65 + 2.18959999084473) + 0.855334206434152*std::sin(0.582639873027802*x_65 - 7.20071983337402) + 8.64351466938499*std::sin(0.219119995832443*x_9 - 7.589439868927) + 1.28790082664579*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 1.41287472082883*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.476777295425794*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 12.6880239302652*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 74.2543422857536*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.767019604174907*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 1.96101366988627*std::sin(0.383759826421738*x_91 + 8.19527912139893) + 4.78074334540621*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 19.9546856392084*std::sin(0.3018399477005*x_92 - 1.18935990333557) + 10.9169925292789*std::sin(0.311039924621582*x_92 + 8.22056007385254) + 7.58205166986052*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.0889867151047796*std::sin(0.279199957847595*x_95 - 1.19967985153198) - 2.00453849698034*std::sin(0.301439940929413*x_97 - 7.45655965805054) - 9.02387804198661*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.131701527723658*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 2.1560843187298*std::sin(0.236799985170364*x_98 + 5.18336009979248) + 1.86956989835173*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 13.7391259633607*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.592281764608666*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 1081.65054900653);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.2754414360189*x_1 - 0.992305375565974*x_10 + 4.88275082938513*x_100 + 2.35623620867783*x_101 - 3.33723529027019*x_102 - 2.20189608855139*x_103 - 17.0104925072781*x_104 + 4.5324237696668*x_105 + 12.666974512222*x_106 - 1.26145483914258*x_107 - 3.48469306444531*x_108 - 12.2240266861627*x_109 + 7.66163477463223*x_110 + 8.99196499418375*x_111 - 2.27129905976056*x_112 - 1.40247387392709*x_113 + 0.0414453694381465*x_114 + 6.87356433944986*x_115 - 9.07742294041531*x_116 + 19.5967077547851*x_117 - 0.147003904489831*x_118 - 6.45121165347669*x_119 + 6.40588598382144*x_12 + 7.56109436167932*x_120 - 8.9818276257348*x_13 - 3.32563991197288*x_14 + 4.5466842197605*x_15 + 2.82533980546477*x_16 + 4.06128797793542*x_17 - 4.9610650158815*x_18 + 4.74974147413939*x_19 + 1.40812281686023*x_2 - 0.312617231894498*x_20 - 8.16620850966796*x_21 - 0.0229919816785042*x_22 + 0.27498997094552*x_23 - 0.820995515108085*x_24 + 0.0966231200569291*x_25 + 1.90625384411764*x_26 + 1.12801236916874*x_27 - 0.250801289472038*x_28 - 2.31998609440398*x_29 - 2.41225255211126*x_3 - 0.0167934458390523*x_30 - 0.683121837353124*x_31 + 0.553045451518035*x_32 - 0.883017847578478*x_33 + 12.3702171335376*x_34 - 45.2174888802752*x_35 + 28.1189497446433*x_36 - 114.131456780049*x_37 - 72.5722237784572*x_38 - 4.64085794129787*x_39 + 1.47136936422269*x_4 - 193.153475997403*x_40 - 8.22868111670753*x_41 + 12.0906904111836*x_42 - 11.6432853470641*x_43 + 15.2050110737045*x_44 + 30.6488449622746*x_45 - 26.6889873016719*x_46 + 63.8441477630189*x_47 + 29.9118678006289*x_48 - 11.2106592994397*x_5 - 0.334264735083803*x_50 + 0.320947956786462*x_52 - 0.65468175393756*x_53 - 0.30921044065568*x_54 - 19.9698866919758*x_56 + 1.23407674385836*x_58 - 10.4397423034824*x_59 + 2.45247037921208*x_6 - 0.963040750849981*x_60 - 2.36777548549587*x_61 - 4.33181435311636*x_62 - 2.11620568524277*x_63 - 5.30481345813253*x_64 - 0.558692869341781*x_65 + 1.02491412434016*x_66 - 0.87472392485201*x_67 - 0.948126718883689*x_68 + 4.49450703718569*x_69 - 5.72054275284933*x_7 + 4.17259822289799*x_70 + 3.94323035784707*x_71 + 6.10020202622986*x_72 + 2.10605619935433*x_73 + 2.56732688435219*x_74 + 3.4182918859694*x_75 + 3.90530779599761*x_76 + 1.53167237991865*x_77 - 3.18661940822223*x_78 + 19.3078443452088*x_79 + 0.857640855170771*x_8 + 0.406435014447327*x_80 - 0.880553045119141*x_81 + 3.09445337682639*x_82 - 0.229966044599919*x_83 - 3.92889678300429*x_84 + 3.19170129996199*x_85 - 13.3039422780621*x_86 - 32.4554539904636*x_87 + 5.00273494257479*x_88 - 0.351520034799806*x_89 - 2.3140170933853*x_9 + 4.2096200643945*x_90 + 4.83559031748745*x_91 + 3.02980823097661*x_92 + 5.43463349953578*x_93 + 2.95813608078328*x_94 + 5.96659713504206*x_95 + 11.5840815782716*x_96 + 1.34518314533264*x_97 - 4.36905123133288*x_98 - 11.9901330376877*x_99 + 0.00927126429038851*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) + 0.00284109431232867*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) - 0.00409128180816115*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) - 0.00049051654793213*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) + 0.0553450893160561*std::exp(1.10463988780975*x_1) + 0.0133642649550529*std::exp(1.27999985218048*x_1) + 0.00681360278586932*std::exp(1.32983994483948*x_1) - 0.420661800601585*std::exp(1.33063983917236*x_1) + 0.0374019762049952*std::exp(1.79583990573883*x_1) - 0.0302876974180578*std::exp(1.89927983283997*x_1) + 0.00401132171134723*std::exp(0.68343985080719*x_10) + 0.926805762138738*std::exp(0.712479829788208*x_10) + 0.0229249320708063*std::exp(0.782719850540161*x_10) + 0.0498585326330421*std::exp(0.806639909744263*x_10) - 2.05122220790201*std::exp(0.807519853115082*x_10) - 0.0152360218315756*std::exp(0.83463990688324*x_10) - 0.00812490718185665*std::exp(0.860239923000336*x_10) + 0.101719931443475*std::exp(0.939199805259705*x_10) - 0.0443775862588165*std::exp(1.05287981033325*x_10) - 0.147930233187998*std::exp(0.837359845638275*x_11) - 0.0016861452538145*std::exp(0.884399890899658*x_11) + 0.0501104991402658*std::exp(0.896239876747131*x_11) - 2.79324682964787*std::exp(0.927199840545654*x_11) - 0.0215875894819024*std::exp(0.931759834289551*x_11) + 0.301388167503215*std::exp(0.933759808540344*x_11) - 0.01212800671937*std::exp(0.951039850711823*x_11) - 0.346719432373859*std::exp(0.958639860153198*x_11) + 0.00520813775956899*std::exp(0.975439846515656*x_11) + 0.185920250380606*std::exp(1.01423990726471*x_11) + 0.378060390038823*std::exp(0.427279859781265*x_12) - 0.0107281004361583*std::exp(0.519439876079559*x_12) - 0.0189394793494729*std::exp(0.88239985704422*x_12) - 0.107478276867325*std::exp(0.905999839305878*x_12) + 0.000766062863848332*std::exp(0.997519791126251*x_12) - 0.0129946753795122*std::exp(1.23287987709045*x_12) - 0.0182130116362452*std::exp(0.619519829750061*x_13) + 0.00076406531040341*std::exp(1.07167983055115*x_13) + 0.000230989260563751*std::exp(1.30135977268219*x_13) - 11.0137185635748*std::exp(0.264079838991165*x_14) + 0.0467114369173353*std::exp(0.453439861536026*x_14) + 1.3801562630233*std::exp(0.619439840316772*x_14) - 0.00701560402802606*std::exp(0.899199843406677*x_14) - 0.444325812415185*std::exp(0.827359914779663*x_15) - 0.982450957118812*std::exp(0.876239895820618*x_15) - 0.0252451179350081*std::exp(0.927279829978943*x_15) - 0.00353676006479721*std::exp(0.928959846496582*x_15) + 0.534724525383116*std::exp(0.932479858398438*x_15) - 0.00198385803594374*std::exp(1.01999986171722*x_15) + 0.000739967447081119*std::exp(1.1373598575592*x_15) - 0.0545893083199029*std::exp(0.38351982831955*x_16) - 0.266756792263289*std::exp(0.547599852085114*x_16) - 5.15107323305695*std::exp(0.600879848003387*x_16) + 0.0333177069011157*std::exp(0.678639829158783*x_16) - 0.000291701817155736*std::exp(0.935519814491272*x_16) + 0.0184330590993628*std::exp(0.628639817237854*x_17) - 0.0677634319771146*std::exp(0.667199850082397*x_17) - 1.77322133170837*std::exp(0.677199840545654*x_17) - 3.31016875608395*std::exp(0.695839881896973*x_17) - 0.186194902133544*std::exp(0.7151198387146*x_17) - 0.0118441198643087*std::exp(0.693999886512756*x_19) + 4.35469722502153*std::exp(0.714319825172424*x_19) - 0.0212806982467909*std::exp(0.71535986661911*x_19) + 0.162433138637206*std::exp(0.717759847640991*x_19) + 1.42622352510734*std::exp(0.728159844875336*x_19) - 9.54943650094084*std::exp(0.751519858837128*x_19) + 7.95200088909417*std::exp(0.766079843044281*x_19) + 0.0319182071547552*std::exp(0.825519859790802*x_19) - 0.013974420188466*std::exp(0.880719900131226*x_19) - 0.704345457540188*std::exp(0.594239830970764*x_2) + 0.044485193330635*std::exp(0.739439845085144*x_2) + 0.198597075905815*std::exp(0.749919831752777*x_2) + 3.25308668358412*std::exp(0.779519855976105*x_2) - 1.59019035591907*std::exp(0.884239912033081*x_2) + 0.0146440120504813*std::exp(0.947919845581055*x_2) + 0.00293893084187383*std::exp(1.33703982830048*x_2) + 3.3729660495489*std::exp(0.395839840173721*x_20) + 5.54572683031606*std::exp(0.457199841737747*x_20) - 0.308680389012047*std::exp(0.519039869308472*x_20) - 0.00458820224489492*std::exp(0.855199873447418*x_20) - 0.313613546281118*std::exp(0.866639912128448*x_20) + 0.000273715155325869*std::exp(1.17951989173889*x_20) - 3.31723827917612e-6*std::exp(1.35351979732513*x_20) - 0.0475360241526904*std::exp(1.0551198720932*x_21) - 0.287231105736466*std::exp(0.538959860801697*x_22) - 0.556789194207437*std::exp(0.831119894981384*x_22) + 0.0257223452300642*std::exp(1.05791985988617*x_22) - 0.000269186056430217*std::exp(1.28927981853485*x_22) - 0.000115106392732559*std::exp(1.33255982398987*x_22) + 6.72583451410574*std::exp(0.619919836521149*x_23) - 0.0533527224645677*std::exp(0.693919837474823*x_23) + 1.1062606391387*std::exp(0.69735985994339*x_23) + 0.00455193428210231*std::exp(0.720719873905182*x_23) - 0.0377042944082087*std::exp(0.722399830818176*x_23) - 0.0363439284093382*std::exp(0.726079881191254*x_23) - 2.64791547854882*std::exp(0.748559832572937*x_23) + 0.515675664768864*std::exp(0.811039865016937*x_23) - 0.152128004473806*std::exp(0.972799837589264*x_23) + 12.3504783532529*std::exp(0.312959849834442*x_24) - 6.79643516816382*std::exp(0.446319848299026*x_24) + 0.339281869380718*std::exp(0.608799874782562*x_24) - 0.0376843666505026*std::exp(0.626559853553772*x_24) - 0.0100736374453986*std::exp(0.689279854297638*x_24) - 0.628635811710505*std::exp(0.733279824256897*x_24) - 0.0618505123574684*std::exp(0.44327986240387*x_25) - 0.101730141675325*std::exp(0.543599843978882*x_25) + 3.75988083638763*std::exp(0.614479839801788*x_25) - 0.16207149854299*std::exp(0.783199846744537*x_25) - 0.337657412809386*std::exp(0.797279894351959*x_25) - 0.00134932838376323*std::exp(0.822319865226746*x_25) + 0.774132087189647*std::exp(0.882079899311066*x_25) - 0.0123919143111397*std::exp(0.994239807128906*x_25) + 0.00241420885959994*std::exp(0.997759819030762*x_25) + 0.105411071055987*std::exp(0.439359873533249*x_26) + 0.504769010900213*std::exp(0.595519840717316*x_26) + 0.865769805067497*std::exp(0.669679820537567*x_26) - 0.326984252252835*std::exp(0.748879849910736*x_26) + 0.016432512100738*std::exp(0.816239893436432*x_26) + 0.0147818870582399*std::exp(0.825599908828735*x_26) - 0.00143930359750891*std::exp(0.871999859809875*x_26) + 0.00038807263938054*std::exp(1.1651998758316*x_26) + 0.0688209176206143*std::exp(1.19079983234406*x_27) - 0.00101603018954703*std::exp(1.22255980968475*x_27) - 0.00603617129499972*std::exp(1.22495996952057*x_27) - 0.0382105352469196*std::exp(1.26967978477478*x_27) - 0.00061288241109029*std::exp(1.42463982105255*x_27) + 2.85260452524955*std::exp(0.559919834136963*x_28) - 3.42504742126295*std::exp(0.587999820709229*x_28) + 0.0219299055063403*std::exp(0.67631983757019*x_28) - 0.0323999459808633*std::exp(0.690719842910767*x_28) - 0.0166495715199858*std::exp(0.717759847640991*x_28) - 0.00173778615626507*std::exp(0.782079875469208*x_28) - 0.107258258485903*std::exp(0.911999821662903*x_28) + 0.0397122676480573*std::exp(1.1043199300766*x_29) - 0.00390603542322739*std::exp(1.13167989253998*x_29) - 0.00150486473934613*std::exp(1.13919985294342*x_29) + 0.161896734120086*std::exp(1.14943981170654*x_29) - 0.136090630709658*std::exp(1.15047979354858*x_29) - 0.000273384177943389*std::exp(1.30935978889465*x_29) + 0.0014723622387265*std::exp(1.35751986503601*x_29) - 1.52710277922774*std::exp(0.411679863929749*x_3) + 7.88126793597373*std::exp(0.555839836597443*x_3) - 0.0795861064901996*std::exp(0.65151983499527*x_3) - 0.0132488896527976*std::exp(0.657999873161316*x_3) - 0.00764680117889198*std::exp(0.949759840965271*x_3) - 0.502367147077242*std::exp(0.983039796352386*x_3) - 0.0269334543969575*std::exp(0.6422398686409*x_30) - 2.58691339014651*std::exp(0.799999833106995*x_30) + 1.31141852740553*std::exp(0.843599855899811*x_30) + 1.21471925876715*std::exp(0.844959855079651*x_30) + 0.276666595832981*std::exp(0.928399801254272*x_30) + 0.0102388749761785*std::exp(0.962799787521362*x_30) + 0.00278695328513381*std::exp(1.03063988685608*x_30) + 0.000279375192886639*std::exp(1.09807980060577*x_30) + 0.00823010537197419*std::exp(1.10879981517792*x_30) + 0.00400233984022643*std::exp(0.816479861736298*x_32) - 0.817329442479865*std::exp(0.830799877643585*x_32) + 0.00118316104802908*std::exp(0.873279869556427*x_32) + 12.5395831163338*std::exp(0.337679862976074*x_33) + 0.0451695008048349*std::exp(0.393599838018417*x_33) - 10.7181334019666*std::exp(0.417359858751297*x_33) + 0.0323961105223458*std::exp(0.425519853830338*x_33) - 12.4187652726795*std::exp(0.358959853649139*x_34) + 0.148138495656871*std::exp(0.365919858217239*x_34) - 5.19170179796848*std::exp(0.429999858140945*x_36) - 0.341660999811461*std::exp(0.381999850273132*x_4) + 3.43150078867653*std::exp(0.475839853286743*x_4) - 3.43808486627011*std::exp(0.60919988155365*x_4) + 0.00519946848364371*std::exp(0.61959981918335*x_4) - 0.0352776824720151*std::exp(0.755119860172272*x_4) - 0.00182348499814986*std::exp(0.894799828529358*x_4) - 0.12110278070827*std::exp(1.16215980052948*x_4) + 0.0356369489441311*std::exp(1.17103981971741*x_4) - 0.00117938850403329*std::exp(1.17639982700348*x_4) - 0.932709943597533*std::exp(0.683199822902679*x_41) - 0.229788253875006*std::exp(0.767599880695343*x_41) + 0.127540859049782*std::exp(0.7704798579216*x_41) - 0.0171073106211021*std::exp(0.784719884395599*x_41) - 0.0297500799839698*std::exp(0.803359866142273*x_41) + 1.81442815101479*std::exp(0.804319858551025*x_41) - 0.858258302597881*std::exp(0.808079898357391*x_41) + 0.00253130714909121*std::exp(0.808239877223969*x_41) - 1.56817524071698*std::exp(0.633279860019684*x_42) - 0.00921791320612544*std::exp(0.719839870929718*x_42) - 0.167220258556771*std::exp(0.733519852161407*x_42) + 0.176187881740973*std::exp(0.816239893436432*x_42) + 0.00430947806510031*std::exp(0.75087982416153*x_43) - 0.000592966086133342*std::exp(0.821199893951416*x_43) - 0.000347520069713482*std::exp(0.844239890575409*x_44) + 0.0163065115818418*std::exp(0.897199809551239*x_44) + 0.00062903580344379*std::exp(0.97439980506897*x_44) - 2.05972745722599*std::exp(0.521199882030487*x_45) - 0.00982708568922001*std::exp(0.675519824028015*x_46) - 0.148620308437409*std::exp(0.691119849681854*x_46) - 0.0867456925499097*std::exp(0.763439834117889*x_46) - 1.30819999952687*std::exp(0.766159892082214*x_46) + 0.822020304044413*std::exp(0.79447990655899*x_46) + 0.0126586405537997*std::exp(0.795199871063232*x_46) - 0.302936702347117*std::exp(0.484159857034683*x_47) + 3.02989179787377*std::exp(0.519519865512848*x_47) - 0.00648088121094572*std::exp(0.598719835281372*x_48) - 0.00648442218860939*std::exp(0.655999839305878*x_49) + 0.136208646533127*std::exp(0.690879821777344*x_49) - 4.86525592077624*std::exp(0.702399849891663*x_49) + 3.86802980109739*std::exp(0.70719987154007*x_49) - 13.7537919093109*std::exp(0.710559844970703*x_49) - 0.140006153756026*std::exp(0.714879810810089*x_49) + 0.0131691995941092*std::exp(0.715039849281311*x_49) + 10.3405195866896*std::exp(0.717039823532104*x_49) - 1.14472705186876*std::exp(0.718959867954254*x_49) - 0.0271535171398479*std::exp(0.719279825687408*x_49) + 0.000870191998116344*std::exp(1.92919981479645*x_5) + 0.00835299410608692*std::exp(0.479759842157364*x_50) + 7.58932673393226*std::exp(0.541039824485779*x_50) - 3.53637689958754*std::exp(0.549919843673706*x_50) + 0.777294434340416*std::exp(0.552239894866943*x_50) - 5.27897357371261*std::exp(0.554079830646515*x_50) - 0.0541072648672124*std::exp(0.58679986000061*x_50) + 1.31844091557431*std::exp(0.61983984708786*x_50) + 0.00431757713634858*std::exp(0.667119860649109*x_50) + 0.0360492822763422*std::exp(0.485599845647812*x_51) + 53.6474480401939*std::exp(0.495279848575592*x_51) + 67.8411856997314*std::exp(0.495439857244492*x_51) - 0.513025316872303*std::exp(0.495919853448868*x_51) + 15.5456765800289*std::exp(0.495999842882156*x_51) - 1.15781218486049*std::exp(0.496239870786667*x_51) + 0.436765123198072*std::exp(0.497919857501984*x_51) + 0.162108307800283*std::exp(0.498719841241837*x_51) + 4.97237902762398*std::exp(0.504399836063385*x_51) - 3.87012954963823*std::exp(0.503519833087921*x_52) - 0.00963510791802509*std::exp(0.579199850559235*x_52) + 0.0284129052834318*std::exp(0.628959834575653*x_52) - 0.0276261277327988*std::exp(0.709119856357574*x_52) - 0.766688915764939*std::exp(0.72111988067627*x_52) - 0.088418708485995*std::exp(0.745919823646545*x_52) - 0.000655306039475431*std::exp(0.87967985868454*x_52) - 0.0944024259438124*std::exp(0.467919856309891*x_54) + 0.125912348533815*std::exp(0.488959848880768*x_54) - 18.4795506817746*std::exp(0.515999853610992*x_54) - 0.306919454163192*std::exp(0.532239854335785*x_54) + 7.21495196064432*std::exp(0.533839821815491*x_54) + 0.0146544726940322*std::exp(0.533999860286713*x_54) + 12.7497024923639*std::exp(0.535999834537506*x_54) - 0.322162431405404*std::exp(0.537439823150635*x_54) - 0.00678685509595486*std::exp(0.61959981918335*x_55) - 8.48662643790847*std::exp(0.635919868946075*x_55) - 9.39322496621549*std::exp(0.65015983581543*x_55) - 0.367544168650626*std::exp(0.651679813861847*x_55) + 4.20890981851778*std::exp(0.652799844741821*x_55) - 3.37227292811217*std::exp(0.655679821968079*x_55) - 29.5191986425628*std::exp(0.656159818172455*x_55) + 0.233600045380263*std::exp(0.656319856643677*x_55) - 32.8579005509575*std::exp(0.657199859619141*x_55) - 0.254290117927682*std::exp(0.659119844436646*x_55) - 8.05324013179869*std::exp(0.402799874544144*x_56) - 17.8768014778918*std::exp(0.458079844713211*x_56) + 8.830646275707*std::exp(0.521679878234863*x_56) + 1.53982379806862*std::exp(0.548719882965088*x_56) + 0.241431636715925*std::exp(0.656559824943542*x_56) + 0.0169993613470882*std::exp(0.671279847621918*x_56) + 0.00223578148772455*std::exp(0.737839818000793*x_56) + 0.00295808137622659*std::exp(0.840079843997955*x_56) - 7.75482262909889*std::exp(0.612879812717438*x_57) - 0.0995848007729066*std::exp(0.620399832725525*x_57) + 0.457045263401224*std::exp(0.626639842987061*x_57) + 0.253769583176958*std::exp(0.628719866275787*x_57) + 0.115974502859343*std::exp(0.631839871406555*x_57) + 17.1568982326426*std::exp(0.63351982831955*x_57) + 0.0382247978781022*std::exp(0.639759838581085*x_57) + 13.4933915211987*std::exp(0.640399813652039*x_57) - 8.73206331233782*std::exp(0.644639849662781*x_57) + 0.576925942546324*std::exp(0.655679821968079*x_57) + 0.0976770674732316*std::exp(0.401999861001968*x_58) - 3.47337000475892*std::exp(0.521199882030487*x_58) + 2.1774229701513*std::exp(0.560399830341339*x_58) + 0.0402412164263501*std::exp(0.562319815158844*x_58) + 0.00605936687317786*std::exp(0.610559821128845*x_58) - 0.0765859393609606*std::exp(0.612719833850861*x_58) - 2.17241482110981*std::exp(0.66023987531662*x_58) - 0.33760623168944*std::exp(0.671919822692871*x_58) + 0.466502341351462*std::exp(0.683759808540344*x_58) + 3.18200112440401*std::exp(0.516079843044281*x_59) - 1.81395551133484*std::exp(0.642879843711853*x_59) - 0.0195298507527836*std::exp(0.651439845561981*x_59) + 0.0218155478889822*std::exp(0.696319878101349*x_59) + 0.34155334009297*std::exp(0.784239888191223*x_59) - 0.0151046350055284*std::exp(0.914319813251495*x_59) + 2.40503634997054e-5*std::exp(1.11175990104675*x_59) - 0.0115948227747777*std::exp(0.776479840278625*x_60) - 0.0792697788721525*std::exp(0.789359867572784*x_60) + 1.86834322213209*std::exp(0.82287985086441*x_60) - 0.00300142412356385*std::exp(0.827119886875153*x_60) + 0.855543466151633*std::exp(0.83383983373642*x_60) - 0.00866256442088702*std::exp(0.855439901351929*x_60) - 1.26990518090593*std::exp(0.855599880218506*x_60) - 0.0151407591598276*std::exp(0.87527984380722*x_60) - 0.131523959835337*std::exp(0.97055983543396*x_60) + 0.541062368409731*std::exp(1.06751978397369*x_61) + 0.0100569006056617*std::exp(1.41151988506317*x_61) + 0.002519686674331*std::exp(1.48039984703064*x_61) + 0.228453057541112*std::exp(1.54959976673126*x_61) - 0.0645586499549951*std::exp(0.620399832725525*x_66) - 1.49181471661004*std::exp(0.898959815502167*x_66) + 1.83399197344224*std::exp(0.940879821777344*x_66) + 7.21208373849035e-5*std::exp(1.60559988021851*x_7) + 0.000634908396506664*std::exp(1.86407995223999*x_7) - 0.137990009242047*std::exp(0.557119846343994*x_8) - 1.33044816365774*std::exp(0.561599850654602*x_8) + 0.622043586174457*std::exp(0.82727986574173*x_8) + 0.185341291340621*std::exp(0.832399845123291*x_8) + 0.00231230969668566*std::exp(0.850879848003387*x_8) - 3.70453667068756e-7*std::exp(1.72775983810425*x_9) - 0.341541317451039*std::log(4.17511987686157 - 0.624479830265045*x_5) - 0.779695593511753*std::sin(0.14544004201889*x_1 + 4.92015981674194) + 9.38844112397152*std::sin(0.217600002884865*x_101 + 8.20775985717773) + 40.2048082205654*std::sin(0.298079937696457*x_103 - 7.48615980148315) + 21.8693451958117*std::sin(0.270719945430756*x_107 - 7.4443998336792) + 30.315373994036*std::sin(0.24415996670723*x_108 - 1.1950398683548) - 2.28042293860002*std::sin(0.285119920969009*x_113 - 7.42575979232788) - 7.4527415707814*std::sin(0.304159939289093*x_113 - 1.22191989421844) - 22.1979338610283*std::sin(0.292639940977097*x_114 + 8.10760021209717) + 39.0606175707891*std::sin(0.221279993653297*x_116 + 5.17928028106689) + 0.249154181992563*std::sin(0.239519983530045*x_117 - 7.43887996673584) - 2.17808722312293*std::sin(0.269199967384338*x_117 + 1.93663990497589) + 41.3658605557283*std::sin(0.258879989385605*x_120 + 8.34255981445313) - 0.546881111023826*std::sin(0.264239966869354*x_120 - 7.42104005813599) - 23.3864017543664*std::sin(0.269279956817627*x_120 + 5.15327978134155) + 0.566646096370857*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.103930760282559*std::sin(0.280559957027435*x_120 - 7.44615983963013) + 0.334548588538613*std::sin(0.245119974017143*x_20 - 4.37967967987061) - 0.337334137593355*std::sin(0.412479877471924*x_21 - 7.41631984710693) + 17.0278320439034*std::sin(0.416879862546921*x_22 + 2.00263977050781) - 3.92170336697605*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.242939886829513*std::sin(0.343199849128723*x_31 - 4.24496030807495) - 0.290594153797847*std::sin(0.3504798412323*x_35 + 1.83119988441467) - 31.3741390662568*std::sin(0.32151985168457*x_37 + 5.08903980255127) - 0.271947322969655*std::sin(0.282319933176041*x_42 + 5.11696004867554) + 14.444397535075*std::sin(0.476879835128784*x_5 - 4.28232002258301) + 39.513175105587*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.0310543181438603*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.0220395733118104*std::sin(0.57287985086441*x_64 + 5.36984014511108) - 0.161981763711915*std::sin(0.576239883899689*x_65 + 2.18959999084473) + 0.857682795306906*std::sin(0.582639873027802*x_65 - 7.20071983337402) - 41.433795837361*std::sin(0.219119995832443*x_9 - 7.589439868927) + 1.29143716311862*std::sin(0.327599853277206*x_9 - 4.33911991119385) + 0.240508082918837*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.264077065262827*std::sin(0.474319845438004*x_9 - 1.12655985355377) + 4.91502259570123*std::sin(0.354399859905243*x_91 - 7.40903997421265) + 12.1712018891525*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.42483626635088*std::sin(0.381119847297668*x_91 - 1.19447994232178) + 0.333815611086383*std::sin(0.383759826421738*x_91 + 8.19527912139893) - 22.9171062121281*std::sin(0.390719830989838*x_91 - 4.39071989059448) - 7.72994528902767*std::sin(0.3018399477005*x_92 - 1.18935990333557) - 25.9572150638758*std::sin(0.311039924621582*x_92 + 8.22056007385254) - 36.3455368485741*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.0362448120032271*std::sin(0.279199957847595*x_95 - 1.19967985153198) - 2.0100425873974*std::sin(0.301439940929413*x_97 - 7.45655965805054) + 43.2571164340399*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.0536428062015898*std::sin(0.315439909696579*x_97 + 1.92727982997894) - 0.367021717116484*std::sin(0.236799985170364*x_98 + 5.18336009979248) + 1.87470339006418*std::sin(0.26079997420311*x_98 + 1.96743977069855) - 5.32219318991243*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.328052597527452*std::sin(0.275039941072464*x_98 + 1.95935988426208) - 495.909813789215);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.14076809231823*x_1 + 2.69307592118638*x_10 - 20.9871851539332*x_100 - 5.40773618793798*x_101 - 4.66875672986574*x_102 + 0.608260094466792*x_103 + 41.7792465892505*x_104 - 14.2994883837237*x_105 - 19.2004777634839*x_106 + 6.9066926573128*x_107 - 0.72438465948989*x_108 + 18.3575851446406*x_109 - 18.5503576579835*x_110 - 12.4925393242724*x_111 + 16.5837220848963*x_112 + 4.83539823667062*x_113 + 1.25451652145813*x_114 + 1.10949105017267*x_115 + 20.9795996616496*x_116 - 35.5412484376238*x_117 - 16.4778271263606*x_118 + 15.7968749883023*x_119 + 0.836688734313046*x_12 - 7.49543909499603*x_120 + 12.257279122452*x_13 + 10.716811021912*x_14 - 10.4904884359615*x_15 - 6.69139492061649*x_16 - 10.0776062514061*x_17 + 59.2100886216214*x_18 - 11.4667979169017*x_19 - 2.46410044889601*x_2 + 1.0379435681652*x_20 + 13.7546391026402*x_21 - 0.107062264580303*x_22 - 0.256298408578325*x_23 + 1.50978673591156*x_24 - 0.223602149486679*x_25 - 5.95738515309294*x_26 - 1.10244202394158*x_27 + 2.04351053851378*x_28 + 5.51972374887155*x_29 + 5.70117432938689*x_3 + 0.0405426381232124*x_30 + 0.014980177332429*x_31 - 8.03457981221177*x_32 + 18.4085121603273*x_33 - 27.0136572288267*x_34 - 52.2901607300401*x_35 - 4.75944534447022*x_36 + 162.080853942717*x_37 + 204.331296637304*x_38 + 70.9757162100683*x_39 - 3.16611068470245*x_4 - 851.937963181956*x_40 + 0.0604163579377787*x_41 - 9.74785308901799*x_42 + 17.4225999531616*x_43 - 12.6635777434188*x_44 - 71.189482088993*x_45 + 27.8104268185228*x_46 - 63.5180806932653*x_47 - 84.5485603831672*x_48 + 28.4906655559607*x_5 + 0.315057789107703*x_50 - 1.47765325046159*x_52 - 0.633149664725599*x_53 + 0.477646434439771*x_54 + 48.2111829384994*x_56 - 1.15019433045826*x_58 + 23.9700132162925*x_59 - 1.12277570914511*x_6 + 2.07228292583134*x_60 + 6.67326563737088*x_61 + 11.2030028475123*x_62 + 8.54129513431503*x_63 + 9.68285551751572*x_64 + 2.06928271848865*x_65 + 0.426608651447632*x_66 + 6.2802796489483*x_67 + 1.32648711576032*x_68 - 3.0067562720443*x_69 + 13.1059144314377*x_7 - 9.30913439738647*x_70 - 11.7820768010021*x_71 - 6.66019934254913*x_72 + 0.707506027389289*x_73 - 1.67289336761145*x_74 - 14.6877140091879*x_75 - 5.42906939947659*x_76 + 3.9213273562958*x_77 + 4.28549377045951*x_78 - 26.8083750272893*x_79 - 1.9091283278933*x_8 - 1.1683231011721*x_80 - 4.12477427076195*x_81 - 2.65156801415619*x_82 + 17.8618106624673*x_83 + 3.34700836860499*x_84 - 0.526603989106738*x_85 + 125.238335733022*x_86 + 90.7158771392822*x_87 + 13.3997110611582*x_88 - 3.34795133951118*x_89 + 6.35774076333903*x_9 - 0.218510172410375*x_90 - 0.0786886231754942*x_91 - 8.07206088934245*x_92 - 26.0987804985528*x_93 + 0.476289234426747*x_94 - 7.41758740943594*x_95 - 13.524280130912*x_96 - 0.358396062576373*x_97 + 7.81392563487343*x_98 + 22.6409215610106*x_99 - 0.0199500204668232*std::pow(-7.29048013687134*x_18 - 4.2513599395752, 2) - 0.00264798002766083*std::pow(-6.34488010406494*x_18 - 3.87999987602234, 2) + 0.00880367048677201*std::pow(-9.99703979492188*x_33 - 8.80000019073486, 2) + 0.000521862235369814*std::pow(-9.93808078765869*x_56 - 0.139600038528442, 2) - 0.0515831841632532*std::exp(1.10463988780975*x_1) - 0.014218287258442*std::exp(1.27999985218048*x_1) - 0.0107741085768823*std::exp(1.32983994483948*x_1) + 0.00308856954783355*std::exp(1.33063983917236*x_1) - 0.101507423019862*std::exp(1.79583990573883*x_1) + 0.0700908254845182*std::exp(1.89927983283997*x_1) + 0.0236439582353796*std::exp(0.68343985080719*x_10) - 2.237489017145*std::exp(0.712479829788208*x_10) - 0.0362503825084668*std::exp(0.782719850540161*x_10) - 0.0464695585950326*std::exp(0.806639909744263*x_10) + 0.0150604177467646*std::exp(0.807519853115082*x_10) + 0.0162096558101633*std::exp(0.83463990688324*x_10) - 0.0075502901064711*std::exp(0.860239923000336*x_10) - 0.218882198869573*std::exp(0.939199805259705*x_10) + 0.102697197841007*std::exp(1.05287981033325*x_10) + 0.318318094202321*std::exp(0.837359845638275*x_11) - 0.00993865634042699*std::exp(0.884399890899658*x_11) - 0.0467043984860818*std::exp(0.896239876747131*x_11) + 0.0205084870679853*std::exp(0.927199840545654*x_11) - 0.0200608523444721*std::exp(0.931759834289551*x_11) - 0.817955073931202*std::exp(0.933759808540344*x_11) + 0.019177587147675*std::exp(0.951039850711823*x_11) + 0.837048013358304*std::exp(0.958639860153198*x_11) - 0.0055409556003372*std::exp(0.975439846515656*x_11) - 0.430250726676091*std::exp(1.01423990726471*x_11) - 0.813514994582647*std::exp(0.427279859781265*x_12) - 0.0632347083855041*std::exp(0.519439876079559*x_12) + 0.0176521289117618*std::exp(0.88239985704422*x_12) + 0.259473423554645*std::exp(0.905999839305878*x_12) + 0.000711884669250739*std::exp(0.997519791126251*x_12) + 0.0352670137942542*std::exp(1.23287987709045*x_12) + 0.0193768854595757*std::exp(0.619519829750061*x_13) - 0.00120818939301659*std::exp(1.07167983055115*x_13) - 0.000215288505532088*std::exp(1.30135977268219*x_13) + 29.8907785815121*std::exp(0.264079838991165*x_14) - 0.0738631395087036*std::exp(0.453439861536026*x_14) - 3.3319651286288*std::exp(0.619439840316772*x_14) + 0.00653874081813331*std::exp(0.899199843406677*x_14) + 1.07268876168703*std::exp(0.827359914779663*x_15) + 0.00721331983093703*std::exp(0.876239895820618*x_15) + 0.0235291619140415*std::exp(0.927279829978943*x_15) + 0.00376277114638167*std::exp(0.928959846496582*x_15) - 1.4512203392587*std::exp(0.932479858398438*x_15) + 0.00313700439431342*std::exp(1.01999986171722*x_15) + 0.000687634796282135*std::exp(1.1373598575592*x_15) + 0.0580777520905538*std::exp(0.38351982831955*x_16) + 0.248624853842706*std::exp(0.547599852085114*x_16) + 0.0378200442814828*std::exp(0.600879848003387*x_16) - 0.0526841089753313*std::exp(0.678639829158783*x_16) - 0.00171937981501318*std::exp(0.935519814491272*x_16) + 0.108650093624438*std::exp(0.628639817237854*x_17) + 0.0720937473709865*std::exp(0.667199850082397*x_17) + 4.81244966413101*std::exp(0.677199840545654*x_17) + 7.99138993217186*std::exp(0.695839881896973*x_17) + 0.17353890012112*std::exp(0.7151198387146*x_17) - 0.0698128685650824*std::exp(0.693999886512756*x_19) - 11.818468920491*std::exp(0.714319825172424*x_19) + 0.0336504138424824*std::exp(0.71535986661911*x_19) - 0.151392266379584*std::exp(0.717759847640991*x_19) - 3.06896531314004*std::exp(0.728159844875336*x_19) + 0.0701135656567742*std::exp(0.751519858837128*x_19) - 18.4022673918397*std::exp(0.766079843044281*x_19) - 0.0339578899121708*std::exp(0.825519859790802*x_19) - 0.0129861085340466*std::exp(0.880719900131226*x_19) + 1.51561921368244*std::exp(0.594239830970764*x_2) - 0.0473279495467616*std::exp(0.739439845085144*x_2) - 0.185098075860568*std::exp(0.749919831752777*x_2) - 7.52818967641832*std::exp(0.779519855976105*x_2) + 4.31571113397008*std::exp(0.884239912033081*x_2) - 0.0231560571978556*std::exp(0.947919845581055*x_2) + 0.00273108110189292*std::exp(1.33703982830048*x_2) - 7.80561069007458*std::exp(0.395839840173721*x_20) - 0.0407176572349154*std::exp(0.457199841737747*x_20) + 0.664222255521447*std::exp(0.519039869308472*x_20) + 0.00488140408298919*std::exp(0.855199873447418*x_20) + 0.851134248432171*std::exp(0.866639912128448*x_20) + 0.000254357223164715*std::exp(1.17951989173889*x_20) - 1.95528179920778e-5*std::exp(1.35351979732513*x_20) + 0.114761189782571*std::exp(1.0551198720932*x_21) + 0.267707491445328*std::exp(0.538959860801697*x_22) + 0.00408803972058449*std::exp(0.831119894981384*x_22) - 0.0698093855795338*std::exp(1.05791985988617*x_22) + 0.000286387967401448*std::exp(1.28927981853485*x_22) + 0.000182013658877476*std::exp(1.33255982398987*x_22) - 16.2374701056224*std::exp(0.619919836521149*x_23) + 0.0843647689439204*std::exp(0.693919837474823*x_23) - 3.00234581327489*std::exp(0.69735985994339*x_23) + 0.0268304942362932*std::exp(0.720719873905182*x_23) - 0.0350377370067037*std::exp(0.722399830818176*x_23) + 0.0386664299130679*std::exp(0.726079881191254*x_23) + 6.12772173278733*std::exp(0.748559832572937*x_23) - 1.10963723437879*std::exp(0.811039865016937*x_23) + 0.00111694934343585*std::exp(0.972799837589264*x_23) - 0.0906792850895497*std::exp(0.312959849834442*x_24) + 16.4079137891983*std::exp(0.446319848299026*x_24) - 0.316220271171215*std::exp(0.608799874782562*x_24) + 0.0400925267488592*std::exp(0.626559853553772*x_24) - 0.059377103153705*std::exp(0.689279854297638*x_24) + 1.35270626712736*std::exp(0.733279824256897*x_24) + 0.0978020228970746*std::exp(0.44327986240387*x_25) - 0.0945354900713575*std::exp(0.543599843978882*x_25) - 10.2041617392532*std::exp(0.614479839801788*x_25) + 0.348747442824314*std::exp(0.783199846744537*x_25) + 0.815170539051421*std::exp(0.797279894351959*x_25) - 0.00795335459164533*std::exp(0.822319865226746*x_25) - 0.00568380772172676*std::exp(0.882079899311066*x_25) + 0.0115496136323215*std::exp(0.994239807128906*x_25) - 0.0025684850744215*std::exp(0.997759819030762*x_25) - 0.166682790361363*std::exp(0.439359873533249*x_26) - 1.08616816251448*std::exp(0.595519840717316*x_26) - 2.00353693049547*std::exp(0.669679820537567*x_26) + 0.887421793766847*std::exp(0.748879849910736*x_26) - 0.0153155647308956*std::exp(0.816239893436432*x_26) + 0.0137364689974585*std::exp(0.825599908828735*x_26) - 0.00848369604743139*std::exp(0.871999859809875*x_26) - 0.000412871810190212*std::exp(1.1651998758316*x_26) - 0.000505294728717971*std::exp(1.19079983234406*x_27) + 0.00108095799857417*std::exp(1.22255980968475*x_27) + 0.0129887075920526*std::exp(1.22495996952057*x_27) + 0.0884256046504577*std::exp(1.26967978477478*x_27) + 0.000571223692514984*std::exp(1.42463982105255*x_27) - 7.7418511970019*std::exp(0.559919834136963*x_28) + 7.92613574304964*std::exp(0.587999820709229*x_28) - 0.0346769822708315*std::exp(0.67631983757019*x_28) + 0.0301976634433847*std::exp(0.690719842910767*x_28) + 0.0177135361650869*std::exp(0.717759847640991*x_28) - 0.0102430436293658*std::exp(0.782079875469208*x_28) + 0.230799639079205*std::exp(0.911999821662903*x_28) - 0.107777458846973*std::exp(1.1043199300766*x_29) + 0.00364053517799774*std::exp(1.13167989253998*x_29) + 0.0016010307503694*std::exp(1.13919985294342*x_29) - 0.00118867299617392*std::exp(1.14943981170654*x_29) + 0.314936606619083*std::exp(1.15047979354858*x_29) - 0.000254049653465705*std::exp(1.30935978889465*x_29) - 0.00316824716426464*std::exp(1.35751986503601*x_29) + 4.14449404909183*std::exp(0.411679863929749*x_3) - 0.0578655920517489*std::exp(0.555839836597443*x_3) - 0.0739575454827775*std::exp(0.65151983499527*x_3) - 0.0780930117696016*std::exp(0.657999873161316*x_3) + 0.0120916156630199*std::exp(0.949759840965271*x_3) + 1.16256206435663*std::exp(0.983039796352386*x_3) - 0.0250286421388963*std::exp(0.6422398686409*x_30) + 5.98655264114656*std::exp(0.799999833106995*x_30) - 3.55913587260289*std::exp(0.843599855899811*x_30) - 0.00891867268772643*std::exp(0.844959855079651*x_30) - 0.595334581830046*std::exp(0.928399801254272*x_30) - 0.0108931741554209*std::exp(0.962799787521362*x_30) - 0.00440691044611567*std::exp(1.03063988685608*x_30) + 0.00164672291776724*std::exp(1.09807980060577*x_30) - 0.00767069032378204*std::exp(1.10879981517792*x_30) - 0.00632875812626043*std::exp(0.816479861736298*x_32) + 2.21819844517497*std::exp(0.830799877643585*x_32) + 0.00697391344259244*std::exp(0.873279869556427*x_32) - 30.2729877699809*std::exp(0.337679862976074*x_33) - 0.0480559866123238*std::exp(0.393599838018417*x_33) + 24.8035632233015*std::exp(0.417359858751297*x_33) + 0.190952593508594*std::exp(0.425519853830338*x_33) + 28.7391113773346*std::exp(0.358959853649139*x_34) - 0.157605052905397*std::exp(0.365919858217239*x_34) + 12.0144710793404*std::exp(0.429999858140945*x_36) + 0.318437687832279*std::exp(0.381999850273132*x_4) - 8.28430901127567*std::exp(0.475839853286743*x_4) + 0.0252429961685218*std::exp(0.60919988155365*x_4) + 0.0306472590631868*std::exp(0.61959981918335*x_4) + 0.0375320472084452*std::exp(0.755119860172272*x_4) - 0.00169452283363602*std::exp(0.894799828529358*x_4) + 0.280252201121518*std::exp(1.16215980052948*x_4) - 0.0967172117265295*std::exp(1.17103981971741*x_4) + 0.00186492523795693*std::exp(1.17639982700348*x_4) + 2.53133637326206*std::exp(0.683199822902679*x_41) + 0.494461189354127*std::exp(0.767599880695343*x_41) - 0.118871677722558*std::exp(0.7704798579216*x_41) - 0.015897431840116*std::exp(0.784719884395599*x_41) + 0.050860711270125*std::exp(0.803359866142273*x_41) - 4.38038176513472*std::exp(0.804319858551025*x_41) + 1.9861540505275*std::exp(0.808079898357391*x_41) + 0.0149202992980409*std::exp(0.808239877223969*x_41) + 3.78587943817478*std::exp(0.633279860019684*x_42) + 0.00980696943145565*std::exp(0.719839870929718*x_42) + 0.359826607912959*std::exp(0.733519852161407*x_42) - 0.407728388894653*std::exp(0.816239893436432*x_42) + 0.00400469923787434*std::exp(0.75087982416153*x_43) - 0.00349512364861518*std::exp(0.821199893951416*x_43) + 0.000369727792428411*std::exp(0.844239890575409*x_44) - 0.0377360101617601*std::exp(0.897199809551239*x_44) + 0.000584548561239372*std::exp(0.97439980506897*x_44) + 0.0151228647149019*std::exp(0.521199882030487*x_45) + 0.0104550701226427*std::exp(0.675519824028015*x_46) + 0.319803006606733*std::exp(0.691119849681854*x_46) + 0.0808494319815437*std::exp(0.763439834117889*x_46) + 3.15824874072405*std::exp(0.766159892082214*x_46) - 2.23092925026801*std::exp(0.79447990655899*x_46) - 0.020016659621722*std::exp(0.795199871063232*x_46) + 0.282345550437961*std::exp(0.484159857034683*x_47) - 7.31474694895721*std::exp(0.519519865512848*x_47) - 0.0382002979832281*std::exp(0.598719835281372*x_48) + 0.0102535869662541*std::exp(0.655999839305878*x_49) - 0.12695030011827*std::exp(0.690879821777344*x_49) + 13.204104193408*std::exp(0.702399849891663*x_49) - 8.95127146892297*std::exp(0.70719987154007*x_49) + 33.2043234929459*std::exp(0.710559844970703*x_49) - 0.130104511213337*std::exp(0.714879810810089*x_49) + 0.0776232941665304*std::exp(0.715039849281311*x_49) - 0.0759218304551364*std::exp(0.717039823532104*x_49) + 2.46323774173749*std::exp(0.718959867954254*x_49) + 0.0288887198861928*std::exp(0.719279825687408*x_49) - 6.38909571134576e-6*std::exp(1.92919981479645*x_5) + 0.0492351045357466*std::exp(0.479759842157364*x_50) - 17.5629784037622*std::exp(0.541039824485779*x_50) + 9.59758125978804*std::exp(0.549919843673706*x_50) - 1.67259171868449*std::exp(0.552239894866943*x_50) + 12.7444669374126*std::exp(0.554079830646515*x_50) - 0.0502806416702685*std::exp(0.58679986000061*x_50) - 0.00968021450161897*std::exp(0.61983984708786*x_50) - 0.0068272316890203*std::exp(0.667119860649109*x_50) + 0.21248550624751*std::exp(0.485599845647812*x_51) + 72.4781034856762*std::exp(0.495279848575592*x_51) - 163.781791303236*std::exp(0.495439857244492*x_51) + 0.478154064392449*std::exp(0.495919853448868*x_51) - 42.1903259894649*std::exp(0.495999842882156*x_51) - 1.07592833848303*std::exp(0.496239870786667*x_51) - 0.690641208156515*std::exp(0.497919857501984*x_51) - 0.17246758389154*std::exp(0.498719841241837*x_51) - 10.6996263144758*std::exp(0.504399836063385*x_51) + 8.95613064017344*std::exp(0.503519833087921*x_52) - 0.056792275863271*std::exp(0.579199850559235*x_52) - 0.0449283200281697*std::exp(0.628959834575653*x_52) + 0.025748330198197*std::exp(0.709119856357574*x_52) + 0.00562915870779495*std::exp(0.72111988067627*x_52) + 0.190260463804744*std::exp(0.745919823646545*x_52) + 0.000697182339828637*std::exp(0.87967985868454*x_52) + 0.100435064291017*std::exp(0.467919856309891*x_54) - 0.199100733768484*std::exp(0.488959848880768*x_54) + 42.7647880916934*std::exp(0.515999853610992*x_54) + 0.286057587457757*std::exp(0.532239854335785*x_54) - 0.0529733883201661*std::exp(0.533839821815491*x_54) + 0.0863779485347825*std::exp(0.533999860286713*x_54) - 30.7802567311403*std::exp(0.535999834537506*x_54) - 0.299378166922155*std::exp(0.537439823150635*x_54) - 0.0400038017355719*std::exp(0.61959981918335*x_55) + 0.0623102357819948*std::exp(0.635919868946075*x_55) + 21.7375022853767*std::exp(0.65015983581543*x_55) + 0.581184566270036*std::exp(0.651679813861847*x_55) - 9.05678388539653*std::exp(0.652799844741821*x_55) + 3.14305347862359*std::exp(0.655679821968079*x_55) + 80.1138893676365*std::exp(0.656159818172455*x_55) + 0.217079170509706*std::exp(0.656319856643677*x_55) + 79.3253501570318*std::exp(0.657199859619141*x_55) + 0.27054012740984*std::exp(0.659119844436646*x_55) + 21.8561620449842*std::exp(0.402799874544144*x_56) + 41.3699250660514*std::exp(0.458079844713211*x_56) - 0.0648360871746234*std::exp(0.521679878234863*x_56) - 3.3134117769264*std::exp(0.548719882965088*x_56) - 0.225021094616614*std::exp(0.656559824943542*x_56) + 0.0157971170528397*std::exp(0.671279847621918*x_56) + 0.0131783805745762*std::exp(0.737839818000793*x_56) - 0.00467750923091891*std::exp(0.840079843997955*x_56) + 17.94596373759*std::exp(0.612879812717438*x_57) + 0.157469915675102*std::exp(0.620399832725525*x_57) - 0.425979075728555*std::exp(0.626639842987061*x_57) - 0.269986328705708*std::exp(0.628719866275787*x_57) + 0.107772448588355*std::exp(0.631839871406555*x_57) - 46.5631151964902*std::exp(0.63351982831955*x_57) + 0.225308661239772*std::exp(0.639759838581085*x_57) - 32.5756664082976*std::exp(0.640399813652039*x_57) + 0.0641122745104789*std::exp(0.644639849662781*x_57) - 1.24143633501771*std::exp(0.655679821968079*x_57) - 0.154453284628006*std::exp(0.401999861001968*x_58) + 8.38538942636137*std::exp(0.521199882030487*x_58) - 5.90943626381949*std::exp(0.560399830341339*x_58) - 0.0428127679826231*std::exp(0.562319815158844*x_58) + 0.0357157634295412*std::exp(0.610559821128845*x_58) - 0.0711695589019294*std::exp(0.612719833850861*x_58) + 0.0159502342550396*std::exp(0.66023987531662*x_58) + 0.726465239364797*std::exp(0.671919822692871*x_58) - 1.07956487231313*std::exp(0.683759808540344*x_58) - 8.63582000090726*std::exp(0.516079843044281*x_59) + 4.37924072120064*std::exp(0.642879843711853*x_59) - 0.0181486428852845*std::exp(0.651439845561981*x_59) - 0.0232096361175907*std::exp(0.696319878101349*x_59) - 0.00250774195247433*std::exp(0.784239888191223*x_59) + 0.0325023392782128*std::exp(0.914319813251495*x_59) + 0.00014176020550138*std::exp(1.11175990104675*x_59) + 0.0123357716624874*std::exp(0.776479840278625*x_60) + 0.0738816695875555*std::exp(0.789359867572784*x_60) - 5.07060655714565*std::exp(0.82287985086441*x_60) - 0.017691312672194*std::exp(0.827119886875153*x_60) - 2.06544800151759*std::exp(0.83383983373642*x_60) + 0.0136978060738195*std::exp(0.855439901351929*x_60) + 2.93877415599427*std::exp(0.855599880218506*x_60) - 0.0140699606198805*std::exp(0.87527984380722*x_60) + 0.000965670989324372*std::exp(0.97055983543396*x_60) - 0.00397257072583998*std::exp(1.06751978397369*x_61) - 0.0106995709993638*std::exp(1.41151988506317*x_61) - 0.0039842912277285*std::exp(1.48039984703064*x_61) - 0.528678795436324*std::exp(1.54959976673126*x_61) + 0.102084304890002*std::exp(0.620399832725525*x_66) + 3.60153031022112*std::exp(0.898959815502167*x_66) - 4.97737868295766*std::exp(0.940879821777344*x_66) - 6.72186544968544e-5*std::exp(1.60559988021851*x_7) - 0.00146928480577305*std::exp(1.86407995223999*x_7) + 0.1286105804035*std::exp(0.557119846343994*x_8) + 3.21196012764895*std::exp(0.561599850654602*x_8) - 1.43951347111396*std::exp(0.82727986574173*x_8) - 0.00136080687044117*std::exp(0.832399845123291*x_8) + 0.00214877642725186*std::exp(0.850879848003387*x_8) - 2.18356732832957e-6*std::exp(1.72775983810425*x_9) - 0.317386521763613*std::log(4.17511987686157 - 0.624479830265045*x_5) - 0.724553252607823*std::sin(0.14544004201889*x_1 + 4.92015981674194) - 0.0689315105760934*std::sin(0.217600002884865*x_101 + 8.20775985717773) - 93.0406877000185*std::sin(0.298079937696457*x_103 - 7.48615980148315) - 52.7968444810517*std::sin(0.270719945430756*x_107 - 7.4443998336792) - 70.1548737358632*std::sin(0.24415996670723*x_108 - 1.1950398683548) + 2.1254184944966*std::sin(0.285119920969009*x_113 - 7.42575979232788) + 16.0369009246314*std::sin(0.304159939289093*x_113 - 1.22191989421844) + 51.3697521107229*std::sin(0.292639940977097*x_114 + 8.10760021209717) - 0.286789610504645*std::sin(0.221279993653297*x_116 + 5.17928028106689) - 0.265075987577828*std::sin(0.239519983530045*x_117 - 7.43887996673584) + 2.03003872145499*std::sin(0.269199967384338*x_117 + 1.93663990497589) - 95.7275580645438*std::sin(0.258879989385605*x_120 + 8.34255981445313) + 0.581828687092347*std::sin(0.264239966869354*x_120 - 7.42104005813599) + 63.4697311923287*std::sin(0.269279956817627*x_120 + 5.15327978134155) - 0.896017387398549*std::sin(0.271759957075119*x_120 - 7.44655990600586) - 0.612599719573916*std::sin(0.280559957027435*x_120 - 7.44615983963013) - 0.529009824968516*std::sin(0.245119974017143*x_20 - 4.37967967987061) + 0.358890944358874*std::sin(0.412479877471924*x_21 - 7.41631984710693) - 39.4052670196496*std::sin(0.416879862546921*x_22 + 2.00263977050781) + 3.65513814346106*std::sin(0.16056002676487*x_3 + 1.77247989177704) + 0.225758471197319*std::sin(0.343199849128723*x_31 - 4.24496030807495) + 0.459506235279573*std::sin(0.3504798412323*x_35 + 1.83119988441467) + 72.6050341716938*std::sin(0.32151985168457*x_37 + 5.08903980255127) + 0.43002066262859*std::sin(0.282319933176041*x_42 + 5.11696004867554) - 33.4267650949369*std::sin(0.476879835128784*x_5 - 4.28232002258301) - 91.4401323559741*std::sin(0.294399946928024*x_53 - 4.27839994430542) + 0.183043658439208*std::sin(0.455759853124619*x_6 + 1.95391988754272) + 0.129907992529229*std::sin(0.57287985086441*x_64 + 5.36984014511108) + 0.172332953202511*std::sin(0.576239883899689*x_65 + 2.18959999084473) - 0.799384554812435*std::sin(0.582639873027802*x_65 - 7.20071983337402) + 95.8847717313155*std::sin(0.219119995832443*x_9 - 7.589439868927) - 1.2036558589687*std::sin(0.327599853277206*x_9 - 4.33911991119385) - 0.255877373160303*std::sin(0.390079855918884*x_9 + 1.9851998090744) + 0.245400766873034*std::sin(0.474319845438004*x_9 - 1.12655985355377) - 10.5762060392121*std::sin(0.354399859905243*x_91 - 7.40903997421265) - 33.0321406561759*std::sin(0.359999865293503*x_91 + 2.00431990623474) - 0.394790609529914*std::sin(0.381119847297668*x_91 - 1.19447994232178) - 0.355147571957111*std::sin(0.383759826421738*x_91 + 8.19527912139893) + 53.0340378785863*std::sin(0.390719830989838*x_91 - 4.39071989059448) + 16.6333912930729*std::sin(0.3018399477005*x_92 - 1.18935990333557) + 0.190582229901079*std::sin(0.311039924621582*x_92 + 8.22056007385254) + 84.1096847090032*std::sin(0.313199937343597*x_92 - 4.37519979476929) - 0.21363801831932*std::sin(0.279199957847595*x_95 - 1.19967985153198) + 1.8734163815257*std::sin(0.301439940929413*x_97 - 7.45655965805054) - 100.104242230514*std::sin(0.303759932518005*x_97 + 1.957359790802) + 0.316187122531484*std::sin(0.315439909696579*x_97 + 1.92727982997894) + 0.390475661893832*std::sin(0.236799985170364*x_98 + 5.18336009979248) - 1.74727643258318*std::sin(0.26079997420311*x_98 + 1.96743977069855) + 11.4523607289692*std::sin(0.271759957075119*x_98 - 1.21863985061646) + 0.304851763358565*std::sin(0.275039941072464*x_98 + 1.95935988426208) + 1618.18925073004);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
