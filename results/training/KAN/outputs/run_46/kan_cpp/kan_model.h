
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.543750395679009*x_1 - 68947.7997195561*x_10 - 31915.8058963786*x_100 - 1897120.69339821*x_101 + 20421.9548585882*x_102 - 12198.923041055*x_103 - 51148.1953957157*x_104 - 35855.588260482*x_105 - 23450.6014129471*x_106 - 245116.178964339*x_107 + 10622.4903147363*x_108 - 46823.3847211188*x_109 + 64954.6803667071*x_11 - 41914.0305937273*x_110 + 70915.162644348*x_111 - 23203.5458644989*x_112 + 160314.243833306*x_113 + 2065.44179219016*x_114 + 27.2415792778839*x_115 - 23896.9023995744*x_116 - 36186.0189529854*x_117 - 16466.0242748098*x_118 + 38283.2905172696*x_119 + 95639.3159854568*x_12 - 82575.5709656226*x_120 + 13180.6607482043*x_13 - 71548.3967259015*x_14 - 22395.0527865362*x_15 + 47262.5746225408*x_16 + 137.15465867758*x_17 - 60652.8504587429*x_18 - 6295.76359120074*x_19 + 67544.4488635769*x_2 + 27272.0924355593*x_20 + 31078.8299800708*x_21 - 6898.76695872768*x_22 + 35949.3549267517*x_23 - 16392.0765889631*x_24 + 36038.2750408543*x_25 + 9808.26185900989*x_26 - 27076.3264722058*x_27 - 23.2376302331674*x_28 + 37266.2790497295*x_29 - 45284.418280992*x_3 + 72885.6496606505*x_30 - 784820.970010002*x_31 + 24970.2632374438*x_32 - 70340.0675132194*x_33 + 50722.3034842629*x_34 - 16910.0007355715*x_35 + 33.7723128726787*x_36 - 90217.220528136*x_37 - 37804.9645888227*x_38 + 44731.476279145*x_39 - 138103.773560054*x_4 + 58887.2807065379*x_40 - 12562.0323998835*x_41 + 34955.3600304749*x_42 - 52004.7189264336*x_43 - 16938.7589905212*x_44 - 64581.3002585693*x_45 + 35989.860979495*x_46 - 64159.7461549579*x_47 + 56398.0263712301*x_48 + 16878.4398954583*x_49 + 9151.02817527358*x_5 + 2.94423274117048*x_50 + 69740.6281363524*x_51 + 41247.1370163965*x_52 + 46391.4740311489*x_53 - 121096.181412955*x_54 + 41594.6985075067*x_55 - 52833.1436069955*x_56 + 37901.264991612*x_57 - 23881.4174222674*x_58 + 40792.6503059349*x_59 - 25979.2115359979*x_6 - 66643.8795773067*x_60 + 73651.1210087668*x_61 - 28513.2054919644*x_62 - 44039.2523252724*x_63 - 93458.0056181611*x_64 - 64768.6827183786*x_65 - 100235.788660643*x_66 - 53585.7392241992*x_67 - 34448.6617207906*x_68 - 57735.0073441131*x_69 - 31114.9215642302*x_7 + 84977.5607101259*x_70 + 12272.1636210192*x_71 - 131580.736134729*x_72 + 10.5140637886917*x_73 + 15599.8501052848*x_74 + 4964.66515756928*x_75 + 44131.00557244*x_76 + 85086.9922990189*x_77 + 86001.1422506731*x_78 + 44866.6395926739*x_79 - 635141.556318074*x_8 + 90.4712099177572*x_80 + 42204.9004670407*x_81 + 93003.6452369824*x_82 + 7330.98048979061*x_83 - 84194.1291019809*x_84 - 59192.2166012752*x_85 - 89298.4907154556*x_86 - 15259.9641446149*x_87 - 58377.847010748*x_88 - 110015.078451767*x_89 + 369723.633004879*x_9 - 211869.493033299*x_90 + 134444.915794554*x_91 + 44064.0122018569*x_92 - 2029368.79056138*x_93 - 50552.4547516589*x_94 - 103991.484618304*x_95 + 74641.6348830606*x_96 + 83436.3726947551*x_97 - 30954.5439044486*x_98 - 76633.1218986802*x_99 + 0.0010655337588133*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 1.06645018415906e-5*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) + 0.423735992356881*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) - 3.7594619560271e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) - 0.00101428565484896*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) - 1.14788544525023*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 0.000159825831629902*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 1.18783837194113e-6*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.000715408918240266*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00208558989336203*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) + 0.144453162645412*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) - 0.0109706397289063*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 2.07774883702093e-6*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) + 0.00244115502935366*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) - 0.00440094291459879*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) + 0.187973065605602*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 3.93283740085195e-5*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) - 0.210705922913092*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00161316179285657*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) - 0.252590329480263*std::exp(0.675439834594727*x_1) + 19.9821089198949*std::exp(0.805679857730865*x_1) + 5620.99403440571*std::exp(0.820959866046906*x_1) + 0.0161781089002959*std::exp(0.863999843597412*x_1) - 5.27843928590363e-5*std::exp(0.999759793281555*x_1) + 0.000595022433006009*std::exp(1.01575982570648*x_1) - 0.163877279633951*std::exp(1.04399979114532*x_1) + 1.92426616739587e-5*std::exp(1.06791973114014*x_1) - 9.13505260245581*std::exp(1.0971999168396*x_1) + 4.20837115223186e-5*std::exp(1.11495983600616*x_1) - 0.00469423123228825*std::exp(1.13255989551544*x_1) - 0.000689330509132602*std::exp(1.20439982414246*x_1) - 0.0312745465671449*std::exp(0.975199818611145*x_108) + 0.29990674908866*std::exp(1.29199981689453*x_108) - 0.015589280231151*std::exp(1.58871984481812*x_108) - 0.00419253885096678*std::exp(1.60567986965179*x_108) + 752.572867849621*std::exp(2.76399993896484*x_17) + 0.00197325168007156*std::exp(2.89416003227234*x_17) + 0.00510593946656349*std::exp(2.91807985305786*x_17) + 0.0009504888383491*std::exp(3.5239999294281*x_17) + 0.000599484340761022*std::exp(3.58959984779358*x_17) - 1.96076591518777e-6*std::exp(3.60615992546082*x_17) - 8.34471217376786e-6*std::exp(3.7247200012207*x_17) - 2.78296461241551*std::exp(0.934719800949097*x_29) + 0.090261181086475*std::exp(1.11599981784821*x_29) - 15.6017516648856*std::exp(1.20207989215851*x_29) - 0.0823587693709604*std::exp(1.28559982776642*x_29) + 0.00990776951440051*std::exp(1.62799978256226*x_29) + 0.000436486963820539*std::exp(1.69127988815308*x_29) + 5.14726339147434e-6*std::exp(2.63527989387512*x_29) + 0.000883061393132781*std::exp(1.38783979415894*x_38) - 0.718750417070693*std::exp(1.42807984352112*x_38) - 0.00843502102126453*std::exp(2.43751978874207*x_38) + 0.000213871986112976*std::exp(2.55167984962463*x_38) + 0.000586695084122563*std::exp(1.51279985904694*x_50) - 0.00977305676899629*std::exp(1.64831984043121*x_50) + 0.0531416050034693*std::exp(1.6839998960495*x_50) + 0.423915390533333*std::exp(1.73599982261658*x_50) - 50219.0175746199*std::exp(1.89111995697021*x_50) - 2.01616195376785*std::exp(1.92567980289459*x_50) + 0.000318988507159337*std::exp(1.93199980258942*x_50) - 0.058555860277956*std::exp(1.93495976924896*x_50) - 92.1889941451235*std::exp(1.95423984527588*x_50) + 0.00961029167209754*std::exp(2.00951981544495*x_50) - 0.190143780189358*std::exp(0.747759819030762*x_66) + 0.180541491971967*std::exp(0.704879820346832*x_71) - 24.2343475422407*std::exp(0.727519869804382*x_71) + 0.0349425715403948*std::exp(1.12319993972778*x_71) - 0.767039571471253*std::exp(1.13343989849091*x_71) - 0.000950886098034742*std::exp(1.17391979694366*x_71) + 0.0326664951438401*std::exp(1.27175986766815*x_71) - 0.00717102717017187*std::exp(1.67999982833862*x_71) + 25.4091695586734*std::exp(1.69519984722137*x_71) - 0.444407461947033*std::exp(1.85879993438721*x_71) + 0.000866327489517594*std::exp(1.86255991458893*x_71) - 0.0123308921298099*std::exp(1.9048798084259*x_71) + 0.0734221657135807*std::exp(1.04767978191376*x_72) + 102493.343608292*std::exp(0.721359848976135*x_73) + 0.099650305937821*std::exp(0.838959872722626*x_73) - 0.00380923775961601*std::exp(0.977439820766449*x_76) + 0.528589454019553*std::exp(1.22399985790253*x_76) + 7.65414037599605e-5*std::exp(2.10399985313416*x_76) - 0.00229433734527639*std::exp(2.24863982200623*x_76) - 0.0483978375916211*std::exp(1.07551980018616*x_77) + 0.692937842745051*std::exp(1.43767976760864*x_77) + 0.0633009657346557*std::exp(1.19447994232178*x_78) - 0.0292166526006104*std::exp(1.61599981784821*x_78) - 0.0191239196069053*std::exp(1.83559989929199*x_78) - 3.48112865618645*std::exp(1.90311992168427*x_78) - 4.74306298870335*std::exp(1.36295986175537*x_81) - 0.0601299711600885*std::exp(1.0487197637558*x_87) - 9.95860526365941*std::exp(0.894479870796204*x_88) - 9.51967771999581*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 0.00529673653844917*std::sin(0.232239991426468*x_104 - 7.55864000320435) - 0.605265471584004*std::sin(0.300959914922714*x_104 - 1.30567979812622) + 201.558532532722*std::sin(0.316399931907654*x_104 + 1.89671981334686) + 0.013058512342607*std::sin(0.34063982963562*x_105 + 5.15248012542725) + 233.844060719806*std::sin(0.426319867372513*x_105 + 2.02519989013672) + 1.01419461666557*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 18.4361595959058*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.00790394981145156*std::sin(0.499759823083878*x_105 + 2.03655982017517) - 27.2815710579743*std::sin(0.517119884490967*x_105 + 8.36359977722168) + 0.452980825012501*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 1.01404403439971*std::sin(0.401439845561981*x_111 - 7.40527963638306) + 375.835693749388*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 0.00657838682827905*std::sin(0.260399967432022*x_112 + 5.04791975021362) + 282392.332733053*std::sin(0.51503986120224*x_115 + 2.13183975219727) - 66.9849978469723*std::sin(0.454559862613678*x_117 - 7.36303997039795) - 170.553110820036*std::sin(0.440479874610901*x_120 - 1.17087984085083) - 58.2361081389353*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 15.906289372761*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.44811753014976*std::sin(0.429919868707657*x_15 + 5.22760009765625) - 0.400994081822873*std::sin(0.551439881324768*x_15 + 2.14655995368958) - 0.526162357169663*std::sin(0.504719853401184*x_17 - 4.07760000228882) - 1.10706055202682*std::sin(0.436239868402481*x_19 - 1.1658399105072) - 121.106991242366*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 1.05485567301835*std::sin(0.459999859333038*x_21 - 4.36111974716187) + 1624.56116917316*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 37.3883988429118*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 1.15885172623774*std::sin(0.314319849014282*x_28 - 4.30048036575317) + 68.6756625313936*std::sin(0.319439828395844*x_28 - 4.27544021606445) + 12.1227075659799*std::sin(0.325839847326279*x_28 - 4.26304006576538) - 0.574410009154026*std::sin(0.341279834508896*x_28 + 5.1275200843811) - 588472.946357009*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 704.912837455003*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 16.7087838885983*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 0.936852012440366*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 1.03076261587726*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 1074.60038245302*std::sin(0.323519825935364*x_36 - 1.24327993392944) - 9.59780789910236*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 0.00462611645529313*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 1.45925074303876*std::sin(0.345119833946228*x_36 + 5.14664030075073) - 0.0243937964037229*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 0.995799445420583*std::sin(0.361759841442108*x_36 + 1.95119988918304) - 0.743014299134326*std::sin(0.380479842424393*x_36 + 8.37952041625977) + 245646.179301051*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.0227851290372644*std::sin(0.343599855899811*x_43 - 7.45887994766235) - 0.816091920378264*std::sin(0.451039850711823*x_45 - 7.353759765625) - 1079.29954193398*std::sin(0.3294398188591*x_46 + 8.31216049194336) - 1.25152576473022*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 1.39060802104175*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 10.0954983555392*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.307905773446928*std::sin(0.237599983811378*x_47 - 7.55951976776123) + 1.08482590497482*std::sin(0.65831983089447*x_47 - 4.15960025787354) - 78.0603185587033*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 1908.55500149146*std::sin(0.23047998547554*x_53 - 4.36679983139038) - 468.096146476878*std::sin(0.25383996963501*x_53 + 5.06503963470459) - 0.71800714651381*std::sin(0.444399863481522*x_53 - 7.35679960250854) - 0.0562096161068695*std::sin(0.175520017743111*x_55 - 7.62400007247925) + 0.427089705446554*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 15.5374640503203*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 1.6633622673108*std::sin(0.167360007762909*x_67 + 1.76391994953156) - 0.0555584310325084*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.0155859508184141*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.0132693504709417*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.0237423548090424*std::sin(0.288719952106476*x_72 - 7.48760032653809) - 40.3488858973397*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.368138601616242*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 397.72783615017*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.110805205074341*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 58.0187826422876*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 1319.54601616379*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.00100728847963934*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.00107899898091905*std::sin(0.49687984585762*x_78 - 7.29647970199585) - 3.09475677635559*std::sin(0.173680007457733*x_80 - 4.44935989379883) - 2.65469484107289*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 0.00574798363649593*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 32.2830178926216*std::sin(0.257039994001389*x_80 + 5.08447980880737) - 457379.153910577*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 5503.76978394933*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.421523455792083*std::sin(0.376319825649261*x_85 - 4.42600011825562) - 1.70013811462918*std::sin(0.333999842405319*x_86 + 5.13912010192871) - 1.51566083317091*std::sin(0.34759983420372*x_92 + 1.99199986457825) + 0.0539016340362939*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 1112.73726596993*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 0.974179082827278*std::sin(0.366079837083817*x_92 + 1.98439979553223) - 90.488940460163*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 4.32285179936246*std::sin(0.134640038013458*x_96 - 7.67208003997803) - 71.9035731795057*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.506164721607681*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.0139239289123014*std::sin(0.513919830322266*x_98 + 5.16983985900879) - 8906478.51490685 - 0.0270515444822455*std::exp(-2.36207985877991*x_86) - 0.00175366888493557*std::exp(-2.35904002189636*x_86) - 2.07317896041885e-5*std::exp(-2.29543995857239*x_86) - 0.0102868620622464*std::exp(-2.10855984687805*x_23) + 5.0833079958654*std::exp(-2.10799980163574*x_23) + 0.12504725949767*std::exp(-2.07343983650208*x_23) - 0.0977948653908253*std::exp(-1.99351978302002*x_23));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.15455529117523*x_1 - 44542.6176004501*x_10 - 20643.6814157888*x_100 - 1222313.08335625*x_101 + 13295.2588464472*x_102 - 7972.45838182305*x_103 - 33119.4321982314*x_104 - 23044.0942050478*x_105 - 15033.399326026*x_106 - 158346.593825895*x_107 + 6846.94801612261*x_108 - 30209.1706990086*x_109 + 41984.0150644981*x_11 - 26968.1467305528*x_110 + 45732.9007409213*x_111 - 14928.2486571194*x_112 + 103405.448714738*x_113 + 1341.44049760151*x_114 + 61.8777241401179*x_115 - 15415.0957190347*x_116 - 23277.0006967866*x_117 - 10547.4596207248*x_118 + 24656.5629773231*x_119 + 61683.0366404261*x_12 - 53248.0015579583*x_120 + 8512.49708249139*x_13 - 46127.757814188*x_14 - 14400.2729508781*x_15 + 30425.9099028095*x_16 + 136.063913847758*x_17 - 39165.430852812*x_18 - 3976.28206020973*x_19 + 43533.7876518615*x_2 + 17456.9813794795*x_20 + 19980.2941382861*x_21 - 4443.84345355869*x_22 + 23190.198183154*x_23 - 10613.2225965991*x_24 + 23224.4955975676*x_25 + 6357.62164605482*x_26 - 17488.9966489447*x_27 + 7.30571507032294*x_28 + 24038.1868049692*x_29 - 29157.8087854406*x_3 + 47158.7382468947*x_30 - 507705.441276291*x_31 + 16023.0782326609*x_32 - 45183.4818463106*x_33 + 32653.4539627163*x_34 - 10957.5762331604*x_35 - 13.026897856272*x_36 - 58147.6345493492*x_37 - 24362.4524099001*x_38 + 28686.0433501985*x_39 - 89220.6296181336*x_4 + 38197.3735702761*x_40 - 8022.54400828856*x_41 + 22621.1171707781*x_42 - 33651.8884103266*x_43 - 10951.9733574012*x_44 - 41756.7640008053*x_45 + 23205.7433497557*x_46 - 41412.4401596171*x_47 + 35979.4527469073*x_48 + 10884.4539917185*x_49 + 5897.5001288209*x_5 + 9.56988862354341*x_50 + 44988.0067213079*x_51 + 26611.9917697131*x_52 + 29931.1248977403*x_53 - 78135.0366722529*x_54 + 26903.3121017967*x_55 - 34122.5792317418*x_56 + 24532.2817257872*x_57 - 15397.8657169341*x_58 + 26249.9483397747*x_59 - 16690.669108972*x_6 - 43087.7288793771*x_60 + 47508.5825458972*x_61 - 18701.0371472661*x_62 - 28396.4136386258*x_63 - 60380.9633287955*x_64 - 41869.1494774587*x_65 - 64798.0792368482*x_66 - 34622.7081004308*x_67 - 22221.8099097242*x_68 - 37339.5891521946*x_69 - 19971.0018939466*x_7 + 54782.6099214483*x_70 + 7901.14915905171*x_71 - 85016.7117712247*x_72 - 1.02506386981078*x_73 + 10014.8858234384*x_74 + 3202.9278207904*x_75 + 28492.17448477*x_76 + 54909.2974719216*x_77 + 55482.5432725131*x_78 + 28997.699661007*x_79 - 409583.578717977*x_8 + 116.153771768776*x_80 + 27299.3133985661*x_81 + 59945.3328613383*x_82 + 4830.26776730317*x_83 - 54485.2963144428*x_84 - 38195.6302887535*x_85 - 57580.9419868166*x_86 - 9931.15168681144*x_87 - 37649.4998637786*x_88 - 70934.5561309709*x_89 + 238857.039517614*x_9 - 136855.668581528*x_90 + 86706.8741846985*x_91 + 28401.5069536302*x_92 - 1311995.51387053*x_93 - 32652.687866566*x_94 - 67020.5411247429*x_95 + 48204.4259953925*x_96 + 53860.8718039977*x_97 - 19951.5014160705*x_98 - 49501.7596153421*x_99 + 0.0093568409946826*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 2.96164296002849e-6*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.117402364071105*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) - 4.12120250745324e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.00262674321437024*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.235869973554212*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 4.4385293950758e-5*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) + 5.55217989046994e-5*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.00132784243276804*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.0038709815982867*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.029682546977123*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.0355172488412988*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) + 9.71178872720122e-5*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.00632197387188267*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.0142479735454533*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.0386251103685983*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 1.09218980634849e-5*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.058379212339712*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00299412633091572*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 1.68406230346262*std::exp(0.675439834594727*x_1) + 22.3970211104055*std::exp(0.805679857730865*x_1) + 3627.42751965496*std::exp(0.820959866046906*x_1) + 0.142065881369462*std::exp(0.863999843597412*x_1) - 1.46587742992998e-5*std::exp(0.999759793281555*x_1) + 0.000832932368915699*std::exp(1.01575982570648*x_1) + 0.0336738563707201*std::exp(1.04399979114532*x_1) - 0.000899438187122018*std::exp(1.06791973114014*x_1) + 2.53100230045821*std::exp(1.0971999168396*x_1) + 4.61330635812577e-5*std::exp(1.11495983600616*x_1) + 0.0121568711705128*std::exp(1.13255989551544*x_1) - 0.000567546347737657*std::exp(1.20439982414246*x_1) - 0.0437791597660205*std::exp(0.975199818611145*x_108) - 1.99952884868342*std::exp(1.29199981689453*x_108) - 0.0128351189187633*std::exp(1.58871984481812*x_108) + 0.0135732691370993*std::exp(1.60567986965179*x_108) + 485.662058111754*std::exp(2.76399993896484*x_17) + 0.00276222391825736*std::exp(2.89416003227234*x_17) + 0.00420387210144536*std::exp(2.91807985305786*x_17) + 0.00834658954171284*std::exp(3.5239999294281*x_17) - 0.00155251276273815*std::exp(3.58959984779358*x_17) + 9.16498855516341e-5*std::exp(3.60615992546082*x_17) - 9.14765174824387e-6*std::exp(3.7247200012207*x_17) - 3.75262989410143*std::exp(0.934719800949097*x_29) + 0.167530237913709*std::exp(1.11599981784821*x_29) + 4.32269753371616*std::exp(1.20207989215851*x_29) - 0.723222425519448*std::exp(1.28559982776642*x_29) + 0.0138692282417141*std::exp(1.62799978256226*x_29) + 0.000121216964725144*std::exp(1.69127988815308*x_29) - 0.000240592768916816*std::exp(2.63527989387512*x_29) + 0.000245235323420844*std::exp(1.38783979415894*x_38) - 0.969183829885742*std::exp(1.42807984352112*x_38) + 0.0562377069623179*std::exp(2.43751978874207*x_38) + 0.0018780880011768*std::exp(2.55167984962463*x_38) + 0.000643147684449918*std::exp(1.51279985904694*x_50) + 0.0253097442805094*std::exp(1.64831984043121*x_50) + 0.0986340486816609*std::exp(1.6839998960495*x_50) - 2.8263153641858*std::exp(1.73599982261658*x_50) - 32408.1194972256*std::exp(1.89111995697021*x_50) + 0.41428530057942*std::exp(1.92567980289459*x_50) - 0.0149101225939253*std::exp(1.93199980258942*x_50) - 0.0819684581786549*std::exp(1.93495976924896*x_50) - 103.330377003382*std::exp(1.95423984527588*x_50) + 0.0843914801803051*std::exp(2.00951981544495*x_50) - 0.352918412428224*std::exp(0.747759819030762*x_66) + 0.33509598189705*std::exp(0.704879820346832*x_71) + 4.97972592783058*std::exp(0.727519869804382*x_71) + 0.0489137842116507*std::exp(1.12319993972778*x_71) + 5.11398211577135*std::exp(1.13343989849091*x_71) - 0.000264070948635472*std::exp(1.17391979694366*x_71) - 0.084597957238307*std::exp(1.27175986766815*x_71) - 0.005904120340009*std::exp(1.67999982833862*x_71) + 28.4799622144425*std::exp(1.69519984722137*x_71) - 0.599251862357201*std::exp(1.85879993438721*x_71) + 0.000949686700872638*std::exp(1.86255991458893*x_71) + 0.0399210415282985*std::exp(1.9048798084259*x_71) - 0.23770294117354*std::exp(1.04767978191376*x_72) + 66142.602698115*std::exp(0.721359848976135*x_73) - 0.258069079140303*std::exp(0.838959872722626*x_73) - 0.00417576780667969*std::exp(0.977439820766449*x_76) + 0.712765292814427*std::exp(1.22399985790253*x_76) + 2.12563430494542e-5*std::exp(2.10399985313416*x_76) - 0.020147413960701*std::exp(2.24863982200623*x_76) - 0.0398473817705942*std::exp(1.07551980018616*x_77) + 0.934377408838929*std::exp(1.43767976760864*x_77) + 0.117490439655719*std::exp(1.19447994232178*x_78) - 0.0408984507348274*std::exp(1.61599981784821*x_78) - 0.167934120788621*std::exp(1.83559989929199*x_78) + 0.964498511440456*std::exp(1.90311992168427*x_78) + 0.974614798315128*std::exp(1.36295986175537*x_81) - 0.0841719514139718*std::exp(1.0487197637558*x_87) + 2.04631565797416*std::exp(0.894479870796204*x_88) + 63.4692960033159*std::sin(0.370079845190048*x_102 + 8.18015956878662) - 0.24757942484916*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 1.5674844288443*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 55.8447916742325*std::sin(0.316399931907654*x_104 + 1.89671981334686) + 0.0143150201915683*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 64.7899778345235*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 3.28343683356083*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 24.8598502917979*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.00219500898056132*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 5.60587597881687*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 1.17310572485481*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 8.90469092415399*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 77.2275278096872*std::sin(0.180640012025833*x_112 - 7.61432027816772) - 0.307486169183238*std::sin(0.260399967432022*x_112 + 5.04791975021362) + 182237.823563842*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 13.7642216268803*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 47.2542780672951*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 16.1351806151344*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 21.4485001850748*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.627289956203251*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 1.03847321353244*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 1.70344116954994*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 3.58408862931842*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 24.8853253952881*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 1.95787624024201*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 450.108853812945*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 50.4155972966968*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 2.15089923560076*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 14.111623047513*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 80.8241347551788*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 1.48757658811252*std::sin(0.341279834508896*x_28 + 5.1275200843811) - 379762.537928674*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 790.104175928923*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 22.5306069774317*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 8.22683959419143*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 1.91315806188083*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 1204.46983586839*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 63.9902030771016*std::sin(0.332959830760956*x_36 - 7.4410400390625) + 0.216233381247626*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 2.70845806817913*std::sin(0.345119833946228*x_36 + 5.14664030075073) - 0.0267410007286165*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 8.74447852667807*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 1.92421903938076*std::sin(0.380479842424393*x_36 + 8.37952041625977) + 158524.222840407*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.00632766705926983*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 2.6420829167396*std::sin(0.451039850711823*x_45 - 7.353759765625) - 1209.73690625211*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 4.05179215758015*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 12.2114367857375*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 13.6130616809985*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.431016834078556*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 7.23271716754524*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 16.0400023802559*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 2139.21097268241*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 129.69300507915*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 2.32453522517635*std::sin(0.444399863481522*x_53 - 7.35679960250854) - 0.0616181819505408*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 1.10605427607687*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 20.9511654634913*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 2.32843031930223*std::sin(0.167360007762909*x_67 + 1.76391994953156) - 0.0609043389611283*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.00432838047218357*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.00368503648741964*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.0065934986011697*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 8.29097597580638*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.51533276818562*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 445.794724578956*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.973020964083281*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 78.2342029041636*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 1479.01806053849*std::sin(0.301919937133789*x_75 - 7.48392009735107) - 0.0470825574645837*std::sin(0.393039852380753*x_75 + 8.3851203918457) + 0.0504344411260794*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 8.01463702415166*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 8.59452680955895*std::sin(0.214559987187386*x_80 + 1.82359993457794) + 0.268671562656713*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 43.5313541089237*std::sin(0.257039994001389*x_80 + 5.08447980880737) - 295163.047613364*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 6168.92083473706*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.590062678498856*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 5.50416657314486*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 4.90692469181175*std::sin(0.34759983420372*x_92 + 1.99199986457825) + 0.0590881227006622*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 1247.21570361626*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 8.55462222849918*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 18.5938623767763*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 3.55913269184402*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 14.7749010796162*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.7085463626982*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.00386681972131427*std::sin(0.513919830322266*x_98 + 5.16983985900879) - 5725257.39194086 + 0.180357206892007*std::exp(-2.36207985877991*x_86) + 0.00454155870364023*std::exp(-2.35904002189636*x_86) - 5.75743336557755e-6*std::exp(-2.29543995857239*x_86) - 0.00846948004732219*std::exp(-2.10855984687805*x_23) + 5.69764467556957*std::exp(-2.10799980163574*x_23) + 0.16861733781053*std::exp(-2.07343983650208*x_23) + 0.652014851937389*std::exp(-1.99351978302002*x_23));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.502261621832385*x_1 - 66601.4872750657*x_10 - 30824.9556761808*x_100 - 1830400.94603482*x_101 + 19805.5105609049*x_102 - 11843.8634347965*x_103 - 49426.6661180679*x_104 - 34570.483647301*x_105 - 22556.4657468237*x_106 - 236636.24295426*x_107 + 10260.8888643771*x_108 - 45206.5629821891*x_109 + 62739.5728791805*x_11 - 40404.5929262306*x_110 + 68472.1603446837*x_111 - 22390.6655144882*x_112 + 154680.495196727*x_113 + 2026.04465723259*x_114 + 64.165426019547*x_115 - 23121.1392273291*x_116 - 34885.3370168112*x_117 - 15887.5355054424*x_118 + 36940.0711011326*x_119 + 92344.2660132942*x_12 - 79692.9519430018*x_120 + 12726.9536106502*x_13 - 69053.8032396773*x_14 - 21588.8425444647*x_15 + 45616.1204556286*x_16 + 145.005917025465*x_17 - 58558.1581109437*x_18 - 6008.28897348976*x_19 + 65161.496856778*x_2 + 26229.3738049593*x_20 + 29955.3772631016*x_21 - 6649.9244610318*x_22 + 34694.895761249*x_23 - 15851.2987511141*x_24 + 34756.794283255*x_25 + 9492.60192485557*x_26 - 26145.8613474551*x_27 + 1.24465483002966*x_28 + 35969.3944142792*x_29 - 43669.0070742536*x_3 + 70385.9033119197*x_30 - 758313.403632172*x_31 + 24003.5734431074*x_32 - 67724.6193816955*x_33 + 48933.1523387834*x_34 - 16365.9837825833*x_35 + 0.154936686812955*x_36 - 87028.140462397*x_37 - 36435.8811548635*x_38 + 43015.5606457832*x_39 - 133437.346525999*x_4 + 56946.3756003447*x_40 - 12083.7445652333*x_41 + 33772.0409193033*x_42 - 50256.7635850273*x_43 - 16382.3823272138*x_44 - 62392.6673484593*x_45 + 34724.7214071963*x_46 - 61954.7739855935*x_47 + 54178.4969612884*x_48 + 16225.4773180319*x_49 + 8827.39642947791*x_5 + 0.373846684837912*x_50 + 67307.609020902*x_51 + 39813.0583699005*x_52 + 44778.8592510177*x_53 - 116930.291160852*x_54 + 40206.3767057792*x_55 - 51006.1256026406*x_56 + 36616.5021759398*x_57 - 23051.0209643133*x_58 + 39351.3002810989*x_59 - 25014.584770204*x_6 - 64390.0106265248*x_60 + 71071.4332334365*x_61 - 27731.268288269*x_62 - 42527.2769021803*x_63 - 90248.9568746551*x_64 - 62566.2235682123*x_65 - 96841.1621831475*x_66 - 51722.0569152525*x_67 - 33275.7794261648*x_68 - 55813.0209193714*x_69 - 29953.426249683*x_7 + 82016.8324276525*x_70 + 11826.8939433336*x_71 - 127147.718674944*x_72 + 0.2470674824994*x_73 + 15031.582023861*x_74 + 4793.41603904694*x_75 + 42610.21250321*x_76 + 82147.2779742775*x_77 + 83017.1227669126*x_78 + 43370.8353966271*x_79 - 612491.894118193*x_8 + 121.765767907748*x_80 + 40809.5127492827*x_81 + 89716.3133047239*x_82 + 7136.63349381298*x_83 - 81347.1306878371*x_84 - 57139.9484929197*x_85 - 86174.6919378888*x_86 - 14789.2870028718*x_87 - 56344.6711711884*x_88 - 106172.143625407*x_89 + 357170.343973354*x_9 - 204643.035709498*x_90 + 129697.704538132*x_91 + 42505.3521374694*x_92 - 1960909.96542597*x_93 - 48814.8777212101*x_94 - 100324.91416259*x_95 + 72093.8354913773*x_96 + 80554.7759414912*x_97 - 29883.1981497448*x_98 - 74006.4161744323*x_99 + 0.00196436021393236*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) - 9.38317628855393e-6*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.0158422262470077*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 4.43856574622086e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.00590151461036599*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.201617391911387*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) - 0.000140622972917452*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 0.000469304114773114*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.000768460818172439*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00224024900300013*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.025372104878959*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) - 0.0443375331946576*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 0.000820899628865753*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.0142036042834939*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) - 0.0177862875261213*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.0330160464999433*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) + 3.46031227661247e-5*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.00787766666647089*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00173278750037436*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 0.952757775678446*std::exp(0.675439834594727*x_1) + 23.667893219541*std::exp(0.805679857730865*x_1) + 5426.32142247566*std::exp(0.820959866046906*x_1) + 0.0298250836236288*std::exp(0.863999843597412*x_1) + 4.64424190494355e-5*std::exp(0.999759793281555*x_1) + 0.000670261436553095*std::exp(1.01575982570648*x_1) + 0.0287838040372816*std::exp(1.04399979114532*x_1) + 0.00760260024940771*std::exp(1.06791973114014*x_1) + 0.341532399222143*std::exp(1.0971999168396*x_1) - 4.96856525273099e-5*std::exp(1.11495983600616*x_1) + 0.0273128916586233*std::exp(1.13255989551544*x_1) - 0.000960210189881607*std::exp(1.20439982414246*x_1) - 0.0352291297720358*std::exp(0.975199818611145*x_108) - 1.13123288512513*std::exp(1.29199981689453*x_108) - 0.0217152520199734*std::exp(1.58871984481812*x_108) - 0.0169440283400102*std::exp(1.60567986965179*x_108) + 726.508914578149*std::exp(2.76399993896484*x_17) + 0.00222276410501688*std::exp(2.89416003227234*x_17) + 0.00711237213464144*std::exp(2.91807985305786*x_17) + 0.00175226964176074*std::exp(3.5239999294281*x_17) - 0.00348803670718741*std::exp(3.58959984779358*x_17) - 0.000774680742633976*std::exp(3.60615992546082*x_17) + 9.85208895575567e-6*std::exp(3.7247200012207*x_17) + 0.970809364190528*std::exp(0.934719800949097*x_29) + 0.0969545937972616*std::exp(1.11599981784821*x_29) + 0.583303009852834*std::exp(1.20207989215851*x_29) - 0.151832157810678*std::exp(1.28559982776642*x_29) + 0.0111605806090541*std::exp(1.62799978256226*x_29) - 0.000384043642171*std::exp(1.69127988815308*x_29) + 0.00203363685371804*std::exp(2.63527989387512*x_29) - 0.00077696275442202*std::exp(1.38783979415894*x_38) + 0.250728892597179*std::exp(1.42807984352112*x_38) + 0.031816466935045*std::exp(2.43751978874207*x_38) + 0.000394282787307386*std::exp(2.55167984962463*x_38) - 0.000692674838666142*std::exp(1.51279985904694*x_50) + 0.0568635049055844*std::exp(1.64831984043121*x_50) + 0.0570823765524372*std::exp(1.6839998960495*x_50) - 1.5989871242951*std::exp(1.73599982261658*x_50) - 48479.7758568788*std::exp(1.89111995697021*x_50) + 0.354123590007737*std::exp(1.92567980289459*x_50) + 0.126029451911517*std::exp(1.93199980258942*x_50) - 0.0659600930173816*std::exp(1.93495976924896*x_50) - 109.193643082952*std::exp(1.95423984527588*x_50) + 0.0177170122005131*std::exp(2.00951981544495*x_50) - 0.204244091972085*std::exp(0.747759819030762*x_66) + 0.193929735983884*std::exp(0.704879820346832*x_71) + 4.25657975398024*std::exp(0.727519869804382*x_71) + 0.0393609667440685*std::exp(1.12319993972778*x_71) + 2.89323394714287*std::exp(1.13343989849091*x_71) + 0.000836638412250903*std::exp(1.17391979694366*x_71) - 0.190066572902019*std::exp(1.27175986766815*x_71) - 0.0099889577923677*std::exp(1.67999982833862*x_71) + 30.0959980912293*std::exp(1.69519984722137*x_71) + 0.155027097236373*std::exp(1.85879993438721*x_71) - 0.00102281963880966*std::exp(1.86255991458893*x_71) - 0.0498349551744593*std::exp(1.9048798084259*x_71) + 0.296733626296383*std::exp(1.04767978191376*x_72) + 98943.6784096564*std::exp(0.721359848976135*x_73) - 0.579804844530769*std::exp(0.838959872722626*x_73) + 0.00449733297924104*std::exp(0.977439820766449*x_76) - 0.184393143012026*std::exp(1.22399985790253*x_76) - 6.73450570426248e-5*std::exp(2.10399985313416*x_76) - 0.00422971582188023*std::exp(2.24863982200623*x_76) - 0.067416277399627*std::exp(1.07551980018616*x_77) - 0.241724434273346*std::exp(1.43767976760864*x_77) + 0.0679951153519478*std::exp(1.19447994232178*x_78) - 0.0329110205886306*std::exp(1.61599981784821*x_78) - 0.0352558203806549*std::exp(1.83559989929199*x_78) + 0.130149028548417*std::exp(1.90311992168427*x_78) + 0.833083121151813*std::exp(1.36295986175537*x_81) - 0.0677332460325071*std::exp(1.0487197637558*x_87) + 1.74915365347832*std::exp(0.894479870796204*x_88) + 35.9077364059876*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 2.09269233178677*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 3.52167361001963*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 7.53567299449252*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.0154173831943093*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 8.74273269975625*std::sin(0.426319867372513*x_105 + 2.02519989013672) + 4.09883913731763*std::sin(0.433839857578278*x_105 + 2.02359986305237) + 6.43126983920992*std::sin(0.471119850873947*x_105 - 7.36047983169556) - 0.00695430087202942*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 4.79180150485741*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 2.63562137968421*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 1.86943655222027*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 66.0126954954466*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 2.59906068031418*std::sin(0.260399967432022*x_112 + 5.04791975021362) + 272612.202623384*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 11.7654079673015*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 6.37647265627212*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 2.17727457077847*std::sin(0.38391986489296*x_14 - 1.22143995761871) + 5.5487499207536*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.504780799583348*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 2.33314197162768*std::sin(0.551439881324768*x_15 + 2.14655995368958) - 2.12647042955214*std::sin(0.504719853401184*x_17 - 4.07760000228882) - 4.47415421405678*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 21.2715265426145*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 1.1330796036698*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 60.7375017897192*std::sin(0.166160017251968*x_26 + 1.75695991516113) - 13.0425689018319*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 1.24478759347268*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 12.0623604251274*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 45.7262315605228*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 3.3421443408541*std::sin(0.341279834508896*x_28 + 5.1275200843811) - 568092.286847982*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 834.936984522071*std::sin(0.344959855079651*x_28 + 5.1547999382019) + 5.82869210442739*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 1.72712952955137*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 1.10719990056454*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 1272.81495699652*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 36.2024394368285*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 1.82773644897563*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 1.5674630149602*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.0288002566336037*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 1.83580181806595*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 4.32315070324546*std::sin(0.380479842424393*x_36 + 8.37952041625977) + 237138.683466245*std::sin(0.424479871988297*x_36 - 4.18911981582642) - 0.020047526428315*std::sin(0.343599855899811*x_43 - 7.45887994766235) - 3.29821263880573*std::sin(0.451039850711823*x_45 - 7.353759765625) - 1278.38089627065*std::sin(0.3294398188591*x_46 + 8.31216049194336) - 5.0580063249627*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 2.56364948282062*std::sin(0.412479877471924*x_46 - 7.39631986618042) + 3.5217136057008*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.346839639290449*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 4.09190770822017*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 13.7107042385636*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 2260.59602417372*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 17.5007202399589*std::sin(0.25383996963501*x_53 + 5.06503963470459) - 2.90180577242701*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.0663632401599907*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 2.48497661835223*std::sin(0.420479863882065*x_55 + 5.20256042480469) + 5.42008889675834*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 1.87369000049901*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.0655944259521822*std::sin(0.297439932823181*x_68 + 5.14079999923706) - 0.0137133197899189*std::sin(0.406319856643677*x_69 + 8.40272045135498) + 0.0116750558584818*std::sin(0.511679828166962*x_70 - 1.10791981220245) - 0.0208897428110355*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 7.08697647035539*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.414688748327339*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 471.090413638422*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.204274462957479*std::sin(0.806719899177551*x_73 - 0.778159856796265) - 20.2392719033461*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 1562.94184633038*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.397970497859724*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.426302663344506*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 18.0065174380401*std::sin(0.173680007457733*x_80 - 4.44935989379883) - 10.7288748465254*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 2.27097594755068*std::sin(0.249999970197678*x_80 + 1.83071994781494) + 11.2616078316874*std::sin(0.257039994001389*x_80 + 5.08447980880737) - 441538.682636435*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 6518.96334234043*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.474823975278884*std::sin(0.376319825649261*x_85 - 4.42600011825562) - 6.87106057217947*std::sin(0.333999842405319*x_86 + 5.13912010192871) - 6.12550080607349*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.0636383475340857*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 1317.98634958691*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 1.7959436908712*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 15.8936976227848*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 6.02156192436479*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 12.629318503469*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.570167903961758*std::sin(0.393919825553894*x_97 - 7.38903999328613) - 0.012250987580488*std::sin(0.513919830322266*x_98 + 5.16983985900879) - 8584975.49735234 + 0.102037039195456*std::exp(-2.36207985877991*x_86) + 0.0102035383195207*std::exp(-2.35904002189636*x_86) + 1.82408929664826e-5*std::exp(-2.29543995857239*x_86) - 0.0143291928084028*std::exp(-2.10855984687805*x_23) + 6.020945603414*std::exp(-2.10799980163574*x_23) - 0.0436214854997143*std::exp(-2.07343983650208*x_23) + 0.368877219544607*std::exp(-1.99351978302002*x_23));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.446201829361645*x_1 - 84409.8454708185*x_10 - 39076.4920147517*x_100 - 2320800.33601611*x_101 + 25086.9308745051*x_102 - 14993.6468490127*x_103 - 62651.2799823612*x_104 - 43826.6948931658*x_105 - 28612.6743579727*x_106 - 299994.205459845*x_107 + 13009.5156231656*x_108 - 57293.8902040385*x_109 + 79531.4452152792*x_11 - 51244.9599913133*x_110 + 86781.5391081455*x_111 - 28383.1199056541*x_112 + 196105.222674429*x_113 + 2563.59107937409*x_114 + 71.0614165815182*x_115 - 29275.3711350613*x_116 - 44242.0022167605*x_117 - 20121.226420297*x_118 + 46830.4549164419*x_119 + 117047.675920412*x_12 - 101026.856302195*x_120 + 16131.7540131019*x_13 - 87544.760200535*x_14 - 27376.9236619059*x_15 + 57824.8509698203*x_16 + 189.640295800168*x_17 - 74238.8560737028*x_18 - 7634.42404838583*x_19 + 82624.7036120227*x_2 + 33274.8385766249*x_20 + 37989.9916243643*x_21 - 8440.47127361679*x_22 + 43987.349388703*x_23 - 20085.4899656995*x_24 + 44062.3641736948*x_25 + 12032.0743702225*x_26 - 33138.0414586723*x_27 - 7.64634928797291*x_28 + 45603.9838097038*x_29 - 55377.0334960393*x_3 + 89241.3622317915*x_30 - 961160.208730018*x_31 + 30495.9538967986*x_32 - 85938.2808840504*x_33 + 62030.5718641219*x_34 - 20734.9439224752*x_35 + 15.0609875952647*x_36 - 110350.381097701*x_37 - 46208.9302826598*x_38 + 54595.8653370392*x_39 - 169134.972774486*x_4 + 72165.1589344232*x_40 - 15335.6625464725*x_41 + 42793.8374792222*x_42 - 63691.8567048623*x_43 - 20757.0734858411*x_44 - 79084.9581390543*x_45 + 44029.2228252204*x_46 - 78525.9896138636*x_47 + 68720.6406053154*x_48 + 20609.8296273334*x_49 + 11186.6017207511*x_5 + 2.41461447271892*x_50 + 85342.8387811613*x_51 + 50476.0427002416*x_52 + 56764.8240412771*x_53 - 148222.858480832*x_54 + 50957.4023169464*x_55 - 64666.1479236821*x_56 + 46416.6486802751*x_57 - 29219.9499900801*x_58 + 49887.5513833968*x_59 - 31729.398076653*x_6 - 81621.8178685422*x_60 + 90105.5982291096*x_61 - 35097.0337010478*x_62 - 53895.8127888147*x_63 - 114412.854840031*x_64 - 79303.6000769049*x_65 - 122759.79597395*x_66 - 65580.6222742127*x_67 - 42181.6847112504*x_68 - 70731.4708962002*x_69 - 37992.1073843671*x_7 + 103960.944351663*x_70 + 15000.6041383333*x_71 - 161128.201268932*x_72 + 3.27944093889912*x_73 + 19064.3223329737*x_74 + 6078.05442644663*x_75 + 54013.3861725462*x_76 + 104133.754979944*x_77 + 105236.329687031*x_78 + 54958.0651942792*x_79 - 776749.675565872*x_8 + 150.088790215254*x_80 + 51700.9052785866*x_81 + 113745.381865061*x_82 + 9037.49039750162*x_83 - 103113.522912377*x_84 - 72433.3948891923*x_85 - 109255.172549773*x_86 - 18738.1105013609*x_87 - 71424.8466620743*x_88 - 134594.945420091*x_89 + 452734.493033085*x_9 - 259379.679167847*x_90 + 164454.235872035*x_91 + 53902.1029842141*x_92 - 2485468.38881229*x_93 - 61887.0911658599*x_94 - 127190.471970608*x_95 + 91379.8063515052*x_96 + 102122.114491581*x_97 - 37875.4265487072*x_98 - 93805.0252744332*x_99 - 0.000559313019213961*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 8.90480282170421e-6*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) + 0.141568224218686*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 3.41242000430246e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) - 0.00224347498890348*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.119473749546773*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 0.000133453726917534*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 0.000124608537932238*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.00150930932712764*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00440000145141787*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.0150349157631971*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) - 0.0741177036195915*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 0.00021796336175644*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) + 0.00539953436806361*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) - 0.0297327950467199*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.0195645367354643*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 3.2838984984588e-5*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) - 0.0703958688362797*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00340331253643481*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) - 0.217444713798891*std::exp(0.675439834594727*x_1) + 29.5489616547042*std::exp(0.805679857730865*x_1) + 6878.89485765759*std::exp(0.820959866046906*x_1) - 0.00849210722734332*std::exp(0.863999843597412*x_1) - 4.40746897937604e-5*std::exp(0.999759793281555*x_1) - 0.00127459077936985*std::exp(1.01575982570648*x_1) + 0.0170566088666845*std::exp(1.04399979114532*x_1) + 0.00201862475043493*std::exp(1.06791973114014*x_1) - 3.05197858666856*std::exp(1.0971999168396*x_1) - 3.81988967394191e-5*std::exp(1.11495983600616*x_1) - 0.0103830615284966*std::exp(1.13255989551544*x_1) + 0.000963101525077269*std::exp(1.20439982414246*x_1) + 0.0669928501385649*std::exp(0.975199818611145*x_108) + 0.258177489835513*std::exp(1.29199981689453*x_108) + 0.0217806398622497*std::exp(1.58871984481812*x_108) - 0.028324816022425*std::exp(1.60567986965179*x_108) + 920.988280538305*std::exp(2.76399993896484*x_17) - 0.00422687995827188*std::exp(2.89416003227234*x_17) - 0.00713378854127224*std::exp(2.91807985305786*x_17) - 0.000498924391188015*std::exp(3.5239999294281*x_17) + 0.00132598555279471*std::exp(3.58959984779358*x_17) - 0.000205691430492887*std::exp(3.60615992546082*x_17) + 7.57439843386633e-6*std::exp(3.7247200012207*x_17) - 0.184402798835221*std::exp(0.934719800949097*x_29) + 0.190425418271933*std::exp(1.11599981784821*x_29) - 5.21247266632604*std::exp(1.20207989215851*x_29) + 0.0432312271428364*std::exp(1.28559982776642*x_29) - 0.0212233202761434*std::exp(1.62799978256226*x_29) + 0.000364464313926785*std::exp(1.69127988815308*x_29) + 0.000539966531402418*std::exp(2.63527989387512*x_29) + 0.000737351608364863*std::exp(1.38783979415894*x_38) - 0.0476253230028602*std::exp(1.42807984352112*x_38) - 0.00726136560980184*std::exp(2.43751978874207*x_38) - 0.000112264285658446*std::exp(2.55167984962463*x_38) - 0.000532536321660629*std::exp(1.51279985904694*x_50) - 0.0216167983068261*std::exp(1.64831984043121*x_50) + 0.112113671000299*std::exp(1.6839998960495*x_50) + 0.364931472076283*std::exp(1.73599982261658*x_50) - 61457.3400427372*std::exp(1.89111995697021*x_50) + 0.209845354610001*std::exp(1.92567980289459*x_50) + 0.0334630471899606*std::exp(1.93199980258942*x_50) + 0.125431841638815*std::exp(1.93495976924896*x_50) - 136.326403979702*std::exp(1.95423984527588*x_50) - 0.00504457151750314*std::exp(2.00951981544495*x_50) - 0.401149291849789*std::exp(0.747759819030762*x_66) + 0.380891194978528*std::exp(0.704879820346832*x_71) + 2.52234957823684*std::exp(0.727519869804382*x_71) - 0.0748500846730408*std::exp(1.12319993972778*x_71) - 0.66031308654682*std::exp(1.13343989849091*x_71) - 0.000793984879432136*std::exp(1.17391979694366*x_71) + 0.0722542653344096*std::exp(1.27175986766815*x_71) + 0.0100190360247562*std::exp(1.67999982833862*x_71) + 37.5743411257047*std::exp(1.69519984722137*x_71) - 0.0294470074972173*std::exp(1.85879993438721*x_71) - 0.000786355412047068*std::exp(1.86255991458893*x_71) - 0.0833075764792719*std::exp(1.9048798084259*x_71) + 0.496040563899751*std::exp(1.04767978191376*x_72) + 125429.938188105*std::exp(0.721359848976135*x_73) + 0.220414207712887*std::exp(0.838959872722626*x_73) + 0.00345760092377545*std::exp(0.977439820766449*x_76) + 0.0350250140879024*std::exp(1.22399985790253*x_76) + 6.39116686651762e-5*std::exp(2.10399985313416*x_76) + 0.00120432856966546*std::exp(2.24863982200623*x_76) + 0.0676192778027264*std::exp(1.07551980018616*x_77) + 0.04591494877476*std::exp(1.43767976760864*x_77) + 0.133547032422395*std::exp(1.19447994232178*x_78) + 0.0625846589021192*std::exp(1.61599981784821*x_78) + 0.0100384029375623*std::exp(1.83559989929199*x_78) - 1.16302889304252*std::exp(1.90311992168427*x_78) + 0.493665567362764*std::exp(1.36295986175537*x_81) + 0.128803726638067*std::exp(1.0487197637558*x_87) + 1.03650753307204*std::exp(0.894479870796204*x_88) - 8.19510232850746*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 0.555646804699387*std::sin(0.232239991426468*x_104 - 7.55864000320435) - 1.33877270239791*std::sin(0.300959914922714*x_104 - 1.30567979812622) + 67.3397682553938*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.0118530601627456*std::sin(0.34063982963562*x_105 + 5.15248012542725) + 78.1262130602958*std::sin(0.426319867372513*x_105 + 2.02519989013672) + 6.85190452590843*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 1.22160354252836*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.00659975642829699*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 2.83950946613178*std::sin(0.517119884490967*x_105 + 8.36359977722168) + 1.00193781358343*std::sin(0.512159824371338*x_109 + 2.15727996826172) + 0.532285369473105*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 39.1175789636079*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 0.69009655184398*std::sin(0.260399967432022*x_112 + 5.04791975021362) + 345587.836170816*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 6.97190550614197*std::sin(0.454559862613678*x_117 - 7.36303997039795) - 56.9810010697175*std::sin(0.440479874610901*x_120 - 1.17087984085083) - 19.4564128687298*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 1.05397110201634*std::sin(0.476879835128784*x_14 + 8.24479961395264) + 0.959907459484148*std::sin(0.429919868707657*x_15 + 5.22760009765625) - 0.886949538295395*std::sin(0.551439881324768*x_15 + 2.14655995368958) - 3.55475583996544*std::sin(0.504719853401184*x_17 - 4.07760000228882) - 7.47930730674398*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 12.6050089753508*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 2.22544542773705*std::sin(0.459999859333038*x_21 - 4.36111974716187) + 542.758330665421*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 2.47740318358425*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 2.44484751947302*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 7.14787258535699*std::sin(0.319439828395844*x_28 - 4.27544021606445) + 10.4359445691214*std::sin(0.325839847326279*x_28 - 4.26304006576538) - 1.27052421845084*std::sin(0.341279834508896*x_28 + 5.1275200843811) - 720165.063294508*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 1042.40460740999*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 1.10714541623872*std::sin(0.364799857139587*x_28 - 4.23216009140015) - 0.491766237625613*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 2.17461593017988*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 1589.08779961758*std::sin(0.323519825935364*x_36 - 1.24327993392944) - 8.26236141348445*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 0.48529633443001*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 3.0786039996592*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.0221419660053997*std::sin(0.354799836874008*x_36 - 7.42647981643677) + 0.522708539023738*std::sin(0.361759841442108*x_36 + 1.95119988918304) - 1.64345614919865*std::sin(0.380479842424393*x_36 + 8.37952041625977) + 300618.401167879*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.0190254626383623*std::sin(0.343599855899811*x_43 - 7.45887994766235) - 5.51352159724685*std::sin(0.451039850711823*x_45 - 7.353759765625) - 1596.03678002145*std::sin(0.3294398188591*x_46 + 8.31216049194336) - 8.45531509508463*std::sin(0.357999831438065*x_46 - 4.24848031997681) + 0.729948877132002*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 0.668940648433892*std::sin(0.41839987039566*x_46 - 4.18064022064209) - 0.65956145177174*std::sin(0.237599983811378*x_47 - 7.55951976776123) + 0.933882381460308*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 8.1246425656968*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 2822.31564150945*std::sin(0.23047998547554*x_53 - 4.36679983139038) - 156.388745387787*std::sin(0.25383996963501*x_53 + 5.06503963470459) - 4.85086031417462*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.0510208164574549*std::sin(0.175520017743111*x_55 - 7.62400007247925) + 0.944669844837919*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 1.02953226386657*std::sin(0.485599845647812*x_55 + 2.05031991004944) - 3.56306937530986*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.0504297433197974*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.0130141867748092*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.0110798376962163*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.0198247411119516*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 4.19957645437279*std::sin(0.379999846220016*x_73 + 1.97735977172852) + 0.788585507238236*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 588.148359441114*std::sin(0.612159848213196*x_73 - 3.98176002502441) - 0.058163144322873*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 3.84439883156258*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 1951.30628051078*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.105668201742573*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.113190892480581*std::sin(0.49687984585762*x_78 - 7.29647970199585) - 6.84522096048693*std::sin(0.173680007457733*x_80 - 4.44935989379883) - 17.9351332550516*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 0.602984256041259*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 2.13911410432197*std::sin(0.257039994001389*x_80 + 5.08447980880737) - 559734.290870474*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 8138.81472442167*std::sin(0.164080023765564*x_85 + 1.76831984519958) - 0.902940595577979*std::sin(0.376319825649261*x_85 - 4.42600011825562) - 11.4861426504085*std::sin(0.333999842405319*x_86 + 5.13912010192871) - 10.2398131008522*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.0489258879066879*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 1645.48351406338*std::sin(0.364559859037399*x_92 + 1.98087978363037) + 0.511359719543791*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 9.41823337339524*std::sin(0.3781598508358*x_95 + 1.99335980415344) + 6.03969373978212*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 7.48383867842636*std::sin(0.476799845695496*x_96 + 5.22983980178833) + 1.0842496874348*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.011626407244258*std::sin(0.513919830322266*x_98 + 5.16983985900879) - 10887658.0184018 - 0.0232875714595379*std::exp(-2.36207985877991*x_86) - 0.00387889966042856*std::exp(-2.35904002189636*x_86) - 1.73109350355573e-5*std::exp(-2.29543995857239*x_86) + 0.0143723401316961*std::exp(-2.10855984687805*x_23) + 7.51704805789177*std::exp(-2.10799980163574*x_23) + 0.00828579153869663*std::exp(-2.07343983650208*x_23) - 0.0841876114563234*std::exp(-1.99351978302002*x_23));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.00483394117921*x_1 - 66382.0202004667*x_10 - 30631.1839708465*x_100 - 1827498.97654676*x_101 + 19624.4003262689*x_102 - 11702.0046555371*x_103 - 49055.8484027105*x_104 - 34640.918597639*x_105 - 22551.9277418746*x_106 - 235473.772673388*x_107 + 10270.8584567027*x_108 - 45136.4769341978*x_109 + 62439.3060400211*x_11 - 40341.6454535673*x_110 + 68386.7597697663*x_111 - 22439.6276250813*x_112 + 154160.483780668*x_113 + 2084.49404749558*x_114 + 44.8260534755051*x_115 - 23241.4240724775*x_116 - 34881.6738153955*x_117 - 16038.3156984062*x_118 + 36895.46985507*x_119 + 92221.0379848924*x_12 - 79516.8572052891*x_120 + 12678.2719837487*x_13 - 68940.4345734214*x_14 - 21604.1604457431*x_15 + 45664.7490416815*x_16 + 46.3947155670219*x_17 - 58302.5406365836*x_18 - 6081.68307477882*x_19 + 65002.2692109767*x_2 + 26300.3857222544*x_20 + 29982.6775708968*x_21 - 6624.32305036245*x_22 + 34586.1871309495*x_23 - 15756.3616584194*x_24 + 34680.3175937667*x_25 + 9434.03441494834*x_26 - 26035.1673544602*x_27 + 4.61351976435801*x_28 + 35880.9569215194*x_29 - 43606.6406877254*x_3 + 69815.7956510494*x_30 - 754335.055225806*x_31 + 23924.1929469175*x_32 - 67622.9893272896*x_33 + 48931.952276667*x_34 - 16308.4431786046*x_35 - 6.79518518612661*x_36 - 86802.3769591927*x_37 - 36270.189911268*x_38 + 42970.1006517367*x_39 - 132996.022392071*x_4 + 56480.954965891*x_40 - 12182.9071893121*x_41 + 33520.3445444401*x_42 - 49981.878006673*x_43 - 16357.6150545189*x_44 - 62099.8907190896*x_45 + 34624.4543853553*x_46 - 61818.8808808561*x_47 + 54450.8964721989*x_48 + 15976.8885875376*x_49 + 8799.6634797322*x_5 - 14.5034157693093*x_50 + 67104.670818636*x_51 + 39702.2516636711*x_52 + 44643.9477231377*x_53 - 116710.824177809*x_54 + 40038.9710168171*x_55 - 50752.5238492288*x_56 + 36409.9982312496*x_57 - 22999.9853303641*x_58 + 39373.9483422793*x_59 - 25002.7933273594*x_6 - 64080.3818738699*x_60 + 70841.4085646369*x_61 - 27369.0077566558*x_62 - 42516.018345185*x_63 - 89805.8496643327*x_64 - 62293.6193817672*x_65 - 96434.7684680974*x_66 - 51414.3822234077*x_67 - 33239.2630791767*x_68 - 55619.2709132444*x_69 - 29986.5156546223*x_7 + 81929.0052054831*x_70 + 11787.0185922727*x_71 - 126836.021465847*x_72 - 5.05423805840128*x_73 + 15080.6842008205*x_74 + 4769.0811954688*x_75 + 42465.1920780557*x_76 + 81924.7333133691*x_77 + 82795.0005207858*x_78 + 43253.8125339467*x_79 - 609305.952006519*x_8 + 39.2511655584362*x_80 + 40687.2173199169*x_81 + 89502.9537651081*x_82 + 6928.55746695205*x_83 - 80854.113429124*x_84 - 56974.123109938*x_85 - 85956.9168788247*x_86 - 14622.843883181*x_87 - 56208.5501009061*x_88 - 105944.131826737*x_89 + 356146.283815734*x_9 - 203875.484941413*x_90 + 129184.563220623*x_91 + 42373.5865233197*x_92 - 1952211.71859218*x_93 - 48609.8178069714*x_94 - 100110.636258864*x_95 + 71893.287173648*x_96 + 80251.2932265125*x_97 - 29856.1610971351*x_98 - 73729.7045660057*x_99 - 0.00593563235620081*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 2.2474576286184e-6*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.0958949292094367*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) - 9.70615166052796e-6*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.00335444703723241*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) - 0.123696939605489*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 3.36820031429924e-5*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) + 0.000382367120471391*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) + 0.000484953074926356*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) + 0.00141375541460831*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) + 0.0155663739874987*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.0237757144591097*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) + 0.000668830758999801*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.00807339157020789*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.00953778126654189*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) + 0.0202561092135865*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 8.2881371769187e-6*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.0476844778971296*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) - 0.00109351134973798*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) - 2.27559089899739*std::exp(0.675439834594727*x_1) + 6.04909177696051*std::exp(0.805679857730865*x_1) + 5409.68403010229*std::exp(0.820959866046906*x_1) - 0.090121317937109*std::exp(0.863999843597412*x_1) - 1.11238844687881e-5*std::exp(0.999759793281555*x_1) - 0.000394189753638971*std::exp(1.01575982570648*x_1) - 0.0176595304396197*std::exp(1.04399979114532*x_1) - 0.0061942443587278*std::exp(1.06791973114014*x_1) + 2.06733730067279*std::exp(1.0971999168396*x_1) + 1.08651421733017e-5*std::exp(1.11495983600616*x_1) + 0.015524768563919*std::exp(1.13255989551544*x_1) - 0.000411240340813782*std::exp(1.20439982414246*x_1) + 0.0207187244087465*std::exp(0.975199818611145*x_108) + 2.70186538882271*std::exp(1.29199981689453*x_108) - 0.0093002425257038*std::exp(1.58871984481812*x_108) + 0.00908612524360484*std::exp(1.60567986965179*x_108) + 724.281399299654*std::exp(2.76399993896484*x_17) - 0.00130723742583204*std::exp(2.89416003227234*x_17) + 0.00304609800173547*std::exp(2.91807985305786*x_17) - 0.00529476636141112*std::exp(3.5239999294281*x_17) - 0.00198261550986096*std::exp(3.58959984779358*x_17) + 0.000631173764561593*std::exp(3.60615992546082*x_17) - 2.15443174766525e-6*std::exp(3.7247200012207*x_17) + 5.54062010226322*std::exp(0.934719800949097*x_29) - 0.061185199399024*std::exp(1.11599981784821*x_29) + 3.53080431786247*std::exp(1.20207989215851*x_29) + 0.458785441804858*std::exp(1.28559982776642*x_29) - 0.00656368736261377*std::exp(1.62799978256226*x_29) + 9.19861022298481e-5*std::exp(1.69127988815308*x_29) - 0.00165691252934485*std::exp(2.63527989387512*x_29) + 0.000186098056338153*std::exp(1.38783979415894*x_38) + 1.43096430028819*std::exp(1.42807984352112*x_38) - 0.0759912586849096*std::exp(2.43751978874207*x_38) - 0.00119138926416646*std::exp(2.55167984962463*x_38) + 0.000151472512066531*std::exp(1.51279985904694*x_50) + 0.0323214679875814*std::exp(1.64831984043121*x_50) - 0.036023012987237*std::exp(1.6839998960495*x_50) + 3.81906150812457*std::exp(1.73599982261658*x_50) - 48331.1342652172*std::exp(1.89111995697021*x_50) - 0.217263024339282*std::exp(1.92567980289459*x_50) - 0.102682923726956*std::exp(1.93199980258942*x_50) + 0.0387920166647774*std::exp(1.93495976924896*x_50) - 27.9079494884697*std::exp(1.95423984527588*x_50) - 0.0535348202059396*std::exp(2.00951981544495*x_50) + 0.128892453714117*std::exp(0.747759819030762*x_66) - 0.122383366283663*std::exp(0.704879820346832*x_71) - 2.61151026586762*std::exp(0.727519869804382*x_71) - 0.0231487132299115*std::exp(1.12319993972778*x_71) - 6.91027353106654*std::exp(1.13343989849091*x_71) - 0.000200391565093173*std::exp(1.17391979694366*x_71) - 0.108034681677854*std::exp(1.27175986766815*x_71) - 0.00427808666289437*std::exp(1.67999982833862*x_71) + 7.69200084199996*std::exp(1.69519984722137*x_71) + 0.884773347916318*std::exp(1.85879993438721*x_71) + 0.000223667804044712*std::exp(1.86255991458893*x_71) + 0.0267236713217334*std::exp(1.9048798084259*x_71) - 0.159121481528184*std::exp(1.04767978191376*x_72) + 98640.3117875194*std::exp(0.721359848976135*x_73) - 0.329563641085118*std::exp(0.838959872722626*x_73) - 0.000983466246986972*std::exp(0.977439820766449*x_76) - 1.05237175554419*std::exp(1.22399985790253*x_76) + 1.61304826367612e-5*std::exp(2.10399985313416*x_76) + 0.0127807710173625*std::exp(2.24863982200623*x_76) - 0.0288731500523208*std::exp(1.07551980018616*x_77) - 1.3795738990011*std::exp(1.43767976760864*x_77) - 0.0429097222527487*std::exp(1.19447994232178*x_78) + 0.0193554132616605*std::exp(1.61599981784821*x_78) + 0.10653116811855*std::exp(1.83559989929199*x_78) + 0.787807956074656*std::exp(1.90311992168427*x_78) - 0.511115789895546*std::exp(1.36295986175537*x_81) + 0.0398348317695684*std::exp(1.0487197637558*x_87) - 1.07314627862126*std::exp(0.894479870796204*x_88) - 85.7629507257258*std::sin(0.370079845190048*x_102 + 8.18015956878662) - 1.70502818055349*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 2.00173487437952*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 45.6143484561595*std::sin(0.316399931907654*x_104 + 1.89671981334686) + 0.00337143726258539*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 52.9208281884315*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 2.19797588906976*std::sin(0.433839857578278*x_105 + 2.02359986305237) + 36.7046551759593*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.00166569358455044*std::sin(0.499759823083878*x_105 + 2.03655982017517) - 2.93988120632149*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 1.49809886309843*std::sin(0.512159824371338*x_109 + 2.15727996826172) + 5.64880514710179*std::sin(0.401439845561981*x_111 - 7.40527963638306) + 40.5003176089327*std::sin(0.180640012025833*x_112 - 7.61432027816772) - 2.1175935112834*std::sin(0.260399967432022*x_112 + 5.04791975021362) + 271776.358996055*std::sin(0.51503986120224*x_115 + 2.13183975219727) - 7.21835028698752*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 38.5975673144183*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 13.1793087397514*std::sin(0.38391986489296*x_14 - 1.22143995761871) + 31.6679221352517*std::sin(0.476879835128784*x_14 + 8.24479961395264) + 0.296868368338062*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 1.3261682281396*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 1.14030596868804*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 2.39923616346464*std::sin(0.436239868402481*x_19 - 1.1658399105072) - 13.0505742045051*std::sin(0.31743985414505*x_21 + 8.31935977935791) + 0.715053292167597*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 367.651512083618*std::sin(0.166160017251968*x_26 + 1.75695991516113) - 74.4367762695587*std::sin(0.263119965791702*x_26 + 5.06063985824585) + 0.785548926906117*std::sin(0.314319849014282*x_28 - 4.30048036575317) + 7.40053749759058*std::sin(0.319439828395844*x_28 - 4.27544021606445) + 109.213694226192*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 1.89968964280609*std::sin(0.341279834508896*x_28 + 5.1275200843811) - 566350.485442443*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 213.395015792226*std::sin(0.344959855079651*x_28 + 5.1547999382019) + 33.2656130388904*std::sin(0.364799857139587*x_28 - 4.23216009140015) - 5.2188014429557*std::sin(0.368799835443497*x_3 + 5.17008018493652) - 0.698721370874683*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 325.308823161462*std::sin(0.323519825935364*x_36 - 1.24327993392944) - 86.4668269385552*std::sin(0.332959830760956*x_36 - 7.4410400390625) + 1.48915447569277*std::sin(0.343119859695435*x_36 - 1.22071981430054) - 0.989179917781721*std::sin(0.345119833946228*x_36 + 5.14664030075073) - 0.00629797269502863*std::sin(0.354799836874008*x_36 - 7.42647981643677) + 5.54717235342035*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 2.45729800321745*std::sin(0.380479842424393*x_36 + 8.37952041625977) + 236411.603550302*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.00480178191485191*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 1.7686451246936*std::sin(0.451039850711823*x_45 - 7.353759765625) - 326.731378062392*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 2.71232306918632*std::sin(0.357999831438065*x_46 - 4.24848031997681) + 7.7464818887395*std::sin(0.412479877471924*x_46 - 7.39631986618042) + 20.0991851932016*std::sin(0.41839987039566*x_46 - 4.18064022064209) - 0.203981050539376*std::sin(0.237599983811378*x_47 - 7.55951976776123) + 9.77321642295964*std::sin(0.65831983089447*x_47 - 4.15960025787354) - 8.41183460448557*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 577.76806300481*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 105.933995788124*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 1.55607451497401*std::sin(0.444399863481522*x_53 - 7.35679960250854) - 0.0145121579921474*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 1.41247171368207*std::sin(0.420479863882065*x_55 + 5.20256042480469) + 30.9336256994934*std::sin(0.485599845647812*x_55 + 2.05031991004944) - 1.10194225627957*std::sin(0.167360007762909*x_67 + 1.76391994953156) - 0.0143440355010903*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.00328461325117943*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.00279640843854748*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.00500350951498253*std::sin(0.288719952106476*x_72 - 7.48760032653809) - 4.34802420628656*std::sin(0.379999846220016*x_73 + 1.97735977172852) + 0.243884022898068*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 120.402315529813*std::sin(0.612159848213196*x_73 - 3.98176002502441) - 0.617248355610252*std::sin(0.806719899177551*x_73 - 0.778159856796265) - 115.509924913377*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 399.460086405102*std::sin(0.301919937133789*x_75 - 7.48392009735107) - 0.324247813963353*std::sin(0.393039852380753*x_75 + 8.3851203918457) + 0.34733154196001*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 10.2349842470628*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 5.7532895142946*std::sin(0.214559987187386*x_80 + 1.82359993457794) + 1.8502853616456*std::sin(0.249999970197678*x_80 + 1.83071994781494) + 64.2724442487006*std::sin(0.257039994001389*x_80 + 5.08447980880737) - 440184.901365643*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 1666.13087116265*std::sin(0.164080023765564*x_85 + 1.76831984519958) - 0.279250357591225*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 3.68456164392724*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 3.28476005746296*std::sin(0.34759983420372*x_92 + 1.99199986457825) + 0.0139162848520862*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 336.853826214237*std::sin(0.364559859037399*x_92 + 1.98087978363037) + 5.42673457029039*std::sin(0.366079837083817*x_92 + 1.98439979553223) - 9.7511516060956*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 2.57892407735477*std::sin(0.134640038013458*x_96 - 7.67208003997803) - 7.74837940999012*std::sin(0.476799845695496*x_96 + 5.22983980178833) + 0.335323402688004*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.00293435555819875*std::sin(0.513919830322266*x_98 + 5.16983985900879) - 8585639.98013048 - 0.243707859102464*std::exp(-2.36207985877991*x_86) + 0.00579973636345548*std::exp(-2.35904002189636*x_86) - 4.36905721363688e-6*std::exp(-2.29543995857239*x_86) - 0.00613692938922106*std::exp(-2.10855984687805*x_23) + 1.53884641109787*std::exp(-2.10799980163574*x_23) - 0.248957301366602*std::exp(-2.07343983650208*x_23) - 0.881035731296378*std::exp(-1.99351978302002*x_23));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.43190276474336*x_1 + 29004.7091845707*x_10 + 13600.013351153*x_100 + 792545.200228931*x_101 - 8866.98718160857*x_102 + 5382.63363617502*x_103 + 21974.4619534935*x_104 + 14671.2737435246*x_105 + 9661.8393121049*x_106 + 103784.534398531*x_107 - 4354.93612422978*x_108 + 19500.7857763141*x_109 - 27531.4668418862*x_11 + 17506.6396916725*x_110 - 29506.8201879147*x_111 + 9527.74260567375*x_112 - 67425.7614167188*x_113 - 778.705100669136*x_114 - 127.907145550478*x_115 + 9661.94301820112*x_116 + 15017.5123540087*x_117 + 6410.03327747337*x_118 - 15895.3139756085*x_119 - 39879.389157051*x_12 + 34541.9906098099*x_120 - 5538.97362782679*x_13 + 29881.5047987665*x_14 + 9242.44529991325*x_15 - 19488.4476427577*x_16 - 303.209558938792*x_17 + 25620.2456985793*x_18 + 2455.17653164614*x_19 - 28355.8827602882*x_2 - 11079.6329339276*x_20 - 12826.9413218748*x_21 + 2937.33893634277*x_22 - 15108.7901097252*x_23 + 6955.61497971582*x_24 - 15023.1289982692*x_25 - 4197.05706844079*x_26 + 11431.6253783219*x_27 + 9.38716907137172*x_28 - 15647.1105434413*x_29 + 18919.4982427404*x_3 - 31297.1191901058*x_30 + 334202.778693728*x_31 - 10594.2357024751*x_32 + 29425.2682966789*x_33 - 21013.0648480386*x_34 + 7199.70199620809*x_35 - 18.035407029748*x_36 + 37810.6442036188*x_37 + 15987.8226036*x_38 - 18644.8875022057*x_39 + 58273.5349742467*x_4 - 25280.9116068272*x_40 + 5091.08986724802*x_41 - 14882.5435165569*x_42 + 22117.0802369732*x_43 + 7081.53243050668*x_44 + 27323.25133089*x_45 - 15125.0240716398*x_46 + 26844.0635890222*x_47 - 22493.5804050695*x_48 - 7525.49654491892*x_49 - 3828.36434710556*x_5 + 2.7276020042891*x_50 - 29309.9763152032*x_51 - 17323.6435509211*x_52 - 19493.3410852826*x_53 + 50711.6671145647*x_54 - 17585.2280809479*x_55 + 22402.3592073045*x_56 - 16148.2759918575*x_57 + 9948.09162909231*x_58 - 16823.1154868675*x_59 + 10776.2889866749*x_6 + 28310.1750533305*x_60 - 30917.1918266172*x_61 + 12704.669913675*x_62 + 18199.6262230501*x_63 + 39666.7508329766*x_64 + 27399.2466433395*x_65 + 42461.8554267223*x_66 + 22814.4987427464*x_67 + 14419.7451006102*x_68 + 24318.6398290586*x_69 + 12745.6681072965*x_7 - 35353.9047129624*x_70 - 5156.42725017647*x_71 + 55177.08439807*x_72 - 3.04814982584638*x_73 - 6367.03966333945*x_74 - 2088.58113884714*x_75 - 18571.1829326702*x_76 - 35707.771879795*x_77 - 36031.5802801067*x_78 - 18847.3763270472*x_79 + 269033.277630056*x_8 - 240.158185160976*x_80 - 17695.1741319764*x_81 - 38914.2850439793*x_82 - 3522.82402625938*x_83 + 35948.5703829224*x_84 + 24872.9076752195*x_85 + 37402.5150945066*x_86 + 6673.10779312859*x_87 + 24423.9739083839*x_88 + 46048.9981059638*x_89 - 155825.945100389*x_9 + 89334.5787712667*x_90 - 56712.8100614158*x_91 - 18522.5877112296*x_92 + 858956.070056482*x_93 + 21422.3844458943*x_94 + 43412.028270174*x_95 - 31353.3081013426*x_96 - 35173.3255349394*x_97 + 12829.4836331114*x_98 + 32333.1078467681*x_99 + 0.00603667451262133*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) - 3.71880951587483e-5*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.163358427122594*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 8.60742676909463e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.0129184417370356*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.00707877303848008*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) - 0.000557327320466045*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 0.000212423273912084*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.000770525263854466*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00224626736108884*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.000890812891903699*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.111116674108909*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 0.000371567564032934*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.0310917529662517*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.0445751707919895*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.00115919116691938*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) + 0.000137141644006649*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.0812312118237702*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.001737442579187*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 1.33228429823025*std::exp(0.675439834594727*x_1) - 46.5559176672357*std::exp(0.805679857730865*x_1) - 2362.08668452125*std::exp(0.820959866046906*x_1) + 0.0916554514139427*std::exp(0.863999843597412*x_1) + 0.000184064014775006*std::exp(0.999759793281555*x_1) + 0.00105700920721678*std::exp(1.01575982570648*x_1) + 0.0010105974193613*std::exp(1.04399979114532*x_1) + 0.00344119981987538*std::exp(1.06791973114014*x_1) + 3.52173960139429*std::exp(1.0971999168396*x_1) - 9.6352209262109e-5*std::exp(1.11495983600616*x_1) + 0.0597880413516437*std::exp(1.13255989551544*x_1) - 0.00121485193917087*std::exp(1.20439982414246*x_1) - 0.0555567014608139*std::exp(0.975199818611145*x_108) - 1.58185411755964*std::exp(1.29199981689453*x_108) - 0.0274740013218374*std::exp(1.58871984481812*x_108) + 0.042464339792722*std::exp(1.60567986965179*x_108) - 316.250531382659*std::exp(2.76399993896484*x_17) + 0.00350532194803914*std::exp(2.89416003227234*x_17) + 0.00899852883350407*std::exp(2.91807985305786*x_17) + 0.0053848990682222*std::exp(3.5239999294281*x_17) - 0.00763532786978014*std::exp(3.58959984779358*x_17) - 0.00035064729757699*std::exp(3.60615992546082*x_17) + 1.91055262122625e-5*std::exp(3.7247200012207*x_17) - 2.40383703636624*std::exp(0.934719800949097*x_29) + 0.0972150592468775*std::exp(1.11599981784821*x_29) + 6.01477726297666*std::exp(1.20207989215851*x_29) - 0.466595337632701*std::exp(1.28559982776642*x_29) + 0.017600350875506*std::exp(1.62799978256226*x_29) - 0.0015220700401408*std::exp(1.69127988815308*x_29) + 0.000920494376282857*std::exp(2.63527989387512*x_29) - 0.0030793159968118*std::exp(1.38783979415894*x_38) - 0.620833935419174*std::exp(1.42807984352112*x_38) + 0.044490405016677*std::exp(2.43751978874207*x_38) + 0.00121167026089327*std::exp(2.55167984962463*x_38) - 0.00134326002801459*std::exp(1.51279985904694*x_50) + 0.124474465215443*std::exp(1.64831984043121*x_50) + 0.0572357265515612*std::exp(1.6839998960495*x_50) - 2.23593603028192*std::exp(1.73599982261658*x_50) + 21103.3265640692*std::exp(1.89111995697021*x_50) + 0.0124332553728217*std::exp(1.92567980289459*x_50) + 0.0570452888471536*std::exp(1.93199980258942*x_50) - 0.104019747856588*std::exp(1.93495976924896*x_50) + 214.789301692397*std::exp(1.95423984527588*x_50) + 0.0544461424295174*std::exp(2.00951981544495*x_50) - 0.204792787265039*std::exp(0.747759819030762*x_66) + 0.194450722085714*std::exp(0.704879820346832*x_71) + 0.149448228215642*std::exp(0.727519869804382*x_71) + 0.0620726510350833*std::exp(1.12319993972778*x_71) + 4.04573991132253*std::exp(1.13343989849091*x_71) + 0.00331582695789313*std::exp(1.17391979694366*x_71) - 0.416056573659909*std::exp(1.27175986766815*x_71) - 0.0126379670537033*std::exp(1.67999982833862*x_71) - 59.2003181800618*std::exp(1.69519984722137*x_71) - 0.383865145643577*std::exp(1.85879993438721*x_71) - 0.0019834887309131*std::exp(1.86255991458893*x_71) + 0.124894058698324*std::exp(1.9048798084259*x_71) - 0.743660083784335*std::exp(1.04767978191376*x_72) - 43070.3467584813*std::exp(0.721359848976135*x_73) - 1.26919538414177*std::exp(0.838959872722626*x_73) + 0.00872139030676988*std::exp(0.977439820766449*x_76) + 0.456578894656495*std::exp(1.22399985790253*x_76) - 0.000266906888750188*std::exp(2.10399985313416*x_76) - 0.0129983378386907*std::exp(2.24863982200623*x_76) - 0.0852946533932501*std::exp(1.07551980018616*x_77) + 0.598537848041305*std::exp(1.43767976760864*x_77) + 0.0681777820786927*std::exp(1.19447994232178*x_78) - 0.0519010193395302*std::exp(1.61599981784821*x_78) - 0.108344646162123*std::exp(1.83559989929199*x_78) + 1.34204247961796*std::exp(1.90311992168427*x_78) + 0.0292494922234396*std::exp(1.36295986175537*x_81) - 0.106816028472747*std::exp(1.0487197637558*x_87) + 0.0614126668588353*std::exp(0.894479870796204*x_88) + 50.2114121972106*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 0.947224928176418*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 7.70895919972534*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 77.704715770173*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.0298979455084283*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 90.1514118228941*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 10.2723209847191*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 15.9245730424618*std::sin(0.471119850873947*x_105 - 7.36047983169556) - 0.0275617972676343*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 0.168239827808313*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 5.76938692560896*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 5.74496464941096*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 2.31770128876551*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 1.17642475620616*std::sin(0.260399967432022*x_112 + 5.04791975021362) - 118668.542410251*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 0.413082680596607*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 65.7515255417837*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 22.4511469379862*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 13.7393509550285*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.796044533801223*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 5.10725815568817*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 5.32926179463785*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 11.2129182634872*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 0.746841862944804*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 1.13612358618638*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 626.299776623778*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 32.2949194064727*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 1.2481316759706*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 0.423508661372574*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 63.9410581372*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 7.31596883082348*std::sin(0.341279834508896*x_28 + 5.1275200843811) + 247291.511480467*std::sin(0.343919843435287*x_28 - 4.24584007263184) - 1642.36238300443*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 14.4325204010375*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 5.30764100040839*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 1.11017435807728*std::sin(0.385039836168289*x_34 + 1.98855984210968) + 2503.6900324796*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 50.6235087769006*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 0.827296731731305*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 1.5716739547719*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.0558504963266438*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 5.64160176262059*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 9.46339612244687*std::sin(0.380479842424393*x_36 + 8.37952041625977) - 103226.860885982*std::sin(0.424479871988297*x_36 - 4.18911981582642) - 0.079453832858617*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 8.26582790068753*std::sin(0.451039850711823*x_45 - 7.353759765625) + 2514.63851057959*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 12.6761414078716*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 7.87835010222363*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 8.72017299082938*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.546969692965036*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 5.72189965659115*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 0.481381901543372*std::sin(0.405279844999313*x_49 + 5.19935989379883) + 4446.70429277664*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 180.460125195613*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 7.27237135468272*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.128693988665891*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 5.43962487285754*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 13.4207712770559*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 2.95482848033519*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.127203076427318*std::sin(0.297439932823181*x_68 + 5.14079999923706) - 0.0543496387158302*std::sin(0.406319856643677*x_69 + 8.40272045135498) + 0.0462714410234997*std::sin(0.511679828166962*x_70 - 1.10791981220245) - 0.0827917668397861*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 0.248823266123507*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.65396843859221*std::sin(0.480799853801727*x_73 + 8.47792053222656) + 926.65816546217*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.627755762598275*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 50.1147940933972*std::sin(0.204880014061928*x_75 + 1.81199991703033) + 3074.38398684163*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.180135211720134*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.19295932972772*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 39.4163467801379*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 26.8882096945411*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 1.02792225886946*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 27.8850524040984*std::sin(0.257039994001389*x_80 + 5.08447980880737) + 192202.518383209*std::sin(0.32015985250473*x_80 - 1.26199984550476) + 12823.1236226447*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.748802312509731*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 17.2199340687143*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 15.3514466813941*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.123409778614233*std::sin(0.353119850158691*x_92 - 7.41048002243042) - 2592.54439796305*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 5.51911376940489*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 0.558026652102377*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 7.6184425636579*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 0.443414521283097*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.899160672656913*std::sin(0.393919825553894*x_97 - 7.38903999328613) - 0.0485540160305402*std::sin(0.513919830322266*x_98 + 5.16983985900879) + 3685602.87904949 + 0.142683007820333*std::exp(-2.36207985877991*x_86) + 0.0223355907754269*std::exp(-2.35904002189636*x_86) + 7.22936500985895e-5*std::exp(-2.29543995857239*x_86) - 0.0181292053067963*std::exp(-2.10855984687805*x_23) - 11.843498075275*std::exp(-2.10799980163574*x_23) + 0.108011877813889*std::exp(-2.07343983650208*x_23) + 0.515817703218594*std::exp(-1.99351978302002*x_23));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.262433133140131*x_1 + 36238.7954043676*x_10 + 16944.8889846993*x_100 + 991785.802061927*x_101 - 11025.5364184858*x_102 + 6677.79725251275*x_103 + 27334.4895372818*x_104 + 18435.9467432381*x_105 + 12102.2992837362*x_106 + 129484.924573841*x_107 - 5473.55245867787*x_108 + 24425.0374089768*x_109 - 34348.6814243422*x_11 + 21897.5794719445*x_110 - 36949.3518051244*x_111 + 11971.1929775259*x_112 - 84224.8494232152*x_113 - 1016.16164620003*x_114 - 145.40696326545*x_115 + 12191.6351201613*x_116 + 18811.473784223*x_117 + 8140.73491967858*x_118 - 19910.7839555877*x_119 - 49936.3514448664*x_12 + 43203.8521329249*x_120 - 6919.81684846836*x_13 + 37403.1171875961*x_14 + 11590.6130728366*x_15 - 24458.7928424645*x_16 - 316.631442677943*x_17 + 31978.5581007737*x_18 + 3105.86251345935*x_19 - 35442.7524381486*x_2 - 13929.079097707*x_20 - 16086.802068506*x_21 + 3664.84607620728*x_22 - 18876.5905022559*x_23 + 8680.03017133391*x_24 - 18804.6138064803*x_25 - 5238.44171957403*x_26 + 14261.577073381*x_27 + 5.25991221391461*x_28 - 19563.2567683732*x_29 + 23669.313247559*x_3 - 38923.1804215261*x_30 + 416643.113448345*x_31 - 13196.2992645518*x_32 + 36782.658124424*x_33 - 26336.0736946353*x_34 + 8986.39637604105*x_35 - 16.2718789214363*x_36 + 47267.7832474814*x_37 + 19933.1686392879*x_38 - 23319.7025059174*x_39 + 72781.8729002916*x_4 - 31452.4618703695*x_40 + 6412.72266624362*x_41 - 18531.286114691*x_42 + 27575.6104604562*x_43 + 8876.76174767832*x_44 + 34102.3237918515*x_45 - 18901.6875513617*x_46 + 33581.1635317003*x_47 - 28341.6448888055*x_48 - 9280.62755418363*x_49 - 4783.82734507721*x_5 + 17.0089090683241*x_50 - 36628.1576005151*x_51 - 21652.1936351113*x_52 - 24357.4629446785*x_53 + 63448.0064075913*x_54 - 21967.0677584807*x_55 + 27933.0846168657*x_56 - 20129.218199922*x_57 + 12455.4335593053*x_58 - 21104.6949642595*x_59 + 13490.697088312*x_6 + 35317.7446466984*x_60 - 38641.0155048892*x_61 + 15734.6872330632*x_62 + 22834.7037986621*x_63 + 49473.2212608944*x_64 + 34201.9736808299*x_65 + 53010.0116024788*x_66 + 28423.673806796*x_67 + 18059.9353748229*x_68 + 30397.8879281999*x_69 + 16000.1611479021*x_7 - 44277.8403061902*x_70 - 6439.03843545398*x_71 + 69018.1320274708*x_72 + 0.689047897405014*x_73 - 8014.13849307835*x_74 - 2608.24738327557*x_75 - 23204.793206564*x_76 - 44645.8119371457*x_77 - 45049.4548094396*x_78 - 23569.20423223*x_79 + 335369.728412792*x_8 - 252.705807375933*x_80 - 22135.2001812603*x_81 - 48657.1001057496*x_82 - 4295.45153269464*x_83 + 44786.5929096118*x_84 + 31085.3424788521*x_85 + 46768.8419761588*x_86 + 8278.06643582559*x_87 + 30548.6916391956*x_88 + 57597.1501316412*x_89 - 194738.690513097*x_9 + 111571.768604242*x_90 - 70787.3166355986*x_91 - 23142.9383044879*x_92 + 1072105.4104177*x_93 + 26736.9648123547*x_94 + 54308.1913518766*x_95 - 39201.6734175988*x_96 - 43926.869501928*x_97 + 16083.6094178466*x_98 + 40379.9724516302*x_99 - 0.00314664103925812*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) - 7.2529780616996e-7*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.0966040849660017*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 3.45610660022114e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.000534624213476795*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) - 0.344092028065264*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) - 1.08698302810896e-5*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 0.00060920935873887*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.00021238332140373*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00061914870970272*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) + 0.0433015174996543*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) - 0.0833606906079789*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 0.00106561975646017*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.00128671896452826*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) - 0.0334406789168912*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) + 0.056347115152921*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) + 2.67474128771462e-6*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.0480371109537295*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.000478899061492284*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 2.18618803182418*std::exp(0.675439834594727*x_1) - 48.5158916692017*std::exp(0.805679857730865*x_1) - 2951.93244951611*std::exp(0.820959866046906*x_1) - 0.0477757752696202*std::exp(0.863999843597412*x_1) + 3.58989148385411e-6*std::exp(0.999759793281555*x_1) + 0.000568244626676743*std::exp(1.01575982570648*x_1) - 0.0491241227392445*std::exp(1.04399979114532*x_1) + 0.00986902751732486*std::exp(1.06791973114014*x_1) + 2.08262553498945*std::exp(1.0971999168396*x_1) - 3.86879279150336e-5*std::exp(1.11495983600616*x_1) + 0.00247430264683575*std::exp(1.13255989551544*x_1) + 0.000100181859830998*std::exp(1.20439982414246*x_1) - 0.0298670975289971*std::exp(0.975199818611145*x_108) - 2.59571515215968*std::exp(1.29199981689453*x_108) + 0.00226562304481272*std::exp(1.58871984481812*x_108) - 0.0318571152324418*std::exp(1.60567986965179*x_108) - 395.222669804091*std::exp(2.76399993896484*x_17) + 0.00188444939565866*std::exp(2.89416003227234*x_17) - 0.000742056974365579*std::exp(2.91807985305786*x_17) - 0.00280690044906413*std::exp(3.5239999294281*x_17) - 0.000315984794459843*std::exp(3.58959984779358*x_17) - 0.00100562246013027*std::exp(3.60615992546082*x_17) + 7.67136764729556e-6*std::exp(3.7247200012207*x_17) - 4.32842979313224*std::exp(0.934719800949097*x_29) + 0.0267958211649397*std::exp(1.11599981784821*x_29) + 3.55691508542817*std::exp(1.20207989215851*x_29) + 0.243214709531193*std::exp(1.28559982776642*x_29) + 0.00946188996684915*std::exp(1.62799978256226*x_29) - 2.96856845245391e-5*std::exp(1.69127988815308*x_29) + 0.00263988864482949*std::exp(2.63527989387512*x_29) - 6.00574223406079e-5*std::exp(1.38783979415894*x_38) - 1.11789445873504*std::exp(1.42807984352112*x_38) + 0.0730057324158753*std::exp(2.43751978874207*x_38) - 0.000631588030960403*std::exp(2.55167984962463*x_38) - 0.000539353975720526*std::exp(1.51279985904694*x_50) + 0.00515132276929102*std::exp(1.64831984043121*x_50) + 0.0157761390550229*std::exp(1.6839998960495*x_50) - 3.66901913939845*std::exp(1.73599982261658*x_50) + 26373.119532587*std::exp(1.89111995697021*x_50) - 0.604368021609312*std::exp(1.92567980289459*x_50) + 0.163600358838416*std::exp(1.93199980258942*x_50) - 0.0559206697389283*std::exp(1.93495976924896*x_50) + 223.83179227816*std::exp(1.95423984527588*x_50) - 0.0283802722574847*std::exp(2.00951981544495*x_50) - 0.05644795102668*std::exp(0.747759819030762*x_66) + 0.0535973213899938*std::exp(0.704879820346832*x_71) - 7.26452785785629*std::exp(0.727519869804382*x_71) + 0.0333700503017783*std::exp(1.12319993972778*x_71) + 6.63878436888863*std::exp(1.13343989849091*x_71) + 6.4670212548742e-5*std::exp(1.17391979694366*x_71) - 0.0172183242362032*std::exp(1.27175986766815*x_71) + 0.00104218053500986*std::exp(1.67999982833862*x_71) - 61.6926132599351*std::exp(1.69519984722137*x_71) - 0.691200488141392*std::exp(1.85879993438721*x_71) - 0.000796422517236714*std::exp(1.86255991458893*x_71) - 0.0936966037673281*std::exp(1.9048798084259*x_71) + 0.557900231076836*std::exp(1.04767978191376*x_72) - 53825.6089589874*std::exp(0.721359848976135*x_73) - 0.0525251108305016*std::exp(0.838959872722626*x_73) + 0.00350186593635144*std::exp(0.977439820766449*x_76) + 0.822131309505899*std::exp(1.22399985790253*x_76) - 5.20561701361089e-6*std::exp(2.10399985313416*x_76) + 0.00677543624388738*std::exp(2.24863982200623*x_76) + 0.00703376002873896*std::exp(1.07551980018616*x_77) + 1.07774737412962*std::exp(1.43767976760864*x_77) + 0.0187921467122036*std::exp(1.19447994232178*x_78) - 0.0279018150053685*std::exp(1.61599981784821*x_78) + 0.0564750856261748*std::exp(1.83559989929199*x_78) + 0.793633900696795*std::exp(1.90311992168427*x_78) - 1.42178835856609*std::exp(1.36295986175537*x_81) - 0.0574239408778773*std::exp(1.0487197637558*x_87) - 2.98520788468312*std::exp(0.894479870796204*x_88) + 82.3935165732633*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 2.71654927658565*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 0.319031995713718*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 45.9516726301938*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.012004805800468*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 53.3121847519266*std::sin(0.426319867372513*x_105 + 2.02519989013672) + 7.70638410751683*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 28.6743216603808*std::sin(0.471119850873947*x_105 - 7.36047983169556) - 0.000537551359029845*std::sin(0.499759823083878*x_105 + 2.03655982017517) - 8.17796858823193*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 0.238763622589576*std::sin(0.512159824371338*x_109 + 2.15727996826172) + 2.99458609158536*std::sin(0.401439845561981*x_111 - 7.40527963638306) + 112.661125390741*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 3.37387216633099*std::sin(0.260399967432022*x_112 + 5.04791975021362) - 148301.721259056*std::sin(0.51503986120224*x_115 + 2.13183975219727) - 20.0795330705562*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 38.8830014586017*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 13.2767714808723*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 24.7395372949003*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.427950888071278*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 0.21136170523414*std::sin(0.551439881324768*x_15 + 2.14655995368958) - 3.99805832197879*std::sin(0.504719853401184*x_17 - 4.07760000228882) - 8.41202832672053*std::sin(0.436239868402481*x_19 - 1.1658399105072) - 36.3032307813467*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 0.313154820586071*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 370.370343917098*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 58.1513177520089*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 0.344028110857515*std::sin(0.314319849014282*x_28 - 4.30048036575317) + 20.5863294956245*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 104.922932911097*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 0.302768256544947*std::sin(0.341279834508896*x_28 + 5.1275200843811) + 309043.627404822*std::sin(0.343919843435287*x_28 - 4.24584007263184) - 1711.50477636253*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 25.9876815061775*std::sin(0.364799857139587*x_28 - 4.23216009140015) - 2.76662936830791*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 0.306002318893778*std::sin(0.385039836168289*x_34 + 1.98855984210968) + 2609.09376241392*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 83.0697390669688*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 2.37260683418984*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 0.433207514843068*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.022425432612823*std::sin(0.354799836874008*x_36 - 7.42647981643677) + 2.94070776820868*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 0.391638621110001*std::sin(0.380479842424393*x_36 + 8.37952041625977) - 129004.037958402*std::sin(0.424479871988297*x_36 - 4.18911981582642) - 0.0015496273852734*std::sin(0.343599855899811*x_43 - 7.45887994766235) - 6.20109563010011*std::sin(0.451039850711823*x_45 - 7.353759765625) + 2620.50316435586*std::sin(0.3294398188591*x_46 + 8.31216049194336) - 9.50975099352664*std::sin(0.357999831438065*x_46 - 4.24848031997681) + 4.10662189943639*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 15.7018366901567*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.294049083830418*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 9.38924864997291*std::sin(0.65831983089447*x_47 - 4.15960025787354) - 23.3994894137102*std::sin(0.405279844999313*x_49 + 5.19935989379883) + 4633.90766551579*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 106.717391777343*std::sin(0.25383996963501*x_53 + 5.06503963470459) - 5.45579593112956*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.0516739968365429*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 0.225116560376082*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 24.1658920149742*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 1.58850594227371*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.0510753566428693*std::sin(0.297439932823181*x_68 + 5.14079999923706) - 0.00106000787505913*std::sin(0.406319856643677*x_69 + 8.40272045135498) + 0.000902454791497221*std::sin(0.511679828166962*x_70 - 1.10791981220245) - 0.0016147287620271*std::sin(0.288719952106476*x_72 - 7.48760032653809) - 12.0950483657043*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.351571252841499*std::sin(0.480799853801727*x_73 + 8.47792053222656) + 965.669874478349*std::sin(0.612159848213196*x_73 - 3.98176002502441) - 0.327220233771516*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 90.238383280113*std::sin(0.204880014061928*x_75 + 1.81199991703033) + 3203.81356289122*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.516610326153486*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.55338865351806*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 1.6312287367482*std::sin(0.173680007457733*x_80 - 4.44935989379883) - 20.1717676246521*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 2.94798139877295*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 50.2107629523036*std::sin(0.257039994001389*x_80 + 5.08447980880737) + 240198.149632728*std::sin(0.32015985250473*x_80 - 1.26199984550476) + 13362.9688278025*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.402553627368271*std::sin(0.376319825649261*x_85 - 4.42600011825562) - 12.918543573262*std::sin(0.333999842405319*x_86 + 5.13912010192871) - 11.5167881639284*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.0495522485223938*std::sin(0.353119850158691*x_92 - 7.41048002243042) - 2701.68883917608*std::sin(0.364559859037399*x_92 + 1.98087978363037) + 2.87686040564787*std::sin(0.366079837083817*x_92 + 1.98439979553223) - 27.1251135461753*std::sin(0.3781598508358*x_95 + 1.99335980415344) + 0.628249188591476*std::sin(0.134640038013458*x_96 - 7.67208003997803) - 21.5539332978317*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.483385780623148*std::sin(0.393919825553894*x_97 - 7.38903999328613) - 0.000946972980394975*std::sin(0.513919830322266*x_98 + 5.16983985900879) + 4619426.74078606 + 0.23413312343007*std::exp(-2.36207985877991*x_86) + 0.000924348918694919*std::exp(-2.35904002189636*x_86) + 1.40997880081499e-6*std::exp(-2.29543995857239*x_86) + 0.00149501140536714*std::exp(-2.10855984687805*x_23) - 12.3421016789197*std::exp(-2.10799980163574*x_23) + 0.194489818930706*std::exp(-2.07343983650208*x_23) + 0.846421811678996*std::exp(-1.99351978302002*x_23));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.852326826851727*x_1 + 75466.584359294*x_10 + 34908.2394978805*x_100 + 2073450.27065746*x_101 - 22440.203879998*x_102 + 13427.684494777*x_103 + 55979.1518372055*x_104 + 39168.0069792209*x_105 + 25529.5081383282*x_106 + 267993.82847395*x_107 - 11622.0682723978*x_108 + 51219.280193082*x_109 - 71067.9489956375*x_11 + 45759.4723868779*x_110 - 77579.2092838362*x_111 + 25379.3909733463*x_112 - 175202.689572458*x_113 - 2312.53140515702*x_114 - 95.7718134323043*x_115 + 26240.3680495562*x_116 + 39526.4911715612*x_117 + 17996.1642251201*x_118 - 41827.7195473431*x_119 - 104629.721417326*x_12 + 90278.9154323087*x_120 - 14414.5071983088*x_13 + 78230.3274283909*x_14 + 24461.6943956325*x_15 - 51693.2633523573*x_16 - 167.726145250744*x_17 + 66315.3493234922*x_18 + 6810.23129501525*x_19 - 73816.2607421686*x_2 - 29689.7280463957*x_20 - 33944.8358635352*x_21 + 7530.98176032429*x_22 - 39298.9758253024*x_23 + 17943.1292177496*x_24 - 39360.502653108*x_25 - 10746.8118340136*x_26 + 29621.0945909535*x_27 - 10.1233864012864*x_28 - 40751.9207845226*x_29 + 49472.8422217745*x_3 - 79668.1204151125*x_30 + 859267.421232908*x_31 - 27181.55844621*x_32 + 76690.7408170767*x_33 - 55443.9895095082*x_34 + 18569.8017782958*x_35 + 20.4597254521573*x_36 + 98569.247203932*x_37 + 41259.96312417*x_38 - 48698.1246727373*x_39 + 151202.018300234*x_4 - 64499.2777723844*x_40 + 13714.0524329092*x_41 - 38220.1934054463*x_42 + 56937.7153613817*x_43 + 18565.4449079447*x_44 + 70673.974177374*x_45 - 39332.449954976*x_46 + 70204.4053216705*x_47 - 61294.2764675879*x_48 - 18328.0499101344*x_49 - 9994.83843488048*x_5 - 4.94567763567101*x_50 - 76239.6037638601*x_51 - 45104.7417647405*x_52 - 50726.6380939676*x_53 + 132503.886934309*x_54 - 45546.688467636*x_55 + 57766.2432164681*x_56 - 41488.1029337994*x_57 + 26096.971689327*x_58 - 44581.4855952972*x_59 + 28335.8863262115*x_6 + 72941.9736029263*x_60 - 80487.6314621261*x_61 + 31478.3061937728*x_62 + 48177.8591647394*x_63 + 102216.30646599*x_64 + 70885.1213774713*x_65 + 109722.927276273*x_66 + 58570.4401975683*x_67 + 37706.2116964384*x_68 + 63239.2211250354*x_69 + 33920.1075001215*x_7 - 92934.7858831688*x_70 - 13389.5865850389*x_71 + 144096.724148536*x_72 + 4.03047041371438*x_73 - 17031.5842276919*x_74 - 5419.73038111841*x_75 - 48267.7720123715*x_76 - 93062.8275650384*x_77 - 94038.4405341215*x_78 - 49146.6765469164*x_79 + 693309.675791345*x_8 - 141.595343631593*x_80 - 46242.2927561351*x_81 - 101627.15042454*x_82 - 8069.74492182393*x_83 + 92158.1204812843*x_84 + 64735.0269752897*x_85 + 97606.3956536906*x_86 + 16744.4501732826*x_87 + 63820.1890349627*x_88 + 120278.08575623*x_89 - 404829.618510869*x_9 + 231818.091575326*x_90 - 146875.78049359*x_91 - 48133.4147626778*x_92 + 2221336.92038501*x_93 + 55300.1241359074*x_94 + 113629.330445757*x_95 - 81689.4462784344*x_96 - 91234.6432860264*x_97 + 33842.7414960595*x_98 + 83847.0600121144*x_99 + 0.00299530114403379*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 1.42347110603973e-5*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) + 0.185785750564325*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 8.89477657799114e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.00879104594123126*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.138698438936086*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 0.000213331533627456*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) + 2.82963438398661e-5*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.000518258458980535*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00151084865821617*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.0174542052442625*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.0830416275597174*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) + 4.94955348252884e-5*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.0211580494214044*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.0333126847163473*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.0227126939098388*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 5.24945326844275e-5*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) - 0.0923833678112192*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00116861101886815*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 0.499566999000921*std::exp(0.675439834594727*x_1) - 25.8637979428009*std::exp(0.805679857730865*x_1) - 6146.90449546955*std::exp(0.820959866046906*x_1) + 0.0454779660396007*std::exp(0.863999843597412*x_1) - 7.04552910213399e-5*std::exp(0.999759793281555*x_1) - 0.000482981322754972*std::exp(1.01575982570648*x_1) + 0.0198012118337876*std::exp(1.04399979114532*x_1) - 0.000458393148413573*std::exp(1.06791973114014*x_1) - 4.00523588933756*std::exp(1.0971999168396*x_1) - 9.95688255239672e-5*std::exp(1.11495983600616*x_1) + 0.0406859766028672*std::exp(1.13255989551544*x_1) + 0.00063298798644922*std::exp(1.20439982414246*x_1) + 0.0253856342747485*std::exp(0.975199818611145*x_108) - 0.593148260785063*std::exp(1.29199981689453*x_108) + 0.0143150882965064*std::exp(1.58871984481812*x_108) + 0.0317351821219943*std::exp(1.60567986965179*x_108) - 822.984958930371*std::exp(2.76399993896484*x_17) - 0.00160169374078003*std::exp(2.89416003227234*x_17) - 0.00468860481155624*std::exp(2.91807985305786*x_17) + 0.00267190061445743*std::exp(3.5239999294281*x_17) - 0.00519586800373674*std::exp(3.58959984779358*x_17) + 4.6708801328732e-5*std::exp(3.60615992546082*x_17) + 1.9743343930988e-5*std::exp(3.7247200012207*x_17) - 0.77479037679886*std::exp(0.934719800949097*x_29) + 0.0653872483595868*std::exp(1.11599981784821*x_29) - 6.8405403257265*std::exp(1.20207989215851*x_29) - 0.231517128460381*std::exp(1.28559982776642*x_29) - 0.00804216338775957*std::exp(1.62799978256226*x_29) + 0.000582611912296202*std::exp(1.69127988815308*x_29) - 0.000122616627143892*std::exp(2.63527989387512*x_29) + 0.00117868832192561*std::exp(1.38783979415894*x_38) - 0.200103481008042*std::exp(1.42807984352112*x_38) + 0.0166825790471605*std::exp(2.43751978874207*x_38) + 0.000601211364147139*std::exp(2.55167984962463*x_38) - 0.00138810333864655*std::exp(1.51279985904694*x_50) + 0.0847053200760305*std::exp(1.64831984043121*x_50) + 0.0384969848916544*std::exp(1.6839998960495*x_50) - 0.838409530225456*std::exp(1.73599982261658*x_50) + 54917.6005165663*std::exp(1.89111995697021*x_50) + 0.243611866312123*std::exp(1.92567980289459*x_50) - 0.00759885241356178*std::exp(1.93199980258942*x_50) + 0.0475299506091343*std::exp(1.93495976924896*x_50) + 119.324618171087*std::exp(1.95423984527588*x_50) + 0.0270153032710959*std::exp(2.00951981544495*x_50) - 0.137744470320644*std::exp(0.747759819030762*x_66) + 0.130788354779797*std::exp(0.704879820346832*x_71) + 2.92822440309855*std::exp(0.727519869804382*x_71) - 0.0283629800943483*std::exp(1.12319993972778*x_71) + 1.51703217468105*std::exp(1.13343989849091*x_71) - 0.00126921904632109*std::exp(1.17391979694366*x_71) - 0.283127990793944*std::exp(1.27175986766815*x_71) + 0.00658490229154586*std::exp(1.67999982833862*x_71) - 32.8883017300335*std::exp(1.69519984722137*x_71) - 0.123725117940076*std::exp(1.85879993438721*x_71) - 0.00204970539741124*std::exp(1.86255991458893*x_71) + 0.0933379800108342*std::exp(1.9048798084259*x_71) - 0.555764867909197*std::exp(1.04767978191376*x_72) - 112082.807902878*std::exp(0.721359848976135*x_73) - 0.863692011583843*std::exp(0.838959872722626*x_73) + 0.00901254466743902*std::exp(0.977439820766449*x_76) + 0.147161778638731*std::exp(1.22399985790253*x_76) + 0.000102165556616167*std::exp(2.10399985313416*x_76) - 0.00644956691260491*std::exp(2.24863982200623*x_76) + 0.0444420337700786*std::exp(1.07551980018616*x_77) + 0.192917139471865*std::exp(1.43767976760864*x_77) + 0.0458566564061263*std::exp(1.19447994232178*x_78) + 0.0237152361604706*std::exp(1.61599981784821*x_78) - 0.0537588769977304*std::exp(1.83559989929199*x_78) - 1.52629021812213*std::exp(1.90311992168427*x_78) + 0.573101989428287*std::exp(1.36295986175537*x_81) + 0.0488076606816344*std::exp(1.0487197637558*x_87) + 1.2032934207552*std::exp(0.894479870796204*x_88) + 18.8277866370408*std::sin(0.370079845190048*x_102 + 8.18015956878662) - 0.126177333433178*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 5.24597438788418*std::sin(0.300959914922714*x_104 - 1.30567979812622) + 88.3727224608694*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.030896056692957*std::sin(0.34063982963562*x_105 + 5.15248012542725) + 102.528213603456*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 7.67688792188683*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 5.13271314206099*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.0105499950652279*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 3.29641893546275*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 3.92608849799293*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 2.8505593851112*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 45.4120437149873*std::sin(0.180640012025833*x_112 - 7.61432027816772) - 0.156708437782186*std::sin(0.260399967432022*x_112 + 5.04791975021362) - 308813.474794314*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 8.09376464520538*std::sin(0.454559862613678*x_117 - 7.36303997039795) - 74.7784900889276*std::sin(0.440479874610901*x_120 - 1.17087984085083) - 25.5334435962308*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 4.42838542811954*std::sin(0.476879835128784*x_14 + 8.24479961395264) + 0.363738214655239*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 3.47550749496862*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 3.98275575351356*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 8.37983128779954*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 14.6332987312168*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 0.764161393025528*std::sin(0.459999859333038*x_21 - 4.36111974716187) + 712.283878633309*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 10.4091052750622*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 0.839498494517231*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 8.29804683509104*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 23.9759956407022*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 4.97854303216786*std::sin(0.341279834508896*x_28 + 5.1275200843811) + 643531.549274549*std::sin(0.343919843435287*x_28 - 4.24584007263184) - 912.40235294036*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 4.65180365827985*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 2.63356639941491*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 0.7467078355597*std::sin(0.385039836168289*x_34 + 1.98855984210968) + 1390.90659912025*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 18.9823106015488*std::sin(0.332959830760956*x_36 - 7.4410400390625) + 0.110202014814793*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 1.05711436085212*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.0577150058806327*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 2.79927237727162*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 6.43987500706029*std::sin(0.380479842424393*x_36 + 8.37952041625977) - 268629.28417966*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.0304130219242339*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 6.17736093620698*std::sin(0.451039850711823*x_45 - 7.353759765625) + 1396.98894567355*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 9.47335242103314*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 3.90911105525914*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 2.81063400517745*std::sin(0.41839987039566*x_46 - 4.18064022064209) - 0.249927951442106*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 2.14554224186588*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 9.43199024932803*std::sin(0.405279844999313*x_49 + 5.19935989379883) + 2470.33389314329*std::sin(0.23047998547554*x_53 - 4.36679983139038) - 205.235324537243*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 5.43491387187858*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.132990300913595*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 3.70168423822052*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 4.32570273166272*std::sin(0.485599845647812*x_55 + 2.05031991004944) - 1.35015566392665*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.131449616152022*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.020803738402149*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.017711598039804*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.0316907030089411*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 4.87533621924383*std::sin(0.379999846220016*x_73 + 1.97735977172852) + 0.29881910143711*std::sin(0.480799853801727*x_73 + 8.47792053222656) + 514.798134253665*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.311482348427614*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 16.1527007078298*std::sin(0.204880014061928*x_75 + 1.81199991703033) + 1707.95143170842*std::sin(0.301919937133789*x_75 - 7.48392009735107) - 0.0239953362671999*std::sin(0.393039852380753*x_75 + 8.3851203918457) + 0.0257036031906062*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 26.822965372541*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 20.0945601828686*std::sin(0.214559987187386*x_80 + 1.82359993457794) + 0.136926811935213*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 8.98774331719535*std::sin(0.257039994001389*x_80 + 5.08447980880737) + 500172.382339885*std::sin(0.32015985250473*x_80 - 1.26199984550476) + 7123.79209754138*std::sin(0.164080023765564*x_85 + 1.76831984519958) - 0.342151732367797*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 12.8690978469668*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 11.4727076565458*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.127529683116714*std::sin(0.353119850158691*x_92 - 7.41048002243042) - 1440.26898891623*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 2.73849579813979*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 10.9337345766843*std::sin(0.3781598508358*x_95 + 1.99335980415344) + 3.96952292107307*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 8.688073705604*std::sin(0.476799845695496*x_96 + 5.22983980178833) + 0.410855277403485*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.0185853130166051*std::sin(0.513919830322266*x_98 + 5.16983985900879) + 9722729.50747805 + 0.0535018855359277*std::exp(-2.36207985877991*x_86) + 0.0151994496417009*std::exp(-2.35904002189636*x_86) - 2.76722756640789e-5*std::exp(-2.29543995857239*x_86) + 0.0094460639960006*std::exp(-2.10855984687805*x_23) - 6.57956832350098*std::exp(-2.10799980163574*x_23) + 0.0348137424642895*std::exp(-2.07343983650208*x_23) + 0.193416301888988*std::exp(-1.99351978302002*x_23));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.952507588926369*x_1 + 89267.3199307678*x_10 + 41133.4163859338*x_100 + 2459716.89888661*x_101 - 26255.7226381684*x_102 + 15586.9728598671*x_103 + 65763.4687895028*x_104 + 46782.7151917881*x_105 + 30477.4062132803*x_106 + 316470.64299766*x_107 - 13888.6580752265*x_108 + 60795.1937538714*x_109 - 83885.8733532777*x_11 + 54306.083405568*x_110 - 92136.441098139*x_111 + 30260.6023907378*x_112 - 207354.096113509*x_113 - 2804.70339072749*x_114 + 59.7426579252442*x_115 + 31378.0238079628*x_116 + 46978.774098725*x_117 + 21882.9340297678*x_118 - 49771.9177727406*x_119 - 124157.224817033*x_12 + 107031.901178883*x_120 - 17071.6701391309*x_13 + 92786.6699300272*x_14 + 29125.6052276857*x_15 - 61572.0791033993*x_16 + 83.4383221690903*x_17 + 78403.0566989206*x_18 + 8248.9815716145*x_19 - 87407.7915006992*x_2 - 35597.8916127725*x_20 - 40414.65532254*x_21 + 8875.52397011944*x_22 - 46529.0955692502*x_23 + 21189.1923893546*x_24 - 46728.1123234009*x_25 - 12646.8555270516*x_26 + 35006.1475879667*x_27 + 5.40486150455331*x_28 - 48237.1488579606*x_29 + 58670.9096171003*x_3 - 93712.3083368155*x_30 + 1011735.26515317*x_31 - 32066.6957364018*x_32 + 90963.5943359844*x_33 - 65935.4759228188*x_34 + 21819.8929498372*x_35 - 12.2468173015296*x_36 + 116812.550199968*x_37 + 48748.9712299712*x_38 - 57828.5603013815*x_39 + 178672.351635622*x_4 - 75791.9243402839*x_40 + 16390.5471631876*x_41 - 45122.9201397055*x_42 + 67101.0424527164*x_43 + 22001.9825805688*x_44 + 83470.5220544259*x_45 - 46556.1501742712*x_46 + 83184.0792101262*x_47 - 74047.175116748*x_48 - 21300.722746667*x_49 - 11860.6393040678*x_5 - 4.39454508925064*x_50 - 90253.8530495449*x_51 - 53390.3142400108*x_52 - 60049.3287044321*x_53 + 156953.239777188*x_54 - 53799.094782862*x_55 + 68197.5926138947*x_56 - 48883.9508093912*x_57 + 31026.0427205582*x_58 - 53113.6851105285*x_59 + 33686.924848996*x_6 + 86007.3494282264*x_60 - 95352.9621526609*x_61 + 36323.8426267416*x_62 + 57358.2729192413*x_63 + 120610.139665911*x_64 + 83689.9610223144*x_65 + 129459.355730967*x_66 + 69045.0109281365*x_67 + 44676.0173119905*x_68 + 74771.6243703322*x_69 + 40525.6458324779*x_7 - 110345.572178619*x_70 - 15864.9591990265*x_71 + 170585.863992793*x_72 - 5.91127999781893*x_73 - 20344.4519001741*x_74 - 6438.44908059154*x_75 - 57109.201875471*x_76 - 110196.549225772*x_77 - 111452.666015605*x_78 - 58168.416890343*x_79 + 819380.308154499*x_8 + 58.335477434859*x_80 - 54759.4544054513*x_81 - 120486.583613133*x_82 - 9093.07688909286*x_83 + 108431.903193661*x_84 + 76618.4363318696*x_85 + 115701.984400136*x_86 + 19563.8689823231*x_87 + 75676.3298035556*x_88 + 142558.019634954*x_89 - 478230.789822043*x_9 + 274102.313694386*x_90 - 173724.595762232*x_91 - 56999.8911191402*x_92 + 2623111.01669217*x_93 + 65240.1053969646*x_94 + 134854.239071257*x_95 - 96668.303015531*x_96 - 107914.896151065*x_97 + 40280.1158683322*x_98 + 99077.7557801034*x_99 + 0.0045179567624414*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) - 5.24462716359843e-5*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.0949701621845028*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 1.24919533605105e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) + 0.00896754340118703*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) - 0.396885166396556*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) - 0.000785997236872222*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 0.000159432167867832*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) + 0.000811908230260621*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) + 0.00236690870940515*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) + 0.0499451558779329*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.115444407395772*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 0.000278876326271375*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) - 0.0215828386905608*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.0463112689244355*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) + 0.0649923053991571*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) + 0.000193410495575926*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.0472246305087016*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) - 0.00183075623320977*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) - 4.56649529692305*std::exp(0.675439834594727*x_1) + 9.25720708549218*std::exp(0.805679857730865*x_1) - 7276.428243447*std::exp(0.820959866046906*x_1) + 0.0685966032563891*std::exp(0.863999843597412*x_1) + 0.000259584990198909*std::exp(0.999759793281555*x_1) - 0.00016121934573102*std::exp(1.01575982570648*x_1) - 0.0566611081839768*std::exp(1.04399979114532*x_1) + 0.0025827581754351*std::exp(1.06791973114014*x_1) + 2.04740084124955*std::exp(1.0971999168396*x_1) - 1.39835904106218e-5*std::exp(1.11495983600616*x_1) + 0.0415028272454678*std::exp(1.13255989551544*x_1) + 0.00143519957100825*std::exp(1.20439982414246*x_1) + 0.00847373419203254*std::exp(0.975199818611145*x_108) + 5.42191287388878*std::exp(1.29199981689453*x_108) + 0.0324571856368704*std::exp(1.58871984481812*x_108) + 0.0441182260190636*std::exp(1.60567986965179*x_108) - 974.212468000217*std::exp(2.76399993896484*x_17) - 0.00053464596824799*std::exp(2.89416003227234*x_17) - 0.0106306656022334*std::exp(2.91807985305786*x_17) + 0.00403015619104077*std::exp(3.5239999294281*x_17) - 0.0053001852273135*std::exp(3.58959984779358*x_17) - 0.000263174829104807*std::exp(3.60615992546082*x_17) + 2.77278388505763e-6*std::exp(3.7247200012207*x_17) - 0.453865871779242*std::exp(0.934719800949097*x_29) - 0.102436234618676*std::exp(1.11599981784821*x_29) + 3.49675484901598*std::exp(1.20207989215851*x_29) - 0.349208418736809*std::exp(1.28559982776642*x_29) - 0.00268447713928336*std::exp(1.62799978256226*x_29) - 0.00214657132701885*std::exp(1.69127988815308*x_29) + 0.000690867865927262*std::exp(2.63527989387512*x_29) - 0.00434275115550875*std::exp(1.38783979415894*x_38) - 0.117218984093492*std::exp(1.42807984352112*x_38) - 0.152493897538786*std::exp(2.43751978874207*x_38) + 0.000906836013372332*std::exp(2.55167984962463*x_38) - 0.000194947248128157*std::exp(1.51279985904694*x_50) + 0.0864059452278161*std::exp(1.64831984043121*x_50) - 0.060309712908954*std::exp(1.6839998960495*x_50) + 7.66382323957902*std::exp(1.73599982261658*x_50) + 65008.9780564514*std::exp(1.89111995697021*x_50) - 0.697094623696641*std::exp(1.92567980289459*x_50) + 0.0428147721295006*std::exp(1.93199980258942*x_50) + 0.0158655152462693*std::exp(1.93495976924896*x_50) - 42.7088358504014*std::exp(1.95423984527588*x_50) + 0.0407484811155522*std::exp(2.00951981544495*x_50) + 0.215791690783422*std::exp(0.747759819030762*x_66) - 0.204894179396214*std::exp(0.704879820346832*x_71) - 8.37910533373605*std::exp(0.727519869804382*x_71) - 0.00946757333743233*std::exp(1.12319993972778*x_71) - 13.8670494744774*std::exp(1.13343989849091*x_71) + 0.00467630193450961*std::exp(1.17391979694366*x_71) - 0.288812339567865*std::exp(1.27175986766815*x_71) + 0.0149302184974659*std::exp(1.67999982833862*x_71) + 11.7714274012806*std::exp(1.69519984722137*x_71) - 0.0724771631094228*std::exp(1.85879993438721*x_71) - 0.000287863601775038*std::exp(1.86255991458893*x_71) + 0.12975838873245*std::exp(1.9048798084259*x_71) - 0.772623896142059*std::exp(1.04767978191376*x_72) - 132678.571731583*std::exp(0.721359848976135*x_73) - 0.881032319807427*std::exp(0.838959872722626*x_73) + 0.00126573485750884*std::exp(0.977439820766449*x_76) + 0.0862061674415854*std::exp(1.22399985790253*x_76) - 0.000376418074901445*std::exp(2.10399985313416*x_76) - 0.00972819194011998*std::exp(2.24863982200623*x_76) + 0.100765242258935*std::exp(1.07551980018616*x_77) + 0.11300928394247*std::exp(1.43767976760864*x_77) - 0.0718394386106213*std::exp(1.19447994232178*x_78) + 0.00791615467827806*std::exp(1.61599981784821*x_78) - 0.0810870994914599*std::exp(1.83559989929199*x_78) + 0.780210694928895*std::exp(1.90311992168427*x_78) - 1.63992962127899*std::exp(1.36295986175537*x_81) + 0.0162920153451705*std::exp(1.0487197637558*x_87) - 3.44322050906699*std::exp(0.894479870796204*x_88) - 172.103039835421*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 0.710930214831921*std::sin(0.232239991426468*x_104 - 7.55864000320435) + 5.35129759522996*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 45.1744644532841*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.00433908705685863*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 52.4104838225269*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 10.6724037429138*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 3.00670141831027*std::sin(0.471119850873947*x_105 - 7.36047983169556) - 0.0388703293380228*std::sin(0.499759823083878*x_105 + 2.03655982017517) - 9.43269288212229*std::sin(0.517119884490967*x_105 + 8.36359977722168) - 4.00491241178996*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 4.29963580668892*std::sin(0.401439845561981*x_111 - 7.40527963638306) + 129.946426682825*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 0.882953857932533*std::sin(0.260399967432022*x_112 + 5.04791975021362) - 365559.460311528*std::sin(0.51503986120224*x_115 + 2.13183975219727) - 23.1602832203985*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 38.2253499532992*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 13.0522134883714*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 2.59411199866999*std::sin(0.476879835128784*x_14 + 8.24479961395264) + 0.12141595175894*std::sin(0.429919868707657*x_15 + 5.22760009765625) + 3.54528511290168*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 5.53682401559179*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 11.6496350749012*std::sin(0.436239868402481*x_19 - 1.1658399105072) - 41.8731403642242*std::sin(0.31743985414505*x_21 + 8.31935977935791) + 1.19714191537808*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 364.106048336526*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 6.09756881548683*std::sin(0.263119965791702*x_26 + 5.06063985824585) + 1.31516567685302*std::sin(0.314319849014282*x_28 - 4.30048036575317) + 23.7448360931384*std::sin(0.319439828395844*x_28 - 4.27544021606445) + 219.162337686986*std::sin(0.325839847326279*x_28 - 4.26304006576538) + 5.07849703142259*std::sin(0.341279834508896*x_28 + 5.1275200843811) + 761783.617126597*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 326.568338692509*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 2.72498857230793*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 3.97233485096309*std::sin(0.368799835443497*x_3 + 5.17008018493652) - 1.16979901974699*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 497.835254246477*std::sin(0.323519825935364*x_36 - 1.24327993392944) - 173.515528968208*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 0.620919304089451*std::sin(0.343119859695435*x_36 - 1.22071981430054) - 1.65608459453003*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.00810557921653026*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 4.22227714632324*std::sin(0.361759841442108*x_36 + 1.95119988918304) + 6.56916810696868*std::sin(0.380479842424393*x_36 + 8.37952041625977) - 317991.228245448*std::sin(0.424479871988297*x_36 - 4.18911981582642) - 0.112053529034892*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 8.58776246933943*std::sin(0.451039850711823*x_45 - 7.353759765625) - 500.012256314548*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 13.1698473215858*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 5.89630019753475*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 1.6464464340442*std::sin(0.41839987039566*x_46 - 4.18064022064209) - 0.0834260434369472*std::sin(0.237599983811378*x_47 - 7.55951976776123) + 19.6122013191913*std::sin(0.65831983089447*x_47 - 4.15960025787354) - 26.9896117668654*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 884.18539573005*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 104.912416577086*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 7.55561312589737*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.0186773509356441*std::sin(0.175520017743111*x_55 - 7.62400007247925) - 3.77600279712374*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 2.5339613141241*std::sin(0.485599845647812*x_55 + 2.05031991004944) - 0.450682464348037*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.0184609749309624*std::sin(0.297439932823181*x_68 + 5.14079999923706) - 0.0766491508435728*std::sin(0.406319856643677*x_69 + 8.40272045135498) + 0.0652564901360915*std::sin(0.511679828166962*x_70 - 1.10791981220245) - 0.116761008445495*std::sin(0.288719952106476*x_72 - 7.48760032653809) - 13.9507599469479*std::sin(0.379999846220016*x_73 + 1.97735977172852) + 0.0997459275460692*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 184.257275228894*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.469823805617254*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 9.46212008806552*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 611.312388468787*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.13519868508268*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.144823698845478*std::sin(0.49687984585762*x_78 - 7.29647970199585) + 27.3614889212045*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 27.9354422638418*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 0.771496790878875*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 5.26494659476897*std::sin(0.257039994001389*x_80 + 5.08447980880737) + 592081.502507889*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 2549.75772803271*std::sin(0.164080023765564*x_85 + 1.76831984519958) - 0.114210375917696*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 17.8906100267953*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 15.9493494474492*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.0179104538445244*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 515.503110513633*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 4.13060490921492*std::sin(0.366079837083817*x_92 + 1.98439979553223) - 31.2868486486916*std::sin(0.3781598508358*x_95 + 1.99335980415344) + 9.00026179863132*std::sin(0.134640038013458*x_96 - 7.67208003997803) - 24.8608968115578*std::sin(0.476799845695496*x_96 + 5.22983980178833) + 0.137143644883201*std::sin(0.393919825553894*x_97 - 7.38903999328613) - 0.0684755995940437*std::sin(0.513919830322266*x_98 + 5.16983985900879) + 11578132.3713996 - 0.48905574060123*std::exp(-2.36207985877991*x_86) + 0.015504608353465*std::exp(-2.35904002189636*x_86) + 0.000101955542343381*std::exp(-2.29543995857239*x_86) + 0.0214174475424489*std::exp(-2.10855984687805*x_23) + 2.35496838625538*std::exp(-2.10799980163574*x_23) + 0.020393605866319*std::exp(-2.07343983650208*x_23) - 1.76800035769113*std::exp(-1.99351978302002*x_23));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.572954741853628*x_1 + 59028.011587797*x_10 + 27389.6267405412*x_100 + 1620880.52114155*x_101 - 17652.888783286*x_102 + 10595.0085068915*x_103 + 43997.7932227564*x_104 + 30487.215428011*x_105 + 19934.400082159*x_106 + 210048.198262377*x_107 - 9038.12605369782*x_108 + 39997.371850029*x_109 - 55695.0451021064*x_11 + 35784.6178359736*x_110 - 60558.8029894017*x_111 + 19759.5449875172*x_112 - 137147.284890754*x_113 - 1753.29879267916*x_114 - 108.530047883951*x_115 + 20322.066766836*x_116 + 30851.2500895236*x_117 + 13865.1836459265*x_118 - 32661.8783897984*x_119 - 81721.5861007822*x_12 + 70570.4681184215*x_120 - 11276.4997504948*x_13 + 61136.8196772477*x_14 + 19069.8637322831*x_15 - 40279.3598044288*x_16 - 227.978344964478*x_17 + 51950.5700791684*x_18 + 5264.28906461246*x_19 - 57762.9865980709*x_2 - 23112.9962061303*x_20 - 26462.4461700367*x_21 + 5916.71932583325*x_22 - 30751.9688640107*x_23 + 14067.9396778045*x_24 - 30766.0080767913*x_25 - 8441.91679492783*x_26 + 23189.451036387*x_27 + 3.53341919928478*x_28 - 31879.8968597431*x_29 + 38675.5133139041*x_3 - 62649.0384661932*x_30 + 673869.022651819*x_31 - 21332.5114839353*x_32 + 60022.9890040062*x_33 - 43256.654483352*x_34 + 14542.303172733*x_35 - 12.3013196251217*x_36 + 77105.4908351851*x_37 + 32351.4256089413*x_38 - 38110.6896457108*x_39 + 118343.488720319*x_4 - 50654.3806718888*x_40 + 10651.7294283433*x_41 - 30001.0342172318*x_42 + 44642.5981931117*x_43 + 14503.0916765695*x_44 + 55354.6173766034*x_45 - 30784.7121245286*x_46 + 54855.2754944624*x_47 - 47562.2269864749*x_48 - 14589.8585682201*x_49 - 7820.79377490161*x_5 + 19.016637719666*x_50 - 59655.4340187982*x_51 - 35281.7236146406*x_52 - 39690.722133876*x_53 + 103571.332861053*x_54 - 35669.7461170805*x_55 + 45284.3059739677*x_56 - 32541.8515369322*x_57 + 20393.9527495608*x_58 - 34749.1906206325*x_59 + 22126.9635526071*x_6 + 57192.236035094*x_60 - 62983.6117367374*x_61 + 24832.4174943435*x_62 + 37558.3336005554*x_63 + 80154.8947849905*x_64 + 55520.9149801998*x_65 + 85965.6235324735*x_66 + 45961.9871331999*x_67 + 29480.5885435803*x_68 + 49468.6748737272*x_69 + 26425.6693911238*x_7 - 72550.7365486104*x_70 - 10486.8626221882*x_71 + 112617.759560839*x_72 + 0.210388349038736*x_73 - 13254.6589250247*x_74 - 4246.99421635964*x_75 - 37777.0186141002*x_76 - 72791.4222467802*x_77 - 73529.9441147476*x_78 - 38427.5411287634*x_79 + 543852.178784501*x_8 - 183.318903551067*x_80 - 36133.8246707089*x_81 - 79462.5272140751*x_82 - 6503.78273859801*x_83 + 72319.4618193809*x_84 + 50650.3479528759*x_85 + 76329.5406972189*x_86 + 13199.900607049*x_87 + 49897.7103582101*x_88 + 94045.8189680562*x_89 - 316748.098411174*x_9 + 181478.146859568*x_90 - 115068.733204508*x_91 - 37684.671905128*x_92 + 1740022.39316915*x_93 + 43345.2089135413*x_94 + 88807.0950256663*x_95 - 63886.3187092425*x_96 - 71440.7991477155*x_97 + 26412.2535125527*x_98 + 65645.5267261581*x_99 - 0.00786358622833469*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 2.03487393693544e-6*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.0774225123123634*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 0.000145936855686833*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) - 0.00505978221991194*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.0237903080742355*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 3.04960723026339e-5*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) - 6.44798502371126e-5*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.000293594178001349*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.000855897983345942*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.00299383989565515*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) - 0.0758700057223624*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) - 0.000112787174590521*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) + 0.0121777457410769*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) - 0.0304357423418632*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.00389580437570661*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 7.50417454473895e-6*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.0384989290626208*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00066201985812797*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 0.504203751034268*std::exp(0.675439834594727*x_1) - 35.7858495200798*std::exp(0.805679857730865*x_1) - 4809.46029119198*std::exp(0.820959866046906*x_1) - 0.119393640320275*std::exp(0.863999843597412*x_1) - 1.00716926961301e-5*std::exp(0.999759793281555*x_1) + 0.00108858047197909*std::exp(1.01575982570648*x_1) + 0.0033964111880602*std::exp(1.04399979114532*x_1) + 0.00104455620580152*std::exp(1.06791973114014*x_1) + 1.66910230743876*std::exp(1.0971999168396*x_1) - 0.000163362859021697*std::exp(1.11495983600616*x_1) - 0.0234172568760468*std::exp(1.13255989551544*x_1) + 0.00134497846699834*std::exp(1.20439982414246*x_1) - 0.057216096023477*std::exp(0.975199818611145*x_108) - 0.598653591220764*std::exp(1.29199981689453*x_108) + 0.0304168261075292*std::exp(1.58871984481812*x_108) - 0.0289944756617932*std::exp(1.60567986965179*x_108) - 643.919794612252*std::exp(2.76399993896484*x_17) + 0.00361002060775101*std::exp(2.89416003227234*x_17) - 0.00996238893439699*std::exp(2.91807985305786*x_17) - 0.00701456042814821*std::exp(3.5239999294281*x_17) + 0.00299053840897507*std::exp(3.58959984779358*x_17) - 0.00010643694929196*std::exp(3.60615992546082*x_17) + 3.23929612932765e-5*std::exp(3.7247200012207*x_17) - 5.50303640238114*std::exp(0.934719800949097*x_29) + 0.0370419722075852*std::exp(1.11599981784821*x_29) + 2.8506589767142*std::exp(1.20207989215851*x_29) + 0.607803628229814*std::exp(1.28559982776642*x_29) + 0.0181260467101368*std::exp(1.62799978256226*x_29) + 8.32852729254184e-5*std::exp(1.69127988815308*x_29) + 0.00027941071820307*std::exp(2.63527989387512*x_29) + 0.000168495316545587*std::exp(1.38783979415894*x_38) - 1.42125763716902*std::exp(1.42807984352112*x_38) + 0.0168374191035956*std::exp(2.43751978874207*x_38) - 0.00157836463717266*std::exp(2.55167984962463*x_38) - 0.00227746514860999*std::exp(1.51279985904694*x_50) - 0.0487530693523622*std::exp(1.64831984043121*x_50) + 0.0218085984684721*std::exp(1.6839998960495*x_50) - 0.846191263410044*std::exp(1.73599982261658*x_50) + 42968.6225264501*std::exp(1.89111995697021*x_50) + 0.0417856278308624*std::exp(1.92567980289459*x_50) + 0.0173157658944642*std::exp(1.93199980258942*x_50) - 0.107126660244548*std::exp(1.93495976924896*x_50) + 165.100765144977*std::exp(1.95423984527588*x_50) - 0.070923475317338*std::exp(2.00951981544495*x_50) - 0.0780324446948188*std::exp(0.747759819030762*x_66) + 0.074091795026862*std::exp(0.704879820346832*x_71) + 0.502264922334928*std::exp(0.727519869804382*x_71) + 0.0639266671467193*std::exp(1.12319993972778*x_71) + 1.5311125723748*std::exp(1.13343989849091*x_71) - 0.000181436823456589*std::exp(1.17391979694366*x_71) + 0.162957398170297*std::exp(1.27175986766815*x_71) + 0.0139916585764897*std::exp(1.67999982833862*x_71) - 45.5051427205243*std::exp(1.69519984722137*x_71) - 0.87877166302221*std::exp(1.85879993438721*x_71) - 0.00336295755334287*std::exp(1.86255991458893*x_71) - 0.0852771469639515*std::exp(1.9048798084259*x_71) + 0.507768030897952*std::exp(1.04767978191376*x_72) - 87695.8173551405*std::exp(0.721359848976135*x_73) + 0.4971073422783*std::exp(0.838959872722626*x_73) + 0.0147869080124802*std::exp(0.977439820766449*x_76) + 1.04523320002248*std::exp(1.22399985790253*x_76) + 1.46047241513126e-5*std::exp(2.10399985313416*x_76) + 0.0169320956771587*std::exp(2.24863982200623*x_76) + 0.0944308260661815*std::exp(1.07551980018616*x_77) + 1.37021583249803*std::exp(1.43767976760864*x_77) + 0.0259778631880518*std::exp(1.19447994232178*x_78) - 0.0534512242117441*std::exp(1.61599981784821*x_78) + 0.141133577053554*std::exp(1.83559989929199*x_78) + 0.636051057984052*std::exp(1.90311992168427*x_78) + 0.0983015597799128*std::exp(1.36295986175537*x_81) - 0.110006461529287*std::exp(1.0487197637558*x_87) + 0.20639541009296*std::exp(0.894479870796204*x_88) + 19.0025375276067*std::sin(0.370079845190048*x_102 + 8.18015956878662) + 0.287524621878077*std::sin(0.232239991426468*x_104 - 7.55864000320435) - 3.01937768399515*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 36.8275724700145*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.0506912492670006*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 42.7265915494947*std::sin(0.426319867372513*x_105 + 2.02519989013672) + 7.01389830232599*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 36.4556764120399*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.00150813809299974*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 0.565419644359088*std::sin(0.517119884490967*x_105 + 8.36359977722168) + 2.25970298741985*std::sin(0.512159824371338*x_109 + 2.15727996826172) + 7.48359461901164*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 7.78931989824375*std::sin(0.180640012025833*x_112 - 7.61432027816772) + 0.357096897615839*std::sin(0.260399967432022*x_112 + 5.04791975021362) - 241621.802567931*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 1.38828638495724*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 31.1624468078105*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 10.6405542147419*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 31.45310905306*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.81982117885563*std::sin(0.429919868707657*x_15 + 5.22760009765625) - 2.00036618461238*std::sin(0.551439881324768*x_15 + 2.14655995368958) - 3.63879792207283*std::sin(0.504719853401184*x_17 - 4.07760000228882) - 7.65613423581539*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 2.50998271954879*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 0.43289855121134*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 296.830123924341*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 73.9318491300204*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 0.475577129828214*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 1.42332597349724*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 24.1985298488482*std::sin(0.325839847326279*x_28 - 4.26304006576538) - 2.86545465506933*std::sin(0.341279834508896*x_28 + 5.1275200843811) + 503511.878970356*std::sin(0.343919843435287*x_28 - 4.24584007263184) - 1262.42454322834*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 33.0399623366637*std::sin(0.364799857139587*x_28 - 4.23216009140015) - 6.91392133011199*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 0.42301108527888*std::sin(0.385039836168289*x_34 + 1.98855984210968) + 1924.49594458952*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 19.1584957127659*std::sin(0.332959830760956*x_36 - 7.4410400390625) - 0.25112111484434*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 0.598856837644896*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.0946931764987496*std::sin(0.354799836874008*x_36 - 7.42647981643677) + 7.34895045832578*std::sin(0.361759841442108*x_36 + 1.95119988918304) - 3.70654018611752*std::sin(0.380479842424393*x_36 + 8.37952041625977) - 210180.892881224*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.00434758846839162*std::sin(0.343599855899811*x_43 - 7.45887994766235) - 5.64387311944343*std::sin(0.451039850711823*x_45 - 7.353759765625) + 1932.9116435896*std::sin(0.3294398188591*x_46 + 8.31216049194336) - 8.65521694979874*std::sin(0.357999831438065*x_46 - 4.24848031997681) + 10.2626181412162*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 19.9628463484093*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.563306849610088*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 2.16545618208311*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 1.61782609455397*std::sin(0.405279844999313*x_49 + 5.19935989379883) + 3418.02070832312*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 85.5277349993265*std::sin(0.25383996963501*x_53 + 5.06503963470459) - 4.96554509680636*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.218197570023271*std::sin(0.175520017743111*x_55 - 7.62400007247925) + 2.13054467209999*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 30.7237935718441*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 3.04308473358537*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.215669764094284*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.00297392654376607*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.00253190030199799*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.00453023495330829*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 0.836244095542686*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.67350148577858*std::sin(0.480799853801727*x_73 + 8.47792053222656) + 712.288605345656*std::sin(0.612159848213196*x_73 - 3.98176002502441) - 0.817736911142818*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 114.726386199078*std::sin(0.204880014061928*x_75 + 1.81199991703033) + 2363.16773962948*std::sin(0.301919937133789*x_75 - 7.48392009735107) + 0.0546789966100981*std::sin(0.393039852380753*x_75 + 8.3851203918457) - 0.0585716831002538*std::sin(0.49687984585762*x_78 - 7.29647970199585) - 15.4382498037871*std::sin(0.173680007457733*x_80 - 4.44935989379883) - 18.3591584228794*std::sin(0.214559987187386*x_80 + 1.82359993457794) - 0.312019827614223*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 63.836464843734*std::sin(0.257039994001389*x_80 + 5.08447980880737) + 391344.816466164*std::sin(0.32015985250473*x_80 - 1.26199984550476) + 9856.67118876903*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.77116790393644*std::sin(0.376319825649261*x_85 - 4.42600011825562) - 11.757699794466*std::sin(0.333999842405319*x_86 + 5.13912010192871) - 10.4819043307788*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.209238318664938*std::sin(0.353119850158691*x_92 - 7.41048002243042) - 1992.79508059025*std::sin(0.364559859037399*x_92 + 1.98087978363037) + 7.18939325599963*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 1.87541342192831*std::sin(0.3781598508358*x_95 + 1.99335980415344) + 8.43447737933952*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 1.49022549650491*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.926017240666441*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.00265679920771229*std::sin(0.513919830322266*x_98 + 5.16983985900879) + 7588751.99011511 + 0.0539984655282866*std::exp(-2.36207985877991*x_86) - 0.00874820875282033*std::exp(-2.35904002189636*x_86) - 3.95579455639161e-6*std::exp(-2.29543995857239*x_86) + 0.0200710802487375*std::exp(-2.10855984687805*x_23) - 9.10366847330819*std::exp(-2.10799980163574*x_23) + 0.247268548785607*std::exp(-2.07343983650208*x_23) + 0.195211503399216*std::exp(-1.99351978302002*x_23));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.413839384599009*x_1 + 32510.4823174691*x_10 + 14961.9472235599*x_100 + 898515.322620628*x_101 - 9508.41682326153*x_102 + 5632.21827785533*x_103 + 23898.4410156749*x_104 + 17112.9561362549*x_105 + 11133.0621056078*x_106 + 115239.550389835*x_107 - 5071.51090444115*x_108 + 22161.5273110966*x_109 - 30540.1949394811*x_11 + 19862.5780938258*x_110 - 33593.5087322502*x_111 + 11075.3360093206*x_112 - 75597.5119867118*x_113 - 1055.32259326104*x_114 + 20.4744127226854*x_115 + 11474.5829478112*x_116 + 17201.2150248069*x_117 + 7974.10027081251*x_118 - 18147.9990043724*x_119 - 45301.929020691*x_12 + 39046.0154635393*x_120 - 6209.23593369424*x_13 + 33885.0909490487*x_14 + 10666.02333901*x_15 - 22516.4546590458*x_16 + 36.112326550135*x_17 + 28552.3262371254*x_18 + 3072.34243124614*x_19 - 31925.1535821491*x_2 - 13046.7000366361*x_20 - 14804.6689645031*x_21 + 3258.4840394334*x_22 - 16966.8000665591*x_23 + 7691.32481137052*x_24 - 17039.5198771849*x_25 - 4607.21081319953*x_26 + 12735.1767892026*x_27 + 10.1556298649075*x_28 - 17618.1993901709*x_29 + 21456.7051834675*x_3 - 34034.8390533987*x_30 + 368508.508914057*x_31 - 11838.246988187*x_32 + 33364.6409408825*x_33 - 24092.3279793506*x_34 + 7964.8410660591*x_35 - 16.7896431182349*x_36 + 42642.5810126788*x_37 + 17781.5958269267*x_38 - 21243.7426552683*x_39 + 65150.2961951814*x_4 - 27471.3894149091*x_40 + 6078.96878331065*x_41 - 16314.7023229571*x_42 + 24397.8601575874*x_43 + 8018.38716746485*x_44 + 30377.3513583031*x_45 - 17000.9706426717*x_46 + 30335.0664102343*x_47 - 27088.963877255*x_48 - 7772.27647313152*x_49 - 4309.17365586083*x_5 + 3.98436009125675*x_50 - 32945.6353840102*x_51 - 19487.9179189083*x_52 - 21891.2448232088*x_53 + 57300.2017022116*x_54 - 19587.5453631806*x_55 + 24834.8775585376*x_56 - 17756.1935756859*x_57 + 11293.001340154*x_58 - 19415.2574601529*x_59 + 12335.0080150316*x_6 + 31338.9386488966*x_60 - 34753.9603805106*x_61 + 13139.9992240494*x_62 + 20914.6740472846*x_63 + 43930.1696177463*x_64 + 30474.6610799433*x_65 + 47204.9372674779*x_66 + 25138.7758027772*x_67 + 16332.2296226066*x_68 + 27229.8548553876*x_69 + 14829.3140798547*x_7 - 40267.477525091*x_70 - 5791.17802393727*x_71 + 62158.7871051476*x_72 - 0.875194753690754*x_73 - 7477.48987927216*x_74 - 2337.09471246582*x_75 - 20810.4429863511*x_76 - 40192.0875202634*x_77 - 40622.6722181246*x_78 - 21180.1414039743*x_79 + 298507.260709035*x_8 + 46.3221319118068*x_80 - 19909.7638470997*x_81 - 43955.3378429541*x_82 - 3259.03015750715*x_83 + 39476.6051740388*x_84 + 27937.3250440971*x_85 + 42209.8338954801*x_86 + 7076.44705137306*x_87 + 27589.7680243921*x_88 + 52020.4941017234*x_89 - 174576.565620406*x_9 + 99824.37767254*x_90 - 63328.5309221027*x_91 - 20810.8194227342*x_92 + 955001.670097449*x_93 + 23812.3906165098*x_94 + 49187.1698046835*x_95 - 35248.4920509609*x_96 - 39328.6533092896*x_97 + 14677.0315416907*x_98 + 36103.1534280466*x_99 + 0.00444933663784365*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) - 6.96407790551893e-5*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.17830769802206*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) + 0.000108398047057218*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) - 0.00772344008304545*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.335491865788363*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) - 0.00104368638996735*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) + 0.000367544283768533*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) - 0.000776507853910446*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) - 0.00226370805694649*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.0422192486676008*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.019744399721428*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) + 0.000642902878196974*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) + 0.0185885647820245*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.00792059334772152*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.0549387874538602*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) + 0.000256820116458311*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.0886648496986877*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) + 0.00175093260629537*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 4.84322709064445*std::exp(0.675439834594727*x_1) + 9.53023332067614*std::exp(0.805679857730865*x_1) - 2653.02992931662*std::exp(0.820959866046906*x_1) + 0.0675547368309361*std::exp(0.863999843597412*x_1) + 0.000344689915690447*std::exp(0.999759793281555*x_1) + 0.000407722462954785*std::exp(1.01575982570648*x_1) + 0.0478963249618785*std::exp(1.04399979114532*x_1) - 0.0059541183967627*std::exp(1.06791973114014*x_1) + 3.84402134875167*std::exp(1.0971999168396*x_1) - 0.000121341622692186*std::exp(1.11495983600616*x_1) - 0.0357449733072857*std::exp(1.13255989551544*x_1) - 0.000850996023325081*std::exp(1.20439982414246*x_1) - 0.0214300074196054*std::exp(0.975199818611145*x_108) - 5.75048338090394*std::exp(1.29199981689453*x_108) - 0.0192453624313004*std::exp(1.58871984481812*x_108) + 0.00754551830765084*std::exp(1.60567986965179*x_108) - 355.203782493923*std::exp(2.76399993896484*x_17) + 0.00135211546725049*std::exp(2.89416003227234*x_17) + 0.00630341196830484*std::exp(2.91807985305786*x_17) + 0.00396894493238584*std::exp(3.5239999294281*x_17) + 0.00456486924019568*std::exp(3.58959984779358*x_17) + 0.000606705694106972*std::exp(3.60615992546082*x_17) + 2.40606372260496e-5*std::exp(3.7247200012207*x_17) - 0.985266850000023*std::exp(0.934719800949097*x_29) + 0.0979698662259925*std::exp(1.11599981784821*x_29) + 6.56520209436115*std::exp(1.20207989215851*x_29) - 0.3439045332717*std::exp(1.28559982776642*x_29) + 0.00678902166493429*std::exp(1.62799978256226*x_29) - 0.00285032462457365*std::exp(1.69127988815308*x_29) - 0.00159268068895251*std::exp(2.63527989387512*x_29) - 0.00576652189523703*std::exp(1.38783979415894*x_38) - 0.254462797048931*std::exp(1.42807984352112*x_38) + 0.161735100486244*std::exp(2.43751978874207*x_38) + 0.000893062707539783*std::exp(2.55167984962463*x_38) - 0.00169164104014935*std::exp(1.51279985904694*x_50) - 0.0744185013587564*std::exp(1.64831984043121*x_50) + 0.0576801219589242*std::exp(1.6839998960495*x_50) - 8.12825458439645*std::exp(1.73599982261658*x_50) + 23702.6682168379*std::exp(1.89111995697021*x_50) + 0.589262577028004*std::exp(1.92567980289459*x_50) - 0.0987023194095655*std::exp(1.93199980258942*x_50) - 0.0401237638257638*std::exp(1.93495976924896*x_50) - 43.9684633550728*std::exp(1.95423984527588*x_50) + 0.0401295805818943*std::exp(2.00951981544495*x_50) - 0.206382860102495*std::exp(0.747759819030762*x_66) + 0.195960496016433*std::exp(0.704879820346832*x_71) + 7.08295980818679*std::exp(0.727519869804382*x_71) + 0.0239434188362435*std::exp(1.12319993972778*x_71) + 14.7073992887608*std::exp(1.13343989849091*x_71) + 0.00620942727972862*std::exp(1.17391979694366*x_71) + 0.248744243557417*std::exp(1.27175986766815*x_71) - 0.00885281519405153*std::exp(1.67999982833862*x_71) + 12.118606466892*std::exp(1.69519984722137*x_71) - 0.15733579154965*std::exp(1.85879993438721*x_71) - 0.00249791616657106*std::exp(1.86255991458893*x_71) + 0.0221925128478399*std::exp(1.9048798084259*x_71) - 0.132141481635035*std::exp(1.04767978191376*x_72) - 48375.413046899*std::exp(0.721359848976135*x_73) + 0.758803167025483*std::exp(0.838959872722626*x_73) + 0.0109833252403848*std::exp(0.977439820766449*x_76) + 0.187139162309736*std::exp(1.22399985790253*x_76) - 0.000499826721116346*std::exp(2.10399985313416*x_76) - 0.00958043715224964*std::exp(2.24863982200623*x_76) - 0.0597483598685168*std::exp(1.07551980018616*x_77) + 0.24532424254387*std::exp(1.43767976760864*x_77) + 0.0687071348984333*std::exp(1.19447994232178*x_78) - 0.0200198931953459*std::exp(1.61599981784821*x_78) - 0.079855523546194*std::exp(1.83559989929199*x_78) + 1.46485559027153*std::exp(1.90311992168427*x_78) + 1.38625248557354*std::exp(1.36295986175537*x_81) - 0.0412023792362528*std::exp(1.0487197637558*x_87) + 2.91059623970282*std::exp(0.894479870796204*x_88) + 182.532566161804*std::sin(0.370079845190048*x_102 + 8.18015956878662) - 1.63893108971849*std::sin(0.232239991426468*x_104 - 7.55864000320435) - 4.60889058399571*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 84.8156366248564*std::sin(0.316399931907654*x_104 + 1.89671981334686) - 0.0376521228826864*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 98.4013558328128*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 1.82529591724746*std::sin(0.433839857578278*x_105 + 2.02359986305237) - 6.52704558660904*std::sin(0.471119850873947*x_105 - 7.36047983169556) - 0.0516139647832353*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 7.97357019705254*std::sin(0.517119884490967*x_105 + 8.36359977722168) + 3.44929482540451*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 4.23433160828829*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 109.84529740976*std::sin(0.180640012025833*x_112 - 7.61432027816772) - 2.03550292048656*std::sin(0.260399967432022*x_112 + 5.04791975021362) - 133285.199373021*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 19.5776695318332*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 71.7685849900828*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 24.5056982916657*std::sin(0.38391986489296*x_14 - 1.22143995761871) - 5.63138300629931*std::sin(0.476879835128784*x_14 + 8.24479961395264) - 0.307059991272682*std::sin(0.429919868707657*x_15 + 5.22760009765625) - 3.05343346798685*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 0.946960264400391*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 1.99243130712317*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 35.3958756250798*std::sin(0.31743985414505*x_21 + 8.31935977935791) - 1.14494479165222*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 683.613777437447*std::sin(0.166160017251968*x_26 + 1.75695991516113) + 13.2368014275707*std::sin(0.263119965791702*x_26 + 5.06063985824585) - 1.25782254595695*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 20.0717991958567*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 232.44367991571*std::sin(0.325839847326279*x_28 - 4.26304006576538) - 4.37393673822917*std::sin(0.341279834508896*x_28 + 5.1275200843811) + 277750.933326393*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 336.199939586825*std::sin(0.344959855079651*x_28 + 5.1547999382019) - 5.91549414455597*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 3.91200180070393*std::sin(0.368799835443497*x_3 + 5.17008018493652) + 1.11879408592606*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 512.518093676717*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 184.030652809952*std::sin(0.332959830760956*x_36 - 7.4410400390625) + 1.43142594089796*std::sin(0.343119859695435*x_36 - 1.22071981430054) + 1.58387690438841*std::sin(0.345119833946228*x_36 + 5.14664030075073) + 0.0703355938004839*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 4.15814789518132*std::sin(0.361759841442108*x_36 + 1.95119988918304) - 5.65780102752663*std::sin(0.380479842424393*x_36 + 8.37952041625977) - 115941.533066734*std::sin(0.424479871988297*x_36 - 4.18911981582642) - 0.148790272682015*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 1.46876075448178*std::sin(0.451039850711823*x_45 - 7.353759765625) - 514.759302872613*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 2.25243245345025*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 5.80674536655802*std::sin(0.412479877471924*x_46 - 7.39631986618042) - 3.57415966396681*std::sin(0.41839987039566*x_46 - 4.18064022064209) + 0.210983810599476*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 20.800710076343*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 22.8146475989026*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 910.263002892922*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 196.974408208856*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 1.29223276435347*std::sin(0.444399863481522*x_53 - 7.35679960250854) + 0.16207139966006*std::sin(0.175520017743111*x_55 - 7.62400007247925) + 3.2521427610974*std::sin(0.420479863882065*x_55 + 5.20256042480469) - 5.50080593678856*std::sin(0.485599845647812*x_55 + 2.05031991004944) + 1.13977242334856*std::sin(0.167360007762909*x_67 + 1.76391994953156) + 0.160193812091435*std::sin(0.297439932823181*x_68 + 5.14079999923706) - 0.101778570948077*std::sin(0.406319856643677*x_69 + 8.40272045135498) + 0.086650827022118*std::sin(0.511679828166962*x_70 - 1.10791981220245) - 0.155041098971748*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 11.7927473235183*std::sin(0.379999846220016*x_73 + 1.97735977172852) - 0.252256669721541*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 189.691643251172*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.462687976352915*std::sin(0.806719899177551*x_73 - 0.778159856796265) + 20.5406791591168*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 629.342051022898*std::sin(0.301919937133789*x_75 - 7.48392009735107) - 0.311678029219016*std::sin(0.393039852380753*x_75 + 8.3851203918457) + 0.333866893844143*std::sin(0.49687984585762*x_78 - 7.29647970199585) - 23.5655196536725*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 4.77778483076494*std::sin(0.214559987187386*x_80 + 1.82359993457794) + 1.77855723362155*std::sin(0.249999970197678*x_80 + 1.83071994781494) - 11.4293179315529*std::sin(0.257039994001389*x_80 + 5.08447980880737) + 215876.51168866*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 2624.95867651392*std::sin(0.164080023765564*x_85 + 1.76831984519958) + 0.288837146392134*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 3.05982215680871*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 2.72780932304139*std::sin(0.34759983420372*x_92 + 1.99199986457825) - 0.155416704067453*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 530.707034568626*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 4.06786800436211*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 26.447154281649*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 5.33667035180285*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 21.0152189163648*std::sin(0.476799845695496*x_96 + 5.22983980178833) - 0.346835204031077*std::sin(0.393919825553894*x_97 - 7.38903999328613) - 0.0909253213478863*std::sin(0.513919830322266*x_98 + 5.16983985900879) + 4235654.39681721 + 0.518692751815829*std::exp(-2.36207985877991*x_86) - 0.0133535917554881*std::exp(-2.35904002189636*x_86) + 0.000135381661580606*std::exp(-2.29543995857239*x_86) - 0.0126993925141668*std::exp(-2.10855984687805*x_23) + 2.42442434057709*std::exp(-2.10799980163574*x_23) + 0.0442711053229914*std::exp(-2.07343983650208*x_23) + 1.87514202290069*std::exp(-1.99351978302002*x_23));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.855463907744641*x_1 - 87525.9274629983*x_10 - 40443.5597143024*x_100 - 2405533.90237374*x_101 + 25968.0838931677*x_102 - 15516.2649556956*x_103 - 64819.5083641757*x_104 - 45525.7281973018*x_105 - 29679.1348852996*x_106 - 310657.85712882*x_107 + 13504.0767817126*x_108 - 59463.4492010877*x_109 + 82371.3906919761*x_11 - 53078.0734224082*x_110 + 90072.7348468163*x_111 - 29481.2469485793*x_112 + 203200.532294919*x_113 + 2680.77859877395*x_114 + 66.5334962857418*x_115 - 30519.0823165197*x_116 - 45854.9105807692*x_117 - 21052.4659263264*x_118 + 48587.3290064639*x_119 + 121431.447183779*x_12 - 104744.41709676*x_120 + 16726.8623349799*x_13 - 90757.4104359828*x_14 - 28392.7256609775*x_15 + 60030.690136918*x_16 + 109.281286567269*x_17 - 76896.1922387018*x_18 - 7920.91949187575*x_19 + 85593.0385985698*x_2 + 34534.6528912261*x_20 + 39395.9609034249*x_21 - 8708.83156028327*x_22 + 45578.1565149818*x_23 - 20814.2049651793*x_24 + 45695.5425065165*x_25 + 12444.4764113366*x_26 - 34354.3251612243*x_27 + 12.0581326850442*x_28 + 47247.0516019527*x_29 - 57376.1125631391*x_3 + 92280.7594681169*x_30 - 995211.337984141*x_31 + 31388.8915234118*x_32 - 88885.0401108337*x_33 + 64375.6569678214*x_34 - 21485.8060355369*x_35 - 19.1008603588703*x_36 - 114326.559338672*x_37 - 47823.8459837783*x_38 + 56447.2492815882*x_39 - 175272.030785126*x_4 + 74713.1575746545*x_40 - 15898.6449399158*x_41 + 44373.390327184*x_42 - 65988.2277538842*x_43 - 21545.1850105316*x_44 - 81932.6719398242*x_45 + 45602.0238108484*x_46 - 81443.7669119389*x_47 + 71494.5502597335*x_48 + 21135.7724854076*x_49 + 11615.3335256954*x_5 - 7.33572777633325*x_50 + 88391.3350556918*x_51 + 52296.2285900709*x_52 + 58838.7616728044*x_53 - 153675.981012206*x_54 + 52805.2054663404*x_55 - 66953.6461223019*x_56 + 48084.7053106036*x_57 - 30318.5280752284*x_58 + 51779.3499337088*x_59 - 32878.0606374523*x_6 - 84510.641944038*x_60 + 93376.4311162722*x_61 - 36286.4771653453*x_62 - 55976.1163694198*x_63 - 118462.793351828*x_64 - 82167.0790205806*x_65 - 127124.935160851*x_66 - 67854.9905105264*x_67 - 43728.0994066806*x_68 - 73332.1571532791*x_69 - 39418.9585912386*x_7 + 107872.314333506*x_70 + 15529.4766485464*x_71 - 167154.648092857*x_72 - 2.7080623240688*x_73 + 19776.3837321946*x_74 + 6296.31391702252*x_75 + 55980.9824209902*x_76 + 107940.130327607*x_77 + 109111.682661099*x_78 + 57018.8662518829*x_79 - 803811.684801019*x_8 + 108.225256188062*x_80 + 53673.1794044507*x_81 + 117911.223974995*x_82 + 9262.89223644466*x_83 - 106719.577778975*x_84 - 75080.8494264179*x_85 - 113233.271758903*x_86 - 19370.8291681898*x_87 - 74064.5011759087*x_88 - 139539.547359554*x_89 + 469116.606919152*x_9 - 268847.397118001*x_90 + 170313.93282459*x_91 + 55813.8488353277*x_92 - 2575045.45129523*x_93 - 64060.3314896277*x_94 - 131878.946431837*x_95 + 94733.2980141744*x_96 + 105797.263374074*x_97 - 39325.2193165466*x_98 - 97209.8939166029*x_99 + 0.00255184057501426*std::pow(-8.65608024597168*x_110 - 9.66464042663574, 2) + 6.19488036739271e-6*std::pow(-9.57056045532227*x_117 - 9.53079986572266, 2) - 0.213383556690954*std::pow(-6.13903999328613*x_13 - 8.59496021270752, 2) - 5.06209022644531e-5*std::pow(-5.71239948272705*x_13 - 9.16720008850098, 2) - 0.000858185610581954*std::pow(-5.6515998840332*x_14 - 8.68272018432617, 2) + 0.0627204999552742*std::pow(-2.38479971885681*x_15 - 3.37839984893799, 2) + 9.2840896018695e-5*std::pow(-2.76128005981445*x_18 - 3.39943981170654, 2) + 0.000225572482964676*std::pow(-6.14247941970825*x_22 - 7.78344058990479, 2) + 0.000938727210931732*std::pow(-8.14391994476318*x_52 - 7.33855962753296, 2) + 0.00273661668708137*std::pow(-5.32800006866455*x_6 - 8.19999980926514, 2) - 0.00789292574335738*std::pow(-5.86223983764648*x_67 - 7.67791986465454, 2) + 0.00112225119710415*std::pow(-2.67999982833862*x_67 - 3.29543995857239, 2) + 0.000394567960772198*std::pow(-9.8080005645752*x_69 - 9.99804019927979, 2) + 0.00206545770353328*std::pow(-5.00727987289429*x_75 - 5.6101598739624, 2) + 0.000450198308972079*std::pow(-4.49512004852295*x_75 - 5.85743951797485, 2) - 0.0102708547283121*std::pow(-4.84863996505737*x_76 - 6.26336002349854, 2) - 2.28453776506188e-5*std::pow(-7.13856029510498*x_78 - 7.5283203125, 2) + 0.106106585369265*std::pow(-8.08672046661377*x_83 - 8.69575977325439, 2) - 0.00211671791052694*std::pow(-5.77191972732544*x_87 - 5.97872018814087, 2) + 4.81800158696443*std::exp(0.675439834594727*x_1) + 21.2124612288296*std::exp(0.805679857730865*x_1) + 7129.2149728563*std::exp(0.820959866046906*x_1) + 0.0387448585061752*std::exp(0.863999843597412*x_1) - 3.06618165465494e-5*std::exp(0.999759793281555*x_1) - 0.000971873522571476*std::exp(1.01575982570648*x_1) + 0.00895426015939341*std::exp(1.04399979114532*x_1) - 0.00365421346470796*std::exp(1.06791973114014*x_1) + 4.60019929869268*std::exp(1.0971999168396*x_1) + 5.66654343843391e-5*std::exp(1.11495983600616*x_1) - 0.00397178218683776*std::exp(1.13255989551544*x_1) - 0.000444746759367946*std::exp(1.20439982414246*x_1) + 0.0510819459116591*std::exp(0.975199818611145*x_108) - 5.72053251612474*std::exp(1.29199981689453*x_108) - 0.0100579936210969*std::exp(1.58871984481812*x_108) + 0.000428879432801517*std::exp(1.60567986965179*x_108) + 954.502659991913*std::exp(2.76399993896484*x_17) - 0.00322298951241702*std::exp(2.89416003227234*x_17) + 0.00329428336798913*std::exp(2.91807985305786*x_17) + 0.0022763201669919*std::exp(3.5239999294281*x_17) + 0.000507222824803658*std::exp(3.58959984779358*x_17) + 0.000372352709298845*std::exp(3.60615992546082*x_17) - 1.12360987905752e-5*std::exp(3.7247200012207*x_17) + 3.82926316637119*std::exp(0.934719800949097*x_29) - 0.118436637587812*std::exp(1.11599981784821*x_29) + 7.85667802809254*std::exp(1.20207989215851*x_29) - 0.197240535694639*std::exp(1.28559982776642*x_29) - 0.0161827492959235*std::exp(1.62799978256226*x_29) + 0.00025355000758211*std::exp(1.69127988815308*x_29) - 0.000977473881223958*std::exp(2.63527989387512*x_29) + 0.000512959702082515*std::exp(1.38783979415894*x_38) + 0.988975743932963*std::exp(1.42807984352112*x_38) + 0.160892718063089*std::exp(2.43751978874207*x_38) + 0.000512200770278556*std::exp(2.55167984962463*x_38) + 0.000789980982911407*std::exp(1.51279985904694*x_50) - 0.00826896905270942*std::exp(1.64831984043121*x_50) - 0.0697300094777247*std::exp(1.6839998960495*x_50) - 8.0859193165898*std::exp(1.73599982261658*x_50) - 63693.7470176423*std::exp(1.89111995697021*x_50) + 0.110163158052375*std::exp(1.92567980289459*x_50) - 0.0605764481909605*std::exp(1.93199980258942*x_50) + 0.0956415876760155*std::exp(1.93495976924896*x_50) - 97.8653190145113*std::exp(1.95423984527588*x_50) + 0.0230156313901239*std::exp(2.00951981544495*x_50) + 0.249498064536605*std::exp(0.747759819030762*x_66) - 0.236898376432288*std::exp(0.704879820346832*x_71) + 1.32416557787077*std::exp(0.727519869804382*x_71) - 0.0570730752437468*std::exp(1.12319993972778*x_71) + 14.6307971497451*std::exp(1.13343989849091*x_71) - 0.000552358254313314*std::exp(1.17391979694366*x_71) + 0.027639073811769*std::exp(1.27175986766815*x_71) - 0.00462665013809788*std::exp(1.67999982833862*x_71) + 26.9736806200409*std::exp(1.69519984722137*x_71) + 0.611489315136214*std::exp(1.85879993438721*x_71) + 0.00116650413513489*std::exp(1.86255991458893*x_71) + 0.00126139940750938*std::exp(1.9048798084259*x_71) - 0.00751078473107964*std::exp(1.04767978191376*x_72) + 129994.281331344*std::exp(0.721359848976135*x_73) + 0.0843139782536529*std::exp(0.838959872722626*x_73) - 0.00512911301103738*std::exp(0.977439820766449*x_76) - 0.727320828076389*std::exp(1.22399985790253*x_76) + 4.44619773608233e-5*std::exp(2.10399985313416*x_76) - 0.00549469510657958*std::exp(2.24863982200623*x_76) - 0.0312256329063031*std::exp(1.07551980018616*x_77) - 0.953458533382231*std::exp(1.43767976760864*x_77) - 0.0830606629276347*std::exp(1.19447994232178*x_78) + 0.0477207068265534*std::exp(1.61599981784821*x_78) - 0.0457997633604423*std::exp(1.83559989929199*x_78) + 1.75301514941937*std::exp(1.90311992168427*x_78) + 0.259161123787907*std::exp(1.36295986175537*x_81) + 0.0982126448380245*std::exp(1.0487197637558*x_87) + 0.544138531922743*std::exp(0.894479870796204*x_88) + 181.581862047943*std::sin(0.370079845190048*x_102 + 8.18015956878662) - 1.00585908050369*std::sin(0.232239991426468*x_104 - 7.55864000320435) - 0.512114231146098*std::sin(0.300959914922714*x_104 - 1.30567979812622) - 101.500173053551*std::sin(0.316399931907654*x_104 + 1.89671981334686) + 0.0175831989988488*std::sin(0.34063982963562*x_105 + 5.15248012542725) - 117.758411575814*std::sin(0.426319867372513*x_105 + 2.02519989013672) - 0.10374792635388*std::sin(0.433839857578278*x_105 + 2.02359986305237) + 25.367518708284*std::sin(0.471119850873947*x_105 - 7.36047983169556) + 0.00459130902119249*std::sin(0.499759823083878*x_105 + 2.03655982017517) + 1.49066597490352*std::sin(0.517119884490967*x_105 + 8.36359977722168) + 0.383266414186996*std::sin(0.512159824371338*x_109 + 2.15727996826172) - 2.42852813477656*std::sin(0.401439845561981*x_111 - 7.40527963638306) - 20.5356751499365*std::sin(0.180640012025833*x_112 - 7.61432027816772) - 1.24924660274451*std::sin(0.260399967432022*x_112 + 5.04791975021362) + 358163.633410288*std::sin(0.51503986120224*x_115 + 2.13183975219727) + 3.66006257144346*std::sin(0.454559862613678*x_117 - 7.36303997039795) + 85.8865662769434*std::sin(0.440479874610901*x_120 - 1.17087984085083) + 29.3263449569301*std::sin(0.38391986489296*x_14 - 1.22143995761871) + 21.886504678149*std::sin(0.476879835128784*x_14 + 8.24479961395264) + 0.731927971778298*std::sin(0.429919868707657*x_15 + 5.22760009765625) - 0.339280506732747*std::sin(0.551439881324768*x_15 + 2.14655995368958) + 0.0538242390413145*std::sin(0.504719853401184*x_17 - 4.07760000228882) + 0.113247728526287*std::sin(0.436239868402481*x_19 - 1.1658399105072) + 6.61729014008396*std::sin(0.31743985414505*x_21 + 8.31935977935791) + 1.38413388290398*std::sin(0.459999859333038*x_21 - 4.36111974716187) - 818.091091134457*std::sin(0.166160017251968*x_26 + 1.75695991516113) - 51.4451451879912*std::sin(0.263119965791702*x_26 + 5.06063985824585) + 1.5205927982145*std::sin(0.314319849014282*x_28 - 4.30048036575317) - 3.75244054757548*std::sin(0.319439828395844*x_28 - 4.27544021606445) - 231.23301834784*std::sin(0.325839847326279*x_28 - 4.26304006576538) - 0.486007469467405*std::sin(0.341279834508896*x_28 + 5.1275200843811) - 746371.569620926*std::sin(0.343919843435287*x_28 - 4.24584007263184) + 748.316220983602*std::sin(0.344959855079651*x_28 + 5.1547999382019) + 22.9907094089607*std::sin(0.364799857139587*x_28 - 4.23216009140015) + 2.24366141227814*std::sin(0.368799835443497*x_3 + 5.17008018493652) - 1.3525200635117*std::sin(0.385039836168289*x_34 + 1.98855984210968) - 1140.76642463772*std::sin(0.323519825935364*x_36 - 1.24327993392944) + 183.072146049313*std::sin(0.332959830760956*x_36 - 7.4410400390625) + 0.878507211043299*std::sin(0.343119859695435*x_36 - 1.22071981430054) - 1.91476279528679*std::sin(0.345119833946228*x_36 + 5.14664030075073) - 0.0328460827122391*std::sin(0.354799836874008*x_36 - 7.42647981643677) - 2.38483427520027*std::sin(0.361759841442108*x_36 + 1.95119988918304) - 0.628663312869851*std::sin(0.380479842424393*x_36 + 8.37952041625977) + 311557.779420976*std::sin(0.424479871988297*x_36 - 4.18911981582642) + 0.0132356063731906*std::sin(0.343599855899811*x_43 - 7.45887994766235) + 0.0834828375758572*std::sin(0.451039850711823*x_45 - 7.353759765625) - 1145.75492403474*std::sin(0.3294398188591*x_46 + 8.31216049194336) + 0.128025923955411*std::sin(0.357999831438065*x_46 - 4.24848031997681) - 3.33035902680995*std::sin(0.412479877471924*x_46 - 7.39631986618042) + 13.8910569780739*std::sin(0.41839987039566*x_46 - 4.18064022064209) - 0.502914599619706*std::sin(0.237599983811378*x_47 - 7.55951976776123) - 20.6923714874729*std::sin(0.65831983089447*x_47 - 4.15960025787354) + 4.26521847361046*std::sin(0.405279844999313*x_49 + 5.19935989379883) - 2026.06987753519*std::sin(0.23047998547554*x_53 - 4.36679983139038) + 235.722295037994*std::sin(0.25383996963501*x_53 + 5.06503963470459) + 0.0734491697490816*std::sin(0.444399863481522*x_53 - 7.35679960250854) - 0.0756858698545041*std::sin(0.175520017743111*x_55 - 7.62400007247925) + 0.361359975752094*std::sin(0.420479863882065*x_55 + 5.20256042480469) + 21.3790137759125*std::sin(0.485599845647812*x_55 + 2.05031991004944) - 2.71683495675448*std::sin(0.167360007762909*x_67 + 1.76391994953156) - 0.0748090535336884*std::sin(0.297439932823181*x_68 + 5.14079999923706) + 0.0090536906614422*std::sin(0.406319856643677*x_69 + 8.40272045135498) - 0.00770800548788033*std::sin(0.511679828166962*x_70 - 1.10791981220245) + 0.0137916472674426*std::sin(0.288719952106476*x_72 - 7.48760032653809) + 2.20466450427707*std::sin(0.379999846220016*x_73 + 1.97735977172852) + 0.601295244852897*std::sin(0.480799853801727*x_73 + 8.47792053222656) - 422.217011116468*std::sin(0.612159848213196*x_73 - 3.98176002502441) + 0.265366738400094*std::sin(0.806719899177551*x_73 - 0.778159856796265) - 79.8318405985673*std::sin(0.204880014061928*x_75 + 1.81199991703033) - 1400.79402127882*std::sin(0.301919937133789*x_75 - 7.48392009735107) - 0.191285758046904*std::sin(0.393039852380753*x_75 + 8.3851203918457) + 0.204903701540236*std::sin(0.49687984585762*x_78 - 7.29647970199585) - 2.61846918668573*std::sin(0.173680007457733*x_80 - 4.44935989379883) + 0.271564333253086*std::sin(0.214559987187386*x_80 + 1.82359993457794) + 1.09155165513459*std::sin(0.249999970197678*x_80 + 1.83071994781494) + 44.4203173709134*std::sin(0.257039994001389*x_80 + 5.08447980880737) - 580102.788292032*std::sin(0.32015985250473*x_80 - 1.26199984550476) - 5842.65172522354*std::sin(0.164080023765564*x_85 + 1.76831984519958) - 0.68849082505603*std::sin(0.376319825649261*x_85 - 4.42600011825562) + 0.173917117099169*std::sin(0.333999842405319*x_86 + 5.13912010192871) + 0.155045852061673*std::sin(0.34759983420372*x_92 + 1.99199986457825) + 0.0725781875268398*std::sin(0.353119850158691*x_92 - 7.41048002243042) + 1181.25149887258*std::sin(0.364559859037399*x_92 + 1.98087978363037) - 2.33305579511386*std::sin(0.366079837083817*x_92 + 1.98439979553223) + 4.94431879903073*std::sin(0.3781598508358*x_95 + 1.99335980415344) - 2.78904575312293*std::sin(0.134640038013458*x_96 - 7.67208003997803) + 3.92881369569604*std::sin(0.476799845695496*x_96 + 5.22983980178833) + 0.826738730681268*std::sin(0.393919825553894*x_97 - 7.38903999328613) + 0.00808824220174949*std::sin(0.513919830322266*x_98 + 5.16983985900879) - 11288732.0709344 + 0.515991188235421*std::exp(-2.36207985877991*x_86) - 0.00148377668123593*std::exp(-2.35904002189636*x_86) - 1.20428462864562e-5*std::exp(-2.29543995857239*x_86) - 0.00663694484088052*std::exp(-2.10855984687805*x_23) + 5.39630097147229*std::exp(-2.10799980163574*x_23) - 0.172060709185402*std::exp(-2.07343983650208*x_23) + 1.86537551781762*std::exp(-1.99351978302002*x_23));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
