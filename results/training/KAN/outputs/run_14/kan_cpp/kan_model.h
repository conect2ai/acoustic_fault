
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.54071939460931e-6*x_1 - 8.69510812393835e-7*x_10 - 4.50497147272302e-7*x_100 + 5.74477644965704e-7*x_101 - 3.8849298842041e-7*x_102 - 6.04580701643137e-7*x_103 - 8.9368961705839e-7*x_104 - 1.68057257073144e-6*x_105 + 8.03540232957347e-7*x_106 - 6.06689459043478e-7*x_107 - 1.13038734904779e-7*x_108 - 1.73076112063443e-7*x_109 + 8.17160076638879e-9*x_11 + 1.0274113279251e-6*x_110 - 6.19272265945073e-7*x_111 - 6.6895274901042e-8*x_112 + 8.59835578710109e-7*x_113 + 1.20231119281784e-6*x_114 + 1.03178242036327e-6*x_115 - 5.31600203425842e-7*x_116 + 8.96650164875768e-7*x_117 - 3.24985351474664e-7*x_118 - 1.94204626973619e-8*x_119 + 6.49747151541713e-7*x_12 - 3.34057315832506e-7*x_120 + 7.2957051551974e-7*x_13 + 5.00654160145933e-7*x_14 - 5.57299164884701e-7*x_15 - 4.1462659110999e-7*x_16 + 1.17664896474749e-6*x_17 + 3.66848413853767e-7*x_18 - 8.12859415901477e-9*x_19 + 9.90506159751006e-7*x_2 + 3.4708709967782e-7*x_20 + 6.6048441585669e-7*x_21 - 5.66106054227977e-8*x_22 + 3.30307437783847e-7*x_23 - 8.79863197322393e-7*x_24 - 1.69709317591711e-7*x_25 - 1.19405560695344e-6*x_26 + 2.13105650191394e-7*x_27 + 4.44557271762302e-7*x_28 + 1.06198698117951e-7*x_29 + 7.62399814762002e-7*x_3 + 5.58793247197324e-7*x_30 + 2.46835134398407e-6*x_31 - 8.29177928599528e-6*x_32 - 5.57221543137942e-7*x_33 + 1.06295556102331e-6*x_34 - 1.91077331423201e-5*x_35 - 2.88278186903836e-6*x_36 + 2.65320100128871e-6*x_37 - 2.77483147293162e-7*x_38 + 1.56172783054538e-8*x_39 - 9.08252523375026e-7*x_4 - 8.66234582418531e-7*x_40 + 4.80443843886539e-7*x_41 + 2.56865155413143e-6*x_42 + 2.73247741342955e-7*x_43 + 1.29218464804587e-7*x_44 + 3.21285490498917e-7*x_45 + 1.53627697573289e-7*x_46 + 1.01215489951982e-6*x_47 - 4.26850785217024e-6*x_48 + 4.95207857621083e-7*x_49 + 1.9848087262354e-7*x_5 + 1.89896118724912e-7*x_50 + 1.78193936540284e-7*x_51 - 7.79965024922708e-7*x_52 - 6.35590015076201e-7*x_53 + 6.94218641532818e-7*x_54 + 4.57769331495426e-7*x_55 - 5.18341692102671e-7*x_56 - 5.59712707472799e-8*x_57 + 3.7642077683494e-7*x_58 + 3.94503001361768e-7*x_59 + 2.17783102458263e-7*x_6 - 2.41385027931514e-7*x_60 + 1.47564107480286e-6*x_61 + 2.84206202705077e-8*x_62 + 3.8552566739658e-7*x_63 - 2.81608579954958e-8*x_64 + 7.88948308614967e-6*x_65 - 1.06258374404545e-7*x_66 + 4.04522251460373e-6*x_67 - 1.28572817142355e-6*x_68 + 4.34779712720413e-7*x_69 - 4.25142282438431e-7*x_7 + 1.95673774128682e-7*x_70 + 9.02013159855741e-7*x_71 + 1.06256387092604e-7*x_72 + 4.95951541816499e-7*x_73 + 1.9977406059371e-6*x_74 + 2.49281306388214e-7*x_75 - 1.09190562681149e-6*x_76 - 2.01441012801097e-7*x_77 + 6.56608166889246e-7*x_78 - 1.19095076676425e-7*x_79 - 8.19803958125235e-7*x_8 + 2.65712120282485e-7*x_80 - 1.37294732502238e-7*x_81 + 7.60897378332023e-7*x_82 + 1.07125215116386e-6*x_83 + 2.55896758495366e-7*x_84 + 5.58069193077495e-7*x_85 - 6.47515654591367e-7*x_86 - 6.38944768910574e-7*x_87 - 4.46681769640286e-7*x_88 - 5.86170667454274e-7*x_89 + 3.60522647601135e-7*x_9 + 4.69619994957255e-7*x_90 + 9.61793064467439e-6*x_91 - 3.66501307339944e-6*x_92 + 4.54155130579804e-6*x_93 - 2.12103688017967e-6*x_94 + 1.46093644524272e-7*x_95 - 1.47987788029252e-6*x_96 + 2.83064930108899e-6*x_97 - 2.69662081894838e-7*x_98 + 3.77753981456921e-7*x_99 + 0.000112277830399757*std::sin(0.357919842004776*x_34 + 5.0032000541687) - 4.79897529255248e-5*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 1.29921933950344e-5*std::sin(0.289679944515228*x_93 + 1.86895990371704) - 1.32780305429362e-5*std::sin(0.330319821834564*x_93 - 1.21183979511261) + 1.88846684646228e-5*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0254053140853989);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.32691020534504e-7*x_1 + 8.89622629928498e-7*x_10 - 8.95021353854829e-7*x_100 + 1.58710511224616e-7*x_101 + 6.50305710281537e-7*x_102 + 1.55233383247403e-6*x_103 - 4.66224930519155e-7*x_104 + 1.35609833260745e-6*x_105 - 5.87457245818676e-7*x_106 + 9.15184768999151e-7*x_107 - 1.1007384139023e-6*x_108 + 6.44897247240809e-7*x_109 - 5.0007937784114e-7*x_11 - 2.33875616214962e-7*x_110 - 3.28186321366993e-7*x_111 + 5.02134426490996e-7*x_112 - 2.35770746750709e-6*x_113 - 2.02285740732627e-6*x_114 + 9.94106584337089e-7*x_115 + 4.72556126672515e-7*x_116 - 9.66813063061109e-7*x_117 + 6.23174859173337e-7*x_118 + 1.90678019625713e-6*x_119 - 5.58575402578455e-7*x_12 - 2.90429995918063e-8*x_120 - 1.36873382595806e-6*x_13 + 1.6044411764359e-6*x_14 + 3.91702331978634e-7*x_15 + 3.11660132335687e-6*x_16 - 6.41522046245206e-7*x_17 - 1.11840960159922e-7*x_18 - 3.68602281175866e-8*x_19 - 1.48922809805509e-6*x_2 - 9.27214548461324e-7*x_20 - 6.65956543967306e-7*x_21 + 2.3219655519384e-7*x_22 - 3.10658774932295e-7*x_23 + 1.03768604944603e-6*x_24 - 4.92786280926611e-8*x_25 + 1.58550466433674e-6*x_26 + 3.85483622721973e-7*x_27 + 3.92482431628035e-7*x_28 - 3.1040969927504e-7*x_29 - 1.73074179202976e-6*x_3 - 7.89123118078166e-7*x_30 + 1.33733124769594e-5*x_31 + 6.53126722813409e-6*x_32 + 1.4146808940893e-6*x_33 + 9.07259305904767e-6*x_34 + 2.44061060188089e-5*x_35 - 1.051232972766e-5*x_36 - 2.30875156903151e-6*x_37 + 8.16104997494594e-8*x_38 - 7.51259838170162e-7*x_39 + 1.35006524170541e-6*x_4 + 1.88298827710714e-6*x_40 - 1.05163917182263e-6*x_41 - 2.13451921245777e-6*x_42 - 5.45851363636376e-7*x_43 + 1.06587419559764e-6*x_44 - 1.49269114304939e-6*x_45 + 1.59204936472754e-7*x_46 - 1.22054614841801e-7*x_47 - 5.77730658631279e-6*x_48 - 2.8383441699812e-6*x_49 + 5.7718116510766e-7*x_5 - 1.68753067735349e-6*x_50 + 1.07997525693603e-6*x_51 + 5.62288987503594e-6*x_52 - 4.62978006067114e-7*x_53 + 1.08005237338997e-6*x_54 - 6.1865627772502e-7*x_55 + 4.92987379165825e-7*x_56 - 1.85620648191692e-7*x_57 + 4.50920550038796e-7*x_58 - 9.34393909647824e-7*x_59 - 4.17795675239587e-7*x_6 - 2.27352762140221e-6*x_60 - 1.33548247255395e-6*x_61 - 2.24727154161389e-7*x_62 - 2.25715428380672e-7*x_63 - 1.00042608840318e-6*x_64 - 6.01497594830332e-6*x_65 - 4.74545296379178e-7*x_66 - 2.46295622669909e-6*x_67 + 2.34405445601334e-6*x_68 - 5.61941550045111e-7*x_69 + 2.97491266763953e-7*x_7 - 5.81059220016343e-7*x_70 - 1.67247527562102e-7*x_71 + 1.09390612268248e-6*x_72 - 4.4167378987782e-7*x_73 - 1.36285770673265e-6*x_74 + 4.01212847233488e-8*x_75 + 1.7231818109757e-6*x_76 + 2.03329800733322e-7*x_77 - 4.64432366882908e-7*x_78 + 6.16764879034108e-7*x_79 + 1.55039524886359e-7*x_8 - 6.11365298357156e-7*x_80 + 2.93176907302331e-8*x_81 + 2.33930970803646e-6*x_82 + 4.42992809797619e-7*x_83 - 6.6386153805483e-7*x_84 - 7.13491433941898e-7*x_85 + 3.21023163002825e-7*x_86 + 2.50915008421655e-6*x_87 + 1.03229243673136e-6*x_88 + 8.97294390311553e-7*x_89 - 5.97804040345273e-7*x_9 - 5.78689790381814e-7*x_90 - 2.40577000007683e-5*x_91 + 5.36488835928017e-6*x_92 - 1.38498127972305e-5*x_93 + 3.24756892549659e-6*x_94 - 7.90946333163202e-7*x_95 + 1.06465484769668e-6*x_96 - 1.02950624079165e-7*x_97 + 7.53750640987696e-7*x_98 - 6.27199036593869e-7*x_99 - 9.24612598453181e-5*std::sin(0.357919842004776*x_34 + 5.0032000541687) - 1.67279027617411e-6*std::sin(0.217919990420341*x_37 - 7.58752012252808) + 9.58410518347931e-5*std::sin(0.289679944515228*x_93 + 1.86895990371704) - 4.62835481012712e-7*std::sin(0.330319821834564*x_93 - 1.21183979511261) + 6.58267397738376e-7*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0541816296868292);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.7122140112064e-6*x_1 - 3.1797730869889e-7*x_10 + 2.20417182626336e-6*x_100 - 1.65470530924307e-6*x_101 + 1.76497060824981e-8*x_102 - 1.67717085807309e-6*x_103 + 3.84551742816034e-6*x_104 + 2.19426336892386e-6*x_105 - 8.93362185334566e-7*x_106 - 2.66333020041007e-7*x_107 + 3.38295056146705e-6*x_108 - 1.16494232749927e-6*x_109 + 5.6303013104392e-7*x_11 + 1.74286832892309e-7*x_110 + 4.80409653356207e-6*x_111 - 5.70085965235024e-8*x_112 + 2.80092680857273e-6*x_113 + 3.37442567045293e-7*x_114 - 3.25669640950862e-6*x_115 + 1.08767643026059e-6*x_116 - 1.64224024240977e-6*x_117 + 1.55604970603449e-7*x_118 - 3.00416355892965e-6*x_119 - 2.56386729205479e-7*x_12 + 1.32672482502821e-6*x_120 + 8.56929061536027e-7*x_13 - 2.8380702097109e-6*x_14 + 5.81663995451522e-7*x_15 - 5.09153823566625e-6*x_16 - 8.37434931906503e-7*x_17 - 3.23820053726242e-7*x_18 - 2.23971589762848e-8*x_19 + 1.18601801632743e-6*x_2 + 1.60153432404168e-6*x_20 - 6.51437028788738e-7*x_21 - 2.06210858746855e-7*x_22 + 1.14192124498946e-7*x_23 + 6.78818416795291e-7*x_24 + 1.86274544443677e-7*x_25 - 6.45117061981352e-7*x_26 - 8.00958998488512e-7*x_27 - 5.4179378772317e-7*x_28 + 6.54293491857347e-7*x_29 + 1.45991683460775e-6*x_3 + 1.3408406450612e-6*x_30 - 1.2868698509315e-5*x_31 + 1.37755094429402e-5*x_32 - 7.78253564621309e-7*x_33 - 2.46950458803137e-5*x_34 - 7.95403929063989e-6*x_35 + 1.72354149029195e-5*x_36 + 1.51963331252304e-6*x_37 + 1.49774312146653e-6*x_38 + 2.27610041022131e-6*x_39 - 2.94541731386298e-9*x_4 - 2.92208583995718e-7*x_40 + 2.01495871671004e-6*x_41 - 1.65537729629554e-6*x_42 + 1.86012692266996e-6*x_43 - 2.36358113614317e-6*x_44 + 3.24733827858948e-6*x_45 - 3.98874318198715e-7*x_46 - 1.78731096627593e-6*x_47 + 1.16003189829974e-5*x_48 + 2.4745081292116e-6*x_49 - 1.61478134462019e-6*x_5 + 2.6924822851995e-6*x_50 - 4.1768317560457e-6*x_51 - 1.00133548430265e-5*x_52 + 1.44376048131405e-6*x_53 - 2.53662547215663e-6*x_54 - 2.56883822873778e-7*x_55 + 3.49928356482959e-7*x_56 + 2.86684215596037e-7*x_57 - 2.57710328655679e-6*x_58 + 1.1494562518427e-6*x_59 - 1.95695494012227e-7*x_6 + 4.53881775868389e-6*x_60 + 8.18129891340407e-7*x_61 + 9.37708787614307e-8*x_62 - 6.81940960389717e-7*x_63 + 1.71401752540959e-6*x_64 - 1.49991685096251e-5*x_65 + 6.47891451921896e-7*x_66 - 9.75206333748147e-6*x_67 - 2.30110209546266e-6*x_68 - 9.42085592514503e-7*x_69 + 1.26263907589297e-7*x_7 + 3.14580702281924e-8*x_70 - 2.85611082524036e-6*x_71 - 2.1900664833156e-6*x_72 - 6.41626253402281e-7*x_73 - 2.98006519965003e-6*x_74 - 2.06820760500322e-6*x_75 - 3.48700970544194e-6*x_76 + 3.25325623082502e-7*x_77 - 9.12225950568442e-7*x_78 - 7.95181525107456e-7*x_79 + 1.83667473456583e-6*x_8 + 1.0610104939704e-6*x_80 + 4.91520653314109e-7*x_81 - 3.8551428682761e-6*x_82 - 3.5503587161216e-6*x_83 - 7.50093192303743e-7*x_84 + 2.12160793773227e-7*x_85 + 5.05286962685648e-7*x_86 - 3.7184260908973e-6*x_87 - 1.02222100621598e-6*x_88 - 7.57233414207538e-7*x_89 - 1.38609084691821e-7*x_9 - 3.89211616216378e-7*x_90 + 3.54091820655248e-5*x_91 - 5.45932297143794e-6*x_92 - 1.49141963279943e-5*x_93 - 4.13799879046081e-6*x_94 + 2.10182816421876e-6*x_95 + 4.67572175265786e-6*x_96 - 9.2899938558118e-6*x_97 - 1.21244705266142e-6*x_98 + 1.25126748606532e-6*x_99 - 0.000192169130963059*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 0.000178994786157632*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 0.000163035992309197*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 4.95251192752702e-5*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 7.04370618187749e-5*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0458848842450646);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.53872640160154e-5*x_1 + 1.78893139864364e-6*x_10 - 1.35033749450996e-7*x_100 - 4.70804747990276e-6*x_101 - 1.39312976136982e-6*x_102 - 4.00548707381412e-7*x_103 + 2.64128952536854e-6*x_104 - 4.36832046105375e-6*x_105 - 2.28095086755712e-6*x_106 - 4.21450931113518e-6*x_107 + 3.30280707168539e-7*x_108 - 5.18843477134686e-6*x_109 - 7.76080315876415e-7*x_11 + 3.50964022927773e-6*x_110 - 2.23163793889795e-6*x_111 + 2.01072593125571e-6*x_112 - 2.52379247292755e-6*x_113 + 7.42512057126106e-6*x_114 - 3.54103291514219e-6*x_115 - 2.12681803573747e-6*x_116 + 4.39539361411066e-6*x_117 - 8.47863305490494e-7*x_118 - 1.38401812107203e-6*x_119 - 8.10110440412815e-7*x_12 - 2.177089890553e-6*x_120 + 1.33846326184793e-6*x_13 + 1.6210857367834e-6*x_14 + 2.86381720607726e-7*x_15 - 1.20142095072101e-5*x_16 + 1.61725190503558e-6*x_17 - 4.60791686622454e-7*x_18 + 5.17553103142541e-7*x_19 + 6.91573712264817e-7*x_2 + 2.71521469097229e-7*x_20 + 3.31085015333334e-6*x_21 - 1.49571967671446e-6*x_22 - 1.20954474023996e-6*x_23 - 4.29809106064033e-6*x_24 - 1.31467200984703e-7*x_25 + 2.18431518760808e-6*x_26 + 1.93831123365641e-6*x_27 + 1.61027256529547e-6*x_28 - 1.05179462297957e-7*x_29 + 3.88574496552256e-6*x_3 - 2.76937858794392e-6*x_30 + 4.01064885946928e-5*x_31 - 3.86300908779836e-5*x_32 - 1.98903511520617e-6*x_33 - 3.83145621632431e-5*x_34 - 2.80006068252819e-5*x_35 - 2.95774072457637e-6*x_36 + 3.94025731527479e-6*x_37 + 1.81343957994685e-6*x_38 + 5.44926733241403e-6*x_39 - 1.71765955157208e-6*x_4 - 6.12825587917513e-6*x_40 + 1.05867152752178e-6*x_41 - 5.03338956834011e-6*x_42 + 9.8153356604593e-6*x_43 - 1.96657252829497e-6*x_44 + 2.49189054175835e-6*x_45 - 2.99219157766791e-7*x_46 + 5.48919139322867e-6*x_47 - 1.53095289026666e-5*x_48 + 4.11423652856346e-6*x_49 - 1.65989314139457e-6*x_5 + 3.77033354703759e-6*x_50 - 4.90665628393996e-6*x_51 - 1.56898106760284e-5*x_52 - 8.7822611995412e-7*x_53 + 1.58376291914521e-6*x_54 + 2.04861356422478e-7*x_55 - 3.53969016167286e-6*x_56 + 2.60335836929376e-6*x_57 + 2.7632594223343e-6*x_58 - 1.21817164603623e-6*x_59 + 2.70572702617682e-6*x_6 + 5.72154012675069e-6*x_60 - 7.37987713010263e-7*x_61 + 6.30365056714991e-7*x_62 + 1.25586170540027e-6*x_63 - 4.15368719724618e-7*x_64 + 3.76465677988729e-5*x_65 - 6.08926941641249e-7*x_66 + 2.3850163344697e-5*x_67 + 1.47522282027628e-6*x_68 + 4.97233076389057e-6*x_69 + 1.96417276546232e-6*x_7 + 5.22414278602744e-7*x_70 + 2.89126352875765e-6*x_71 - 7.76941361315675e-7*x_72 + 2.10253000552257e-6*x_73 + 8.48633254974228e-6*x_74 - 3.35002915377048e-7*x_75 + 4.87008369210235e-6*x_76 - 1.82167422369751e-6*x_77 + 2.23690433555966e-6*x_78 + 1.46813662897291e-6*x_79 - 1.8867664208548e-6*x_8 - 1.79839261209467e-6*x_80 + 3.0794124959582e-8*x_81 + 2.65204257657426e-6*x_82 + 1.23055445792612e-7*x_83 + 1.27027873722443e-6*x_84 - 1.48129636928332e-6*x_85 + 1.23504863521345e-6*x_86 - 7.10341657618691e-6*x_87 - 1.79229517196962e-6*x_88 + 3.07946880217558e-7*x_89 + 1.6032410551464e-6*x_9 + 2.39768860088876e-6*x_90 - 3.45747579793837e-5*x_91 + 4.11193235557394e-6*x_92 + 6.03519394601779e-5*x_93 + 4.4269483075302e-6*x_94 - 1.44969377510273e-6*x_95 + 8.53513921532681e-6*x_96 - 9.01012040088217e-6*x_97 + 1.19185836636654e-6*x_98 + 6.89108767338481e-7*x_99 + 0.000526891940643697*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 0.000264015323772442*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 0.000313546247580261*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 7.30490014877553e-5*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 0.000103893884737438*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0464647931756367);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.07657588541033e-6*x_1 - 2.75611025922395e-6*x_10 - 2.32416180215841e-6*x_100 + 4.38589457383708e-6*x_101 - 1.24533769363393e-6*x_102 - 6.21538221559198e-7*x_103 - 6.64136627865835e-6*x_104 - 1.86269843058092e-6*x_105 + 3.76644792764304e-6*x_106 + 1.30590796986082e-6*x_107 + 4.95186689033104e-7*x_108 + 1.16733464727943e-6*x_109 - 1.12300954731125e-8*x_11 + 2.03004840598236e-6*x_110 - 4.46279547177725e-6*x_111 - 8.71728580503713e-7*x_112 + 8.55766709558437e-7*x_113 + 4.40573280677296e-7*x_114 + 3.02324313082667e-6*x_115 - 1.37071813361531e-6*x_116 + 1.18625544431652e-7*x_117 + 3.63901927500689e-8*x_118 + 1.45501123988171e-7*x_119 + 1.23479861732306e-6*x_12 - 3.43323650893445e-7*x_120 + 5.72460332542384e-7*x_13 + 1.23474660953402e-6*x_14 - 9.20147268529064e-7*x_15 - 1.45240918843064e-6*x_16 + 1.52834295811727e-6*x_17 + 6.61158548307294e-7*x_18 - 9.71591169879744e-8*x_19 + 1.2945160301801e-7*x_2 - 4.83652922514341e-7*x_20 + 6.27745375949108e-7*x_21 - 2.44256109612835e-7*x_22 + 5.44967857402355e-7*x_23 - 1.1209230025479e-6*x_24 - 4.32244652077449e-7*x_25 - 2.83554384423589e-6*x_26 - 2.94320510370108e-8*x_27 + 5.35209071826707e-7*x_28 + 5.43620154056971e-7*x_29 + 3.58828411560889e-7*x_3 + 1.29504845289522e-6*x_30 + 1.69392963186698e-6*x_31 - 6.01288430070031e-6*x_32 - 5.67611201797823e-8*x_33 + 2.28410462323887e-5*x_34 - 2.29271476130111e-5*x_35 - 7.26658605604417e-6*x_36 + 4.50944420677878e-6*x_37 - 4.01355673836686e-6*x_38 + 3.33283317472137e-7*x_39 - 1.04845700494979e-6*x_4 - 5.00039979885121e-7*x_40 + 1.21264014893725e-6*x_41 + 1.13830965524586e-5*x_42 + 8.50827461115377e-7*x_43 + 4.19920966721011e-8*x_44 + 1.05169455559841e-6*x_45 + 3.262378730113e-7*x_46 + 8.64511218414885e-7*x_47 - 8.23751645197881e-6*x_48 - 2.08556314980516e-7*x_49 + 1.39812449140417e-6*x_5 + 8.33866712266694e-7*x_50 + 7.38274073397745e-6*x_51 - 1.52802766297732e-6*x_52 - 2.57314077008279e-6*x_53 + 1.82991666990937e-6*x_54 + 4.49234961888595e-7*x_55 + 5.97452987707124e-7*x_56 - 1.50129061305956e-6*x_57 + 1.21280269853811e-7*x_58 + 1.32197235075497e-6*x_59 - 5.36308913376656e-7*x_6 - 1.11911045588016e-6*x_60 + 1.5099397254498e-6*x_61 - 1.56275916898692e-7*x_62 - 1.30949616550635e-7*x_63 - 1.21970761902109e-6*x_64 + 4.07162067203389e-6*x_65 - 2.38814499778239e-7*x_66 + 1.77282302096352e-6*x_67 - 1.31027619084051e-6*x_68 - 9.21622207162454e-7*x_69 - 9.31384778067921e-7*x_7 + 4.87990046500995e-8*x_70 + 5.25179016532999e-7*x_71 + 6.68554688922749e-7*x_72 + 3.29285238600657e-7*x_73 + 2.08921597682065e-6*x_74 - 2.36863043569476e-7*x_75 - 2.68247225925389e-6*x_76 + 5.24543197358152e-8*x_77 + 7.04424000243712e-7*x_78 - 5.1829573607973e-8*x_79 - 1.26415491668651e-6*x_8 + 3.78724999418006e-7*x_80 - 1.02864007998312e-6*x_81 + 1.58852894893169e-6*x_82 + 6.77779267951071e-6*x_83 - 7.55563811802393e-7*x_84 + 3.6096977668545e-6*x_85 - 2.47077410596048e-6*x_86 - 1.13083997967178e-6*x_87 - 3.33033670611894e-7*x_88 - 1.03461826911729e-6*x_89 + 1.5783274033018e-6*x_9 + 2.13135271035498e-7*x_90 + 3.39574521675106e-5*x_91 - 5.99309378855951e-6*x_92 - 1.01566208844513e-5*x_93 - 3.74977836896249e-6*x_94 - 4.36970239772335e-7*x_95 - 1.42279061836852e-5*x_96 + 2.32951320646771e-5*x_97 - 2.28731471015459e-6*x_98 - 9.84215852626012e-7*x_99 + 6.83002506162572e-5*std::sin(0.357919842004776*x_34 + 5.0032000541687) - 0.000436507037483392*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 2.12823447372289e-5*std::sin(0.289679944515228*x_93 + 1.86895990371704) - 0.000120774820093485*std::sin(0.330319821834564*x_93 - 1.21183979511261) + 0.000171771892598432*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0314414973640719);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.67117581616132e-6*x_1 + 1.0981960076303e-6*x_10 + 3.65984029545985e-6*x_100 - 1.23263031662378e-6*x_101 + 5.57234928190056e-6*x_102 + 2.2158077843714e-6*x_103 + 1.20630356513885e-5*x_104 + 2.68037682159046e-5*x_105 - 5.20952920127755e-6*x_106 + 1.0375611427504e-5*x_107 + 1.25711888082243e-5*x_108 + 2.89823353353351e-6*x_109 - 3.69454794972016e-7*x_11 - 1.76549418563793e-7*x_110 + 2.5945740960769e-5*x_111 + 1.98790683084702e-6*x_112 + 4.77911037115981e-7*x_113 - 2.02483958349294e-5*x_114 - 5.67030876976794e-6*x_115 + 1.13580513380024e-5*x_116 - 2.21737594275109e-5*x_117 + 7.17983102678834e-6*x_118 - 1.12439910068116e-6*x_119 - 4.34528729681195e-6*x_12 + 9.51634395347426e-6*x_120 - 6.59263637140086e-6*x_13 - 3.27510987523647e-6*x_14 + 5.78465648681556e-6*x_15 + 1.87966607895354e-6*x_16 - 9.81719810459764e-6*x_17 - 1.76374731938258e-6*x_18 - 9.8683231542049e-7*x_19 - 5.08469127160004e-6*x_2 + 1.88215340550435e-6*x_20 - 1.16336670800182e-5*x_21 + 1.58693485788344e-6*x_22 - 2.98945439457203e-7*x_23 + 1.52907314836858e-5*x_24 + 2.31728228274132e-7*x_25 + 4.67142463975608e-6*x_26 - 2.90924513883224e-6*x_27 + 3.42977639802378e-8*x_28 + 2.24202669218732e-6*x_29 - 7.96496593624151e-6*x_3 + 5.66845709946346e-6*x_30 + 1.57964163701492e-5*x_31 + 0.000166308098851639*x_32 + 8.78482129900936e-6*x_33 - 2.97875306974787e-5*x_34 + 0.000149320798183346*x_35 + 7.98551605922405e-6*x_36 - 6.38714843328561e-6*x_37 + 5.35607561089925e-6*x_38 + 4.66735024315971e-6*x_39 + 1.17773824184316e-5*x_4 + 1.87006245218836e-5*x_40 + 4.75755826864589e-6*x_41 - 1.32270713789679e-5*x_42 + 1.47519866233315e-6*x_43 - 4.24157085763906e-6*x_44 + 7.49744118522763e-6*x_45 - 4.39547862169279e-7*x_46 - 1.50291919878206e-5*x_47 + 2.09024783183891e-5*x_48 - 1.27182068191753e-5*x_49 - 2.62573462903124e-6*x_5 + 5.39976521226037e-7*x_50 - 7.12465963235815e-6*x_51 - 5.59628411573002e-6*x_52 + 2.64638059080759e-6*x_53 - 5.34204717831547e-6*x_54 - 6.69583504394673e-6*x_55 + 9.49140292523131e-6*x_56 - 3.2515195393759e-6*x_57 - 1.4574161252267e-5*x_58 + 1.6414272596796e-6*x_59 - 7.49041136788086e-6*x_6 + 3.57250384707901e-6*x_60 - 3.04702730251286e-6*x_61 - 2.07378037852036e-6*x_62 - 7.27272871962677e-6*x_63 + 1.20279300969084e-6*x_64 - 0.000171434137337692*x_65 - 5.57445714578624e-8*x_66 - 9.96159296384078e-5*x_67 + 2.50421839475988e-6*x_68 - 1.56501250981468e-5*x_69 + 7.46512389409204e-7*x_7 - 5.37360939999126e-6*x_70 - 2.13058549456151e-5*x_71 - 3.09422689462438e-6*x_72 - 9.07194542058277e-6*x_73 - 3.45423891018453e-5*x_74 - 1.32924473497205e-5*x_75 - 1.49905203356495e-5*x_76 + 5.23921237100833e-6*x_77 - 1.06326466191765e-5*x_78 - 8.22159785475786e-7*x_79 + 1.29358962225119e-5*x_8 + 3.44633097083947e-6*x_80 + 2.40629823301217e-6*x_81 - 3.22476292540493e-6*x_82 - 1.19136472944173e-5*x_83 - 1.27069687990999e-5*x_84 + 1.17975937554821e-8*x_85 + 2.2743473845897e-6*x_86 + 1.82080995578531e-6*x_87 + 3.23460014722941e-6*x_88 + 1.3369965417542e-6*x_89 - 5.76658190291688e-6*x_9 - 9.02770157436315e-6*x_90 + 8.32528971362538e-5*x_91 - 3.97838044058551e-8*x_92 - 0.000280589459667483*x_93 - 7.07832108626797e-6*x_94 + 7.59289999051345e-6*x_95 + 1.98140273995091e-5*x_96 - 3.09685950364872e-5*x_97 - 4.52220801889065e-6*x_98 + 1.61584555796707e-6*x_99 - 0.002343983568004*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 0.00051707054796258*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 4.75718443644829e-6*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 0.000143065511075973*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 0.000203474810263099*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0157869133571788);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.44360801973161e-5*x_1 + 1.03019442551273e-6*x_10 + 3.39734901480524e-6*x_100 + 1.33846317698536e-6*x_101 + 4.29610462546029e-6*x_102 + 1.90238110306413e-6*x_103 + 5.82689678444347e-6*x_104 + 1.4185379666463e-5*x_105 - 2.15496188014452e-6*x_106 + 6.82558651986274e-6*x_107 + 2.08793766846295e-6*x_108 + 6.18300927026009e-6*x_109 + 9.22484084844707e-7*x_11 - 6.97068903796333e-6*x_110 + 1.28267338310595e-5*x_111 - 1.29719523002091e-6*x_112 + 1.97328789667981e-6*x_113 - 1.48930340862464e-5*x_114 - 3.45880202617043e-7*x_115 + 6.71385322381981e-6*x_116 - 1.10936910722945e-5*x_117 + 2.81858075698225e-6*x_118 + 1.23303864949044e-6*x_119 - 1.49622147953522e-6*x_12 + 5.36375940182574e-6*x_120 - 4.10110320341072e-6*x_13 - 4.31592371621044e-6*x_14 + 2.12919870920536e-6*x_15 + 1.67277413227552e-5*x_16 - 6.39135719427519e-6*x_17 - 6.72643854619896e-7*x_18 - 7.67503932247939e-7*x_19 - 2.78916997829963e-6*x_2 + 2.72417381625525e-7*x_20 - 7.70027222450677e-6*x_21 + 2.44855577712988e-6*x_22 + 7.23495849285626e-7*x_23 + 1.03067805240912e-5*x_24 + 7.27575117788994e-7*x_25 + 1.60559143189158e-6*x_26 - 3.22444016856831e-6*x_27 - 2.84548308358928e-6*x_28 + 9.02060735124374e-8*x_29 - 7.3889062600115e-6*x_3 + 3.17470642161069e-6*x_30 - 5.08362147487524e-5*x_31 + 9.59815362610075e-5*x_32 + 4.80414033570589e-6*x_33 + 2.00077481395946e-5*x_34 + 0.000101134970299077*x_35 + 1.47586067694531e-5*x_36 - 1.217842959726e-5*x_37 + 2.58785608903084e-6*x_38 - 6.00327336859205e-6*x_39 + 6.26531998578668e-6*x_4 + 1.27273780563216e-5*x_40 - 1.63455385855807e-6*x_41 - 8.36444969856953e-6*x_42 - 1.2803994970715e-5*x_43 + 1.30115097563198e-6*x_44 - 2.51830392672713e-6*x_45 - 1.40759747446554e-7*x_46 - 1.16826808496057e-5*x_47 + 3.45899331999349e-5*x_48 - 7.93234172451036e-6*x_49 + 8.58880044362814e-8*x_5 - 5.32599305538213e-6*x_50 - 2.02317912672427e-6*x_51 + 1.98496154504259e-5*x_52 + 4.4344584452328e-6*x_53 - 5.35516803538493e-6*x_54 - 2.43840498087667e-6*x_55 + 6.35863401686221e-6*x_56 - 2.60270454554284e-6*x_57 - 7.07479168742894e-6*x_58 + 4.82968231863746e-7*x_59 - 4.6954083133807e-6*x_6 - 5.01797110758892e-6*x_60 - 2.15648198557823e-6*x_61 - 1.11195234536174e-6*x_62 - 3.34235469660473e-6*x_63 + 1.92156066132004e-6*x_64 - 9.39212756699807e-5*x_65 + 1.0703390125775e-6*x_66 - 5.61550968439358e-5*x_67 + 7.23512399918997e-7*x_68 - 9.13944562847472e-6*x_69 - 1.15394187579039e-6*x_7 - 1.98858023870813e-6*x_70 - 9.44176071436753e-6*x_71 - 4.49196782629113e-7*x_72 - 5.26054721904422e-6*x_73 - 2.14575847282164e-5*x_74 - 2.49911147606779e-6*x_75 - 6.26998173681922e-6*x_76 + 3.51962325607745e-6*x_77 - 6.22154941526586e-6*x_78 - 1.90826200047923e-6*x_79 + 6.92643695428332e-6*x_8 + 2.49354402589927e-6*x_80 + 1.4830487310098e-6*x_81 - 6.15495611164327e-6*x_82 - 9.49365882583332e-6*x_83 - 3.87836341975017e-6*x_84 - 1.66185019963433e-6*x_85 + 1.59069993875747e-6*x_86 + 1.05539638140195e-5*x_87 + 3.51691319007803e-6*x_88 + 1.21408125202048e-6*x_89 - 4.86716670538061e-6*x_9 - 5.48721294107999e-6*x_90 + 2.59217494671658e-5*x_91 + 2.63782313087309e-6*x_92 - 0.000130591672288436*x_93 - 2.33504155174329e-6*x_94 + 3.77969215494836e-6*x_95 + 7.08439102454101e-6*x_96 - 1.78993462378185e-5*x_97 - 3.41058752362287e-7*x_98 + 7.88060394888647e-8*x_99 - 0.00131302425745822*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 0.000199258825682619*std::sin(0.217919990420341*x_37 - 7.58752012252808) + 0.000411233538274166*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 5.51318690360705e-5*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 7.84112572428956e-5*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.00214976881570399);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.15559587287503e-5*x_1 - 3.36134717441348e-6*x_10 - 3.15419470430515e-6*x_100 + 8.11093280061371e-6*x_101 + 1.10338418640524e-7*x_102 + 1.45139238385548e-6*x_103 - 8.8960162924307e-6*x_104 + 1.21280636394057e-5*x_105 + 4.42118962656635e-6*x_106 + 9.44606131368327e-6*x_107 + 7.67993804670202e-6*x_108 + 3.68152198837412e-6*x_109 - 4.62140435535235e-7*x_11 + 2.74088591321486e-6*x_110 + 1.02390249548696e-6*x_111 - 6.76814298472202e-7*x_112 - 1.42502027418699e-6*x_113 - 1.0351510271765e-5*x_114 + 8.45101136654861e-7*x_115 + 2.72982130744652e-6*x_116 - 1.18936082440124e-5*x_117 + 4.36591710649211e-6*x_118 - 4.72893979220845e-7*x_119 - 1.2550439249978e-6*x_12 + 4.0047045401078e-6*x_120 - 3.78556925779924e-6*x_13 + 5.21909136102608e-7*x_14 + 2.28325432515302e-6*x_15 - 5.31621965802165e-6*x_16 - 4.21614770739194e-6*x_17 - 4.98077282835801e-7*x_18 - 5.34469866186261e-7*x_19 - 5.53935051766023e-6*x_2 - 1.73967237781099e-6*x_20 - 5.07517065624666e-6*x_21 - 2.01090307747213e-7*x_22 - 2.40371103349852e-7*x_23 + 5.89941375141751e-6*x_24 - 4.95026130938632e-7*x_25 - 5.92317353445182e-7*x_26 - 1.64536360964593e-6*x_27 + 2.9511561995592e-7*x_28 + 2.11389758304103e-6*x_29 - 4.35950454073168e-6*x_3 + 3.24417155216252e-6*x_30 + 1.45329538991208e-5*x_31 + 7.91257841242962e-5*x_32 + 5.37406681778924e-6*x_33 + 3.4691696808094e-5*x_34 + 6.84782464644179e-5*x_35 - 6.45764828348632e-6*x_36 + 7.71431540400387e-7*x_37 - 7.20691262260508e-6*x_38 + 4.67390796351701e-6*x_39 + 5.38877129812884e-6*x_4 + 8.58174629430655e-6*x_40 + 4.06537598686516e-6*x_41 + 1.45428286335487e-5*x_42 + 5.00474690179903e-6*x_43 - 2.92644905534984e-6*x_44 + 5.91766760627206e-6*x_45 + 3.19786210653708e-8*x_46 - 6.65654613120072e-6*x_47 - 1.76842484295258e-6*x_48 - 7.01473513324443e-6*x_49 + 1.45239679542634e-6*x_5 + 3.02431841052101e-6*x_50 + 1.52879146169441e-5*x_51 - 8.68528506880392e-6*x_52 - 3.83571598861377e-6*x_53 + 4.99649542152155e-7*x_54 - 3.48722964850955e-6*x_55 + 6.92317123178994e-6*x_56 - 4.6917950156975e-6*x_57 - 6.9277105520233e-6*x_58 + 2.58550365682258e-6*x_59 - 4.93667351528021e-6*x_6 + 1.18323886117034e-6*x_60 - 3.03353965940555e-6*x_61 - 1.30100595142768e-6*x_62 - 4.78698400925872e-6*x_63 - 2.88256897112595e-6*x_64 - 8.56770628249809e-5*x_65 - 4.67503383884549e-7*x_66 - 4.87885816763606e-5*x_67 + 2.82913189285421e-6*x_68 - 9.88868464968634e-6*x_69 - 4.60546055703735e-8*x_7 - 2.90408488295568e-6*x_70 - 1.08427367327719e-5*x_71 - 1.9305483552688e-7*x_72 - 4.48085274068118e-6*x_73 - 1.49930241754998e-5*x_74 - 7.79714932012329e-6*x_75 - 8.72031824748755e-6*x_76 + 2.75822486831816e-6*x_77 - 4.71670431770535e-6*x_78 + 3.76399887810232e-7*x_79 + 4.93425690804651e-6*x_8 + 1.07603371606857e-6*x_80 - 1.25269472854156e-6*x_81 + 8.43304341597577e-7*x_82 + 9.50598650113556e-6*x_83 - 8.51546702366196e-6*x_84 + 7.55417241169782e-6*x_85 - 3.03831521893336e-6*x_86 - 2.07700782677585e-6*x_87 + 1.70240725619204e-6*x_88 + 4.21535509072056e-8*x_89 + 9.06882174239937e-7*x_9 - 4.59425362793337e-6*x_90 + 8.61654960362263e-5*x_91 - 1.56873006637249e-6*x_92 - 0.000155623845346121*x_93 - 4.29948742366106e-6*x_94 + 1.24731696994834e-6*x_95 - 2.26309498552541e-5*x_96 + 3.76504664614601e-5*x_97 - 7.09802016643866e-6*x_98 - 3.26121586203366e-6*x_99 - 0.0011491034266743*std::sin(0.357919842004776*x_34 + 5.0032000541687) - 0.000724798000426736*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 0.000108459712776737*std::sin(0.289679944515228*x_93 + 1.86895990371704) - 0.000200540519599269*std::sin(0.330319821834564*x_93 - 1.21183979511261) + 0.000285218595793193*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0360869874598302);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.98516031913552e-6*x_1 + 7.15399753078377e-7*x_10 + 1.86176468323177e-6*x_100 + 5.98003556233883e-7*x_101 + 1.71758539643054e-6*x_102 + 1.10209428013906e-6*x_103 + 2.62232554237182e-6*x_104 + 1.19686166046701e-5*x_105 - 1.30301336506381e-6*x_106 + 5.61333236279035e-6*x_107 + 5.61095930455161e-6*x_108 + 1.87310951248346e-6*x_109 + 2.78750841010271e-7*x_11 - 2.1233686531895e-6*x_110 + 7.48168083611476e-6*x_111 - 2.04782145851305e-7*x_112 - 2.83219674950178e-7*x_113 - 8.69913403906952e-6*x_114 - 4.09831882641914e-6*x_115 + 4.10910934286406e-6*x_116 - 9.29196197468729e-6*x_117 + 2.91589751288004e-6*x_118 - 1.76757583453039e-6*x_119 - 2.31720769755928e-6*x_12 + 3.97868449002191e-6*x_120 - 3.11882152613565e-6*x_13 - 3.30593245943386e-6*x_14 + 2.80906904031893e-6*x_15 - 1.42757662897266e-6*x_16 - 5.65885226450238e-6*x_17 - 1.28909516891222e-6*x_18 - 3.24621042373872e-7*x_19 - 3.77672317026889e-6*x_2 - 2.08530087681617e-7*x_20 - 5.03103058395159e-6*x_21 + 3.5012953479345e-7*x_22 - 6.05126980664793e-7*x_23 + 6.30797801334973e-6*x_24 + 4.13805423842349e-7*x_25 + 2.34065468922119e-6*x_26 - 2.03974121759457e-6*x_27 - 1.54335738366351e-6*x_28 + 9.71331254466878e-7*x_29 - 3.54521824568026e-6*x_3 + 1.40493944143501e-6*x_30 - 1.44250941513918e-5*x_31 + 7.23245497715762e-5*x_32 + 3.52690075486614e-6*x_33 - 4.10858265048895e-6*x_34 + 7.83109086824956e-5*x_35 + 1.65075922458368e-5*x_36 - 6.35476551265032e-6*x_37 - 2.6313670516644e-7*x_38 + 2.20159756031104e-6*x_39 + 5.06233701067529e-6*x_4 + 7.07842175114047e-6*x_40 + 1.51003671649486e-6*x_41 - 3.37019803692974e-6*x_42 + 4.20528320899174e-7*x_43 - 2.62935081793278e-6*x_44 + 3.17247286426564e-6*x_45 - 5.83413097568805e-7*x_46 - 7.6641941314202e-6*x_47 + 2.09698725772324e-5*x_48 - 3.55517029155175e-6*x_49 - 1.00449964106038e-6*x_5 + 1.45376087061723e-6*x_50 + 1.50415850654942e-6*x_51 - 4.58529552090126e-6*x_52 + 1.67252297509611e-6*x_53 - 3.77892657136149e-6*x_54 - 2.88861615569979e-6*x_55 + 4.86870222131615e-6*x_56 - 1.75778216426099e-6*x_57 - 6.23309918962601e-6*x_58 + 8.48366327342875e-7*x_59 - 3.18280685072678e-6*x_6 + 3.02486062949694e-6*x_60 - 3.99854045891194e-6*x_61 - 6.79985811112891e-7*x_62 - 3.56705207866863e-6*x_63 + 4.63507947973521e-7*x_64 - 7.42924236604952e-5*x_65 + 5.99290359857509e-7*x_66 - 4.25673515151555e-5*x_67 + 2.43542940279369e-6*x_68 - 6.69039738706656e-6*x_69 + 8.10558755291694e-7*x_7 - 1.86159677164171e-6*x_70 - 9.4054055035557e-6*x_71 - 1.78544526391218e-6*x_72 - 4.0274687588267e-6*x_73 - 1.54086938553218e-5*x_74 - 5.24551738990679e-6*x_75 - 4.22376086302325e-6*x_76 + 2.24686852244523e-6*x_77 - 4.8050080147808e-6*x_78 - 4.09687119238227e-7*x_79 + 5.96702584562328e-6*x_8 + 9.41079986934736e-7*x_80 + 4.90175898571775e-7*x_81 - 4.59786447058824e-6*x_82 - 3.12755602288251e-6*x_83 - 4.88049648835325e-6*x_84 + 1.18947392558311e-6*x_85 + 9.82362765329839e-7*x_86 + 2.44600526708411e-8*x_87 + 1.52009390353935e-6*x_88 + 1.01191167743983e-6*x_89 - 1.49088750213098e-6*x_9 - 3.89058976127532e-6*x_90 + 3.65840260877451e-5*x_91 + 4.20996179574333e-6*x_92 - 0.000100329663428892*x_93 - 1.19358104283259e-7*x_94 + 2.23548016384466e-6*x_95 + 4.08895181402786e-7*x_96 - 3.10448181573713e-6*x_97 - 2.72344432226164e-6*x_98 - 1.01256482817678e-6*x_99 - 0.00101408544352263*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 2.21841154062817e-5*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 4.6868904085293e-5*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 6.13800538606144e-6*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 8.72977331803961e-6*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0132513811610547);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.08345290673598e-6*x_1 - 1.50093064051032e-7*x_10 + 4.95067743616864e-7*x_100 + 1.66931333319415e-7*x_101 + 1.7163977025483e-6*x_102 + 8.1336883979952e-7*x_103 + 3.21187564723734e-6*x_104 + 1.03235904383968e-5*x_105 - 1.37362480536271e-6*x_106 + 4.27189341234904e-6*x_107 + 5.81294482962985e-6*x_108 + 5.8573837838868e-7*x_109 - 4.33178588022583e-7*x_11 + 1.68255518772735e-6*x_110 + 9.22905883416486e-6*x_111 + 1.09957329669151e-6*x_112 - 3.15729303608637e-7*x_113 - 7.32114247332442e-6*x_114 - 1.96785985115325e-6*x_115 + 4.06337609960869e-6*x_116 - 8.95482110729973e-6*x_117 + 3.11394687265546e-6*x_118 - 5.28440759298153e-7*x_119 - 1.68021614163277e-6*x_12 + 3.59139221007408e-6*x_120 - 2.54568654556235e-6*x_13 - 3.03940589650338e-7*x_14 + 2.31619080750886e-6*x_15 - 2.3363692484913e-6*x_16 - 3.40190642544832e-6*x_17 - 6.24364441436163e-7*x_18 - 3.64080870342386e-7*x_19 - 2.20581078566199e-6*x_2 + 6.14775924125378e-7*x_20 - 4.22080591628496e-6*x_21 + 2.72623509653016e-7*x_22 - 2.26468469997172e-7*x_23 + 5.45926768336955e-6*x_24 - 1.276186854905e-7*x_25 + 1.60307742353988e-6*x_26 - 7.7735647416498e-7*x_27 + 7.26328073017743e-7*x_28 + 1.17944846050459e-6*x_29 - 2.67083022648324e-6*x_3 + 2.34882617425915e-6*x_30 + 1.98478917919689e-5*x_31 + 6.34039917364632e-5*x_32 + 3.610012975427e-6*x_33 - 1.21264400682096e-5*x_34 + 5.29723609440458e-5*x_35 - 1.82678382673976e-6*x_36 - 1.51214529134475e-7*x_37 + 1.19051003262127e-6*x_38 + 3.49951850009513e-6*x_39 + 4.58212370916582e-6*x_4 + 6.92425609006182e-6*x_40 + 2.81037969080151e-6*x_41 - 2.59029543924045e-6*x_42 + 3.40316057187796e-6*x_43 - 2.23145926349359e-6*x_44 + 4.26508415731316e-6*x_45 - 1.03426580889275e-7*x_46 - 5.01513641356096e-6*x_47 + 1.09681775215037e-6*x_48 - 5.1742597990173e-6*x_49 - 9.21942577055947e-7*x_5 + 1.30788159992654e-6*x_50 - 1.20066308789899e-6*x_51 - 6.34155237614002e-6*x_52 - 2.05614698507489e-7*x_53 - 1.0581535584844e-6*x_54 - 2.84161472192839e-6*x_55 + 3.69237943604341e-6*x_56 - 1.47999432845438e-6*x_57 - 5.76430209650878e-6*x_58 + 8.91122560201893e-7*x_59 - 2.98118582958123e-6*x_6 + 2.23608040539412e-6*x_60 - 1.00576044308112e-6*x_61 - 8.75626625024465e-7*x_62 - 3.03437585927564e-6*x_63 - 2.08261652550458e-7*x_64 - 6.67343525046128e-5*x_65 - 3.49748170671338e-7*x_66 - 3.84321670143111e-5*x_67 + 1.18073041712776e-6*x_68 - 6.27327297597882e-6*x_69 + 4.4619597078312e-7*x_7 - 2.34623269818934e-6*x_70 - 8.65490706014156e-6*x_71 - 1.15397921595833e-6*x_72 - 3.46780206365531e-6*x_73 - 1.26840583168281e-5*x_74 - 6.16951263576008e-6*x_75 - 6.53258056201728e-6*x_76 + 1.9522916475797e-6*x_77 - 3.97502066201088e-6*x_78 + 4.75257197438899e-8*x_79 + 4.81516923859442e-6*x_8 + 1.20544903375093e-6*x_80 + 6.61033514441575e-7*x_81 + 2.43794420157443e-7*x_82 - 2.3910608257183e-6*x_83 - 5.81953091903076e-6*x_84 + 1.08506775810472e-6*x_85 + 3.0120216755771e-7*x_86 - 1.11122675434059e-6*x_87 + 9.88717888154918e-7*x_88 + 3.30150154881483e-7*x_89 - 1.60816573708949e-6*x_9 - 3.44392348971529e-6*x_90 + 4.06129027276162e-5*x_91 - 1.02770637814428e-6*x_92 - 0.000117737515642046*x_93 - 3.37509522696684e-6*x_94 + 2.7936018282159e-6*x_95 + 5.1872594525465e-6*x_96 - 6.33631888277631e-6*x_97 - 2.6184903981742e-6*x_98 + 4.3333305401266e-7*x_99 - 0.000905248397967429*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 0.000113644983713409*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 7.65390080294313e-5*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 3.14438285844045e-5*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 4.47209603980621e-5*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.026203771318877);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.89213724617168e-5*x_1 - 2.35511468177509e-6*x_10 - 7.69526589425647e-7*x_100 + 3.89047177444141e-6*x_101 - 1.12676366817839e-7*x_102 - 6.9808419153644e-7*x_103 - 3.90095796806212e-6*x_104 - 1.0399751674113e-6*x_105 + 2.92983259181536e-6*x_106 + 1.32473397714884e-6*x_107 - 9.03569691839065e-7*x_108 + 2.76876511328158e-6*x_109 + 5.30895728688775e-7*x_11 - 8.0018518195711e-7*x_110 - 1.39895304811023e-6*x_111 - 1.51598475195288e-6*x_112 + 2.58536928791704e-6*x_113 - 1.70654039763072e-6*x_114 + 3.65946924918937e-6*x_115 - 1.73159581474798e-7*x_116 - 2.49725977880594e-7*x_117 - 3.08389764382259e-7*x_118 + 6.89739300017401e-7*x_119 + 1.55676596715907e-6*x_12 + 3.31475147061263e-7*x_120 + 5.13365910201879e-7*x_13 - 2.79411746461107e-7*x_14 - 1.19786882220661e-6*x_15 + 6.01999284489422e-6*x_16 + 1.01527804173592e-6*x_17 + 8.14002102760729e-7*x_18 - 2.57249726632636e-7*x_19 + 9.98771968702583e-7*x_2 + 8.11508425837725e-8*x_20 - 4.53560638883872e-7*x_21 + 6.68819119558335e-7*x_22 + 1.13148566789401e-6*x_23 + 5.01183613673603e-7*x_24 - 1.45290554998873e-7*x_25 - 3.18780487605912e-6*x_26 - 7.93776005108859e-7*x_27 - 4.97646627245275e-7*x_28 + 1.20642365663688e-7*x_29 - 8.48714934558552e-7*x_3 + 2.02792210465653e-6*x_30 - 2.31663106441832e-5*x_31 + 3.14516390833214e-6*x_32 - 4.79535072416059e-8*x_33 + 2.71369532873891e-5*x_34 - 1.59874649969202e-5*x_35 - 1.33632579604577e-6*x_36 + 1.36436515028334e-6*x_37 - 2.15496899916615e-6*x_38 - 3.3374158025147e-6*x_39 - 8.36155449964395e-7*x_4 + 1.36600006677048e-6*x_40 - 2.07367562047244e-7*x_41 + 7.78050818844075e-6*x_42 - 5.40296592672004e-6*x_43 + 1.43041683180065e-6*x_44 - 1.33814036172487e-6*x_45 + 3.70381695182257e-7*x_46 - 1.21020310767718e-6*x_47 + 3.19301314359019e-6*x_48 - 9.01078092772053e-7*x_49 + 1.43331066956915e-6*x_5 - 1.78629275041407e-6*x_50 + 4.28098591764235e-6*x_51 + 8.02824410607385e-6*x_52 - 5.19967459495686e-7*x_53 + 1.76302650746385e-7*x_54 + 8.37946638451686e-7*x_55 + 1.02143795162511e-6*x_56 - 1.53954273562997e-6*x_57 - 3.91188692067139e-7*x_58 + 1.23483555794e-6*x_59 - 9.39134749023904e-7*x_6 - 3.70061860765095e-6*x_60 + 2.3178862633217e-6*x_61 - 2.10822896868525e-7*x_62 + 8.19555622420424e-8*x_63 + 8.83243212323604e-8*x_64 - 2.92392734425148e-6*x_65 + 2.76153148229089e-7*x_66 - 3.53071916659582e-6*x_67 - 2.61099620596246e-6*x_68 - 1.58960237343062e-6*x_69 - 1.73488210008806e-6*x_7 + 2.72453363049265e-7*x_70 + 5.51587492227566e-7*x_71 + 7.19277377420294e-7*x_72 - 1.19448107944335e-7*x_73 - 5.60360358489437e-7*x_74 + 1.214407054751e-6*x_75 - 3.44222322543392e-6*x_76 + 5.38172012208096e-7*x_77 + 9.75305142514803e-8*x_78 - 9.84350103945822e-7*x_79 - 6.35725609252353e-7*x_8 + 1.19266233289531e-6*x_80 - 4.25518172880449e-7*x_81 - 6.68633012675282e-7*x_82 + 2.46418970325064e-6*x_83 + 2.52400683724714e-7*x_84 + 1.90468980162867e-6*x_85 - 1.8054308302491e-6*x_86 + 3.04793071404758e-6*x_87 + 2.85833785530848e-7*x_88 - 1.02722836957725e-6*x_89 + 1.21414885734604e-8*x_9 - 3.20039698685194e-7*x_90 + 3.06261708755516e-5*x_91 - 7.09768699719887e-6*x_92 - 1.35797313819033e-5*x_93 - 4.91641809190535e-6*x_94 + 5.37929195931839e-7*x_95 - 9.45973567690277e-6*x_96 + 1.27215012286496e-5*x_97 - 1.02749824588251e-6*x_98 - 2.0908245823983e-7*x_99 - 4.03760286819214e-5*std::sin(0.357919842004776*x_34 + 5.0032000541687) - 0.000284939081933833*std::sin(0.217919990420341*x_37 - 7.58752012252808) + 0.000159038509587308*std::sin(0.289679944515228*x_93 + 1.86895990371704) - 7.88382853036384e-5*std::sin(0.330319821834564*x_93 - 1.21183979511261) + 0.000112127689077399*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0495202594008603);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.04813873188689e-5*x_1 - 3.03369072892082e-7*x_10 + 3.9735179801085e-6*x_100 - 5.49414653971526e-6*x_101 - 1.43597267741065e-6*x_102 - 4.71142284571699e-6*x_103 + 7.21206729264078e-6*x_104 - 1.03357391278233e-5*x_105 - 1.45979005277363e-6*x_106 - 8.04468908994527e-6*x_107 - 1.67035751423751e-6*x_108 - 3.95768634309353e-6*x_109 + 1.3557301643422e-6*x_11 - 3.2786446448322e-7*x_110 + 1.53471600281735e-6*x_111 - 4.82336640485227e-7*x_112 + 6.77739303582009e-6*x_113 + 1.09113607684838e-5*x_114 - 2.52440231308539e-6*x_115 - 2.44216141036706e-6*x_116 + 9.0627953977832e-6*x_117 - 3.9628252432296e-6*x_118 - 4.07340865068327e-6*x_119 + 2.19998343845502e-6*x_12 - 2.15723773472887e-6*x_120 + 5.62364784063721e-6*x_13 - 3.68908348938331e-6*x_14 - 2.33680669034924e-6*x_15 - 4.08732605957815e-6*x_16 + 4.40771171627808e-6*x_17 + 7.08266262787303e-7*x_18 + 3.67689159706474e-7*x_19 + 7.34173044736623e-6*x_2 + 3.63101253076557e-6*x_20 + 4.53588648150009e-6*x_21 - 3.62030562593904e-7*x_22 + 1.03667054846489e-6*x_23 - 5.82338744162178e-6*x_24 + 3.10794584937104e-7*x_25 - 3.61734051165841e-6*x_26 + 2.4175142500485e-7*x_27 - 6.38905184778588e-7*x_28 - 4.38377353237808e-7*x_29 + 6.82148351949069e-6*x_3 + 4.07791387571493e-7*x_30 - 3.42761838228409e-5*x_31 - 6.12585326633664e-5*x_32 - 6.48008720776513e-6*x_33 - 4.58873498008849e-5*x_34 - 0.000103433078151771*x_35 + 2.57175502344263e-5*x_36 + 6.37995451479725e-6*x_37 + 4.81809303440818e-6*x_38 - 7.93584179964437e-7*x_39 - 6.37824456768826e-6*x_4 - 9.24418289211278e-6*x_40 + 4.71120810695538e-7*x_41 - 4.00257040998944e-6*x_42 - 1.3361768203008e-6*x_43 - 7.56936987022088e-7*x_44 + 3.83150202615402e-7*x_45 - 2.97718979212207e-7*x_46 + 4.46678124098526e-6*x_47 + 1.15803027304441e-5*x_48 + 1.04307730390567e-5*x_49 - 2.34692106983609e-6*x_5 + 2.10309145429358e-6*x_50 - 1.30292454880179e-5*x_51 - 8.46584766221285e-6*x_52 + 3.20454248263944e-6*x_53 - 2.52455344295298e-6*x_54 + 3.49585078816126e-6*x_55 - 5.42951940737786e-6*x_56 + 3.28650407521048e-6*x_57 + 2.79306930760113e-6*x_58 + 7.72004910567264e-7*x_59 + 3.8467995830576e-6*x_6 + 4.58216011392477e-6*x_60 + 5.85194961214292e-6*x_61 + 1.23312593239337e-6*x_62 + 3.41612866816312e-6*x_63 + 4.15984319712159e-6*x_64 + 6.36374737904786e-5*x_65 + 1.24293402053998e-6*x_66 + 3.36888938325039e-5*x_67 - 7.81273845301673e-6*x_68 + 7.02603692222311e-6*x_69 - 8.29528681009534e-7*x_7 + 2.93908610414472e-6*x_70 + 6.61634372696792e-6*x_71 - 2.48843975115501e-6*x_72 + 3.67323556392016e-6*x_73 + 1.20322325494605e-5*x_74 + 4.14699056715364e-6*x_75 + 2.83319763074477e-8*x_76 - 2.0751018451489e-6*x_77 + 3.88786532033987e-6*x_78 - 1.71340361409691e-6*x_79 - 3.2783527656614e-6*x_8 + 1.0626536491193e-6*x_80 + 8.38606146954051e-7*x_81 - 5.27292244151654e-6*x_82 - 7.29430309410652e-6*x_83 + 6.2932678428607e-6*x_84 - 2.98149320330865e-6*x_85 + 9.92704933402421e-7*x_86 - 4.84924213605881e-6*x_87 - 3.57342129168619e-6*x_88 - 2.36433311886586e-6*x_89 + 6.24061689018824e-7*x_9 + 4.04533552885202e-6*x_90 + 9.73947147941737e-6*x_91 - 1.36189107418167e-5*x_92 + 0.000116363880688032*x_93 - 6.45438556656127e-6*x_94 + 1.59649230228385e-6*x_95 + 1.32064695102625e-5*x_96 - 2.50014105824341e-5*x_97 + 2.45355902485051e-6*x_98 + 3.98367570603775e-6*x_99 + 0.000882112428661216*std::sin(0.357919842004776*x_34 + 5.0032000541687) + 0.000491963287391371*std::sin(0.217919990420341*x_37 - 7.58752012252808) - 0.000164642068670319*std::sin(0.289679944515228*x_93 + 1.86895990371704) + 0.000136118716137659*std::sin(0.330319821834564*x_93 - 1.21183979511261) - 0.000193594736642424*std::sin(0.349919855594635*x_94 - 4.40439987182617) + 0.0460774733958099);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
