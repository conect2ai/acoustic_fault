
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00337005294995519*x_1 + 0.00453176212314013*x_10 - 0.00305303382561754*x_100 - 0.000242639149986107*x_101 - 0.00104686574423846*x_102 - 0.000139260504127068*x_103 - 0.00140614794761339*x_104 + 0.000301924169072067*x_105 - 0.000564891517373802*x_106 - 0.000322074164632054*x_107 + 0.00220995641608785*x_108 + 0.000326074970615499*x_109 + 0.00193881034176643*x_11 + 0.00148517583391169*x_110 - 0.000132898552719875*x_111 + 0.000721399392507687*x_112 + 0.000608285798999947*x_113 + 0.000471399193661193*x_114 - 0.000287293788032775*x_115 - 0.000565163149697835*x_116 - 6.05263256486206e-5*x_117 + 0.000638092378597909*x_118 - 0.000330364511065127*x_119 + 0.000983880685336462*x_12 + 5.57273234854496e-5*x_120 + 0.00060714912547255*x_13 + 0.00111220652181831*x_14 - 0.00168504306905201*x_15 + 0.00177097816781842*x_16 + 0.00263275021837361*x_17 + 0.000655748658740115*x_18 - 0.0019155396888706*x_19 + 0.00202900393651445*x_2 - 0.00186294007799233*x_20 - 0.00123940980462553*x_21 + 0.00153700198241263*x_22 + 0.000663348113650552*x_23 - 0.000208931373942063*x_24 - 0.00362394261276506*x_25 - 0.000196896234650909*x_26 + 0.000498948007832201*x_27 - 0.000439944488799747*x_28 + 0.00156321962647462*x_29 - 0.00208845379851049*x_3 + 0.000349254956988065*x_30 - 0.00200488640719563*x_31 - 0.0033831445359595*x_32 - 0.00211797510947407*x_33 + 1.1588603950173e-5*x_34 + 9.44845714056085e-5*x_35 - 1.79974826794335e-5*x_36 + 7.76895379704008e-5*x_37 - 0.000295545808273824*x_38 - 0.000301415741709963*x_39 - 0.00450445809511536*x_4 - 0.000921528457129468*x_40 - 0.0014678952077228*x_41 + 0.000291040222008518*x_42 - 0.000104356316242211*x_43 + 0.000421416174220666*x_44 + 0.0012085631952604*x_45 + 0.0011972882764158*x_46 - 0.000318196761143813*x_47 + 0.000137552527813341*x_48 + 0.0010205404470513*x_49 - 0.00152991386776994*x_5 + 0.000246238212092287*x_50 + 0.000222731339049669*x_51 - 0.00313071941939617*x_52 + 0.000125835468351037*x_53 + 2.73580924538542e-5*x_54 + 0.000685423063737552*x_55 - 0.000229417497189648*x_56 - 0.000392850690541501*x_57 - 0.000254826877214481*x_58 + 0.000176290741478902*x_59 - 2.17569835069413e-5*x_6 + 3.11053695162534e-5*x_60 + 0.000187354684671056*x_61 + 0.0016377885605728*x_62 + 0.00128260816362228*x_63 - 0.00110404535265862*x_64 + 5.24003957875325e-5*x_65 + 0.000213909932867681*x_66 - 1.96379799977269e-5*x_67 - 0.000942416746288676*x_68 - 0.000376571680950251*x_69 - 1.20862831028328e-5*x_7 + 0.000398383319920275*x_70 - 0.000916923834516056*x_71 + 0.000635086126234502*x_72 - 0.000813806060125924*x_73 - 0.000231556096977513*x_74 + 0.000752249219556581*x_75 - 0.000651030311003685*x_76 - 0.000409143028207527*x_77 - 0.00109202338470428*x_78 - 0.000183383391653428*x_79 - 0.00207573187477495*x_8 + 0.000114335542076587*x_80 + 6.21589274045267e-5*x_81 - 4.23009307639526e-5*x_82 + 0.000172097350099583*x_83 + 0.00140297901017683*x_84 + 0.000205558597418802*x_85 + 0.000384743378562027*x_86 + 0.00044857991369543*x_87 + 0.00031563791607746*x_88 - 2.68905066837047e-5*x_89 - 0.00146195276479132*x_9 + 0.00078368727642689*x_90 + 0.00350904408386858*x_91 - 0.00279883959726844*x_92 - 0.00113872560487741*x_93 - 0.000596546711438564*x_94 + 0.000212126877918009*x_95 + 0.000888644679172109*x_96 - 0.000188797429052046*x_97 - 0.000132028910388773*x_98 + 0.00010768783647366*x_99 + 7.11065460457027e-6*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 7.18703253034296e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 1.19171067428863e-6*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 1.43593822706e-6*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) + 2.93888606830247e-7*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) + 5.38647848315817e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 1.4121709935672e-6*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 3.16585916796997e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 4.24528374267777e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) - 3.27180749161708e-5*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 7.44537214671206e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 1.70738602349241e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) + 2.33856901413579e-6*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) + 1.17270882604013e-5*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 3.85013986644942e-5*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 1.60281640970977e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 1.52856004133273e-5*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) - 0.0001061435556241*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 1.55606618587348e-7*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 5.30473681376666e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 2.70203299765167e-5*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) - 1.98809080013443e-5*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 4.66863438023699e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 2.5059051154256e-6*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 1.24732638303629e-5*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 7.29709268191068e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 6.9726545801779e-6*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) - 3.26648990394465e-5*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) - 6.60869714101582e-7*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) - 4.50244439235964e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) + 1.56441617357977e-6*std::pow(-6.0*x_54 - 10.0, 2) - 5.27619125325827e-8*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) - 4.17368994803553e-7*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 1.33902011079584e-5*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) - 4.5527989836611e-7*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) - 1.0995337045533e-6*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) - 1.71110642644365e-7*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) - 4.68309563847737e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 9.08984653970578e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) - 1.55024116831606e-5*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 7.52937772271815e-7*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) + 7.6738903475338e-7*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 7.0767469308245e-7*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) - 1.60312350345831e-5*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) - 2.51928809538331e-6*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 1.50999085773371e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) - 4.63393730928499e-6*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 7.02215096077971e-6*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) - 2.62924892087831e-5*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) - 4.21103363541819e-6*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) + 4.92771887549062e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) - 5.31994531543415e-7*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) + 4.28376895204095e-6*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 5.60438868559503e-6*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) - 1.23310283044739e-6*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) - 5.54744986154812e-7*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) + 9.50967007003355e-6*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) - 3.3096791764505e-6*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 1.42866299984461e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) - 7.1046983630449e-8*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 7.00585507255043e-7*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 7.55353816718855e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) - 3.89954331116931e-7*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) - 2.9625571166682e-7*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 1.98655557700147e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 3.70525635968906e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 2.25421335554818e-6*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 1.99384293139597e-5*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) + 8.68438528217549e-6*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) - 1.66445226009883e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 4.55490633170291e-7*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) + 0.000232922751371394*std::exp(0.523359894752502*x_117) + 0.000286443215303742*std::exp(1.36367988586426*x_17) + 0.000219379634849594*std::exp(0.873679876327515*x_29) + 8.50314689136819e-6*std::exp(0.669199824333191*x_71) + 2.11467668724396e-5*std::exp(0.698639869689941*x_71) + 0.00130495017089717*std::exp(0.633919835090637*x_72) - 3.96834315006086e-5*std::exp(0.662319839000702*x_72) - 0.000206635384514009*std::exp(0.661519825458527*x_73) + 3.04508845431684e-6*std::exp(0.936639785766602*x_81) - 0.000112215308756352*std::exp(0.557839810848236*x_84) + 1.4058008717297e-5*std::exp(0.783999860286713*x_87) - 0.000167358619503782*std::exp(0.646719813346863*x_90) + 0.00373902098904205*std::sin(0.192880004644394*x_1 + 8.19839954376221) + 0.000768357503560927*std::sin(0.297999948263168*x_1 - 7.60376024246216) + 0.000176820995954781*std::sin(1.06031978130341*x_1 - 9.03824043273926) - 0.0142377566783778*std::sin(0.296639919281006*x_10 + 8.33568000793457) + 0.0133473389422086*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.00874455664452085*std::sin(0.349039852619171*x_10 + 2.1275999546051) + 0.000663610617721228*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.00441412320945402*std::sin(0.291599929332733*x_102 - 7.51024007797241) + 0.0011044326671948*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.00603710303079287*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.0138422058741012*std::sin(0.229759991168976*x_103 - 7.57151985168457) + 0.00149085356509383*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 4.89161133821147e-5*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 0.00533035302972328*std::sin(0.356399834156036*x_104 - 1.21031987667084) + 0.00115527845545185*std::sin(0.303839921951294*x_105 - 7.50559997558594) + 0.00561185499683621*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.000463575894115705*std::sin(0.357039839029312*x_105 + 1.9761598110199) - 0.00798729394198517*std::sin(0.284959942102432*x_106 + 5.08791971206665) + 0.00592819554783983*std::sin(0.319679945707321*x_106 - 7.47704029083252) - 0.0120168363932979*std::sin(0.391679853200912*x_106 - 7.40991973876953) + 0.000571004875498523*std::sin(0.287759929895401*x_107 - 7.49671983718872) + 0.00277421429621923*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.00318832987510015*std::sin(0.401439845561981*x_107 + 5.19271993637085) + 0.000243081663897801*std::sin(0.330799847841263*x_108 + 4.96007966995239) - 0.000457109391390063*std::sin(0.296799927949905*x_109 + 1.88975989818573) + 0.00523902391132792*std::sin(0.345119833946228*x_109 - 1.21783995628357) - 0.006778952462095*std::sin(0.250399976968765*x_11 - 1.1360799074173) + 0.000926806570001003*std::sin(0.26063996553421*x_11 + 8.29399967193604) + 0.00915588582532615*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.0307336475261578*std::sin(0.282399952411652*x_11 + 8.30943965911865) + 0.000448326786460865*std::sin(0.335919857025146*x_111 - 1.24431991577148) - 0.0099326944693145*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 3.86871652125547e-5*std::sin(0.333999842405319*x_112 + 8.17199993133545) + 0.00181920364626676*std::sin(0.378399848937988*x_112 - 1.21479988098145) - 0.00462056848889735*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.00885435740445052*std::sin(0.328399837017059*x_114 - 7.44743967056274) - 0.00553931657140597*std::sin(0.309359937906265*x_115 - 7.49728012084961) + 0.000132196587464304*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.00656402727652136*std::sin(0.35607984662056*x_115 - 7.43911981582642) - 0.00280590064194395*std::sin(0.609919846057892*x_116 + 1.98527979850769) - 0.0217947550493051*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.000705718457892533*std::sin(0.303839921951294*x_117 - 7.50871992111206) - 0.00727116982387688*std::sin(0.403199851512909*x_119 - 1.18383979797363) - 0.00157852062993742*std::sin(0.296079933643341*x_12 + 5.11951971054077) - 0.0037657691330862*std::sin(0.300559937953949*x_12 + 8.32791996002197) - 0.000327300822907541*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 2.58991187383324e-5*std::sin(0.454639852046967*x_120 - 1.17119991779327) - 0.0331680707949655*std::sin(0.23055998980999*x_13 - 4.35663986206055) - 3.82368286825439e-5*std::sin(1.31927990913391*x_13 + 1.20903992652893) - 0.0119348773959032*std::sin(0.249839976429939*x_14 + 8.26024055480957) - 0.00106422706069004*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.0635233993066426*std::sin(0.202800005674362*x_15 - 4.3919997215271) - 0.0128123696186436*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 0.0110899449582177*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.00829430943048158*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.000538752682171892*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.0067405775832413*std::sin(0.34215983748436*x_16 - 7.24799966812134) + 0.000729956942868198*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.0217393475986959*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.00529520469703165*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0606630886161741*std::sin(0.19072000682354*x_18 + 4.97863960266113) - 2.70455278633542e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 3.43161338763708e-6*std::sin(1.75519990921021*x_2 + 3.0064799785614) + 0.00953972807665678*std::sin(0.284399926662445*x_21 - 4.31175994873047) - 0.0164316912009864*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 0.00886841196180513*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.0433481555831167*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.0317812890506621*std::sin(0.305279940366745*x_23 + 5.12815999984741) - 0.00201233430610513*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.000930851833481656*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.0243672890359985*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.0230333069957876*std::sin(0.334719836711884*x_24 + 5.11863994598389) - 0.00183251393043006*std::sin(0.338799834251404*x_24 - 4.25447988510132) + 0.0100758496437604*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.0101610271181708*std::sin(0.368879854679108*x_24 - 1.02383983135223) - 0.00724918570118177*std::sin(0.381999850273132*x_24 + 8.38024044036865) + 0.00759366008047369*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.00170585075326399*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 0.000519549162586827*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.0266568231612591*std::sin(0.334959834814072*x_26 - 4.26191997528076) - 0.00356968761430005*std::sin(0.423199862241745*x_26 + 2.22815990447998) + 0.0033927454403122*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.0364476908624794*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 7.29400393340412e-5*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 0.00723346563941921*std::sin(0.364719837903976*x_27 - 4.22952032089233) + 0.00839790813189806*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.0162378815467542*std::sin(0.270719945430756*x_28 - 7.51624011993408) - 0.0146512444388381*std::sin(0.271519958972931*x_28 - 1.10407996177673) + 0.000989410132745292*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.0115058300519419*std::sin(0.3574398458004*x_28 - 1.04567980766296) + 0.00101865819765338*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.000714499479370852*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 0.0080097636105063*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.00390521553622783*std::sin(0.302559942007065*x_3 - 4.27119970321655) - 0.0164947450705184*std::sin(0.31007993221283*x_3 - 4.25759983062744) + 0.0217622373896698*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.00942864302689587*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.0126557940814276*std::sin(0.339759826660156*x_3 - 1.05527985095978) + 0.00621706729376103*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.000342380936249862*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.00657415145947122*std::sin(0.258879989385605*x_30 - 1.12431991100311) - 0.000922906623498383*std::sin(0.282159924507141*x_30 + 8.27752017974854) - 0.00038958717357387*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 0.000103139235408154*std::sin(1.7519998550415*x_30 - 9.99600028991699) + 0.0134823751581773*std::sin(0.232399985194206*x_33 - 4.37471961975098) - 0.00413803512468945*std::sin(0.247519969940186*x_33 - 1.18367981910706) + 0.000898792653004988*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.00704632815421472*std::sin(0.295999944210052*x_34 - 1.14071989059448) - 0.011147180592587*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.00615881719459842*std::sin(0.351599842309952*x_34 + 8.19431972503662) - 0.00348736036653238*std::sin(0.390399843454361*x_34 + 1.79423987865448) + 0.00452273800988213*std::sin(0.282239943742752*x_35 + 8.25271987915039) - 0.00265528924181644*std::sin(0.30447992682457*x_35 - 4.34575986862183) + 0.0037770073274614*std::sin(0.343759834766388*x_35 + 8.19143962860107) - 5.80601193647172e-5*std::sin(0.207520008087158*x_36 - 4.396559715271) - 0.000712217946032093*std::sin(0.302719831466675*x_37 + 8.13655948638916) - 0.00394470785178595*std::sin(0.323999851942062*x_38 - 7.47088003158569) - 0.00038405065451484*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.00671984940025626*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 0.00137264342091258*std::sin(0.213359996676445*x_40 + 5.00423955917358) - 0.0082919205915028*std::sin(0.229039996862411*x_41 + 5.02951955795288) + 0.00046764826828536*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.00327798447861171*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.00973318274013956*std::sin(0.244239971041679*x_42 + 5.06047964096069) - 0.000164952172187991*std::sin(0.308959931135178*x_42 - 7.50464010238647) - 0.000504688066944143*std::sin(0.351759850978851*x_43 - 7.43048000335693) + 0.00552939384889338*std::sin(0.357199847698212*x_44 - 4.25239992141724) - 0.0285344713660115*std::sin(0.157600030303001*x_45 - 4.46623992919922) - 0.00534015936636388*std::sin(0.233679980039597*x_45 + 1.83839988708496) - 0.00373497327754111*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.00604283628280249*std::sin(0.321759849786758*x_45 - 4.27936029434204) + 0.00159097516182226*std::sin(0.32415983080864*x_45 + 1.94247984886169) + 0.00690222892734858*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.00565633208555126*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.00585299732748863*std::sin(0.209200009703636*x_46 + 5.00407981872559) - 0.00596439900477123*std::sin(0.221759989857674*x_47 + 1.82455992698669) + 0.000750937904571812*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.0192074995015392*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 5.1708569305433e-5*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.00259887220950198*std::sin(0.452239871025085*x_48 - 1.14887976646423) + 0.0528951272031877*std::sin(0.145920038223267*x_49 + 4.93440008163452) + 0.00980420610732243*std::sin(0.247039973735809*x_49 - 4.34455966949463) + 0.000332042761232457*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 1.66333843418572e-6*std::sin(0.8711998462677*x_5 - 3.34791970252991) - 0.00893858004206815*std::sin(0.200879991054535*x_51 - 7.59600019454956) + 0.00585621999743546*std::sin(0.299919933080673*x_51 + 5.09696006774902) + 0.000729675058451423*std::sin(0.346159845590591*x_51 + 5.14703989028931) + 0.000809120035721376*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 0.00609205933566342*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 0.000606044381102522*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.00370390113270516*std::sin(0.371679842472076*x_54 - 1.22119987010956) - 0.0131465731775355*std::sin(0.192479997873306*x_55 + 4.99200010299683) + 0.00689536886283571*std::sin(0.246559977531433*x_55 - 7.53864002227783) - 0.00616501415640788*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.0123922001700724*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.00562910879152152*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.0199982452669471*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.00748160770330867*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 0.00481381637268611*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.0637420564377122*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.0104040330959789*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.0237775105168554*std::sin(0.193120002746582*x_65 + 4.99616003036499) - 0.00114195994704896*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.029517890104476*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 0.000145931206338251*std::sin(1.35967981815338*x_67 + 6.00071954727173) + 0.00196149192734682*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.000194688946945293*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.00142560729930956*std::sin(0.176880016922951*x_71 + 1.76879990100861) - 0.00636382514922816*std::sin(0.283279955387115*x_72 + 1.90391993522644) + 0.00733458063795643*std::sin(0.298239946365356*x_74 - 7.49944019317627) + 0.00155055373444841*std::sin(0.372399836778641*x_75 - 7.43207979202271) + 0.0243691377042906*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 0.00110494733973925*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.000661048929742192*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.0388988071505109*std::sin(0.150240033864975*x_83 + 4.93767976760864) + 0.00922992201285825*std::sin(0.276799947023392*x_88 - 7.51471996307373) + 0.0199626002401552*std::sin(0.24679996073246*x_9 - 4.34816026687622) - 0.000786659063376065*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 0.0177069264645406*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 0.000607252182148097*std::sin(0.329439848661423*x_92 + 4.98511981964111) + 0.00127273506026786*std::sin(0.391039848327637*x_92 - 7.39135980606079) + 0.000510391140527295*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.0119959874192069*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.0209589729147146*std::sin(0.344079852104187*x_95 - 7.42312002182007) - 0.0122794045637642*std::sin(0.362079858779907*x_95 - 1.19927990436554) + 0.00392133655715898*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.000484227371244794*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.00629559898437142*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.00757701482634254*std::sin(0.406319856643677*x_96 + 2.01399970054626) - 0.0135668018603446*std::sin(0.223999992012978*x_97 + 1.82631993293762) + 0.000272606388188416*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.00304855589817179*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 0.0108564403898391*std::sin(0.346879839897156*x_98 - 7.43207979202271) + 0.000398320794624899*std::sin(0.356479853391647*x_98 + 8.17695999145508) + 0.00647531320645672*std::sin(0.376399844884872*x_98 + 1.98295974731445) + 0.00190894546317976*std::sin(0.299839943647385*x_99 - 7.50551986694336) + 0.00116560707189743*std::sin(0.355119854211807*x_99 - 7.43391990661621) - 0.00866697757138508*std::sin(0.359599858522415*x_99 + 5.1715202331543) - 0.0105427985985613*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 4.77980225277008e-5*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.000588545622383569*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.0378597163232451);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0105716167835504*x_1 - 0.0041262832446875*x_10 - 0.000578611782558866*x_100 - 0.000630519416135301*x_101 - 0.000802657945505515*x_102 + 0.00032377214335756*x_103 - 0.00088607101632288*x_104 + 0.000690437435361519*x_105 - 0.000992943589746253*x_106 - 3.88624139268469e-5*x_107 + 0.000687561381952582*x_108 + 0.000238508805564543*x_109 + 0.00315660974839076*x_11 + 0.00202502514281961*x_110 - 0.00104447146776949*x_111 - 0.000934734738115657*x_112 + 0.000771684186124401*x_113 + 7.25329486496165e-5*x_114 + 0.0015594823482981*x_115 - 0.00110672298882009*x_116 - 0.000336855681663537*x_117 + 0.0013775258036707*x_118 - 0.000966433112832018*x_119 + 0.00176183298374506*x_12 - 0.000430344745257083*x_120 + 0.000326658946769063*x_13 + 0.000300621365879473*x_14 + 0.00027925923063349*x_15 + 0.00265340607880806*x_16 + 0.000425546725229849*x_17 + 0.00190395754890028*x_18 - 0.00184852924196259*x_19 - 0.00159244663266884*x_2 + 0.00256395320036517*x_20 + 0.000181771523387779*x_21 + 0.00189054964983583*x_22 - 0.000478087598727237*x_23 - 0.00021284852807941*x_24 - 0.00470982785692369*x_25 + 0.000221798980063134*x_26 - 0.00121939367850384*x_27 - 0.0016750923934951*x_28 - 0.000652062935724554*x_29 - 0.00267269266617132*x_3 + 0.000858369537047824*x_30 + 0.0164923587021153*x_31 + 0.00631400335672321*x_32 - 4.85261296709951e-5*x_33 + 0.000173471069165037*x_34 - 0.000370446693192079*x_35 - 8.06864641031297e-5*x_36 - 0.0012746460557959*x_37 - 0.000124082126484935*x_38 - 0.000561707963243411*x_39 - 0.00452839959060336*x_4 - 0.00108981349149475*x_40 + 0.0013545973874397*x_41 - 0.00177741261035436*x_42 + 0.000466103872357477*x_43 + 0.000606504293089695*x_44 + 0.00196579771786036*x_45 + 0.00056597635317378*x_46 - 0.000453975328185533*x_47 - 0.000114773507057832*x_48 + 0.00132461822324935*x_49 - 0.000873426602947791*x_5 - 0.000936604019892107*x_50 - 0.00185243441259717*x_51 + 0.00120532577943742*x_52 + 0.00124226172251085*x_53 + 0.00106647190447712*x_54 + 0.000908501147124094*x_55 + 0.000866385059247109*x_56 + 0.000175614455902381*x_57 - 0.00077653583708899*x_58 + 0.000273319128460794*x_59 + 0.000169772765017318*x_6 + 4.55279981305752e-5*x_60 + 0.000496883973804242*x_61 + 0.000667411964885127*x_62 + 0.00169271156542865*x_63 - 0.00119004206589082*x_64 - 0.000453764368231314*x_65 + 0.000407793872991271*x_66 + 0.000229457746330829*x_67 - 0.000161920350202907*x_68 - 0.000248726025141198*x_69 - 0.00114911478884223*x_7 - 0.000180006687752496*x_70 + 0.000775775163710169*x_71 - 0.00127440624724073*x_72 + 0.000284889520582799*x_73 - 0.00028630232439088*x_74 + 0.00154773378170547*x_75 - 0.00041975810440403*x_76 - 3.4213001386242e-5*x_77 - 0.00169226174919878*x_78 - 0.000173343610021334*x_79 + 0.00134955091248398*x_8 + 0.00127327612144984*x_80 + 0.000539687671822843*x_81 + 0.000430933261329249*x_82 - 0.000756040663628781*x_83 + 0.000852382381186603*x_84 - 0.000533703642238599*x_85 - 0.00115902662764004*x_86 + 0.000946751455064233*x_87 + 0.00116145369183317*x_88 - 0.000490512881527353*x_89 + 7.42603299055235e-5*x_9 + 0.000264833813746304*x_90 + 0.00313180428058005*x_91 + 0.00479142254290656*x_92 - 0.000772857534197038*x_93 + 0.000142730758238851*x_94 - 0.000360727312032441*x_95 + 2.78204269864376e-5*x_96 + 0.00107105685982259*x_97 + 1.44913230201677e-5*x_98 + 0.000105376440617659*x_99 - 2.54326717887095e-7*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 7.33147634779569e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 2.33249431893009e-6*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 3.37662213860675e-6*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) + 2.19424352443523e-6*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) - 4.20802925959627e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 1.05436106947144e-5*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 3.22948609352077e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 4.33060476875821e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) - 4.64772608727912e-7*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 7.5950080319939e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 2.54573799254644e-6*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) + 1.74603227088564e-5*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) + 1.66587716958718e-7*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 7.53574635130312e-5*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 2.38982314083186e-6*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 3.59442319905458e-5*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) + 0.000229823041480715*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) - 1.02818508187751e-5*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 5.41135055632696e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 5.28859626129161e-5*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) - 2.82415805310645e-7*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) - 3.64723448461187e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 3.35210610360443e-5*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 9.31284090374927e-5*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) + 5.70064089394865e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 1.63962623019595e-5*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) - 4.64017225319508e-7*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) + 9.8334359752389e-8*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) + 9.74873564641486e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) + 2.27117047543998e-6*std::pow(-6.0*x_54 - 10.0, 2) + 3.48629202599602e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) - 5.58307314320886e-6*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 3.14871828394048e-5*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) - 3.39922999931875e-6*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 4.5245753449902e-6*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) + 7.04119384215379e-7*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) + 3.65853192096038e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 9.27253280538098e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) - 2.20217611764057e-7*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 1.00719188708708e-5*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 3.1578017956908e-6*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 9.46644245803848e-6*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) - 2.2772974715792e-7*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) + 3.74858427622323e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 2.25141886019871e-6*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 1.00334453673515e-5*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 1.04701316774793e-6*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) - 5.14613849092401e-5*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) + 1.73283810080912e-5*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 3.8496366923147e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) - 7.1163992016034e-6*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 1.31787722845731e-5*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) - 9.20664441488469e-6*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) - 4.14186043723091e-6*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) - 2.05904285580293e-5*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) + 1.18377264684591e-7*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 2.92357959686964e-7*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 9.37161164048136e-6*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 7.70534795565649e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 1.60465999808584e-6*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) + 1.21909067750205e-6*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 8.02265649612511e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 4.41209427666753e-6*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 2.03391486417158e-5*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) - 1.88035140447732e-5*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) - 2.4817231118281e-6*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) + 1.87434153239854e-6*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) + 0.000338149966042896*std::exp(0.523359894752502*x_117) + 0.00029220010471912*std::exp(1.36367988586426*x_17) - 7.84654938333043e-6*std::exp(0.873679876327515*x_29) - 0.000561853272186504*std::exp(0.669199824333191*x_71) - 8.70188331845332e-5*std::exp(0.698639869689941*x_71) + 0.0013311768483853*std::exp(0.633919835090637*x_72) - 0.000530838426907341*std::exp(0.662319839000702*x_72) - 0.000404440331758015*std::exp(0.661519825458527*x_73) - 1.25305227903984e-5*std::exp(0.936639785766602*x_81) + 1.66971194253825e-5*std::exp(0.557839810848236*x_84) + 0.000104960498221016*std::exp(0.783999860286713*x_87) + 5.98591420558591e-6*std::exp(0.646719813346863*x_90) - 0.000556349046132381*std::sin(0.192880004644394*x_1 + 8.19839954376221) + 0.00573674323351234*std::sin(0.297999948263168*x_1 - 7.60376024246216) - 6.32435493713936e-6*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.0313863920567291*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.0171154199882305*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.00273075416167893*std::sin(0.206560000777245*x_102 - 7.59832000732422) - 0.000164334477584384*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.00615843575113907*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.0141204042890911*std::sin(0.229759991168976*x_103 - 7.57151985168457) + 0.00216437458102825*std::sin(0.290079951286316*x_103 + 5.08432006835938) + 0.00323217730065169*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 0.0104329166700995*std::sin(0.356399834156036*x_104 - 1.21031987667084) + 0.00862558878051025*std::sin(0.303839921951294*x_105 - 7.50559997558594) + 0.000836735938887755*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.00620117487523151*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.00623984050395076*std::sin(0.284959942102432*x_106 + 5.08791971206665) + 0.0116030532705408*std::sin(0.319679945707321*x_106 - 7.47704029083252) + 0.0260189690522936*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.00234968202507209*std::sin(0.287759929895401*x_107 - 7.49671983718872) - 0.00325240841328871*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 0.00100027975380528*std::sin(0.330799847841263*x_108 + 4.96007966995239) + 0.0018810027138615*std::sin(0.296799927949905*x_109 + 1.88975989818573) - 0.0040928346747366*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.0146778526848041*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.00381380410517301*std::sin(0.26063996553421*x_11 + 8.29399967193604) - 0.0313513274036569*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.00184486234129913*std::sin(0.335919857025146*x_111 - 1.24431991577148) - 0.000141097675582341*std::sin(0.257199972867966*x_112 - 4.34687995910645) - 0.00255629011752804*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.00904367979838216*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.00132019787757123*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.00432742955968814*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 0.000543988254162547*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.000978706244049669*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.0471902120134102*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.00944027423690417*std::sin(0.303839921951294*x_117 - 7.50871992111206) + 0.0157436064226471*std::sin(0.403199851512909*x_119 - 1.18383979797363) - 0.0117856173731439*std::sin(0.296079933643341*x_12 + 5.11951971054077) - 0.0054670258572039*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 0.00134684114510532*std::sin(0.382879853248596*x_12 - 4.20423984527588) + 0.00171130815400244*std::sin(0.454639852046967*x_120 - 1.17119991779327) + 0.0718158240067087*std::sin(0.23055998980999*x_13 - 4.35663986206055) + 1.36761630005093e-6*std::sin(1.31927990913391*x_13 + 1.20903992652893) - 0.00177950799673214*std::sin(0.249839976429939*x_14 + 8.26024055480957) - 0.00794577701270564*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.00947143345474018*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.000458259906390558*std::sin(0.25383996963501*x_15 + 5.07239961624146) - 0.00866369614533957*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.00221696442110667*std::sin(0.333039849996567*x_16 - 1.04951989650726) + 0.00545003534597802*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.00324136910772945*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.0124517232506997*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0618822855602813*std::sin(0.19072000682354*x_18 + 4.97863960266113) - 3.92638515334342e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) - 0.000226747019115964*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.00745263440681695*std::sin(0.284399926662445*x_21 - 4.31175994873047) - 0.00244998963307538*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 0.0208541534727628*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.0442193598034295*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.00473863753569201*std::sin(0.305279940366745*x_23 + 5.12815999984741) + 0.00828074496450316*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.0124518446183677*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.00363319909035072*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.0234962266746656*std::sin(0.334719836711884*x_24 + 5.11863994598389) - 0.0136819928770021*std::sin(0.338799834251404*x_24 - 4.25447988510132) - 0.0218163259843316*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.000259281558346348*std::sin(0.381999850273132*x_24 + 8.38024044036865) + 0.0148628097236471*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.00401132396232914*std::sin(0.407919853925705*x_24 - 7.39991998672485) - 0.00112493281426642*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.0271925676820079*std::sin(0.334959834814072*x_26 - 4.26191997528076) + 0.0253310592498137*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.037180210658833*std::sin(0.293599933385849*x_27 + 1.90855991840363) + 0.0048195803620475*std::sin(0.325439840555191*x_27 - 4.27992010116577) - 0.00565093412219734*std::sin(0.364719837903976*x_27 - 4.22952032089233) - 0.0181832309799713*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.0165642278639659*std::sin(0.270719945430756*x_28 - 7.51624011993408) - 0.000208126459652537*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.00407141743283033*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.0136264152254649*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.000728859374352903*std::sin(0.897199869155884*x_29 + 8.85704040527344) + 0.00625739427732718*std::sin(0.285119920969009*x_3 - 4.29447984695435) - 0.000139677808191126*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.0357145797337021*std::sin(0.31007993221283*x_3 - 4.25759983062744) + 0.000309140799673206*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.0221715420494245*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.0129101481840839*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.00140889573128651*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.0154591784954806*std::sin(0.258879989385605*x_30 - 1.12431991100311) - 0.00689064439792803*std::sin(0.282159924507141*x_30 + 8.27752017974854) + 0.000843537873083015*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 1.53782136252737e-5*std::sin(1.7519998550415*x_30 - 9.99600028991699) + 0.000191522230148614*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.00014800506427177*std::sin(0.247519969940186*x_33 - 1.18367981910706) + 0.00671060365332673*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.00105061802330103*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.0241359819977754*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.012054441088484*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.00272439860421024*std::sin(0.390399843454361*x_34 + 1.79423987865448) + 0.00885219956627177*std::sin(0.282239943742752*x_35 + 8.25271987915039) - 0.00385486588007293*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.000135092186366549*std::sin(0.343759834766388*x_35 + 8.19143962860107) + 0.00383637592827195*std::sin(0.207520008087158*x_36 - 4.396559715271) + 0.000105974739396913*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.00158036640027433*std::sin(0.377359837293625*x_38 + 5.17280006408691) - 0.00524968641103331*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 0.0183616145758658*std::sin(0.213359996676445*x_40 + 5.00423955917358) + 0.00647782119178438*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 0.00192437013622144*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.00770821108589871*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.0190504238455663*std::sin(0.244239971041679*x_42 + 5.06047964096069) + 0.000678777311048934*std::sin(0.308959931135178*x_42 - 7.50464010238647) + 0.00207678871065979*std::sin(0.351759850978851*x_43 - 7.43048000335693) - 0.00431967772204534*std::sin(0.357199847698212*x_44 - 4.25239992141724) + 0.0617831102210803*std::sin(0.157600030303001*x_45 - 4.46623992919922) + 0.000191001430974924*std::sin(0.233679980039597*x_45 + 1.83839988708496) - 0.000556890078925047*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.0118274356384994*std::sin(0.321759849786758*x_45 - 4.27936029434204) + 0.00230972798396782*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 0.000246871958605563*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.0133009176742155*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.000872690619569594*std::sin(0.209200009703636*x_46 + 5.00407981872559) + 0.000213328604384405*std::sin(0.221759989857674*x_47 + 1.82455992698669) - 0.00309010548250958*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.0195935287201368*std::sin(0.241199985146523*x_48 + 5.0479998588562) - 0.00341669140090152*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.000387495717457577*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.114529035153084*std::sin(0.145920038223267*x_49 + 4.93440008163452) + 0.00146182173396932*std::sin(0.247039973735809*x_49 - 4.34455966949463) - 0.00136635419608641*std::sin(0.489439845085144*x_5 - 3.86071991920471) + 0.000109906620918135*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.000319706110209479*std::sin(0.200879991054535*x_51 - 7.59600019454956) - 0.00457500112121353*std::sin(0.299919933080673*x_51 + 5.09696006774902) + 0.00976073755556989*std::sin(0.346159845590591*x_51 + 5.14703989028931) + 0.00117465516353768*std::sin(0.349679857492447*x_51 + 1.93831980228424) + 0.00475924372775694*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 0.00810695128256643*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.000552257175848039*std::sin(0.371679842472076*x_54 - 1.22119987010956) - 0.0257313355595348*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.00538680587349329*std::sin(0.246559977531433*x_55 - 7.53864002227783) - 0.000919212793510602*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.0126412566049287*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.0110176610482247*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.0204001667660524*std::sin(0.305759936571121*x_58 - 7.48072004318237) - 0.0161992485311991*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 0.0094219172353772*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.000372120956119615*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.0242553870777416*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.00469915910716274*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.0301111358859359*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 0.000343158593280307*std::sin(1.35967981815338*x_67 + 6.00071954727173) + 0.0146449738430955*std::sin(0.153440043330193*x_69 + 4.9322395324707) - 0.012864251705542*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.0190701032530795*std::sin(0.176880016922951*x_71 + 1.76879990100861) - 0.000948855808669131*std::sin(0.283279955387115*x_72 + 1.90391993522644) + 0.00109359689797907*std::sin(0.298239946365356*x_74 - 7.49944019317627) + 0.000231189871356448*std::sin(0.372399836778641*x_75 - 7.43207979202271) + 0.00363347472954666*std::sin(0.221279993653297*x_8 - 4.37391948699951) + 0.00454685242498119*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.00067433458422224*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.00579987008592454*std::sin(0.150240033864975*x_83 + 4.93767976760864) + 0.0013761951200884*std::sin(0.276799947023392*x_88 - 7.51471996307373) + 0.0390721109207394*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.00323709786096137*std::sin(0.350239843130112*x_9 + 2.12519979476929) + 0.0138330200135913*std::sin(0.19336000084877*x_91 - 1.18735980987549) - 9.03563187502881e-5*std::sin(0.329439848661423*x_92 + 4.98511981964111) + 0.00950254824246224*std::sin(0.391039848327637*x_92 - 7.39135980606079) - 7.59438433266268e-5*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.0122370808342749*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.0213802029627084*std::sin(0.344079852104187*x_95 - 7.42312002182007) - 0.000174433578605977*std::sin(0.362079858779907*x_95 - 1.19927990436554) - 0.000583476760235673*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.00647742612715135*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.0064221269145867*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.0178174210596531*std::sin(0.406319856643677*x_96 + 2.01399970054626) + 0.0293749691008343*std::sin(0.223999992012978*x_97 + 1.82631993293762) - 0.00112177383719695*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.0110746313730071*std::sin(0.346879839897156*x_98 - 7.43207979202271) + 0.00297395953412519*std::sin(0.356479853391647*x_98 + 8.17695999145508) + 0.0009654788440634*std::sin(0.376399844884872*x_98 + 1.98295974731445) + 0.00277134732331371*std::sin(0.299839943647385*x_99 - 7.50551986694336) + 0.00870270473269543*std::sin(0.355119854211807*x_99 - 7.43391990661621) + 0.0187658227029339*std::sin(0.359599858522415*x_99 + 5.1715202331543) - 0.000149764435117315*std::sin(0.359679847955704*x_99 + 8.18544006347656) - 0.00315829841637744*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.00787287340169925*std::sin(0.386799842119217*x_99 - 7.39559984207153) - 0.00785408914089203*std::sin(0.0842310976259721*x_1 + 0.0114280108507483*x_100 - 0.159929850607966*x_101 + 0.00153584453827809*x_103 + 0.00873551012049028*x_104 + 0.00788448164586951*x_105 - 0.00109113159034487*x_106 - 0.00453647698453824*x_108 - 0.0558232082965348*x_109 - 0.00988311568021763*x_110 - 0.0100809462023477*x_111 + 0.000905295943211351*x_113 - 0.00317626814835963*x_114 - 0.000758832912031679*x_115 - 0.00167323426559798*x_117 + 0.0355150857609876*x_118 + 0.0034495849424772*x_119 + 0.0214360311012164*x_12 - 0.0103952660204404*x_120 + 0.0105912617677194*x_13 + 0.0183462919789318*x_14 + 0.0852207598478277*x_17 + 0.0621712361032186*x_18 + 0.0738899900996699*x_19 - 0.0297652067054756*x_2 - 0.179410235077202*x_20 + 0.00961723947274071*x_21 - 0.0113540340038354*x_22 - 0.139523883177161*x_23 - 0.0319593968712868*x_25 - 0.086077338620159*x_27 - 0.0292952477433117*x_29 + 0.0102395084087132*x_30 + 0.033255793403122*x_31 + 0.000165710734110927*x_32 + 0.00366659369910712*x_33 + 0.0043564517949007*x_34 - 0.0132775993017886*x_35 - 0.0104827238394828*x_36 + 0.00516132339990001*x_37 - 0.036650230593569*x_39 + 0.00393765991857734*x_4 + 0.00087849291405503*x_40 + 0.00805726345949004*x_41 - 0.0309559052310438*x_42 + 0.000286408946471179*x_43 - 0.0614033458200193*x_44 + 0.0064435975327572*x_45 + 0.00519305771719887*x_46 - 0.00220557047207397*x_47 + 0.0010899491474087*x_48 + 0.000775666315454117*x_49 - 0.00161476964907355*x_5 + 0.0293366957334952*x_50 + 0.0658247815772567*x_51 - 0.00342363963815006*x_52 - 0.000711352283512821*x_53 - 0.001340782766437*x_54 + 0.00159224694029332*x_55 - 0.00321317101367192*x_56 + 0.00200831467830832*x_57 - 0.0198920497597231*x_58 + 0.00705084258546088*x_59 + 0.0127553417566484*x_60 - 0.00163261757802889*x_61 + 0.0119679996352234*x_62 - 0.00311040139630991*x_63 - 0.0306472962192474*x_64 + 0.00147521078883533*x_65 + 0.00215801801818685*x_66 - 0.00051447485729222*x_67 + 0.000572223715290226*x_68 + 0.0608753647606323*x_69 + 0.0840191760439964*x_7 - 0.00187291397358434*x_70 - 0.0024316690256034*x_72 - 0.00326650281492661*x_73 - 0.0120771780375604*x_74 + 0.000174160077624802*x_75 - 0.0025059212978141*x_76 - 0.0276947153576048*x_77 - 0.000759854184343572*x_78 + 0.00525311120642194*x_79 - 0.00016277216648426*x_8 - 0.0116579704519681*x_81 + 0.00118853334401316*x_82 + 0.0334532259797204*x_83 - 0.00212384112833819*x_84 - 0.0818451783708933*x_86 - 5.75565789588201e-5*x_87 - 0.0559857005527202*x_88 - 0.0169544341704409*x_89 + 0.123281128997983*x_9 + 0.00167229543150851*x_90 + 0.0175684697192128*x_91 + 0.0125712034142496*x_92 + 0.000814960859607105*x_93 + 9.14137101683868e-5*x_94 - 8.53494643702603e-5*x_95 - 0.00624043267754252*x_96 - 0.000237910394878914*x_98 + 0.000359996116246267*x_99 - 0.000696596927777349*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 0.000232319312190442*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 0.000323039950868236*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 2.31524568006267*std::sin(0.296639919281006*x_10 + 8.33568000793457) - 0.717794237028443*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.451123573044619*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 1.4888669319954*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.295826335448602*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 0.45627618779379*std::sin(0.609919846057892*x_116 + 1.98527979850769) + 1.34876332780632*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 1.09610618324633*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 1.65231606858904*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.58047795132871*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 1.87099863588404*std::sin(0.3574398458004*x_28 - 1.04567980766296) - 1.01097655478259*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.641461152853282*std::sin(0.323999851942062*x_38 - 7.47088003158569) + 10.3652930822905*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.49573511003954*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 3.24624505731187) - 0.134063507009764);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00273033075205363*x_1 - 0.00161890030172499*x_10 + 8.99439203495305e-5*x_100 + 0.000962959847095098*x_101 - 0.000383811244462662*x_102 - 0.000751031749664096*x_103 - 0.00210633469003495*x_104 + 3.92349751926848e-5*x_105 + 0.000273065037496822*x_106 - 0.000130439057507709*x_107 - 0.000596990453560621*x_108 + 0.000323925687485887*x_109 - 0.00104176733670902*x_11 - 2.00456531565624e-5*x_110 + 0.000146410198489303*x_111 - 0.000178050058892279*x_112 - 0.00161068841156455*x_113 - 7.5434547697828e-5*x_114 + 0.000183696364864115*x_115 + 0.000318722293225506*x_116 - 0.000182200720367005*x_117 - 0.000780149329179084*x_118 - 9.00002233320081e-5*x_119 + 0.000392775517775771*x_12 + 0.000219841398962141*x_120 - 0.00227326554606926*x_13 + 0.000463136893828103*x_14 - 0.000991922487193084*x_15 - 0.000784349796049117*x_16 - 0.00154375650610599*x_17 - 8.49889010858166e-5*x_18 - 0.00306852176334817*x_19 - 0.00285877254654215*x_2 + 0.0017667942763161*x_20 + 0.00027847398123063*x_21 + 0.000858648507659525*x_22 - 6.48584793515929e-6*x_23 - 7.3125117323074e-6*x_24 + 0.00247865712867932*x_25 + 0.000616560133390154*x_26 + 0.000225130872205601*x_27 - 0.000241934740411964*x_28 + 0.0036606625701823*x_29 - 0.000380233948316706*x_3 - 0.0014813482444402*x_30 + 0.00331640001855496*x_31 - 0.00119983739633396*x_32 + 0.00209628735250319*x_33 + 0.00134680557928973*x_34 + 0.00105968832142317*x_35 + 0.000808368482775175*x_36 + 0.00169560743717061*x_37 - 3.53791092389281e-5*x_38 + 0.000230617270483602*x_39 - 1.53134738169091e-7*x_4 + 0.000862963213843187*x_40 + 2.11866256841158e-5*x_41 - 7.88390377584174e-5*x_42 + 1.22168469860962e-5*x_43 - 3.78572632001288e-5*x_44 - 0.0006193619482726*x_45 + 8.17029839713978e-5*x_46 + 0.000192611319578826*x_47 + 0.000807314245186982*x_48 - 0.000615367175288451*x_49 + 4.59180155137146e-5*x_5 - 0.000243404699618649*x_50 + 0.000241901396095566*x_51 + 0.00190088484186228*x_52 - 3.0228396012088e-5*x_53 + 0.00038579777730968*x_54 - 0.000682792606265081*x_55 + 0.000460873053706551*x_56 + 0.000157000671153242*x_57 - 0.00143524420958003*x_58 + 3.23265627402685e-5*x_59 - 0.000103012079539123*x_6 + 0.000371747639288945*x_60 + 0.000396400482342307*x_61 + 0.000258072615968452*x_62 + 0.00169812401712484*x_63 + 0.000897820703190692*x_64 + 0.000414309498258731*x_65 + 3.89631009001109e-5*x_66 + 0.000400649337847683*x_67 - 0.000139791435430563*x_68 - 0.000295390568470223*x_69 - 0.000833833372987032*x_7 + 0.000105805815607495*x_70 + 2.51475572200961e-5*x_71 - 0.000262013360096941*x_72 + 1.64461859563118e-5*x_73 - 0.00011197217606999*x_74 - 0.00022431831042527*x_75 + 7.50701929892341e-5*x_76 - 0.000921731335777779*x_77 - 0.000687657894425721*x_78 + 0.000125128711600472*x_79 + 0.000441882906386858*x_8 - 0.0013619034822815*x_80 - 0.000655596165391863*x_81 + 0.000143181206923944*x_82 - 6.20920166259357e-5*x_83 - 0.000389693204022052*x_84 + 0.000290608072092349*x_85 + 0.00111039330037913*x_86 + 1.20431122650919e-5*x_87 + 0.000570692243622849*x_88 + 0.000461231517590575*x_89 - 0.00111204512412794*x_9 + 6.05011030104683e-6*x_90 - 0.00164137730377824*x_91 - 6.13177444310053e-5*x_92 + 1.76431367393281e-5*x_93 - 0.000453412826763471*x_94 + 5.77911915667494e-5*x_95 + 9.25129907660093e-5*x_96 - 8.7270280695075e-5*x_97 - 0.000543507431131219*x_98 - 9.92989881506794e-5*x_99 + 6.55190337462253e-6*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) - 4.80568090030189e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 1.96511969933892e-8*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 5.28768036824087e-7*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) + 2.34771993873252e-8*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 2.54079561634643e-6*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) - 2.11688327168778e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) + 2.83865126704458e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) - 3.64553338371075e-7*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) + 4.97842225842637e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 4.2075824575822e-6*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) + 1.30666281119998e-7*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 6.34884444690087e-7*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 3.63675929506285e-5*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 2.28231669845252e-5*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) + 3.54706511754584e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 4.45562701292298e-7*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) - 2.21518270873453e-7*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 2.03484448242113e-8*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) - 2.01213866848277e-7*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 2.2442051427259e-5*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 3.18046939900824e-8*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 3.6396083886032e-7*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) - 1.08412850182199e-7*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) + 1.54265667832026e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) - 3.31147205141897e-7*std::pow(-6.0*x_54 - 10.0, 2) - 7.73870643219515e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) + 3.35130124560755e-8*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 8.19145255956009e-7*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 3.43224507847954e-5*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) + 5.34129748510247e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) - 2.0411474843576e-8*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) - 6.07801644393764e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) - 1.72731921006322e-7*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) - 6.04578041372522e-8*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 2.39544020060894e-5*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) + 5.6823365174225e-8*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) - 1.7862420894391e-7*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) - 4.13278437523626e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) + 1.58770963373064e-6*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 4.33560675452351e-7*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) + 0.000131449353581641*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) + 2.14776757999318e-8*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 4.27169712751905e-8*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) + 2.98010646235842e-6*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 2.218613949994e-6*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) - 9.98104079061888e-7*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) - 3.25826479213244e-6*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) - 3.04960645271202e-6*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 9.93883630521393e-7*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 2.21776430223658e-6*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) + 5.62541327302838e-8*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) - 5.050748545593e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 1.21726039708043e-5*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) + 9.24775842822383e-6*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 1.38199496264514e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) - 1.26951894794359e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 3.71717663278035e-8*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) + 1.3332029392045e-5*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) - 2.97550036939669e-6*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) + 1.42183498106354e-5*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) - 4.93038357907677e-5*std::exp(0.523359894752502*x_117) - 0.000191533109526717*std::exp(1.36367988586426*x_17) + 0.000202140906826029*std::exp(0.873679876327515*x_29) + 0.00124717536540198*std::exp(0.669199824333191*x_71) - 0.000660106063353207*std::exp(0.698639869689941*x_71) - 0.000872567931987219*std::exp(0.633919835090637*x_72) + 3.18641621859255e-6*std::exp(0.662319839000702*x_72) - 3.4073980660729e-6*std::exp(0.661519825458527*x_73) - 9.50538379822553e-5*std::exp(0.936639785766602*x_81) - 1.84084414775914e-5*std::exp(0.557839810848236*x_84) + 2.5293344139042e-5*std::exp(0.783999860286713*x_87) - 0.00015420767353743*std::exp(0.646719813346863*x_90) + 0.000613370402158881*std::sin(0.192880004644394*x_1 + 8.19839954376221) + 0.00138243837731226*std::sin(0.297999948263168*x_1 - 7.60376024246216) + 0.000162926501781654*std::sin(1.06031978130341*x_1 - 9.03824043273926) - 0.009904836409654*std::sin(0.296639919281006*x_10 + 8.33568000793457) - 0.000144196917044405*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.0207149109415048*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.00307079052334812*std::sin(0.291599929332733*x_102 - 7.51024007797241) + 0.00018117745560135*std::sin(0.310559928417206*x_102 + 1.90255987644196) - 0.00403676908456284*std::sin(0.333999842405319*x_102 + 1.93591976165771) - 0.00925572885698912*std::sin(0.229759991168976*x_103 - 7.57151985168457) - 0.000315575867658646*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 0.00717463456303616*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 8.78970203853619e-5*std::sin(0.356399834156036*x_104 - 1.21031987667084) + 0.00207859136651489*std::sin(0.303839921951294*x_105 - 7.50559997558594) - 3.72232362903438e-5*std::sin(0.357039839029312*x_105 + 1.9761598110199) - 3.48129660273358e-5*std::sin(0.284959942102432*x_106 + 5.08791971206665) + 9.77553873094855e-5*std::sin(0.319679945707321*x_106 - 7.47704029083252) + 0.00411728636690337*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.0178241800647105*std::sin(0.287759929895401*x_107 - 7.49671983718872) + 0.00192994861410327*std::sin(0.356399834156036*x_107 + 5.16552019119263) + 0.00213190853386878*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 0.00758790604714384*std::sin(0.330799847841263*x_108 + 4.96007966995239) + 0.0142688800937004*std::sin(0.296799927949905*x_109 + 1.88975989818573) + 2.28345122598716e-5*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.00232264862735724*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.0289306937605953*std::sin(0.26063996553421*x_11 + 8.29399967193604) + 0.00636951124632212*std::sin(0.279119968414307*x_11 - 1.08031988143921) + 0.0205503595941034*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.013994727037549*std::sin(0.335919857025146*x_111 - 1.24431991577148) - 0.000110672676711149*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 0.00567433210630696*std::sin(0.333999842405319*x_112 + 8.17199993133545) + 0.00126557258416157*std::sin(0.378399848937988*x_112 - 1.21479988098145) - 7.61927400297641e-5*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 2.41433508038751e-5*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 0.00412657733762222*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.00195199197935474*std::sin(0.609919846057892*x_116 + 1.98527979850769) + 0.00746746022809716*std::sin(0.186160013079643*x_117 - 7.60880041122437) - 5.66662875400381e-5*std::sin(0.303839921951294*x_117 - 7.50871992111206) + 0.00249129532994095*std::sin(0.403199851512909*x_119 - 1.18383979797363) - 0.0028400939511767*std::sin(0.296079933643341*x_12 + 5.11951971054077) + 0.000797117764883256*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 0.0102168458679773*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 0.00379868103994046*std::sin(0.454639852046967*x_120 - 1.17119991779327) + 0.0113642593800114*std::sin(0.23055998980999*x_13 - 4.35663986206055) - 3.52322002420146e-5*std::sin(1.31927990913391*x_13 + 1.20903992652893) - 0.00191477056455332*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.0118055808374306*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 4.8336004644334e-5*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.00577013499357897*std::sin(0.441039860248566*x_15 + 5.44664001464844) - 0.0168174130019358*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.0046892442241254*std::sin(0.34215983748436*x_16 - 7.24799966812134) + 0.00131334761088399*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.0405629785429894*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 5.72485193824313e-6*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 0.000503322327053904*std::sin(1.75519990921021*x_2 + 3.0064799785614) + 4.15793173326149e-5*std::sin(0.284399926662445*x_21 - 4.31175994873047) + 0.0289851760750494*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.0628159417922606*std::sin(0.153600037097931*x_24 + 4.94071960449219) - 7.47435709854647e-5*std::sin(0.208800002932549*x_24 + 1.8199999332428) + 0.0154014501858898*std::sin(0.334719836711884*x_24 + 5.11863994598389) - 0.00329708185661646*std::sin(0.338799834251404*x_24 - 4.25447988510132) - 0.00345225290712623*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.00706876185855753*std::sin(0.368879854679108*x_24 - 1.02383983135223) - 0.00667954877576403*std::sin(0.381999850273132*x_24 + 8.38024044036865) + 0.000125218740892206*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.000178011301314534*std::sin(1.52239990234375*x_25 - 9.59887981414795) - 0.0178243503682423*std::sin(0.334959834814072*x_26 - 4.26191997528076) - 0.00248333867841029*std::sin(0.423199862241745*x_26 + 2.22815990447998) + 0.00610426979550782*std::sin(0.274159967899323*x_27 - 7.50144004821777) - 0.0243711115955623*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 0.0106982769286525*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 3.15273727740656e-5*std::sin(0.364719837903976*x_27 - 4.22952032089233) - 0.00287734571149318*std::sin(0.41431987285614*x_27 + 8.41983985900879) + 0.0108576212617862*std::sin(0.270719945430756*x_28 - 7.51624011993408) - 0.000163247993201129*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.0308848927927356*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.0080043062257719*std::sin(0.3574398458004*x_28 - 1.04567980766296) - 8.17940606309513e-5*std::sin(0.358319848775864*x_28 - 4.23296022415161) - 0.000477757194891157*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 3.49109010492035e-5*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.00359834590109243*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.00565153645948523*std::sin(0.31007993221283*x_3 - 4.25759983062744) + 0.000242480534418815*std::sin(0.321439832448959*x_3 + 8.31455993652344) + 0.00846242279250796*std::sin(0.339759826660156*x_3 - 1.05527985095978) + 0.00432505175383636*std::sin(0.353119850158691*x_3 - 4.22575998306274) - 0.0106875785484558*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.00166050507620073*std::sin(0.282159924507141*x_30 + 8.27752017974854) + 0.000133482882347531*std::sin(1.43687975406647*x_30 + 6.00695943832397) + 0.000150224146306833*std::sin(0.232399985194206*x_33 - 4.37471961975098) - 0.00381287065755289*std::sin(0.247519969940186*x_33 - 1.18367981910706) + 0.0016171189205571*std::sin(0.281599938869476*x_33 + 2.00543975830078) + 0.00381931926017284*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.000101558316585166*std::sin(0.351599842309952*x_34 + 8.19431972503662) - 1.51998109556232e-5*std::sin(0.390399843454361*x_34 + 1.79423987865448) + 7.45795246272643e-5*std::sin(0.282239943742752*x_35 + 8.25271987915039) + 0.000562057351567024*std::sin(0.30447992682457*x_35 - 4.34575986862183) + 0.00348021222108902*std::sin(0.343759834766388*x_35 + 8.19143962860107) - 0.00851580614907177*std::sin(0.207520008087158*x_36 - 4.396559715271) - 0.000116836308023614*std::sin(0.302719831466675*x_37 + 8.13655948638916) - 0.00274423048787972*std::sin(0.323999851942062*x_38 - 7.47088003158569) + 0.0119883179877685*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 2.92887541862258e-5*std::sin(0.328799843788147*x_39 + 1.9366397857666) - 0.00011021761710988*std::sin(0.213359996676445*x_40 + 5.00423955917358) - 3.61406944517192e-5*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 0.0145978559878161*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.0001604992684263*std::sin(0.244239971041679*x_42 + 5.06047964096069) + 0.00514905799460463*std::sin(0.308959931135178*x_42 - 7.50464010238647) + 0.0157540703551249*std::sin(0.351759850978851*x_43 - 7.43048000335693) + 2.41001021887323e-5*std::sin(0.357199847698212*x_44 - 4.25239992141724) + 0.00977666551302956*std::sin(0.157600030303001*x_45 - 4.46623992919922) - 0.00492053265405599*std::sin(0.233679980039597*x_45 + 1.83839988708496) + 9.96458022523264e-5*std::sin(0.321759849786758*x_45 - 4.27936029434204) - 0.000336769068988889*std::sin(0.32415983080864*x_45 + 1.94247984886169) + 0.00635985566960968*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.00549571989361415*std::sin(0.221759989857674*x_47 + 1.82455992698669) - 0.0234408724037927*std::sin(0.299439936876297*x_47 - 7.47208023071289) + 0.0128432858912773*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.00758421025084048*std::sin(0.400319814682007*x_48 - 1.2060798406601) - 0.0181232712988228*std::sin(0.145920038223267*x_49 + 4.93440008163452) - 0.0103648676558565*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 0.00024396552781519*std::sin(0.8711998462677*x_5 - 3.34791970252991) - 0.00823619146179851*std::sin(0.200879991054535*x_51 - 7.59600019454956) + 2.55245880895495e-5*std::sin(0.299919933080673*x_51 + 5.09696006774902) - 5.85899039632303e-5*std::sin(0.346159845590591*x_51 + 5.14703989028931) - 0.000171270179239031*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 2.65525040432221e-5*std::sin(0.296959936618805*x_54 + 1.8899998664856) + 4.86628694169845e-5*std::sin(0.358159840106964*x_54 - 1.23015987873077) - 0.000216785755866432*std::sin(0.192479997873306*x_55 + 4.99200010299683) + 3.00537633535729e-5*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 0.00828616809769647*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 9.28234748131632e-5*std::sin(0.264799952507019*x_58 + 1.87719988822937) + 0.0133720259249104*std::sin(0.305759936571121*x_58 - 7.48072004318237) - 0.00256339692005229*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 7.9379379467357e-5*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.0443436881028652*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.00958649004093322*std::sin(0.262399971485138*x_6 + 8.30399990081787) + 0.0158990692841802*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.0356468054762531*std::sin(0.212959989905357*x_65 + 5.0129599571228) + 0.019737431282438*std::sin(0.235039979219437*x_67 + 5.03983974456787) + 0.00352914067290997*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.028555458543555*std::sin(0.166640013456345*x_70 - 7.62864017486572) - 0.000114470398553972*std::sin(0.176880016922951*x_71 + 1.76879990100861) + 0.0344914398994239*std::sin(0.305519938468933*x_8 - 4.23663949966431) - 0.000442016952395158*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.000329181401394879*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.0245559248209743*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 7.7176404666707e-5*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 9.96171233773857e-5*std::sin(0.329439848661423*x_92 + 4.98511981964111) + 0.00228992075083653*std::sin(0.391039848327637*x_92 - 7.39135980606079) + 8.37274837560522e-5*std::sin(0.330639839172363*x_94 - 7.62272024154663) + 0.00802123649466681*std::sin(0.388399839401245*x_94 + 1.99583983421326) - 0.0140144260375822*std::sin(0.344079852104187*x_95 - 7.42312002182007) - 0.000136820333665681*std::sin(0.362079858779907*x_95 - 1.19927990436554) + 0.000643278491378877*std::sin(0.157040029764175*x_96 + 1.74959981441498) - 3.88814649055031e-5*std::sin(0.301839828491211*x_96 + 8.14343929290771) - 0.0042096149791199*std::sin(0.359439849853516*x_96 + 5.1733603477478) + 0.00464834558064134*std::sin(0.223999992012978*x_97 + 1.82631993293762) - 0.00850953390830245*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.00212080091963741*std::sin(0.40175986289978*x_97 - 1.17407977581024) + 0.00725926702104769*std::sin(0.346879839897156*x_98 - 7.43207979202271) + 0.000716663728041944*std::sin(0.356479853391647*x_98 + 8.17695999145508) - 0.000404075312935295*std::sin(0.299839943647385*x_99 - 7.50551986694336) + 0.00209717474169211*std::sin(0.355119854211807*x_99 - 7.43391990661621) + 0.00296953602670527*std::sin(0.359599858522415*x_99 + 5.1715202331543) - 0.000117470616310003*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 0.00701064170395455*std::sin(0.36847984790802*x_99 + 1.96631979942322) + 4.72577911140546e-5*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.160800322890282*std::sin(-0.00845402884413466*x_1 - 0.00702258657227089*x_100 - 0.0101290801182572*x_101 + 0.00017798951235929*x_102 + 0.00085442487396867*x_103 + 0.000489949361924577*x_104 - 0.0119935458712259*x_105 + 0.0109753447623325*x_106 - 8.02253975685427e-5*x_107 - 0.00835901717252505*x_108 + 0.000605836323521507*x_109 - 0.037883254926485*x_11 - 0.00472970614538407*x_110 + 0.00137182424237519*x_111 + 0.000232926242927537*x_112 - 0.00149995987557358*x_113 - 0.00822878259511511*x_115 - 0.000977411228483536*x_116 - 0.000629809740374131*x_117 - 0.000607441690488732*x_118 - 0.000121517522496365*x_119 - 0.0380426372788053*x_12 + 0.000150488648220449*x_120 - 0.00423920375923572*x_13 + 0.000846227835792768*x_14 + 0.00737001070597967*x_15 + 0.000327861273452509*x_17 - 0.015668695245226*x_18 + 0.00573764469414516*x_19 - 0.0149269670105013*x_2 + 0.0171320662003621*x_20 + 0.00594855568640009*x_23 + 0.0248557947150141*x_25 + 0.00265986154016876*x_26 + 0.016866848150337*x_27 + 0.00364824485651339*x_28 + 0.0111914968410966*x_29 + 0.000180840574228471*x_31 - 0.000543338129175784*x_32 - 0.0206386091458108*x_33 - 0.00411021240811705*x_34 - 0.000399099868897612*x_35 + 0.00058098601506867*x_36 - 0.00154696227164484*x_37 - 0.00160130298977743*x_38 + 0.00915310151815213*x_39 + 0.0683168525506243*x_4 + 0.000251242557807863*x_40 + 0.00119943477356104*x_42 - 0.000721433827610454*x_43 + 8.75541272058136e-5*x_44 + 0.000729784044422749*x_45 + 0.000447489987399973*x_47 + 0.0070260141996585*x_48 + 0.00792877929887096*x_5 - 0.000206956542220444*x_50 + 0.000524187546552487*x_51 - 0.000110779458121783*x_52 - 0.00220683946028971*x_53 - 0.00358135720954276*x_54 - 0.00279241981744613*x_55 - 0.000169966827103785*x_56 + 0.014751551139892*x_58 - 0.000125986154687921*x_59 + 0.0129839047059568*x_6 - 5.90994897925583e-5*x_60 + 0.000384524330188002*x_61 - 0.0103097987445732*x_62 - 0.000144400366540579*x_63 + 0.000323534715736511*x_64 - 0.000232750397233197*x_65 - 0.00359144937429876*x_66 + 0.00742333707477132*x_68 + 0.00828480064086201*x_69 + 0.0011276665715326*x_7 + 0.000116442712768915*x_70 + 7.32233935153517e-5*x_71 + 0.000187306234031366*x_72 + 0.00218620456375357*x_74 - 0.0126766630171583*x_75 - 0.000150119920817394*x_76 - 0.000871093624542534*x_77 + 0.0170777732655344*x_78 + 0.000248762656757373*x_79 + 0.00758909893820999*x_8 - 0.00795271334700851*x_80 + 0.000124259412700087*x_81 - 0.00471398418181218*x_82 + 0.010630083280331*x_83 - 3.78609503756055e-5*x_84 + 0.00964764653457215*x_85 - 0.000126359658435081*x_86 - 0.0118167382417935*x_87 - 0.0106708409203756*x_88 + 0.000474268896710613*x_89 + 0.000186964254534234*x_9 - 1.01606157211257e-5*x_90 - 0.0249593733671128*x_91 + 0.000235362858379625*x_92 + 0.012173430381412*x_93 + 0.00176289400120423*x_94 - 0.000228829676757665*x_95 - 0.0011428795778995*x_97 - 0.000400396717914138*x_98 - 0.000300907676789488*x_99 - 4.17389944236922e-5*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) + 0.00044431269980251*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) + 0.000202676957236697*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 0.000389218365278495*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 0.000162905021739825*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) - 0.387972473454248*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.153917846294984*std::sin(0.423199862241745*x_16 - 7.38815975189209) - 0.25778170010744*std::sin(0.333759844303131*x_21 + 8.35000038146973) + 0.0495846504650244*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 0.274066161974353*std::sin(0.329119831323624*x_3 - 7.27343988418579) + 0.191093506626112*std::sin(0.258879989385605*x_30 - 1.12431991100311) - 0.0952824942573294*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.164414881454027*std::sin(0.176400005817413*x_46 + 4.97695970535278) + 0.00424184111322529*std::sin(1.35967981815338*x_67 + 6.00071954727173) + 0.220244139772268*std::sin(0.406319856643677*x_96 + 2.01399970054626) + 5.51182848697131) - 0.00460449093952775*std::sin(-0.00357750788327373*x_1 + 0.0158144332104491*x_10 + 0.0695365657962179*x_100 + 0.0503839348999002*x_101 - 0.00214193141929628*x_102 + 0.00015326505045934*x_103 + 0.0373942205047116*x_104 + 0.00167743231114575*x_106 + 0.00161433569683755*x_107 + 0.000726161054990963*x_108 - 0.00052606502841143*x_109 - 0.0446565790164562*x_11 - 0.00455257472043618*x_110 + 0.00206631538584435*x_111 - 0.00684282803466009*x_112 - 0.0447525587607134*x_113 - 0.0107423448799017*x_116 - 0.00153291360592024*x_117 + 0.00160233652973086*x_118 - 0.00608490871942876*x_119 + 0.014027397861854*x_12 - 0.000533433462436612*x_120 - 0.0311598319561519*x_13 - 0.0151131101851684*x_18 + 0.0695564406650915*x_19 + 0.00792210160431438*x_2 - 0.0061730513494638*x_20 - 0.00527723654629147*x_25 + 0.0203694687132588*x_26 - 0.040214940789805*x_27 + 0.0025267005831373*x_28 - 0.111189606963884*x_29 + 0.047587878168784*x_3 - 0.00563339417731604*x_31 + 0.10833232912837*x_32 + 0.0118893156347834*x_33 - 0.077916913880227*x_35 - 0.00792369939694945*x_36 - 0.0559162621933479*x_37 + 0.00118223074895354*x_38 - 0.00735713097706375*x_39 + 0.110826129498855*x_4 - 0.000950944528683164*x_40 + 0.0476451789785276*x_41 + 0.0371204677455846*x_42 + 0.011094472405108*x_43 + 0.0254877703393175*x_44 - 0.000106957309138344*x_47 + 0.0469579568302155*x_5 + 0.000383411975381604*x_50 + 0.00717934592442354*x_51 + 0.0281796941797142*x_52 + 0.00471641565935349*x_53 - 0.0409064471102862*x_56 + 0.0197313792664589*x_57 - 0.00264745911255811*x_58 + 0.0026822406298576*x_59 - 0.0051492968715285*x_6 - 0.0045165180818056*x_60 + 0.0107651706701275*x_61 - 0.0794145493958182*x_62 + 9.49964704488326e-6*x_63 + 0.0396679682822525*x_64 - 0.0020195082580301*x_65 - 0.00128036673368815*x_66 + 0.0274502991230969*x_67 + 0.00582284148880274*x_7 - 0.009395260232655*x_70 + 0.0033254995419963*x_71 + 0.00105641424973376*x_73 + 0.000566642151023707*x_76 - 0.00233789763514424*x_77 + 0.0440600734068475*x_78 + 0.0126285985913265*x_79 + 0.0118205142867793*x_80 - 0.000379266427243448*x_81 - 0.000625989741178384*x_82 + 0.00237200418850771*x_84 - 0.042481507456546*x_85 - 0.000509977906919629*x_86 - 0.00346236848148241*x_87 + 0.12029843382442*x_9 - 0.0308537469374823*x_90 - 0.000889209066838232*x_91 - 0.0257168164860675*x_92 - 0.0518734350827473*x_93 + 0.00167828867301096*x_94 - 0.000204292939724585*x_95 - 0.00519717271418392*x_96 + 0.0675594951329228*x_97 - 0.0105529964292276*x_99 - 0.00133625463957704*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 0.00125441513190085*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) + 0.00118176690074946*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 0.000549575882199081*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 0.00130265330997741*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 0.439201631791342*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.692970189481166*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.513721664689548*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.934061487772837*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 4.971543393074*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 1.70139052858801*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 1.28599644727693*std::sin(0.318879842758179*x_21 - 4.26336002349854) - 2.48730482511618*std::sin(0.305279940366745*x_23 + 5.12815999984741) + 1.90706158889981*std::sin(0.237119987607002*x_24 + 5.04519987106323) + 0.00807200480385017*std::sin(1.7519998550415*x_30 - 9.99600028991699) + 0.551468066301268*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.292310895259753*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.458074198024114*std::sin(0.209200009703636*x_46 + 5.00407981872559) - 0.203396010031254*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.76730837186318*std::sin(0.247039973735809*x_49 - 4.34455966949463) - 0.289879090317733*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 0.482493628049472*std::sin(0.286639958620071*x_55 - 4.2851996421814) + 0.49805320906394*std::sin(0.283279955387115*x_72 + 1.90391993522644) - 0.574027623042959*std::sin(0.298239946365356*x_74 - 7.49944019317627) - 0.121351269898069*std::sin(0.372399836778641*x_75 - 7.43207979202271) - 1.90720627156374*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 3.04434444312491*std::sin(0.150240033864975*x_83 + 4.93767976760864) - 0.722363070970218*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 0.506778619233597*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 16.4868848487189) + 0.234599001068199);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00516400478822914*x_1 + 0.00254898987789865*x_10 + 0.00020512835017987*x_100 + 0.00314602329788617*x_101 - 0.00250960992532639*x_102 - 0.000461453265607239*x_103 + 0.000314008181152612*x_104 - 0.000263301254873521*x_105 - 0.000353053918419218*x_106 - 0.000591093850117052*x_107 + 0.000955908155278582*x_108 + 0.00125576680805481*x_109 + 0.00141915716368174*x_11 - 0.000634552073038343*x_110 - 0.000301921279487039*x_111 - 0.000182297453067495*x_112 - 0.000368635739357981*x_113 + 0.00054601624007824*x_114 - 0.000624340679920499*x_115 - 0.00213271998578323*x_116 - 5.88524538438056e-5*x_117 + 0.000720709143211357*x_118 - 0.00179082662620069*x_119 + 0.00100176701778135*x_12 - 0.000130087232228225*x_120 - 0.000620247867852529*x_13 + 0.00116633291751527*x_14 - 0.00361526831239826*x_15 + 0.000717996071635207*x_16 - 0.00386794298720677*x_17 - 0.000921352658321541*x_18 - 0.0030115817564078*x_19 + 0.00275235981437012*x_2 + 0.00105488104871486*x_20 - 0.00294804907141851*x_21 + 0.00316168036320663*x_22 + 0.00336319635229457*x_23 + 3.30522353877433e-5*x_24 - 0.00253984391661981*x_25 - 0.000988924774895731*x_26 + 0.00198506025767533*x_27 + 0.000577065109226408*x_28 + 0.00061717989217118*x_29 - 0.00238171918080755*x_3 + 0.000809594516482843*x_30 - 0.00189817830227632*x_31 - 0.00287150369368227*x_32 - 0.00138124636712817*x_33 + 0.000620680557882403*x_34 - 0.000827224863432546*x_35 + 0.000627643474476062*x_36 - 0.00240936816368394*x_37 - 0.000386322269364098*x_38 + 0.000320605271866409*x_39 - 0.00224806480039607*x_4 - 0.00050816462302256*x_40 - 0.000715121426301173*x_41 + 0.00163682131470763*x_42 + 9.02945179786128e-5*x_43 + 0.00140403208900048*x_44 - 0.000394576383954088*x_45 - 5.86811107949306e-6*x_46 + 0.000105053089925986*x_47 - 0.000235937725501657*x_48 + 0.000490148173663644*x_49 - 0.000325937061902196*x_5 - 0.00310286064540351*x_50 - 0.000919456911254745*x_51 + 3.21325559929948e-5*x_52 + 0.00132736101095195*x_53 + 0.000106828574932475*x_54 + 0.00127994987578773*x_55 - 0.000144548213147111*x_56 - 0.000132006148777477*x_57 - 0.00127078902676495*x_58 - 0.000640693336213952*x_59 + 5.13588546816313e-5*x_6 - 0.00130802715680879*x_60 - 0.00185671083938712*x_61 - 0.000526885517528293*x_62 + 0.0016413792161568*x_63 - 7.85131557475919e-5*x_64 + 2.72462973851347e-5*x_65 + 9.36123482650717e-5*x_66 + 0.00101928262283374*x_67 - 0.000957634619790285*x_68 - 0.00101661057359126*x_69 - 0.00216887946805838*x_7 + 0.000168203949780263*x_70 - 0.000253318774772956*x_71 + 0.000353474147069886*x_72 + 1.47401550893493e-5*x_73 + 0.000307124128939492*x_74 + 0.00020620421411958*x_75 + 0.000820711306268973*x_76 + 0.000429646021731529*x_77 - 0.000654867769947653*x_78 + 0.00018220054819064*x_79 + 0.00100445353131096*x_8 + 0.00047063143464029*x_80 + 0.000502915803290853*x_81 - 0.00011411866351397*x_82 - 0.000741645300602817*x_83 + 0.000946278037528718*x_84 - 0.00027517310875636*x_85 + 0.00163818245343133*x_86 + 4.04337680255429e-5*x_87 + 0.00107576979213737*x_88 + 0.00116155204912992*x_89 - 0.00153183811793499*x_9 + 0.00134966654551895*x_90 - 0.000463523709194564*x_91 - 0.00329485812482313*x_92 + 0.00108989239700065*x_93 + 0.000523978422394498*x_94 - 0.000183105590134777*x_95 + 0.000248779981995864*x_96 + 0.0012161381883688*x_97 - 1.22024312508267e-5*x_98 - 1.98217202513998e-6*x_99 + 2.0945369822327e-5*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 6.77488186241104e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 2.34409340900221e-6*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 3.19391557562137e-7*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) - 3.93544797275853e-6*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) + 1.41710625984165e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) + 1.89103127670156e-5*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 2.98430844238908e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 4.00183186977778e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 3.07913143764174e-7*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 7.01840662369353e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) - 3.13156633906279e-5*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 1.10364825030565e-7*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 7.57322031210981e-5*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) - 3.39993157942517e-6*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) - 7.28573488824149e-5*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) - 6.40115301001277e-6*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 5.0005290880097e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 5.3148955340881e-5*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 1.87101255170568e-7*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 1.22825163524403e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) - 5.70657923580636e-5*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) + 0.000167028866427741*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 1.9197618166512e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 1.5509072498651e-6*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 3.07412700158719e-7*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) + 1.47208651368508e-7*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) - 3.09049532012604e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) - 1.73420124299651e-7*std::pow(-6.0*x_54 - 10.0, 2) + 2.17045443367428e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) + 9.5045467793413e-6*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 2.97834343243123e-6*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 6.09663087108899e-6*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 1.07618925200742e-5*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) + 1.67477753301578e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) - 1.23205618763233e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 8.56857627872929e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 1.45894779247211e-7*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) - 1.71462958858715e-5*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 7.5109642195593e-6*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) + 1.61155411846632e-5*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 1.50871589803749e-7*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) + 5.61171128010126e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 3.18075256907222e-6*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 5.17172934591362e-5*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) + 4.12162821340697e-5*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) + 1.29641309939909e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 1.21148599305707e-5*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) + 1.78917790406458e-5*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 1.24656785211487e-6*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) + 1.65124197451111e-5*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) + 7.42856300115756e-6*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) + 6.52747447525475e-6*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) - 9.74909599735788e-6*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 5.96701712976082e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 6.95385688078556e-7*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) + 1.5954102507706e-5*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 7.12036970889754e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 3.81675121175368e-6*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) + 2.89965838628992e-6*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 8.29713596451996e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 2.54330235791875e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 4.43403485697523e-6*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 1.87950315451911e-5*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) + 5.96099579114825e-6*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) + 4.45820006952009e-6*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) - 2.58201706024386e-5*std::exp(0.523359894752502*x_117) + 0.000270016719108884*std::exp(1.36367988586426*x_17) + 0.000646211613268128*std::exp(0.873679876327515*x_29) - 0.00034979196137283*std::exp(0.669199824333191*x_71) - 0.000206977950094505*std::exp(0.698639869689941*x_71) + 0.00123011593544847*std::exp(0.633919835090637*x_72) + 0.000903692022546735*std::exp(0.662319839000702*x_72) - 0.000406451543446201*std::exp(0.661519825458527*x_73) - 2.98043748215888e-5*std::exp(0.936639785766602*x_81) + 2.49959468749148e-5*std::exp(0.557839810848236*x_84) - 0.000188250107767751*std::exp(0.783999860286713*x_87) - 0.00049297685985307*std::exp(0.646719813346863*x_90) - 0.000832866487131564*std::sin(0.192880004644394*x_1 + 8.19839954376221) - 0.0102890377832484*std::sin(0.297999948263168*x_1 - 7.60376024246216) + 0.000520849536165721*std::sin(1.06031978130341*x_1 - 9.03824043273926) - 0.0594660448254681*std::sin(0.296639919281006*x_10 + 8.33568000793457) + 0.00296880972574293*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.0172005320060624*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.00649521348324404*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.0184362224027303*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.000246012247188681*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.0056908967160155*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.0130484047645924*std::sin(0.229759991168976*x_103 - 7.57151985168457) - 0.000165265493247578*std::sin(0.290079951286316*x_103 + 5.08432006835938) + 0.00201225069509678*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 0.0104847977568783*std::sin(0.356399834156036*x_104 - 1.21031987667084) - 0.0154702773425502*std::sin(0.303839921951294*x_105 - 7.50559997558594) - 0.0105567946499513*std::sin(0.357039839029312*x_105 + 1.9761598110199) - 0.00210134400049549*std::sin(0.284959942102432*x_106 + 5.08791971206665) + 0.0116607532438716*std::sin(0.319679945707321*x_106 - 7.47704029083252) - 0.00824840317833313*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.00558881739878083*std::sin(0.287759929895401*x_107 - 7.49671983718872) + 0.0115869062395877*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.00300549053465443*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 0.00237920741277478*std::sin(0.330799847841263*x_108 + 4.96007966995239) + 0.00447404396944332*std::sin(0.296799927949905*x_109 + 1.88975989818573) + 0.00137831304876019*std::sin(0.345119833946228*x_109 - 1.21783995628357) - 0.00465309930201756*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.00907129326908766*std::sin(0.26063996553421*x_11 + 8.29399967193604) + 0.0382408780543752*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.0289711825167938*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.00438808257516964*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 9.34776018433788e-5*std::sin(0.257199972867966*x_112 - 4.34687995910645) - 0.00159146485090025*std::sin(0.333999842405319*x_112 + 8.17199993133545) + 0.00759816648221295*std::sin(0.378399848937988*x_112 - 1.21479988098145) - 0.00908865245092563*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.00145731579790541*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 0.00129389891362121*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.011719248833845*std::sin(0.609919846057892*x_116 + 1.98527979850769) - 0.01496000452498*std::sin(0.186160013079643*x_117 - 7.60880041122437) - 0.0160709927656252*std::sin(0.303839921951294*x_117 - 7.50871992111206) - 0.00499095921110451*std::sin(0.403199851512909*x_119 - 1.18383979797363) + 0.021137892618726*std::sin(0.296079933643341*x_12 + 5.11951971054077) + 0.000417446560686749*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 0.00320351823984677*std::sin(0.382879853248596*x_12 - 4.20423984527588) + 0.0010654059793446*std::sin(0.454639852046967*x_120 - 1.17119991779327) - 0.0227666926310953*std::sin(0.23055998980999*x_13 - 4.35663986206055) - 0.000112631615811305*std::sin(1.31927990913391*x_13 + 1.20903992652893) + 0.014251012564657*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.0377405224816226*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 0.00291760757436003*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.0346423799430682*std::sin(0.441039860248566*x_15 + 5.44664001464844) - 0.00527314300273414*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.0281529947286781*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 0.0097748177515128*std::sin(0.354799836874008*x_16 + 5.1593599319458) + 0.00117779695806136*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0571842769666634*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 2.99807614049409e-6*std::sin(0.931919813156128*x_19 - 1.39031994342804) - 0.000141165475896147*std::sin(1.75519990921021*x_2 + 3.0064799785614) + 0.00250976745138527*std::sin(0.284399926662445*x_21 - 4.31175994873047) + 0.00197257504271824*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.040862293552888*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.0196960997439908*std::sin(0.153600037097931*x_24 + 4.94071960449219) - 0.0211978486809406*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.0217124290363634*std::sin(0.334719836711884*x_24 + 5.11863994598389) + 0.0245391044938613*std::sin(0.338799834251404*x_24 - 4.25447988510132) + 0.00691610233391815*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.0424389956740563*std::sin(0.368879854679108*x_24 - 1.02383983135223) - 0.0213534314160592*std::sin(0.381999850273132*x_24 + 8.38024044036865) + 0.0149367199009668*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.000379427414624268*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 0.000356620563326602*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.0251281494806445*std::sin(0.334959834814072*x_26 - 4.26191997528076) - 0.0149093153142065*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 0.0454320883996521*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.0343575458589434*std::sin(0.293599933385849*x_27 + 1.90855991840363) + 0.00300051730814688*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 0.00190302244221727*std::sin(0.364719837903976*x_27 - 4.22952032089233) + 0.00576435676241137*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.0153066969866399*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.000137884357401184*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.00968403739037994*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.0480557591395043*std::sin(0.3574398458004*x_28 - 1.04567980766296) - 0.023197421495847*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.000673525483995649*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 0.00210725545229418*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.011503326794922*std::sin(0.302559942007065*x_3 - 4.27119970321655) - 0.0113220570882816*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.000204806638140057*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.00209718560680942*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.0119300294543931*std::sin(0.339759826660156*x_3 - 1.05527985095978) + 0.0259664784786776*std::sin(0.353119850158691*x_3 - 4.22575998306274) - 0.00335111767978074*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.00146226936139794*std::sin(0.258879989385605*x_30 - 1.12431991100311) + 0.0123585974960576*std::sin(0.282159924507141*x_30 + 8.27752017974854) - 0.0002674141492462*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 0.000126884009251735*std::sin(0.232399985194206*x_33 - 4.37471961975098) - 0.0121891275619957*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.0120356884955457*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.00765146805865056*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.0121143857352167*std::sin(0.351599842309952*x_34 + 8.19431972503662) - 0.00091747515954787*std::sin(0.390399843454361*x_34 + 1.79423987865448) + 0.00889622002080076*std::sin(0.282239943742752*x_35 + 8.25271987915039) + 0.000294346605554225*std::sin(0.30447992682457*x_35 - 4.34575986862183) + 0.0111256726271686*std::sin(0.343759834766388*x_35 + 8.19143962860107) + 0.00238840552675167*std::sin(0.207520008087158*x_36 - 4.396559715271) + 0.000158646464013507*std::sin(0.302719831466675*x_37 + 8.13655948638916) - 0.016475641439632*std::sin(0.323999851942062*x_38 - 7.47088003158569) + 0.00375896786886763*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.0017678972783556*std::sin(0.328799843788147*x_39 + 1.9366397857666) - 0.0312585596147585*std::sin(0.213359996676445*x_40 + 5.00423955917358) - 0.00218148696092795*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 0.00457719520524428*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.000729112540190464*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.0191451583022822*std::sin(0.244239971041679*x_42 + 5.06047964096069) + 0.00161450034745513*std::sin(0.308959931135178*x_42 - 7.50464010238647) + 0.00493972918713159*std::sin(0.351759850978851*x_43 - 7.43048000335693) + 0.00145470527003805*std::sin(0.357199847698212*x_44 - 4.25239992141724) - 0.0195861719843947*std::sin(0.157600030303001*x_45 - 4.46623992919922) - 0.0157301428713418*std::sin(0.233679980039597*x_45 + 1.83839988708496) + 0.011886251426465*std::sin(0.321759849786758*x_45 - 4.27936029434204) - 0.000176364266095211*std::sin(0.32415983080864*x_45 + 1.94247984886169) + 0.0203314245342137*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.0012581214712779*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.0175689229571857*std::sin(0.221759989857674*x_47 + 1.82455992698669) - 0.00734994569496599*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.0181060179491128*std::sin(0.241199985146523*x_48 + 5.0479998588562) - 0.00212712330013859*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.0363074207771061*std::sin(0.145920038223267*x_49 + 4.93440008163452) - 0.00324993085128217*std::sin(0.489439845085144*x_5 - 3.86071991920471) + 6.84243634449335e-5*std::sin(0.8711998462677*x_5 - 3.34791970252991) - 0.0263297649905895*std::sin(0.200879991054535*x_51 - 7.59600019454956) + 0.00154068860449803*std::sin(0.299919933080673*x_51 + 5.09696006774902) - 0.0166165451030554*std::sin(0.346159845590591*x_51 + 5.14703989028931) - 8.96933306736773e-5*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 0.00160273459680353*std::sin(0.296959936618805*x_54 + 1.8899998664856) + 0.0138011621425235*std::sin(0.358159840106964*x_54 - 1.23015987873077) - 0.0258592930325322*std::sin(0.192479997873306*x_55 + 4.99200010299683) + 0.00181407396502075*std::sin(0.246559977531433*x_55 - 7.53864002227783) - 0.0116815517131914*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.011072449967471*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.0188514172667342*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.00513540458896744*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 0.00946877079715364*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.266227894675918*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.0306464500046094*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.0224139551412667*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.0111771473320714*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.027825144444687*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 3.2459053189722e-5*std::sin(1.35967981815338*x_67 + 6.00071954727173) - 0.0262662425478714*std::sin(0.153440043330193*x_69 + 4.9322395324707) - 0.00800887359463776*std::sin(0.166640013456345*x_70 - 7.62864017486572) - 0.0324646809752501*std::sin(0.176880016922951*x_71 + 1.76879990100861) + 0.0108148794906171*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.000623140132644272*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.039266409757911*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.00769957324176326*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 0.0046584417656012*std::sin(0.19336000084877*x_91 - 1.18735980987549) - 0.000135265352409332*std::sin(0.329439848661423*x_92 + 4.98511981964111) - 0.0170431329979491*std::sin(0.391039848327637*x_92 - 7.39135980606079) - 0.000113689566739487*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.0113080603496612*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.0197570506123601*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.000115562730156597*std::sin(0.362079858779907*x_95 - 1.19927990436554) - 0.000873477258563968*std::sin(0.157040029764175*x_96 + 1.74959981441498) - 0.0110270809742344*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.00593456884912639*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.00168533333917284*std::sin(0.406319856643677*x_96 + 2.01399970054626) - 0.00931230549557074*std::sin(0.223999992012978*x_97 + 1.82631993293762) - 0.00266818619367491*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.0127327335189636*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 0.0102338622758338*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 0.00533389429628203*std::sin(0.356479853391647*x_98 + 8.17695999145508) - 0.000211612207222562*std::sin(0.299839943647385*x_99 - 7.50551986694336) - 0.0156085873406497*std::sin(0.355119854211807*x_99 - 7.43391990661621) - 0.00594904707084353*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 9.92193540993176e-5*std::sin(0.359679847955704*x_99 + 8.18544006347656) - 0.00196625605358876*std::sin(0.36847984790802*x_99 + 1.96631979942322) + 0.0134026711839342*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.615746676921844*std::sin(-0.000394678093682118*x_1 + 0.00174468108968963*x_10 + 0.00767141824004546*x_100 + 0.00555846025426495*x_101 - 0.000236302319085906*x_102 + 1.69085184203793e-5*x_103 + 0.00412540800609583*x_104 + 0.000185057813552032*x_106 + 0.000178096864124251*x_107 + 8.01115945068906e-5*x_108 - 5.80365856178791e-5*x_109 - 0.00492660646786652*x_11 - 0.000502249490604317*x_110 + 0.000227960201358047*x_111 - 0.000754914988934369*x_112 - 0.00493719515242894*x_113 - 0.00118511777952973*x_116 - 0.000169114210088154*x_117 + 0.00017677309110852*x_118 - 0.000671299757253418*x_119 + 0.00154753164159934*x_12 - 5.88494865504187e-5*x_120 - 0.00343761732389402*x_13 - 0.00166730967816394*x_18 + 0.00767361087682367*x_19 + 0.000873982688833567*x_2 - 0.000681023835111361*x_20 - 0.000582195687041778*x_25 + 0.00224720205891197*x_26 - 0.00443659572147058*x_27 + 0.000278750851708976*x_28 - 0.0122666681795295*x_29 + 0.00524999347334646*x_3 - 0.000621487735990244*x_31 + 0.0119514473593285*x_32 + 0.00131165397338757*x_33 - 0.00859595563146627*x_35 - 0.000874158960632787*x_36 - 0.00616879808189412*x_37 + 0.000130426149574935*x_38 - 0.000811653956815338*x_39 + 0.0122265685913037*x_4 - 0.000104910173792451*x_40 + 0.00525631501758729*x_41 + 0.00409520703362065*x_42 + 0.0012239652188411*x_43 + 0.00281186371573392*x_44 - 1.17997523006047e-5*x_47 + 0.00518049924407075*x_5 + 4.22988047758073e-5*x_50 + 0.000792040340870764*x_51 + 0.00310884234005299*x_52 + 0.000520324762986329*x_53 - 0.00451288413375129*x_56 + 0.00217680670698582*x_57 - 0.000292073183271262*x_58 + 0.000295910352437908*x_59 - 0.000568081116623123*x_6 - 0.000498271647406307*x_60 + 0.00118763596807523*x_61 - 0.00876117788942068*x_62 + 1.04802077553958e-6*x_63 + 0.00437625257936693*x_64 - 0.000222796341884016*x_65 - 0.000141252715061418*x_66 + 0.00302837396377552*x_67 + 0.000642387956532135*x_7 - 0.00103650460579236*x_70 + 0.000366876010507853*x_71 + 0.000116545812288192*x_73 + 6.25131379895999e-5*x_76 - 0.000257921718684879*x_77 + 0.00486079873115356*x_78 + 0.00139321320330409*x_79 + 0.00130406366590006*x_80 - 4.18414593024165e-5*x_81 - 6.90604872928365e-5*x_82 + 0.000261684424429427*x_84 - 0.00468664805969609*x_85 - 5.62618209911113e-5*x_86 - 0.000381975675940662*x_87 + 0.0132715728613067*x_9 - 0.00340384938945061*x_90 - 9.80993895290647e-5*x_91 - 0.00283713256195707*x_92 - 0.00572278500542869*x_93 + 0.000185152289170114*x_94 - 2.25380210565552e-5*x_95 - 0.000573362878936216*x_96 + 0.00745330370167857*x_97 - 0.00116422846551784*x_99 - 0.000147418384816959*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 0.000138389680497805*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) + 0.000130374976878489*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 6.06303517971607e-5*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 0.000143711416406471*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 0.0484536354449228*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.0764499093465831*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.0566748401172879*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.10304760168375*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 0.54847098400824*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.187700933818054*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.141873796747243*std::sin(0.318879842758179*x_21 - 4.26336002349854) - 0.274404629930505*std::sin(0.305279940366745*x_23 + 5.12815999984741) + 0.210390991997649*std::sin(0.237119987607002*x_24 + 5.04519987106323) + 0.000890520320883589*std::sin(1.7519998550415*x_30 - 9.99600028991699) + 0.0608391014739507*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.0322483445649491*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.0505356961158343*std::sin(0.209200009703636*x_46 + 5.00407981872559) - 0.0224390699114896*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.084651051892628*std::sin(0.247039973735809*x_49 - 4.34455966949463) - 0.0319800627972944*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 0.0532296983111258*std::sin(0.286639958620071*x_55 - 4.2851996421814) + 0.0549462635776887*std::sin(0.283279955387115*x_72 + 1.90391993522644) - 0.0633279185890023*std::sin(0.298239946365356*x_74 - 7.49944019317627) - 0.0133877239217839*std::sin(0.372399836778641*x_75 - 7.43207979202271) - 0.210406953689377*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 0.335858396550837*std::sin(0.150240033864975*x_83 + 4.93767976760864) - 0.0796925930281933*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 0.0559088689344667*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 8.36674792649577) + 0.249322497563858);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000141220803108118*x_1 - 0.000487676445639151*x_10 + 0.000726719550642217*x_100 - 0.000485159198611513*x_101 - 5.94066131654435e-5*x_102 + 2.88414617258018e-5*x_103 + 0.000103908099132612*x_104 + 4.35977224971917e-6*x_105 + 5.21200547123904e-5*x_106 - 1.00219966938458e-6*x_107 - 0.000520218466952361*x_108 - 3.76532311526148e-5*x_109 - 8.98015150061811e-5*x_11 - 0.000355503343076236*x_110 - 0.000123097554608705*x_111 + 3.96268468749635e-5*x_112 + 4.37797380700607e-5*x_113 + 9.37175778071189e-5*x_114 - 9.25447344792326e-5*x_115 + 0.000257126131544416*x_116 - 9.5803171715838e-5*x_117 - 9.72859322328988e-5*x_118 - 0.000162981887257495*x_119 + 0.000132192369381598*x_12 - 0.000176583037492879*x_120 + 2.56163321970818e-5*x_13 - 0.000286680891400877*x_14 - 0.000216575864392224*x_15 - 0.00059402456945465*x_16 - 0.00211402852701141*x_17 + 0.000214784016063575*x_18 - 0.000165759863328531*x_19 - 6.21844316009437e-5*x_2 - 0.000147930772002964*x_20 + 0.000229759782282019*x_21 + 0.000373231250402691*x_22 - 0.000194268957550569*x_23 + 5.01542890923253e-5*x_24 + 0.000377861810918175*x_25 + 7.26028649864858e-5*x_26 - 4.55604819410793e-5*x_27 - 0.000227890281591307*x_28 + 0.00033714160670928*x_29 - 0.000573918873558613*x_3 - 0.000115109523884715*x_30 - 0.00121846671310128*x_31 - 8.49490393718005e-5*x_32 + 0.000258785023543899*x_33 + 2.91154212234778e-5*x_34 + 0.000305862579351454*x_35 + 4.03873887186459e-5*x_36 + 0.000293158505061736*x_37 - 5.13818737335861e-5*x_38 - 0.000120350751743026*x_39 - 5.60044760019253e-5*x_4 + 8.69922601220968e-5*x_40 + 5.24522541181592e-5*x_41 - 4.45327009812199e-5*x_42 + 1.93899386629714e-5*x_43 - 0.000128209393205597*x_44 + 2.72965169619093e-5*x_45 - 0.000441778656831663*x_46 + 3.77186503712934e-5*x_47 - 0.000219453310713944*x_48 - 0.000101833177046335*x_49 - 5.80814322194552e-5*x_5 + 0.000166131830331415*x_50 + 0.000158935092627177*x_51 + 0.000791384483092393*x_52 + 0.000418972968146899*x_53 + 0.000455498751675216*x_54 + 3.04537319793952e-5*x_55 + 6.62182974590405e-5*x_56 - 2.40961204020403e-6*x_57 - 4.99315367569816e-6*x_58 + 6.9960362093147e-7*x_59 - 8.53734972456642e-5*x_6 - 0.000100920491347865*x_60 - 0.000135870510417579*x_61 - 6.56712671043309e-5*x_62 + 6.17450446480391e-5*x_63 + 3.50109695943264e-5*x_64 - 1.17692893102402e-5*x_65 + 1.82498257064598e-5*x_66 + 6.36476613815262e-5*x_67 + 0.000302444055399197*x_68 + 0.000132529288514291*x_69 + 9.62733619248446e-5*x_7 + 2.56417278086854e-5*x_70 + 0.000639587663040328*x_71 + 3.34174463266452e-5*x_72 + 0.000345133379308407*x_73 + 0.000238887263468143*x_74 - 5.95008646095654e-5*x_75 + 0.000281679512634501*x_76 + 0.000306464894648075*x_77 - 0.000176552991175874*x_78 - 1.94038819810663e-5*x_79 + 0.000838694641338003*x_8 - 0.00030127904807322*x_80 - 4.64856074576671e-5*x_81 + 2.14810657557629e-6*x_82 - 0.000255468427020697*x_83 - 0.000343625714573086*x_84 + 8.54621382135532e-5*x_85 - 1.05269611559425e-5*x_86 - 4.33410373380456e-7*x_87 + 0.000108790038490831*x_88 - 5.11616553208448e-5*x_89 - 0.000241544694508492*x_9 + 0.000179916321097403*x_90 - 0.000156281895513166*x_91 + 6.14694204255931e-5*x_92 + 0.00046089187559581*x_93 + 0.000196752187188793*x_94 + 3.31215953326396e-5*x_95 - 0.000253252910517398*x_96 + 1.34747350319321e-5*x_97 - 2.8950335378493e-5*x_98 + 3.47264417730448e-5*x_99 - 8.60867792871609e-7*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 3.91744594708911e-7*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 1.07750652805209e-8*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) + 4.17429630696854e-7*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) - 2.00580084639367e-6*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) - 3.79208829647888e-6*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) + 5.08503061624286e-6*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 1.61640450536793e-5*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) + 8.91811893154449e-6*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 2.00613739608982e-6*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) + 3.32162587198783e-6*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 5.79365330861545e-6*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 1.2656356228874e-5*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 1.88327062207528e-6*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 1.1470085495445e-7*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) - 3.57942668103944e-6*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 1.51055534239776e-6*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) + 6.35405092901975e-6*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 8.88224670964714e-6*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 9.8219682382032e-6*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 1.58933924545573e-6*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 1.77166102845908e-5*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 5.23217551173953e-8*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 1.6137774031642e-5*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) + 1.3080533717532e-7*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) - 1.51833707596746e-7*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) - 1.22494774155092e-7*std::pow(-6.0*x_54 - 10.0, 2) - 5.12187653550724e-7*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) - 2.64711109448785e-7*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 1.0047806259254e-7*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) - 6.46664468855847e-7*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 2.03124945433609e-7*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) + 3.16105270864498e-8*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) - 1.08878818832962e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 7.6588149372885e-6*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 4.77541445400802e-7*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 1.41765418527081e-7*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 4.4883389870121e-7*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 7.92007494417251e-6*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) + 4.98640385127001e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 1.77420283742108e-6*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) - 1.5626797826389e-7*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 8.25085800725533e-7*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) - 8.64298755663282e-6*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) + 7.77935204597404e-7*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 3.3741093473373e-7*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 8.9132426705284e-7*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 4.2054492879084e-8*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) - 1.75145836606798e-6*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) - 7.87941380916784e-7*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) + 3.20689905066943e-7*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) - 2.97262064191232e-7*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 1.31250316505945e-8*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 4.44337670498287e-7*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) - 9.04768094885577e-7*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 7.20391306803152e-8*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) + 5.4729495801282e-8*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) + 4.13342832784423e-7*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 1.2495052945966e-6*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 7.41015345762319e-7*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) + 2.38823903528596e-6*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) + 2.92859233937207e-7*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) - 1.95569125964871e-6*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) + 8.41461336065398e-8*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) - 1.82379984985285e-5*std::exp(0.523359894752502*x_117) - 3.4310369057118e-5*std::exp(1.36367988586426*x_17) + 8.25445220811031e-5*std::exp(0.669199824333191*x_71) - 3.90659772344734e-6*std::exp(0.698639869689941*x_71) - 0.000156307845927347*std::exp(0.633919835090637*x_72) - 2.51687243423659e-5*std::exp(0.662319839000702*x_72) - 6.79261306501942e-5*std::exp(0.661519825458527*x_73) - 5.6254157881855e-7*std::exp(0.936639785766602*x_81) + 2.22106732762928e-5*std::exp(0.557839810848236*x_84) + 1.99675293659274e-5*std::exp(0.783999860286713*x_87) - 0.000740060999530185*std::sin(0.192880004644394*x_1 + 8.19839954376221) + 0.00109134951645082*std::sin(0.297999948263168*x_1 - 7.60376024246216) + 0.0029624515649439*std::sin(0.296639919281006*x_10 + 8.33568000793457) + 0.000100156431323649*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.00287455073830047*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.000122593668530198*std::sin(0.206560000777245*x_102 - 7.59832000732422) - 0.000918447091427056*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.000218599346190721*std::sin(0.310559928417206*x_102 + 1.90255987644196) - 0.000723128431590549*std::sin(0.333999842405319*x_102 + 1.93591976165771) - 0.0016580291196683*std::sin(0.229759991168976*x_103 - 7.57151985168457) - 0.000116734775463615*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 0.000474854457152865*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 0.00175221807804217*std::sin(0.356399834156036*x_104 - 1.21031987667084) + 0.00164091920477152*std::sin(0.303839921951294*x_105 - 7.50559997558594) + 0.000659379426543411*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.000294017262357592*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.00194874361063348*std::sin(0.319679945707321*x_106 - 7.47704029083252) - 0.000405237836201617*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.000105485928896634*std::sin(0.287759929895401*x_107 - 7.49671983718872) - 0.000577231067293444*std::sin(0.356399834156036*x_107 + 5.16552019119263) + 0.000381900386694521*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 4.4906263001016e-5*std::sin(0.330799847841263*x_108 + 4.96007966995239) + 8.44451787142064e-5*std::sin(0.296799927949905*x_109 + 1.88975989818573) - 0.000228603264415344*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.000171215791911942*std::sin(0.26063996553421*x_11 + 8.29399967193604) - 0.00190506614942204*std::sin(0.279119968414307*x_11 - 1.08031988143921) + 0.00368129783760349*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 8.28227035325719e-5*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.00490715059849314*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 0.000375556673775064*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.000378521898538908*std::sin(0.378399848937988*x_112 - 1.21479988098145) - 0.00151889445069237*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.00104036563864328*std::sin(0.328399837017059*x_114 - 7.44743967056274) - 2.44216475620501e-5*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.000771257372802409*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.00058382404865982*std::sin(0.609919846057892*x_116 + 1.98527979850769) - 0.000734973755792379*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.00044759318078993*std::sin(0.303839921951294*x_117 - 7.50871992111206) - 0.000245202067303316*std::sin(0.403199851512909*x_119 - 1.18383979797363) - 0.00224207835311814*std::sin(0.296079933643341*x_12 + 5.11951971054077) + 0.000294862100806637*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 6.0464687456288e-5*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 0.000251416376300352*std::sin(0.454639852046967*x_120 - 1.17119991779327) - 0.0011185104631557*std::sin(0.23055998980999*x_13 - 4.35663986206055) - 0.0014023193075397*std::sin(0.249839976429939*x_14 + 8.26024055480957) - 0.00151159282325646*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.00746384620246178*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.00172579785618718*std::sin(0.441039860248566*x_15 + 5.44664001464844) - 9.95277440929701e-5*std::sin(0.333039849996567*x_16 - 1.04951989650726) + 0.00140251270345309*std::sin(0.34215983748436*x_16 - 7.24799966812134) + 0.00103680663354901*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.00255432090835157*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 3.97344225601238e-5*std::sin(0.423199862241745*x_16 - 7.38815975189209) - 0.00726626726472999*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 2.11768190809867e-6*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 3.33124772120737e-5*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.00193068408348988*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 6.65472344298904e-5*std::sin(0.333759844303131*x_21 + 8.35000038146973) + 0.00519227245241258*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.00373422480816953*std::sin(0.305279940366745*x_23 + 5.12815999984741) + 0.00037175331181671*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.00059038123253344*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.00286309768873794*std::sin(0.237119987607002*x_24 + 5.04519987106323) + 0.00275894565278275*std::sin(0.334719836711884*x_24 + 5.11863994598389) - 0.00260284201377055*std::sin(0.338799834251404*x_24 - 4.25447988510132) + 0.000339782899083786*std::sin(0.353439837694168*x_24 + 8.3342399597168) - 0.00211420600644034*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.00249622274496965*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 1.28004484307647e-5*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 1.75204997019409e-5*std::sin(1.52239990234375*x_25 - 9.59887981414795) - 0.00319297295829922*std::sin(0.334959834814072*x_26 - 4.26191997528076) + 0.000742745286229241*std::sin(0.423199862241745*x_26 + 2.22815990447998) + 0.00481894310729774*std::sin(0.274159967899323*x_27 - 7.50144004821777) - 0.00436572995260286*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 0.000708067350161527*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 0.000283198506546063*std::sin(0.41431987285614*x_27 + 8.41983985900879) + 0.00194498483053309*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.00723830408141765*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.000182781008342983*std::sin(0.324479848146439*x_28 + 8.32696056365967) - 0.00239401929765506*std::sin(0.3574398458004*x_28 - 1.04567980766296) + 0.000646071330183125*std::sin(0.358319848775864*x_28 - 4.23296022415161) - 8.55832483319158e-5*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 0.000556244137999763*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.0107514206302409*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 7.07511243917086e-5*std::sin(0.329119831323624*x_3 - 7.27343988418579) + 0.00151591988375156*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.00129358586115845*std::sin(0.353119850158691*x_3 - 4.22575998306274) - 6.32505476687641e-5*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 4.93314474153034e-5*std::sin(0.258879989385605*x_30 - 1.12431991100311) - 0.00131086596098342*std::sin(0.282159924507141*x_30 + 8.27752017974854) - 1.31378557603589e-5*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 1.2118611392471e-5*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.00666083564041458*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.00127661527700401*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.000827926562639658*std::sin(0.295999944210052*x_34 - 1.14071989059448) - 0.000375910863329057*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.00202455461534272*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.00148673516725314*std::sin(0.282239943742752*x_35 + 8.25271987915039) + 0.000207910824169299*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.000563620135716748*std::sin(0.207520008087158*x_36 - 4.396559715271) + 0.000140968645687888*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.000820775787418586*std::sin(0.323999851942062*x_38 - 7.47088003158569) + 7.09485010955272e-5*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.00087058206850839*std::sin(0.213359996676445*x_40 + 5.00423955917358) - 8.63921029289202e-5*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 2.45975043215419e-5*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.00319953643953034*std::sin(0.244239971041679*x_42 + 5.06047964096069) + 3.04728275596183e-5*std::sin(0.308959931135178*x_42 - 7.50464010238647) + 9.32347372658947e-5*std::sin(0.351759850978851*x_43 - 7.43048000335693) - 0.000962253879063267*std::sin(0.157600030303001*x_45 - 4.46623992919922) - 0.000438850351494907*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.00198642883845263*std::sin(0.321759849786758*x_45 - 4.27936029434204) - 0.000124574359703679*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 4.24442683686373e-5*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.000687713068768767*std::sin(0.209200009703636*x_46 + 5.00407981872559) - 0.000138726280293652*std::sin(0.299439936876297*x_47 - 7.47208023071289) + 0.00230068775014763*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.000501962296470193*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.000305361216233692*std::sin(0.452239871025085*x_48 - 1.14887976646423) + 0.0017837562393197*std::sin(0.145920038223267*x_49 + 4.93440008163452) + 0.0011519705702311*std::sin(0.247039973735809*x_49 - 4.34455966949463) - 6.13407005875901e-5*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 1.61469015957336e-5*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.000462787357625107*std::sin(0.346159845590591*x_51 + 5.14703989028931) - 6.33546096709388e-5*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 0.000384376133575424*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.000435199449421537*std::sin(0.371679842472076*x_54 - 1.22119987010956) - 0.00432160178838621*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.000724374293593831*std::sin(0.286639958620071*x_55 - 4.2851996421814) + 0.00148434642033328*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.00185042644132*std::sin(0.264799952507019*x_58 + 1.87719988822937) + 0.00239540383205144*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.000252298559934551*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 0.00158241978074647*std::sin(0.337439835071564*x_59 + 1.93647980690002) + 0.01326281654563*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.00284808687204454*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.000210962657143761*std::sin(0.212959989905357*x_65 + 5.0129599571228) + 0.0035356735616799*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 1.09504590457158e-6*std::sin(1.35967981815338*x_67 + 6.00071954727173) + 0.00278603808319858*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.00188994807279951*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.000904173751613109*std::sin(0.176880016922951*x_71 + 1.76879990100861) - 0.000747734105725517*std::sin(0.283279955387115*x_72 + 1.90391993522644) + 0.000861795534225074*std::sin(0.298239946365356*x_74 - 7.49944019317627) + 0.00018218632391994*std::sin(0.372399836778641*x_75 - 7.43207979202271) + 0.00286331490280334*std::sin(0.221279993653297*x_8 - 4.37391948699951) + 0.000204125046064623*std::sin(0.305519938468933*x_8 - 4.23663949966431) - 7.91809040413714e-5*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.00457051601771371*std::sin(0.150240033864975*x_83 + 4.93767976760864) + 0.00108449357428337*std::sin(0.276799947023392*x_88 - 7.51471996307373) + 0.00656219744367378*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.000145325312595155*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 0.000120192868187816*std::sin(0.329439848661423*x_92 + 4.98511981964111) + 0.00180775067095208*std::sin(0.391039848327637*x_92 - 7.39135980606079) - 0.000101021250941615*std::sin(0.330639839172363*x_94 - 7.62272024154663) + 0.00143688777938445*std::sin(0.388399839401245*x_94 + 1.99583983421326) - 0.00251048046294083*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.00606651977873367*std::sin(0.362079858779907*x_95 - 1.19927990436554) - 0.000776146552931987*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.000307115205641976*std::sin(0.301839828491211*x_96 + 8.14343929290771) - 0.000754091258053893*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 5.68567838412344e-5*std::sin(0.406319856643677*x_96 + 2.01399970054626) - 0.000457506555812676*std::sin(0.223999992012978*x_97 + 1.82631993293762) - 5.03605823962634e-5*std::sin(0.263919949531555*x_97 - 7.51999998092651) + 0.000634313353948042*std::sin(0.40175986289978*x_97 - 1.17407977581024) + 0.00130039203765744*std::sin(0.346879839897156*x_98 - 7.43207979202271) + 0.000565761646878638*std::sin(0.356479853391647*x_98 + 8.17695999145508) + 0.00076083368354484*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 0.000149471635064676*std::sin(0.299839943647385*x_99 - 7.50551986694336) + 0.00165558962903529*std::sin(0.355119854211807*x_99 - 7.43391990661621) - 0.00029227220230733*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 0.00520856657904363*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 0.000464000560777802*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.000373277762847979*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.150060802698135*std::sin(0.00988475305900299*x_1 - 0.00189799807973476*x_10 - 0.000307460647368892*x_100 - 0.00142193069460263*x_101 + 0.000356643776722049*x_102 + 0.0001972664436292*x_103 + 0.00819978761961127*x_104 + 0.000343495596315191*x_105 + 8.6209720073343e-7*x_107 + 0.000441752113766477*x_108 + 0.0010222383615764*x_11 - 0.00749003735583069*x_110 - 0.0019338588878449*x_111 - 0.00295464222131121*x_112 - 0.000116626586850766*x_113 + 0.0005894385570483*x_114 + 0.00122063876630226*x_116 - 6.42406023879962e-6*x_117 + 0.000511332847780742*x_118 - 0.00399741183002609*x_119 + 0.00877981945575083*x_12 + 0.00201717312624855*x_13 - 0.00114028368892446*x_14 + 0.0121488358194459*x_16 + 6.99732979737302e-5*x_17 - 3.30193901217071e-5*x_18 - 0.000142859750166148*x_19 - 0.0198483032742049*x_2 - 0.00235981425991842*x_20 - 0.00324629512470942*x_22 - 0.000160916531665132*x_23 - 0.000507942186425262*x_24 + 0.000394014572714037*x_25 + 0.00024536205301167*x_26 + 0.000622847379303237*x_28 + 0.000263016473712548*x_29 + 0.000159096862762836*x_30 + 0.0290405450950893*x_31 - 0.000905837186375213*x_32 + 0.00659372541446504*x_33 - 0.000209447018447584*x_35 - 0.000587560845568811*x_36 - 0.0104114237639923*x_37 + 0.00261620997838955*x_38 + 0.00820603820949767*x_4 - 0.000856903778656274*x_40 + 0.000753401482004809*x_42 + 0.000140672087866848*x_43 - 6.26056520255681e-5*x_45 - 0.000220525399368007*x_47 + 0.000253564562317095*x_48 + 4.48406749192906e-5*x_5 + 0.00125378881333644*x_50 - 0.000275422188671304*x_52 - 6.33522670061059e-6*x_53 + 0.0130227957322939*x_56 + 0.000745046854333493*x_57 + 3.41802586507417e-5*x_58 - 0.000131570001970051*x_59 - 0.00559775775178133*x_6 + 0.000139136751002614*x_60 + 0.00045059336146154*x_61 + 0.000348135189511608*x_62 + 0.00355717685902318*x_63 + 0.000394671732493828*x_65 + 0.000646578058173128*x_66 - 0.000119661435860544*x_67 + 2.45856812278579e-5*x_68 + 4.69573129632239e-5*x_69 - 0.00212356339820736*x_7 + 0.000267419363911232*x_71 - 0.00558048799035103*x_72 + 0.000152254433421666*x_73 - 0.00511709939704819*x_74 + 7.23073295040638e-5*x_75 + 0.000350241903274674*x_76 + 0.000110612227459477*x_77 + 0.000617494252595135*x_78 + 0.000480457442133265*x_79 + 0.000843683395283727*x_8 + 0.00745190563091404*x_80 - 6.61167158889278e-5*x_81 - 0.000781132747749265*x_82 - 0.00170721895302935*x_83 - 0.000391245844927692*x_84 - 0.00018207556270498*x_85 + 0.000689407955935495*x_86 + 9.29070570733944e-5*x_87 + 0.000262763597966386*x_88 + 0.000602424348728736*x_89 + 0.000249767796635333*x_9 + 0.000587840182134009*x_90 + 0.00939868675826514*x_92 + 0.0157367761786413*x_93 + 0.000389644889731345*x_94 - 0.00306599875799591*x_95 - 0.00865797345966387*x_96 + 0.00113608085880791*x_97 - 0.000195748444703448*x_98 + 0.00105652404915602*x_99 - 0.000130302665397252*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 0.0001129375166748*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 0.000176521753326722*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) + 0.000113287344581773*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) - 0.000119204951029212*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 0.19321820243154*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 0.126735636624266*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.133999925181205*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 0.268273491054089*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.230772665191184*std::sin(0.284399926662445*x_21 - 4.31175994873047) - 0.174982570861981*std::sin(0.364719837903976*x_27 - 4.22952032089233) + 0.193761759359884*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.0843616756997565*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 0.162557836378496*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 0.200587333211008*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 0.133759887613909*std::sin(0.357199847698212*x_44 - 4.25239992141724) - 0.141666039733463*std::sin(0.299919933080673*x_51 + 5.09696006774902) + 0.147371157552593*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 0.166803774401771*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 0.428342881445985*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 11.1971043887824) - 0.00457225274294615*std::sin(-0.0387013353751705*x_100 + 0.00130692332177264*x_101 + 0.0871470331655887*x_102 + 0.00257462440934958*x_103 + 0.000830954364174193*x_104 + 0.00271391513934452*x_105 - 0.000865453431622897*x_106 + 0.0409911886763667*x_107 + 0.0084142888333115*x_108 + 0.00499827832887843*x_109 - 0.000127016671290923*x_11 - 0.00107231045950566*x_110 - 0.00812136819895911*x_111 + 0.00214948290714633*x_112 + 0.00454669809509267*x_113 - 0.00167794217185548*x_114 - 5.8137806826159e-5*x_115 - 8.43257435054647e-5*x_116 + 0.00222131018249578*x_117 - 0.00186914688275987*x_118 - 0.00403909038802518*x_119 - 0.101779547061897*x_12 - 0.00769510145715073*x_120 - 0.108095947564521*x_14 - 0.00141604833229869*x_16 - 0.019442423072801*x_17 + 0.00126496624741782*x_18 + 0.0119871824672596*x_19 - 0.0418909627800541*x_2 + 0.00338583634172715*x_20 + 0.00208767939539896*x_21 - 0.109534265701649*x_22 + 0.0032730685684825*x_23 + 0.00568636593003502*x_25 - 0.00184974753832738*x_26 + 0.00100254498897949*x_27 + 0.00496461837900798*x_28 + 0.000833972889248691*x_30 - 0.0999963378493648*x_31 + 0.00403001234072787*x_32 - 0.015035783999673*x_34 + 0.00412979027541861*x_36 + 0.0100177910523067*x_37 - 0.00610771136805281*x_38 + 0.00386384969937024*x_39 + 0.00330896127088251*x_4 - 0.0384047287539116*x_40 + 0.0143737942540917*x_41 + 0.00990662160982017*x_42 - 0.00262181334461897*x_43 - 0.000647010527122467*x_44 + 0.0048907150362684*x_48 + 0.00185343329763481*x_49 + 0.0139606967327609*x_5 + 0.059261133740547*x_50 + 0.0105222630778224*x_52 + 2.7613067344496e-5*x_53 - 0.0652845554475249*x_54 + 0.00200949135955052*x_55 + 0.0104772529571451*x_56 + 0.000616847799578372*x_57 + 0.00782265296073341*x_58 + 0.039535593357815*x_59 - 0.00281694764327199*x_60 + 0.0453159424568126*x_61 - 0.00659885860925332*x_62 + 0.0405768902808001*x_63 + 0.00358841593872297*x_64 + 0.00819411167061045*x_65 - 0.00292798297112887*x_66 + 0.017004302752163*x_67 + 0.0268628158714303*x_68 - 5.28024323112622e-5*x_69 + 0.0339751807625154*x_7 + 0.0113754019160605*x_70 + 0.0097837037067055*x_71 + 0.000865929878916641*x_72 + 0.00126684417754588*x_73 + 0.0048843855976418*x_74 + 0.00168581921042914*x_75 + 0.00259316642910954*x_77 + 0.00215038178386669*x_78 - 0.0492196204386521*x_79 - 0.0599493154736103*x_8 + 0.00646661798351888*x_80 + 8.77214784105655e-5*x_81 - 0.0124388741657802*x_82 + 0.0003784018064674*x_83 - 0.00375932962216502*x_84 + 0.00280063594481648*x_85 - 0.00169993541297532*x_86 - 6.27637626583368e-5*x_87 + 0.0284289893862309*x_88 + 0.00514206090640788*x_89 - 0.0063166919777951*x_9 + 0.00224089000239468*x_91 + 0.000559960253621182*x_92 - 0.0161456828087768*x_93 - 0.00579037965780028*x_94 + 0.000589825656779254*x_95 - 0.00557631803751103*x_96 + 0.00369531857574525*x_97 + 0.00217939658644786*x_98 - 0.000630746578402473*x_99 - 0.00146893377416564*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 0.000683720387827033*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) - 0.0453198999129517*std::exp(0.873679876327515*x_29) + 0.0345732906825249*std::exp(0.646719813346863*x_90) - 0.0365280480326862*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.00789904336411917*std::sin(1.31927990913391*x_13 + 1.20903992652893) + 2.64680588589168*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 1.49755181538706*std::sin(0.381999850273132*x_24 + 8.38024044036865) - 0.806747524042919*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.854843877444587*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.780262006399965*std::sin(0.343759834766388*x_35 + 8.19143962860107) + 1.10318119623432*std::sin(0.233679980039597*x_45 + 1.83839988708496) - 1.42587676553559*std::sin(0.175040006637573*x_46 - 7.61616039276123) + 1.23213791527396*std::sin(0.221759989857674*x_47 + 1.82455992698669) + 1.84655040176436*std::sin(0.200879991054535*x_51 - 7.59600019454956) - 2.14928673267265*std::sin(0.262399971485138*x_6 + 8.30399990081787) + 13.2775889416645) + 0.24113449053706);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00409162809546099*x_1 + 0.00122092796747913*x_10 - 0.000381982128088427*x_100 - 0.00206489949570381*x_101 + 0.00154983190261493*x_102 - 2.58748232063433e-5*x_103 + 0.000148838765011032*x_104 + 0.000159094588158131*x_105 - 0.000192505376113432*x_106 + 0.000189431148220942*x_107 + 0.000505463330552692*x_108 - 0.000644500921932894*x_109 + 0.00089808932085814*x_11 + 3.14342515880709e-5*x_110 + 0.000163497819165247*x_111 - 0.000484644843784753*x_112 + 1.80837911518345e-5*x_113 - 4.20216996825433e-5*x_114 + 0.000309339257034473*x_115 - 0.00162119139803399*x_116 + 0.000350561275320852*x_117 + 0.00150327886654544*x_118 + 0.000632145246692164*x_119 - 0.000637926912477961*x_12 + 2.27208948555072e-6*x_120 + 0.000166568092203548*x_13 - 0.000419777263084893*x_14 + 0.0014784008163397*x_15 - 0.000598280157960987*x_16 + 0.00361466453524251*x_17 + 0.000578554000714066*x_18 + 0.00205059440067769*x_19 + 0.000490396331251576*x_2 - 0.00463531364545763*x_20 + 0.000182625427243086*x_21 - 0.00331781715847379*x_22 - 0.00225561150979333*x_23 - 0.00047932268612351*x_24 - 0.00211046106229551*x_25 - 0.000862107482569801*x_26 - 0.00170150588814398*x_27 + 0.000713880731505169*x_28 + 0.00094189692539246*x_29 + 0.00250548725080358*x_3 + 0.00116019680330561*x_30 + 0.00323969241066575*x_31 + 0.00236140898907058*x_32 - 0.00024688787934689*x_33 - 5.31388421926657e-5*x_34 - 0.000742668916942764*x_35 - 0.000221858554996451*x_36 - 0.000442843080997031*x_37 + 0.000352758861438162*x_38 - 0.00222002368485044*x_39 - 0.00116299022936352*x_4 - 0.000785038021725404*x_40 + 0.000513618856619838*x_41 + 0.000691176208254503*x_42 - 0.00018719757463596*x_43 - 0.000659221932980366*x_44 + 0.000708659914309003*x_45 + 8.5045710996356e-5*x_46 + 0.000165868049298653*x_47 - 0.000513255780561473*x_48 + 6.62685116535042e-5*x_49 - 0.000681496477470584*x_5 - 0.000412693577602057*x_50 + 0.00105495068377799*x_51 - 0.000285313980945131*x_52 - 0.000419397732806082*x_53 - 0.00112868045661067*x_54 + 0.000724090657483952*x_55 + 0.000149608390545728*x_56 + 8.82032477491025e-5*x_57 - 0.00118483121742557*x_58 + 0.000942893296900319*x_59 + 0.000710054169828805*x_6 - 0.000237048877258888*x_60 + 0.000428817155866177*x_61 + 0.00138470428184055*x_62 + 0.000238499983049578*x_63 - 0.000265211837014105*x_64 + 8.56589372589028e-5*x_65 + 8.55393565340105e-5*x_66 - 0.000503789820171976*x_67 + 6.21110612716789e-5*x_68 + 0.00130004589088834*x_69 + 0.0022491951166676*x_7 + 0.000443512543506876*x_70 - 0.00016352766515955*x_71 - 0.000139083563612055*x_72 - 0.000209749526748939*x_73 - 0.000555932680834779*x_74 + 0.000110560806381366*x_75 + 0.00035218753804792*x_76 - 0.000668398240995734*x_77 + 7.36715344554385e-5*x_78 - 0.000109190948182839*x_79 - 0.00144981393789732*x_8 + 0.001244593765348*x_80 - 0.000268296454525981*x_81 + 4.79285137276538e-5*x_82 + 0.000800582160642011*x_83 + 0.000172264162894771*x_84 + 0.000129488652541612*x_85 - 0.00145398674722157*x_86 + 2.92850147100246e-5*x_87 - 0.000627084918488857*x_88 + 0.00036902912474483*x_89 + 0.00302433590278587*x_9 - 0.000896418643036291*x_90 + 0.000434617264636252*x_91 + 0.000215268071792617*x_92 + 0.000323498073937733*x_93 - 0.000156028608541678*x_94 - 3.92430019352128e-5*x_95 - 0.000149396507485255*x_96 - 0.000755123180801986*x_97 + 0.000323792692289643*x_98 - 9.50043148796561e-5*x_99 - 1.44465120625041e-5*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 3.02027787982339e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) - 2.26212781094787e-6*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 1.23174144108083e-7*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) + 9.48318439716286e-8*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) - 2.01551582884954e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 4.5567870346392e-7*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 1.33042036129472e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 1.78403764383291e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) - 1.0763082076176e-5*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 3.12884249609686e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) - 1.89889853636274e-6*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) + 7.54608401657119e-7*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) + 3.85779462222809e-6*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) - 7.30840853895459e-5*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) - 1.78259965384424e-6*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 1.31119202247625e-6*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) + 1.7689905392339e-6*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) - 4.16485253791435e-7*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 2.22926210355412e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) + 5.12905029883645e-5*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) - 6.54011108892025e-6*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) - 1.74691248129924e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) - 4.84134285699132e-5*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 4.02486718398434e-6*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) + 2.73043062382196e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 5.98111216687342e-7*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) - 1.07455891054825e-5*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) - 3.34081145569354e-8*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) + 7.50378248277046e-8*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) + 4.76153329356206e-6*std::pow(-6.0*x_54 - 10.0, 2) + 1.41218662362482e-7*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) + 8.06345934362582e-6*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 1.14860551089638e-6*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) - 1.46909513611095e-7*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 1.75232360379415e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 3.8199162615384e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) - 5.09974164898254e-6*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) - 1.45465599759072e-5*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) + 1.3672089175836e-5*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) - 5.27370570859613e-6*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) - 1.27354399054141e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) + 1.67936213030878e-6*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 7.72292883098683e-8*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) + 7.8098051630221e-7*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 4.99089018345319e-5*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) - 1.84385687694213e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 1.02779946031944e-5*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 1.21581235369509e-5*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 4.80741975238431e-7*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) - 3.9789706882208e-7*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) - 1.79004863572214e-7*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) - 1.58488344263696e-7*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) + 6.72417981248584e-6*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) - 4.05480814657522e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 1.35351279678632e-5*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 3.17429817444733e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 5.63820980743964e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) - 6.17518737448247e-7*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) + 4.2789905582071e-6*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 8.37892367414972e-6*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) - 1.44734132118545e-7*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) + 1.85114901789014e-6*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) + 0.000708935035454885*std::exp(0.523359894752502*x_117) + 0.000120374870067006*std::exp(1.36367988586426*x_17) - 0.000445707282573591*std::exp(0.873679876327515*x_29) - 2.27588988388009e-5*std::exp(0.669199824333191*x_71) + 0.000548392138033693*std::exp(0.633919835090637*x_72) + 0.000766673472406181*std::exp(0.662319839000702*x_72) + 0.000392239207149902*std::exp(0.661519825458527*x_73) - 5.67267921343697e-6*std::exp(0.557839810848236*x_84) + 4.53623195403605e-6*std::exp(0.783999860286713*x_87) + 0.000340017684710976*std::exp(0.646719813346863*x_90) + 0.000189014020263459*std::sin(0.192880004644394*x_1 + 8.19839954376221) + 0.000247933254977139*std::sin(0.297999948263168*x_1 - 7.60376024246216) - 0.000359242122282652*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.040409370001688*std::sin(0.296639919281006*x_10 + 8.33568000793457) + 0.00114492881333282*std::sin(0.343679845333099*x_10 - 1.06495988368988) + 0.016599083323465*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.0125280928753861*std::sin(0.291599929332733*x_102 - 7.51024007797241) + 5.58309940352243e-5*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.00253703161424933*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.00581704730471204*std::sin(0.229759991168976*x_103 - 7.57151985168457) + 0.0045376345539667*std::sin(0.290079951286316*x_103 + 5.08432006835938) + 0.00013092527863784*std::sin(0.301279932260513*x_104 - 1.31343984603882) - 0.010118177247934*std::sin(0.356399834156036*x_104 - 1.21031987667084) + 0.000372784734368677*std::sin(0.303839921951294*x_105 - 7.50559997558594) - 0.000624132041210866*std::sin(0.325759828090668*x_105 - 7.45359992980957) - 0.00895616450054318*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.0029886905554492*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 0.01125301325803*std::sin(0.319679945707321*x_106 - 7.47704029083252) + 0.000200272826421494*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.00787373000482179*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.00133986344916203*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 0.00196034118655043*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.000112978152096496*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.0259860865982273*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.0129155051681829*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.00326750293483719*std::sin(0.257199972867966*x_112 - 4.34687995910645) - 0.000103547226771575*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.005163234272858*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 0.0087708507665784*std::sin(0.394319832324982*x_113 - 1.17887985706329) + 0.000984752486221721*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.00207270487862997*std::sin(0.309359937906265*x_115 - 7.49728012084961) + 0.000730029508062617*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.00796366167715722*std::sin(0.609919846057892*x_116 + 1.98527979850769) + 0.000363231806777605*std::sin(0.186160013079643*x_117 - 7.60880041122437) - 0.0136342952258377*std::sin(0.303839921951294*x_117 - 7.50871992111206) + 0.00012118145611358*std::sin(0.403199851512909*x_119 - 1.18383979797363) - 0.00050935632959289*std::sin(0.296079933643341*x_12 + 5.11951971054077) - 0.0114616784241166*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 6.9319680220761e-5*std::sin(0.454639852046967*x_120 - 1.17119991779327) + 0.000552779705710295*std::sin(0.23055998980999*x_13 - 4.35663986206055) + 7.76846630181186e-5*std::sin(1.31927990913391*x_13 + 1.20903992652893) + 0.00132735778007556*std::sin(0.249839976429939*x_14 + 8.26024055480957) - 0.000343404311103617*std::sin(0.292079925537109*x_14 - 4.27263975143433) + 0.00706486338229684*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.0260305221584002*std::sin(0.25383996963501*x_15 + 5.07239961624146) - 0.00414964241929963*std::sin(0.346319854259491*x_15 + 8.34296035766602) + 0.0235407744531709*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.0191309979331179*std::sin(0.34215983748436*x_16 - 7.24799966812134) + 0.000235542179258646*std::sin(0.354799836874008*x_16 + 5.1593599319458) + 0.0024177786844129*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.000454220309859279*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0254930506986941*std::sin(0.19072000682354*x_18 + 4.97863960266113) - 8.23170864237775e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) - 9.18480451306666e-6*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.00356958131394016*std::sin(0.284399926662445*x_21 - 4.31175994873047) + 0.0018274786101209*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 0.000760728443889803*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.0182166248567936*std::sin(0.26503998041153*x_23 + 5.08439970016479) - 0.00353461035944176*std::sin(0.305279940366745*x_23 + 5.12815999984741) - 0.01798381290338*std::sin(0.208800002932549*x_24 + 1.8199999332428) + 0.00271004968114588*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.00967951478233241*std::sin(0.334719836711884*x_24 + 5.11863994598389) - 0.000591314773991075*std::sin(0.338799834251404*x_24 - 4.25447988510132) - 0.000167924303927392*std::sin(0.353439837694168*x_24 + 8.3342399597168) - 0.0288388623074946*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.0147279616996365*std::sin(0.381999850273132*x_24 + 8.38024044036865) - 0.0144144296308986*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.000146327120867604*std::sin(0.407919853925705*x_24 - 7.39991998672485) - 8.65881633490631e-6*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.0112022608775464*std::sin(0.334959834814072*x_26 - 4.26191997528076) + 0.0101314294699078*std::sin(0.423199862241745*x_26 + 2.22815990447998) + 0.00109476957851919*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.0153167742065771*std::sin(0.293599933385849*x_27 + 1.90855991840363) + 0.000195225955485581*std::sin(0.325439840555191*x_27 - 4.27992010116577) - 0.00270662261796333*std::sin(0.364719837903976*x_27 - 4.22952032089233) - 0.000139959698422898*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.0068238058258119*std::sin(0.270719945430756*x_28 - 7.51624011993408) - 0.00481973792215361*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.0326556601751417*std::sin(0.3574398458004*x_28 - 1.04567980766296) - 0.0196802087938882*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.000300261194530329*std::sin(0.897199869155884*x_29 + 8.85704040527344) + 0.00299709826982417*std::sin(0.285119920969009*x_3 - 4.29447984695435) - 0.00793411387392279*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.000274901738548854*std::sin(0.31007993221283*x_3 - 4.25759983062744) + 0.00715900149340616*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.000808784816124281*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.00531846972368046*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.017645179523296*std::sin(0.353119850158691*x_3 - 4.22575998306274) - 0.00056392779577658*std::sin(0.258879989385605*x_30 - 1.12431991100311) - 0.00029780309575095*std::sin(0.282159924507141*x_30 + 8.27752017974854) + 6.49286732677131e-6*std::sin(1.43687975406647*x_30 + 6.00695943832397) + 1.14708062771597e-5*std::sin(1.7519998550415*x_30 - 9.99600028991699) + 0.00443522153369535*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.00840712672296993*std::sin(0.247519969940186*x_33 - 1.18367981910706) + 0.000290022010556698*std::sin(0.281599938869476*x_33 + 2.00543975830078) + 0.000783669424176318*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.000185779126122858*std::sin(0.339359849691391*x_34 + 1.96919977664948) + 0.0116907836432375*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.00130490264495171*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 0.00858514709528184*std::sin(0.282239943742752*x_35 + 8.25271987915039) - 0.00808176771786709*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.00767363695056528*std::sin(0.343759834766388*x_35 + 8.19143962860107) + 0.000155399453881208*std::sin(0.207520008087158*x_36 - 4.396559715271) - 3.60038570732386e-5*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.0111958058233612*std::sin(0.323999851942062*x_38 - 7.47088003158569) - 0.00251443737797326*std::sin(0.328799843788147*x_39 + 1.9366397857666) - 0.0265191103211527*std::sin(0.213359996676445*x_40 + 5.00423955917358) + 0.0031026759423605*std::sin(0.229039996862411*x_41 + 5.02951955795288) + 0.000281184054399932*std::sin(0.330479830503464*x_41 - 7.44247961044312) - 0.0184757121342818*std::sin(0.244239971041679*x_42 + 5.06047964096069) - 0.00206899198822264*std::sin(0.357199847698212*x_44 - 4.25239992141724) + 0.00047555604852052*std::sin(0.157600030303001*x_45 - 4.46623992919922) + 0.0108494479048786*std::sin(0.233679980039597*x_45 + 1.83839988708496) + 0.000415391434186019*std::sin(0.302559942007065*x_45 + 5.11320018768311) - 0.0114706264760885*std::sin(0.321759849786758*x_45 - 4.27936029434204) + 0.00484236952428867*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 0.0140230596199986*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.00048519765704361*std::sin(0.176400005817413*x_46 + 4.97695970535278) + 0.000650951097501039*std::sin(0.209200009703636*x_46 + 5.00407981872559) + 0.0121176975904067*std::sin(0.221759989857674*x_47 + 1.82455992698669) - 0.00807175779799195*std::sin(0.241199985146523*x_48 + 5.0479998588562) - 0.000138399361196043*std::sin(0.400319814682007*x_48 - 1.2060798406601) - 0.000289038012898965*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.000881551207172557*std::sin(0.145920038223267*x_49 + 4.93440008163452) - 0.0010903915325084*std::sin(0.247039973735809*x_49 - 4.34455966949463) + 4.45196956396823e-6*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.018160255501146*std::sin(0.200879991054535*x_51 - 7.59600019454956) - 0.00219128399732063*std::sin(0.299919933080673*x_51 + 5.09696006774902) - 0.01409713045563*std::sin(0.346159845590591*x_51 + 5.14703989028931) + 0.00246267716585902*std::sin(0.349679857492447*x_51 + 1.93831980228424) + 0.00227953050582337*std::sin(0.296959936618805*x_54 + 1.8899998664856) + 0.0117086182449973*std::sin(0.358159840106964*x_54 - 1.23015987873077) - 0.000411935692511975*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 0.0249550746210415*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.00258011335833893*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 0.000685652582203566*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.00520769704297236*std::sin(0.300799936056137*x_56 - 7.48128032684326) - 0.0106852811029432*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.00840406072465083*std::sin(0.305759936571121*x_58 - 7.48072004318237) - 0.000124688617859034*std::sin(0.266799956560135*x_59 + 1.86759984493256) + 0.00913767756586534*std::sin(0.337439835071564*x_59 + 1.93647980690002) + 0.180911670387772*std::sin(0.157440036535263*x_6 + 4.9488000869751) - 0.0211375742429041*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.00999225880057336*std::sin(0.193120002746582*x_65 + 4.99616003036499) - 0.0124045953827556*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 1.25179141418756e-5*std::sin(1.35967981815338*x_67 + 6.00071954727173) + 0.000632933336246019*std::sin(0.153440043330193*x_69 + 4.9322395324707) - 0.000521090145233002*std::sin(0.166640013456345*x_70 - 7.62864017486572) - 0.0275423585390417*std::sin(0.176880016922951*x_71 + 1.76879990100861) + 0.000707763686434526*std::sin(0.283279955387115*x_72 + 1.90391993522644) - 0.000815727916629034*std::sin(0.298239946365356*x_74 - 7.49944019317627) - 0.000172447482665536*std::sin(0.372399836778641*x_75 - 7.43207979202271) - 0.00271025528394839*std::sin(0.221279993653297*x_8 - 4.37391948699951) + 0.00027779914054264*std::sin(0.525279879570007*x_81 + 8.33559989929199) - 0.00432619729504832*std::sin(0.150240033864975*x_83 + 4.93767976760864) - 0.00102652154579012*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 0.0378933865042754*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.006625588625508*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 3.06976549738431e-5*std::sin(0.329439848661423*x_92 + 4.98511981964111) + 0.000410685578982849*std::sin(0.391039848327637*x_92 - 7.39135980606079) + 2.58011606943753e-5*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.00504119263352512*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.00880779682168897*std::sin(0.344079852104187*x_95 - 7.42312002182007) - 0.004039487026819*std::sin(0.362079858779907*x_95 - 1.19927990436554) + 0.000198230389625223*std::sin(0.157040029764175*x_96 + 1.74959981441498) - 0.00935514561387337*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.00264566192965711*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.000649952970497807*std::sin(0.406319856643677*x_96 + 2.01399970054626) + 0.000226104580702037*std::sin(0.223999992012978*x_97 + 1.82631993293762) + 0.00865236188838197*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 0.0045623094962515*std::sin(0.346879839897156*x_98 - 7.43207979202271) + 0.000128529975537098*std::sin(0.356479853391647*x_98 + 8.17695999145508) - 0.000720163021194231*std::sin(0.376399844884872*x_98 + 1.98295974731445) + 0.00581015942690341*std::sin(0.299839943647385*x_99 - 7.50551986694336) + 0.000376117567695475*std::sin(0.355119854211807*x_99 - 7.43391990661621) + 0.000144444014875751*std::sin(0.359599858522415*x_99 + 5.1715202331543) - 0.00346820547723684*std::sin(0.359679847955704*x_99 + 8.18544006347656) - 0.000127932678724739*std::sin(0.36847984790802*x_99 + 1.96631979942322) + 0.0113705468231836*std::sin(0.386799842119217*x_99 - 7.39559984207153) - 0.0903831347823143*std::sin(0.00161594751385143*x_1 + 0.000162179076614405*x_10 + 0.00157384860569771*x_100 - 0.0037504816204322*x_101 + 0.0116685514097778*x_103 + 0.0300092493446872*x_104 + 0.000126632226456968*x_105 - 0.000725332669407399*x_106 + 0.000445509728400361*x_110 + 0.000770959448475279*x_112 + 0.0125585422227562*x_113 - 0.000263772019308718*x_114 + 0.00263310100122414*x_116 + 0.0013304056004689*x_117 + 0.000584467121384054*x_118 + 0.00172372437898407*x_119 + 0.00343070735509328*x_120 + 0.0335121523170881*x_13 - 0.00154996376892245*x_14 + 0.0127965565790533*x_15 + 0.0244049835322951*x_17 - 0.00299355026538925*x_18 + 0.0407434184628839*x_19 + 0.0480262159303293*x_2 + 0.000688517309797724*x_20 + 0.00792207233577834*x_21 - 0.00214754274021771*x_22 + 0.00774884983393186*x_23 - 0.00486522701106097*x_25 - 0.00140747411965287*x_26 + 0.00224616343613607*x_27 - 0.0174737305529881*x_29 - 0.00155275967679531*x_3 - 0.0471260783923715*x_31 + 0.00961264358555823*x_32 - 0.00726291044512267*x_33 - 0.0179630343174347*x_34 - 0.00539464040350466*x_35 - 0.0127835650993935*x_36 + 0.00142682249741795*x_37 - 0.00227044462865065*x_39 + 0.00102230551784152*x_4 - 0.000883825357563253*x_40 + 2.83380493671508e-5*x_44 - 0.000327117733895134*x_45 - 0.000646280832162612*x_46 - 0.0134449435945383*x_48 - 0.00120711092802511*x_49 + 0.00071022100319945*x_50 - 0.0126810064393387*x_51 - 0.0221157383378498*x_52 - 0.00679869445057195*x_53 + 0.00170085477237916*x_54 + 0.000547013830047324*x_55 - 0.00753282817694192*x_56 + 0.000176330779870677*x_57 + 0.0239703787819012*x_58 + 0.00132567835472842*x_59 - 0.00106330526657922*x_61 + 0.00220280157503523*x_62 - 0.019990440473801*x_63 + 0.000530475260265859*x_64 - 0.000315624733702444*x_67 - 0.000241717769123426*x_68 + 0.000377055644026113*x_69 - 0.00359851372786262*x_70 + 0.00192549494185057*x_72 - 1.77950508828742e-5*x_73 + 0.000906024914583719*x_74 - 0.000478780845358899*x_75 - 0.00121306337976418*x_76 + 0.015639179923008*x_77 + 0.0122499634149865*x_78 + 0.00123788030682044*x_79 + 0.000456535270566251*x_82 + 0.000953647982261325*x_85 + 0.000358113243092204*x_86 + 0.000257596176848621*x_87 - 0.00744964590448987*x_88 - 0.00580675758108616*x_89 - 0.013902626510862*x_91 + 0.0183866669701922*x_92 - 0.00175052419374194*x_93 - 0.00489947253757643*x_94 + 0.00496210933278125*x_95 + 9.55029653590028e-6*x_96 + 0.0094233243258711*x_98 + 0.00202004111658729*x_99 - 0.000546300933284963*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) - 8.50159512023173e-5*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) + 0.000381275575402878*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 0.00209224291678983*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 3.52995395263159e-5*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 0.00019374796256404*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) - 0.000147194006972561*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 0.000226309531916151*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) + 0.0105067251968111*std::exp(0.698639869689941*x_71) + 0.00151294558560566*std::exp(0.936639785766602*x_81) + 0.329713494272738*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.28370253235833*std::sin(0.287759929895401*x_107 - 7.49671983718872) + 0.120774596814911*std::sin(0.330799847841263*x_108 + 4.96007966995239) - 0.227113808422239*std::sin(0.296799927949905*x_109 + 1.88975989818573) + 0.460481831588673*std::sin(0.26063996553421*x_11 + 8.29399967193604) + 0.22275019023607*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.0656815873945185*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.162618703072834*std::sin(0.382879853248596*x_12 - 4.20423984527588) + 0.267678100145055*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.999823929865983*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.491586275784009*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.170111224637964*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.190814733665118*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.232350026520724*std::sin(0.329839825630188*x_41 + 5.13431978225708) - 0.0819561285302219*std::sin(0.308959931135178*x_42 - 7.50464010238647) - 0.250753170046188*std::sin(0.351759850978851*x_43 - 7.43048000335693) + 0.373101867098562*std::sin(0.299439936876297*x_47 - 7.47208023071289) + 0.164974724831652*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 0.567380319733211*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.548990686170484*std::sin(0.305519938468933*x_8 - 4.23663949966431) - 0.390849847275952*std::sin(0.350239843130112*x_9 + 2.12519979476929) + 0.135443891960799*std::sin(0.263919949531555*x_97 - 7.51999998092651) + 2.69676119133506) + 0.287813842787952);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00204581531440688*x_1 - 0.000146432050347741*x_10 + 0.00139180441246811*x_100 + 0.00197101966280889*x_101 + 0.00217520748625561*x_102 + 3.25451771830966e-6*x_103 + 0.00110371606845228*x_104 - 0.00099412070731358*x_105 + 0.000973920687452764*x_106 + 0.000311379905463644*x_107 - 0.00133683819514677*x_108 - 0.000602112412834493*x_109 - 0.00453821926559734*x_11 - 0.00145034308303942*x_110 + 0.00097546373496493*x_111 - 0.000571174996881719*x_112 - 0.00152514804324641*x_113 - 0.000911378188987854*x_114 - 0.000230540740430763*x_115 - 0.000243453019171873*x_116 + 0.000593516141848629*x_117 - 0.000145637691451425*x_118 + 0.00221094799960658*x_119 - 0.00295942500930397*x_12 - 0.000705900534020549*x_120 - 0.00147176053395066*x_13 - 0.000743034817276758*x_14 + 0.00380969037011979*x_15 - 0.00300090479611347*x_16 + 0.000426798657896196*x_17 - 0.00263549558457407*x_18 + 0.00383355132686617*x_19 - 0.00146295514917692*x_2 + 0.00112162652299688*x_20 + 0.000929556292423691*x_21 - 0.00416931936278541*x_22 + 0.000169023439471883*x_23 + 0.000427765233731844*x_24 + 0.00136077943268126*x_25 + 0.000540355015804086*x_26 - 2.65000370275609e-5*x_27 + 0.00143255702345683*x_28 - 0.00340905067875836*x_29 + 0.00710257501608513*x_3 - 0.000890455052562771*x_30 - 0.00288713375044733*x_31 + 0.00210482080264764*x_32 - 0.00176810566213077*x_33 - 0.000312151620695392*x_34 - 0.00142892405283859*x_35 - 0.000138715929485789*x_36 - 0.00162189834087418*x_37 + 0.000914237486229498*x_38 + 0.000692478520125913*x_39 + 0.00940900645612896*x_4 + 0.000412016861599424*x_40 + 0.00122227667530233*x_41 + 0.000392197511123335*x_42 - 5.14664705156535e-5*x_43 + 0.00118210095001543*x_44 + 0.000476784686398631*x_45 - 0.00115184140004344*x_46 - 8.95861973760158e-5*x_47 + 0.00107927921952999*x_48 + 8.58212032353214e-5*x_49 + 0.00342004817486588*x_5 + 6.21430810159188e-5*x_50 + 6.08747207067758e-5*x_51 + 0.00136402652781512*x_52 - 0.000638845627554371*x_53 - 0.00079434435292514*x_54 + 3.62656136853773e-5*x_55 - 0.00093879714971148*x_56 + 0.000592599909573013*x_57 + 0.0011069583721603*x_58 + 3.74977956276828e-6*x_59 + 0.000667050006409637*x_6 - 0.000302377333907372*x_60 + 0.000298187503479378*x_61 - 0.00264845210189658*x_62 - 0.00357855334246331*x_63 + 0.00165011315361374*x_64 - 2.88374521555855e-5*x_65 - 0.00061488862138141*x_66 - 0.000864286355215721*x_67 + 0.000762131635072597*x_68 - 0.000261756003387439*x_69 - 1.08989039768703e-5*x_7 - 0.000825026345489705*x_70 - 0.00068449331612557*x_71 + 7.33047499742616e-5*x_72 + 0.000256268582247135*x_73 + 0.000402582963084844*x_74 - 0.000975302515766611*x_75 + 0.000320798010502217*x_76 + 0.000115021085621977*x_77 + 0.0027403620501534*x_78 + 0.000433132390673215*x_79 + 0.000882417454282421*x_8 + 0.00115533224621062*x_80 - 0.00031572179386051*x_81 - 2.76694924402792e-5*x_82 + 0.000392261067558299*x_83 - 0.00059767075700213*x_84 - 0.000529302551244329*x_85 - 0.000242287412916443*x_86 - 0.00105661737856039*x_87 - 0.000839766338172817*x_88 + 2.81465652612907e-5*x_89 + 0.00372400831784203*x_9 - 0.00285104685131578*x_90 - 0.00406681297788999*x_91 - 0.000982367843900418*x_92 - 5.15273525414628e-5*x_93 + 0.000240974005467386*x_94 - 2.54949343118352e-5*x_95 - 0.000465138888593655*x_96 - 0.000387037167912652*x_97 + 9.13073110772711e-5*x_98 - 0.00045904493426998*x_99 - 2.64586214759633e-6*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 6.59828911452231e-7*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) - 4.7394875241275e-6*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) - 3.44149167096561e-6*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) - 3.65423148657417e-8*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) - 1.221743641906e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) + 1.75590328756796e-7*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 2.90652004119009e-6*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 3.89752090158308e-6*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 1.23159832831445e-5*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 6.8354662069233e-6*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) - 3.5845787582696e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 2.907793063893e-7*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 4.41439856547546e-6*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) - 0.00015312181267551*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) - 3.36503964340735e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) + 3.66347698785628e-5*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) + 3.1945518458283e-6*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 3.89684267032003e-6*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 4.87018627311154e-6*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) + 0.000107461080599915*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 7.48372058031056e-6*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) - 1.05892456235972e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 1.55093434620916e-6*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) + 1.65510297987788e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) + 1.67112569398849e-5*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 1.22959664205852e-5*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) + 3.33436566346163e-6*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) + 1.35507916234587e-7*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) - 4.34670759988015e-6*std::pow(-6.0*x_54 - 10.0, 2) - 1.32131186957994e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) + 3.20920947135338e-5*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 5.66098209031524e-8*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) - 3.91719043839381e-7*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) - 6.09597478002037e-8*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) + 1.06220461821892e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 8.34522944238808e-7*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 5.83553413907813e-6*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 2.7338943563221e-7*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) + 6.03459779342035e-6*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) + 1.27108680309755e-5*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) + 3.17015664843153e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 1.39465395687837e-7*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) + 1.47426843285772e-5*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 0.000104566424780637*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) - 1.50021964984842e-6*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 1.11768927028202e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) - 1.34956984244171e-6*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) + 1.34319545359685e-5*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) + 1.53324868146634e-7*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) + 6.8977379466669e-8*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) - 2.86207993474701e-7*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) + 1.23152583561431e-6*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) - 4.50089750681808e-7*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) - 2.53111445152999e-8*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) + 6.93477154225579e-7*std::pow(-8.0*x_83 - 9.99989986419678, 2) - 1.38924834312567e-7*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) - 1.05543835196238e-7*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) + 6.25849696160256e-7*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) - 1.11515329155077e-6*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) + 8.96510898647417e-6*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 1.83051239225009e-6*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) - 2.61369791787519e-7*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) + 3.49444128838543e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 1.62272747587804e-7*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) - 0.000647172479209484*std::exp(0.523359894752502*x_117) + 2.62978516027012e-5*std::exp(1.36367988586426*x_17) - 8.16307786105895e-5*std::exp(0.873679876327515*x_29) + 0.000212943549182534*std::exp(0.669199824333191*x_71) + 7.53373113099033e-6*std::exp(0.698639869689941*x_71) + 0.000119805197364453*std::exp(0.633919835090637*x_72) + 0.000821798317391123*std::exp(0.661519825458527*x_73) + 1.08484090373194e-6*std::exp(0.936639785766602*x_81) + 0.000566173429418815*std::exp(0.557839810848236*x_84) - 1.74798263353412e-6*std::exp(0.783999860286713*x_87) + 6.22738497429513e-5*std::exp(0.646719813346863*x_90) + 0.00869096668077706*std::exp(0.136028395413162*x_1 - 0.00557410494368127*x_10 - 0.0133159841562781*x_100 + 0.000898406167426325*x_101 + 0.00238077342575348*x_102 + 1.34773569830694e-5*x_103 - 0.000196210695980156*x_104 + 0.00107271237802285*x_106 - 9.41933290951138e-5*x_107 + 0.000475241484381876*x_108 - 0.00257440361001015*x_109 - 0.0166709800055828*x_11 - 0.00249606305104285*x_110 - 0.000300011510149316*x_111 + 0.00874555856203618*x_112 + 0.00202173558767726*x_113 + 0.000806957018641014*x_114 + 0.0011647788485192*x_115 + 0.0257045852124382*x_116 - 0.0128461219029882*x_118 + 0.01089938604771*x_119 - 0.000480049513321561*x_12 - 0.00180253077277111*x_120 - 0.00222892021422373*x_13 - 9.10013467863356e-5*x_14 + 0.00382820038251146*x_15 + 0.0114839855687241*x_16 + 0.000986606277809845*x_17 + 0.00104260682839738*x_18 + 0.000356544530147284*x_19 - 0.032458797663338*x_2 + 0.0215964100946853*x_20 + 0.00185383570487686*x_21 + 0.00233497593669647*x_22 + 0.000429592622193586*x_23 + 0.0040807027144594*x_25 + 0.0171270101370741*x_26 + 0.00144951650623562*x_27 - 0.0104619726537135*x_29 + 0.00491804521276641*x_3 - 0.00887517085395868*x_30 - 0.0359545963394256*x_31 - 0.0188323775188013*x_32 - 0.0114691457709539*x_33 - 0.00212571418854868*x_34 + 0.000769043177535055*x_35 + 0.000527332673083615*x_36 + 0.00171798135516353*x_37 + 0.00211938790803453*x_38 + 0.0351392358178238*x_39 + 0.0204392457649795*x_4 + 0.000595004260059582*x_41 - 0.00975765569873789*x_42 + 0.000798013144285719*x_43 + 0.000495651408007129*x_44 - 0.00117830793506991*x_45 - 0.00631561069976537*x_47 + 0.00997710124391409*x_48 + 0.00883298676971344*x_49 - 0.00126197966793442*x_5 + 0.0326979304701261*x_50 - 0.0105736244326095*x_52 - 0.000545171361570353*x_53 - 0.00851208767363471*x_55 - 0.00021748756185697*x_57 + 0.0205755008169451*x_58 + 0.00169675745276702*x_59 + 0.000272613926407336*x_6 + 0.00864898750471912*x_60 + 0.00427839647139376*x_61 - 0.00229980526461644*x_62 - 0.0266156908833113*x_63 - 0.00130812445645945*x_64 + 0.000649667459685099*x_65 + 0.00897152876471907*x_68 - 0.00485634731797851*x_69 - 0.000213034930571483*x_7 - 0.000119407798239413*x_73 + 0.0015408454420092*x_74 + 0.00280095687194647*x_75 - 0.0146925742511653*x_76 + 5.40959855043129e-5*x_77 + 0.00135416134725237*x_78 + 0.000655487097133614*x_79 - 0.0039355580283902*x_8 - 0.000567468403433492*x_80 - 0.000485000446830241*x_81 - 0.00309285636425093*x_83 - 5.25547506415694e-5*x_84 + 0.000195761883168505*x_85 + 0.00125152384972398*x_86 + 0.000321960128389327*x_87 - 0.00117346222693048*x_88 - 0.0124661064640536*x_89 - 0.00834630074897288*x_9 - 0.00315039591796939*x_90 + 0.0460634067225035*x_91 + 0.00727683923086499*x_92 - 0.0141146255287006*x_93 - 0.00144328154587304*x_94 - 0.000325233897149795*x_95 - 0.00181832721486027*x_97 - 0.00613758944996134*x_98 + 0.00108083615630902*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 0.00018001778971165*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) + 0.00032475386346938*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 0.000305231187916904*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) - 0.000229457580461161*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 0.000302173510946659*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) - 0.0171160860434197*std::exp(0.662319839000702*x_72) + 0.19994754967745*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.304387433015535*std::sin(0.303839921951294*x_117 - 7.50871992111206) + 0.401490986869486*std::sin(0.208800002932549*x_24 + 1.8199999332428) + 0.439363248100221*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.592042623605103*std::sin(0.213359996676445*x_40 + 5.00423955917358) + 0.314720290355947*std::sin(0.346159845590591*x_51 + 5.14703989028931) - 0.26139644130631*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.61488677456574*std::sin(0.176880016922951*x_71 + 1.76879990100861) + 0.208854855474828*std::sin(0.301839828491211*x_96 + 8.14343929290771) - 0.253848952378039*std::sin(0.386799842119217*x_99 - 7.39559984207153)) - 0.0188649334880972*std::sin(0.192880004644394*x_1 + 8.19839954376221) - 9.5538109242855e-5*std::sin(0.297999948263168*x_1 - 7.60376024246216) - 6.57947834783507e-5*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.00448550032746445*std::sin(0.296639919281006*x_10 + 8.33568000793457) - 0.0319893676019856*std::sin(0.343679845333099*x_10 - 1.06495988368988) + 0.0347774992830978*std::sin(0.349039852619171*x_10 + 2.1275999546051) + 0.000236417415472523*std::sin(0.206560000777245*x_102 - 7.59832000732422) - 0.00139063699069553*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.0055723273203796*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.000554255891331403*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.00127082875935863*std::sin(0.229759991168976*x_103 - 7.57151985168457) - 0.0041423149614167*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 0.0012250018644717*std::sin(0.301279932260513*x_104 - 1.31343984603882) - 0.0211990563050458*std::sin(0.356399834156036*x_104 - 1.21031987667084) - 0.000143648130943416*std::sin(0.303839921951294*x_105 - 7.50559997558594) - 0.0117818325436454*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.00181165219914388*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 0.0235767031761689*std::sin(0.319679945707321*x_106 - 7.47704029083252) + 0.000361664979616628*std::sin(0.391679853200912*x_106 - 7.40991973876953) + 0.000203425763968533*std::sin(0.287759929895401*x_107 - 7.49671983718872) - 0.000873995771612364*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.000292715000517407*std::sin(0.401439845561981*x_107 + 5.19271993637085) + 8.66000892583978e-5*std::sin(0.330799847841263*x_108 + 4.96007966995239) - 0.000162849445163722*std::sin(0.296799927949905*x_109 + 1.88975989818573) - 0.00118829847245682*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.000204022891198973*std::sin(0.250399976968765*x_11 - 1.1360799074173) + 0.000330183405857797*std::sin(0.26063996553421*x_11 + 8.29399967193604) - 0.00288449436209966*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.0028216025329683*std::sin(0.282399952411652*x_11 + 8.30943965911865) + 0.000159720560991243*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.00373893938913251*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 0.000968839227808154*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.000573126703551993*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 0.0183762109209754*std::sin(0.394319832324982*x_113 - 1.17887985706329) + 0.0185893178422528*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.00125640988315094*std::sin(0.309359937906265*x_115 - 7.49728012084961) + 4.70962560091634e-5*std::sin(0.316559851169586*x_115 - 1.27255988121033) + 0.0137808746354806*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.000883978321345091*std::sin(0.609919846057892*x_116 + 1.98527979850769) + 0.000655946322532324*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.000218836921804822*std::sin(0.403199851512909*x_119 - 1.18383979797363) + 0.00019627435885788*std::sin(0.296079933643341*x_12 + 5.11951971054077) + 0.0104631348017352*std::sin(0.300559937953949*x_12 + 8.32791996002197) - 0.000116603942986242*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 0.00064858932055365*std::sin(0.454639852046967*x_120 - 1.17119991779327) + 0.000998243568887602*std::sin(0.23055998980999*x_13 - 4.35663986206055) + 1.42278571075922e-5*std::sin(1.31927990913391*x_13 + 1.20903992652893) + 0.0250567284769018*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 0.000132326736853875*std::sin(0.292079925537109*x_14 - 4.27263975143433) + 0.133364467481059*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.00476746033666068*std::sin(0.25383996963501*x_15 + 5.07239961624146) - 0.00251538547571547*std::sin(0.346319854259491*x_15 + 8.34296035766602) + 0.00261306106762006*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.000191935622029898*std::sin(0.333039849996567*x_16 - 1.04951989650726) + 0.0021235692981637*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 9.07633566759232e-5*std::sin(0.354799836874008*x_16 + 5.1593599319458) + 0.0456407646242343*std::sin(0.385039836168289*x_16 - 4.21935987472534) - 0.0126909378951515*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.00556937227679841*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 7.51456060681143e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 8.59375879919863e-5*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.00216377029252218*std::sin(0.284399926662445*x_21 - 4.31175994873047) + 0.0344975831072001*std::sin(0.318879842758179*x_21 - 4.26336002349854) - 0.0212547903009263*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.00397971849871465*std::sin(0.26503998041153*x_23 + 5.08439970016479) - 0.0667233607830548*std::sin(0.305279940366745*x_23 + 5.12815999984741) - 0.0007169126939978*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.0511580073124829*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.00211464771002649*std::sin(0.334719836711884*x_24 + 5.11863994598389) + 0.000227856063438051*std::sin(0.338799834251404*x_24 - 4.25447988510132) - 0.000303248029411736*std::sin(0.353439837694168*x_24 + 8.3342399597168) - 0.00320115671980448*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.002697409326467*std::sin(0.381999850273132*x_24 + 8.38024044036865) - 0.0302003313307181*std::sin(0.394479840993881*x_24 + 5.38800001144409) + 0.00408838698534288*std::sin(0.407919853925705*x_24 - 7.39991998672485) - 1.56366227471982e-5*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.00244731640423351*std::sin(0.334959834814072*x_26 - 4.26191997528076) + 0.00112460377885268*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 0.000421856340320157*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.00334619887765968*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 0.00182663089932875*std::sin(0.325439840555191*x_27 - 4.27992010116577) - 0.00164067129972539*std::sin(0.364719837903976*x_27 - 4.22952032089233) - 0.000252747825961846*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.00149077156114859*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.00551513137763524*std::sin(0.271519958972931*x_28 - 1.10407996177673) + 0.000352486503650596*std::sin(0.324479848146439*x_28 + 8.32696056365967) - 0.00362482697461126*std::sin(0.3574398458004*x_28 - 1.04567980766296) + 6.55969500229823e-5*std::sin(0.897199869155884*x_29 + 8.85704040527344) + 0.00181674869674194*std::sin(0.285119920969009*x_3 - 4.29447984695435) - 0.00145312387397767*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.000496434456163327*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.00819190470654878*std::sin(0.321439832448959*x_3 + 8.31455993652344) + 0.0225974877150577*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.00116190636358696*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.00195864123906428*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.000121976372730761*std::sin(0.241119980812073*x_30 + 2.04959988594055) + 0.0157561704710374*std::sin(0.258879989385605*x_30 - 1.12431991100311) + 0.000114754854879544*std::sin(0.282159924507141*x_30 + 8.27752017974854) + 1.17252188993833e-5*std::sin(1.43687975406647*x_30 + 6.00695943832397) + 0.00021653610097616*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.00507513683157212*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.00153975563583172*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.000111756506927451*std::sin(0.281599938869476*x_33 + 2.00543975830078) + 0.0147934432388818*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.00033549136476963*std::sin(0.339359849691391*x_34 + 1.96919977664948) + 0.0244938959488681*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.000790991808129869*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 0.0179871346587788*std::sin(0.282239943742752*x_35 + 8.25271987915039) + 0.00737768256439918*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.00140541782362779*std::sin(0.343759834766388*x_35 + 8.19143962860107) - 0.00145399439071611*std::sin(0.207520008087158*x_36 - 4.396559715271) + 0.00359343909015257*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.00124275114125307*std::sin(0.323999851942062*x_38 - 7.47088003158569) - 0.000136821594962894*std::sin(0.377359837293625*x_38 + 5.17280006408691) - 0.00152417452422744*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 0.0018807466313164*std::sin(0.229039996862411*x_41 + 5.02951955795288) + 0.000166604017455114*std::sin(0.329839825630188*x_41 + 5.13431978225708) - 0.00785629636993109*std::sin(0.330479830503464*x_41 - 7.44247961044312) - 0.0387093102060878*std::sin(0.244239971041679*x_42 + 5.06047964096069) - 5.87657357852067e-5*std::sin(0.308959931135178*x_42 - 7.50464010238647) - 0.000179799788039078*std::sin(0.351759850978851*x_43 - 7.43048000335693) - 0.00125415924329819*std::sin(0.357199847698212*x_44 - 4.25239992141724) + 0.000858788342222543*std::sin(0.157600030303001*x_45 - 4.46623992919922) + 0.00198706396461906*std::sin(0.233679980039597*x_45 + 1.83839988708496) + 0.00784140533491837*std::sin(0.302559942007065*x_45 + 5.11320018768311) - 0.0240326345904248*std::sin(0.321759849786758*x_45 - 4.27936029434204) - 0.00442050136268343*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 0.0025683073174695*std::sin(0.175040006637573*x_46 - 7.61616039276123) + 0.0135564465057081*std::sin(0.176400005817413*x_46 + 4.97695970535278) + 0.0122880998225635*std::sin(0.209200009703636*x_46 + 5.00407981872559) + 0.00221934244278191*std::sin(0.221759989857674*x_47 + 1.82455992698669) + 0.000267528568468143*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.0017634070020294*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.00129493308909288*std::sin(0.400319814682007*x_48 - 1.2060798406601) - 0.00545621317584798*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.00159195935399681*std::sin(0.145920038223267*x_49 + 4.93440008163452) - 0.0205834816909881*std::sin(0.247039973735809*x_49 - 4.34455966949463) + 0.000118293302338201*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 4.16548360497902e-5*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.00332603000733115*std::sin(0.200879991054535*x_51 - 7.59600019454956) - 0.00132828889409665*std::sin(0.299919933080673*x_51 + 5.09696006774902) - 0.00224812825888755*std::sin(0.349679857492447*x_51 + 1.93831980228424) + 0.00138178121062446*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 0.00777617078993539*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 0.0522845191406483*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.0015639852814982*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 0.0129431648645502*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.0011377062666957*std::sin(0.300799936056137*x_56 - 7.48128032684326) - 0.0223872215504811*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.00183600399048351*std::sin(0.305759936571121*x_58 - 7.48072004318237) - 0.000225170370050628*std::sin(0.266799956560135*x_59 + 1.86759984493256) + 0.0191447665394166*std::sin(0.337439835071564*x_59 + 1.93647980690002) + 0.0200814651832631*std::sin(0.157440036535263*x_6 + 4.9488000869751) - 0.00387132252680324*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.00218297173626847*std::sin(0.193120002746582*x_65 + 4.99616003036499) - 0.000406833784820285*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.00270998596622097*std::sin(0.235039979219437*x_67 + 5.03983974456787) + 0.000349751139486914*std::sin(1.35967981815338*x_67 + 6.00071954727173) - 0.000243893277758534*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.00487557793353256*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.0133605594384593*std::sin(0.283279955387115*x_72 + 1.90391993522644) - 0.0153986161265721*std::sin(0.298239946365356*x_74 - 7.49944019317627) - 0.00325531655031968*std::sin(0.372399836778641*x_75 - 7.43207979202271) - 0.0511618885068933*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 0.000393647701405725*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 6.06897483609468e-5*std::sin(0.525279879570007*x_81 + 8.33559989929199) - 0.0816662640523054*std::sin(0.150240033864975*x_83 + 4.93767976760864) - 0.0193777985367957*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 0.0793921686099166*std::sin(0.24679996073246*x_9 - 4.34816026687622) - 0.000280254561417419*std::sin(0.350239843130112*x_9 + 2.12519979476929) + 0.0040162278366822*std::sin(0.19336000084877*x_91 - 1.18735980987549) - 0.00306384266370774*std::sin(0.329439848661423*x_92 + 4.98511981964111) - 0.000158252767314116*std::sin(0.391039848327637*x_92 - 7.39135980606079) - 0.00257513796985353*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.00110133066563875*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.00192420671884909*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.00462230561308306*std::sin(0.362079858779907*x_95 - 1.19927990436554) - 0.0197847922095247*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.000577987953617812*std::sin(0.359439849853516*x_96 + 5.1733603477478) + 0.0181597181022406*std::sin(0.406319856643677*x_96 + 2.01399970054626) + 0.000408313549231721*std::sin(0.223999992012978*x_97 + 1.82631993293762) + 9.71185451464229e-5*std::sin(0.263919949531555*x_97 - 7.51999998092651) + 0.000960425071760759*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 0.000996710841982473*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 4.95274861170883e-5*std::sin(0.356479853391647*x_98 + 8.17695999145508) - 0.0135946235084725*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 0.00530397722338372*std::sin(0.299839943647385*x_99 - 7.50551986694336) - 0.000144932398334223*std::sin(0.355119854211807*x_99 - 7.43391990661621) + 0.000260845880238577*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 0.00396859936381115*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 0.00119700161493007*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.131392863543686);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00956516081588998*x_1 - 0.000247312350639808*x_10 - 0.00076701446730111*x_100 - 0.00180979080643451*x_101 + 6.92215978204729e-5*x_102 + 0.00089439859216471*x_103 + 0.00269390854460001*x_104 + 0.00139633767988598*x_105 - 0.00132930779691779*x_106 + 0.000103299213178577*x_107 + 0.00104061885000575*x_108 - 0.00111025772057627*x_109 + 0.00392637083042795*x_11 - 0.000120716047178411*x_110 - 0.000439893094775438*x_111 + 0.000555478724561134*x_112 + 0.00183292187068155*x_113 - 0.00015804129685203*x_114 + 0.000858384457389858*x_115 + 0.00145581615384422*x_116 + 0.000275711775204246*x_117 + 0.000193210729826946*x_118 + 0.000737780465631451*x_119 + 0.00413143649585616*x_12 - 0.000191295087122908*x_120 + 0.00387607871807657*x_13 - 0.000168420265270879*x_14 - 0.000102541994726848*x_15 + 0.000454580841063848*x_16 + 0.002953147572709*x_17 + 0.00245635063904922*x_18 + 0.00320800068392093*x_19 + 0.00387763681253131*x_2 - 0.00331655688626048*x_20 + 0.00027401816172353*x_21 - 0.000381387488361352*x_22 - 0.00170161864198159*x_23 + 0.000215688102959581*x_24 - 0.00421996410470126*x_25 + 7.23587897992946e-5*x_26 - 0.00213873035261749*x_27 - 6.22041603183538e-5*x_28 - 0.00295960206906873*x_29 - 0.000471877216145586*x_3 - 0.000530284778841197*x_30 - 0.00693144078978167*x_31 - 0.00324144988436296*x_32 + 0.000375152399036405*x_33 - 0.00114467467519316*x_34 + 5.84645839386171e-5*x_35 - 0.0011314719637916*x_36 + 0.000565043644116643*x_37 + 0.000284088830998843*x_38 + 0.000620432640356887*x_39 - 0.00778919614595794*x_4 - 0.000242578867679358*x_40 - 0.00060153570168242*x_41 - 0.00168059632393929*x_42 - 2.92525038664939e-5*x_43 - 0.00107331758168054*x_44 - 0.000291768902619524*x_45 - 9.51483088990194e-5*x_46 - 0.000457758578360319*x_47 - 0.0013673919666828*x_48 + 0.000594984392834523*x_49 - 0.00107721990646154*x_5 + 0.00195293690221244*x_50 - 0.000433556865803943*x_51 - 0.00303915443433923*x_52 - 0.000235422909533946*x_53 + 0.000115297840583779*x_54 + 0.000249914499374564*x_55 - 0.000165551936389556*x_56 - 0.000208147591481878*x_57 + 0.00123362436946883*x_58 + 0.000228720573002676*x_59 - 0.00150321064421469*x_6 + 0.00042927015989515*x_60 - 0.000429209361092172*x_61 + 0.00205016194703453*x_62 - 0.00341918194511047*x_63 - 0.00103242241303076*x_64 + 0.000235529551929542*x_65 + 0.00038263005853727*x_66 - 0.000156223264408637*x_67 - 0.00059657855287538*x_68 - 0.000554739370483978*x_69 + 0.000663295727780068*x_7 - 0.000433569957155021*x_70 - 0.000408901630790442*x_71 + 0.000176614548173913*x_72 - 7.40358205648849e-5*x_73 - 0.000142721729128417*x_74 + 0.00157732193587016*x_75 - 0.00077028977156653*x_76 + 0.00122679642553133*x_77 - 0.00134395977575588*x_78 - 0.000147775240853425*x_79 - 0.00100673823645048*x_8 + 0.000965331332879017*x_80 - 0.000215279390345344*x_81 + 0.000568052180233695*x_82 - 0.000965535552861059*x_83 + 0.00010993607500498*x_84 - 0.000549514561979931*x_85 - 0.0010509248833772*x_86 + 0.00137541596150598*x_87 - 0.000328695250065123*x_88 - 0.00132229427841701*x_89 - 9.96928552161912e-5*x_9 + 0.000390959093374146*x_90 + 0.00330045060675226*x_91 + 0.00182526980083549*x_92 - 0.00137042816125323*x_93 - 0.000703718308841886*x_94 + 0.000441379722747257*x_95 - 4.14878152193984e-5*x_96 - 0.000723886286190227*x_97 + 0.000586511887991746*x_98 + 0.000344708344685767*x_99 - 3.42744551089617e-7*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 1.95434119579206e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 9.73693653953035e-8*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 4.613782249659e-6*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) - 1.49425664001509e-6*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) + 7.18008740363773e-6*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 8.60879502898873e-6*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 1.15440313802859e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 8.87005168673118e-7*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 2.02459046106861e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 1.6956040230291e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 1.18902951536476e-5*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 3.17927870973872e-7*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 3.14577760833702e-6*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 1.59175600308703e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 4.91138341004994e-5*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) - 1.02282811574455e-5*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 6.81447367974209e-7*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 1.44249600154296e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 2.20771067957046e-6*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 5.38982449312485e-7*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 5.02838302739272e-5*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) + 6.3419461891374e-5*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 2.24036865436024e-5*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 8.85563541143868e-7*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) + 1.45201150599572e-7*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) - 4.3386776399228e-7*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) - 2.29623022396133e-6*std::pow(-6.0*x_54 - 10.0, 2) - 2.3106000728646e-7*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) - 8.37498258298462e-6*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 4.30237673369507e-5*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 2.3148396888754e-6*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) - 4.86803302694714e-5*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) - 7.57568645877324e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) + 2.471765847862e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 4.20278984172927e-7*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 1.51085509641551e-5*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) + 3.39750855315e-5*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 1.42002959078791e-5*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 4.34615678713441e-7*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) + 5.5351837485661e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 1.49957100379287e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) - 4.46538778418141e-7*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 6.97369385457467e-6*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) - 2.14824205585829e-6*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) - 0.000186437675624771*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 1.06750740744799e-5*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 8.48110769316463e-6*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 1.80073408107045e-5*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) + 6.26962750305491e-6*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) + 2.82056316513047e-6*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) + 9.16377622917725e-7*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) + 1.59531655897627e-7*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) - 2.82850099867055e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) - 3.14550669384445e-6*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 1.40580433482226e-5*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 2.05400361718132e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) - 1.72646873398894e-5*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) - 1.3116310876543e-5*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) + 3.93302999662928e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 3.57048561115924e-6*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 1.84181721814622e-7*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 5.42177785103194e-6*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) + 8.36850940439995e-7*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) - 1.65296652867675e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 2.01662162474489e-5*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) - 0.000629343325272202*std::pow(0.0903854090952229*x_1 - 0.0173551460390329*x_10 - 0.00281139611958322*x_100 - 0.0130020230924895*x_101 + 0.003261122808822*x_102 + 0.00180378893653246*x_103 + 0.0749782168627349*x_104 + 0.00314089687522123*x_105 + 7.88294939722014e-6*x_107 + 0.00403934678824336*x_108 + 0.00934726765073407*x_11 - 0.0684883159451979*x_110 - 0.0176830544644809*x_111 - 0.0270170174519431*x_112 - 0.00106642439127855*x_113 + 0.00538978007819672*x_114 + 0.0111614254388714*x_116 - 5.87411045344641e-5*x_117 + 0.00467558757964048*x_118 - 0.0365520212211992*x_119 + 0.0802819826204417*x_12 + 0.0184448733462092*x_13 - 0.0104266648941904*x_14 + 0.111088004830955*x_16 + 0.000639830365548398*x_17 - 0.000301926721528669*x_18 - 0.00130629838549664*x_19 - 0.181491333225679*x_2 - 0.021577957081811*x_20 - 0.0296838687966459*x_22 - 0.00147140818368651*x_23 - 0.00464458363731749*x_24 + 0.00360283844539762*x_25 + 0.00224357142819108*x_26 + 0.00569526773670244*x_28 + 0.00240500207070316*x_29 + 0.00145476927352153*x_30 + 0.26554447370612*x_31 - 0.00828290440595462*x_32 + 0.0602925096348439*x_33 - 0.00191516716028807*x_35 - 0.00537261043124415*x_36 - 0.095201244841931*x_37 + 0.0239224194842551*x_38 + 0.0750353717679304*x_4 - 0.0078354611518137*x_40 + 0.00688904424394596*x_42 + 0.00128629457248238*x_43 - 0.000572461187065293*x_45 - 0.00201646700921986*x_47 + 0.00231857453193609*x_48 + 0.000410019625426512*x_5 + 0.0114645468769919*x_50 - 0.00251843895829891*x_52 - 5.79288176070452e-5*x_53 + 0.11907942594022*x_56 + 0.00681265018175719*x_57 + 0.000312541612591324*x_58 - 0.00120306581072262*x_59 - 0.0511854592007119*x_6 + 0.00127225557224187*x_60 + 0.00412019046588108*x_61 + 0.00318332095264537*x_62 + 0.0325265470677625*x_63 + 0.00360884746304154*x_65 + 0.00591225920881706*x_66 - 0.00109417481333296*x_67 + 0.00022480954682431*x_68 + 0.000429373998202996*x_69 - 0.0194176976744803*x_7 + 0.00244526175442352*x_71 - 0.051027545852494*x_72 + 0.00139220263462673*x_73 - 0.0467903567870991*x_74 + 0.000661172567366805*x_75 + 0.00320258457857357*x_76 + 0.00101142955925973*x_77 + 0.00564631916463774*x_78 + 0.00439326528450875*x_79 + 0.00771457499994014*x_8 + 0.0681396424340313*x_80 - 0.000604566080506225*x_81 - 0.00714261676964079*x_82 - 0.0156106766212164*x_83 - 0.00357752141500259*x_84 - 0.0016648847091171*x_85 + 0.00630389244514077*x_86 + 0.000849534865594201*x_87 + 0.00240268979465228*x_88 + 0.00550852114198006*x_89 + 0.00228385720340636*x_9 + 0.00537516466295536*x_90 + 0.0859408568461833*x_92 + 0.143895850938932*x_93 + 0.00356288240586384*x_94 - 0.0280352529165616*x_95 - 0.0791678323592063*x_96 + 0.0103882345442186*x_97 - 0.00178990847304579*x_98 + 0.00966077329720767*x_99 - 0.00119147738419238*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 0.00103269182203323*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 0.00161410111040761*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) + 0.00103589062106199*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) - 0.00109000075172724*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 1.7667721355479*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 1.15886075199366*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 1.2252848385728*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 2.45307182623469*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 2.11016720668628*std::sin(0.284399926662445*x_21 - 4.31175994873047) - 1.60002694629674*std::sin(0.364719837903976*x_27 - 4.22952032089233) + 1.77174237760065*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.771396566466183*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 1.48641614565398*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 1.83415489121236*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 1.22308995382568*std::sin(0.357199847698212*x_44 - 4.25239992141724) - 1.29538319063487*std::sin(0.299919933080673*x_51 + 5.09696006774902) + 1.34755034189708*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 1.5252406709543*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 3.91673381635565*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 1.24819541124451, 2) - 0.000341881061177838*std::exp(0.523359894752502*x_117) + 7.78913652553795e-5*std::exp(1.36367988586426*x_17) - 1.05744377481646e-5*std::exp(0.873679876327515*x_29) + 3.72377931043357e-5*std::exp(0.669199824333191*x_71) + 0.000936243783359142*std::exp(0.698639869689941*x_71) + 0.000354849914296761*std::exp(0.633919835090637*x_72) - 0.000796293092655551*std::exp(0.662319839000702*x_72) - 1.68832558878889e-5*std::exp(0.661519825458527*x_73) + 0.000134817069310414*std::exp(0.936639785766602*x_81) + 2.46550743643307e-5*std::exp(0.557839810848236*x_84) - 7.14769895225795e-5*std::exp(0.783999860286713*x_87) + 8.06694433954557e-6*std::exp(0.646719813346863*x_90) - 0.000821508594115124*std::sin(0.192880004644394*x_1 + 8.19839954376221) - 0.00390666148641992*std::sin(0.297999948263168*x_1 - 7.60376024246216) - 8.52304552140499e-6*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.0281882494248121*std::sin(0.296639919281006*x_10 + 8.33568000793457) + 0.0428860478335684*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.00071447873171778*std::sin(0.349039852619171*x_10 + 2.1275999546051) + 0.0293804400058128*std::sin(0.206560000777245*x_102 - 7.59832000732422) - 0.00873918615345509*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.000242657350782745*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.00164164543662593*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.00376405603650439*std::sin(0.229759991168976*x_103 - 7.57151985168457) - 0.00218825595994414*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 0.000214218116288277*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 0.000435519378180366*std::sin(0.356399834156036*x_104 - 1.21031987667084) - 0.00587393475965002*std::sin(0.303839921951294*x_105 - 7.50559997558594) + 0.00557312978925982*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.0093021764612341*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.000484366424574481*std::sin(0.319679945707321*x_106 - 7.47704029083252) - 0.00115797497578616*std::sin(0.391679853200912*x_106 - 7.40991973876953) + 0.0252804491664394*std::sin(0.287759929895401*x_107 - 7.49671983718872) - 0.00549245546936942*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.00086698987299358*std::sin(0.401439845561981*x_107 + 5.19271993637085) + 0.0107621036372005*std::sin(0.330799847841263*x_108 + 4.96007966995239) - 0.0202378845232267*std::sin(0.296799927949905*x_109 + 1.88975989818573) - 0.000653238261405314*std::sin(0.250399976968765*x_11 - 1.1360799074173) + 0.0410330758727348*std::sin(0.26063996553421*x_11 + 8.29399967193604) - 0.0181270405991234*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.00835727864090475*std::sin(0.282399952411652*x_11 + 8.30943965911865) + 0.0198490468670374*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.000269280859454795*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 0.000169422529374482*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.00360170266242656*std::sin(0.378399848937988*x_112 - 1.21479988098145) - 0.000377526048256665*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.00879325696107908*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.00585282061987706*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.00651873150195775*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.00555518885053512*std::sin(0.609919846057892*x_116 + 1.98527979850769) - 0.00210020176063646*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.0141610418285206*std::sin(0.303839921951294*x_117 - 7.50871992111206) - 0.000700669662560846*std::sin(0.403199851512909*x_119 - 1.18383979797363) + 0.0080258808196917*std::sin(0.296079933643341*x_12 + 5.11951971054077) + 0.00552734818642698*std::sin(0.300559937953949*x_12 + 8.32791996002197) - 0.0144907901327881*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 0.000113419894714704*std::sin(0.454639852046967*x_120 - 1.17119991779327) - 0.00319616533991385*std::sin(0.23055998980999*x_13 - 4.35663986206055) + 1.84307428931589e-6*std::sin(1.31927990913391*x_13 + 1.20903992652893) - 0.0118525194937806*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 0.00541099013354527*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.0630850492734548*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.000617576034492488*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 0.0164212711534851*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.0238525280244558*std::sin(0.333039849996567*x_16 - 1.04951989650726) + 0.0133451558750301*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 0.00371141644642231*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.0215893328978867*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.0170139083834383*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0164958726214247*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 3.96970828809035e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 1.5028049141738e-5*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.0163183025526788*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 0.0284949038342793*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.0117874916886797*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.0315619788553298*std::sin(0.305279940366745*x_23 + 5.12815999984741) - 0.0890933113083455*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.0186785985298633*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.0241991399433143*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.00626335564047392*std::sin(0.334719836711884*x_24 + 5.11863994598389) + 0.00931729248710517*std::sin(0.338799834251404*x_24 - 4.25447988510132) + 0.000970936223594241*std::sin(0.353439837694168*x_24 + 8.3342399597168) - 0.0201170432456015*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.000349421964233766*std::sin(0.381999850273132*x_24 + 8.38024044036865) + 0.000620444105281458*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.00548103238541889*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 5.00651676760571e-5*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.00724868399204345*std::sin(0.334959834814072*x_26 - 4.26191997528076) + 0.00706735247086809*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 0.0172501835193485*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.00991107573860365*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 0.000319425987630574*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 0.00080924522456782*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.00441550260211484*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.000397203367803268*std::sin(0.271519958972931*x_28 - 1.10407996177673) + 0.043804761813618*std::sin(0.324479848146439*x_28 + 8.32696056365967) - 0.0227795160902124*std::sin(0.3574398458004*x_28 - 1.04567980766296) + 0.0204405328847607*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.000194291004112068*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 0.000188237429647098*std::sin(0.302559942007065*x_3 - 4.27119970321655) - 0.00158947841166294*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.000589986333119737*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.0302949702264913*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.00344143979234432*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.0123086977482568*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.0151584412424951*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.0211232647328991*std::sin(0.258879989385605*x_30 - 1.12431991100311) + 0.00469245597898568*std::sin(0.282159924507141*x_30 + 8.27752017974854) - 3.75416776196946e-5*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 0.000102427512047037*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.000365514672911964*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.000199459693949017*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.00456985013551487*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.00699770421069209*std::sin(0.295999944210052*x_34 - 1.14071989059448) - 0.0010741725820603*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.000503209490996378*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.000369532756039393*std::sin(0.282239943742752*x_35 + 8.25271987915039) + 0.00389739988207005*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.000182057595665088*std::sin(0.343759834766388*x_35 + 8.19143962860107) - 0.000254262420741092*std::sin(0.207520008087158*x_36 - 4.396559715271) + 0.000156482984520044*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.00780982645974156*std::sin(0.323999851942062*x_38 - 7.47088003158569) - 0.0170033102437587*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.0275436481528824*std::sin(0.213359996676445*x_40 + 5.00423955917358) + 0.0207044786856501*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.0105324214628938*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.000795254961737782*std::sin(0.244239971041679*x_42 + 5.06047964096069) - 0.00730302871801495*std::sin(0.308959931135178*x_42 - 7.50464010238647) - 0.0223443644157168*std::sin(0.351759850978851*x_43 - 7.43048000335693) - 0.00274965912056161*std::sin(0.157600030303001*x_45 - 4.46623992919922) + 0.000257403941909229*std::sin(0.233679980039597*x_45 + 1.83839988708496) - 0.00370919969366437*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.00049373320784881*std::sin(0.321759849786758*x_45 - 4.27936029434204) - 0.00233521317015568*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 0.000332698111043298*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.0181742390325003*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.00581260809138419*std::sin(0.209200009703636*x_46 + 5.00407981872559) + 0.000287493258088468*std::sin(0.221759989857674*x_47 + 1.82455992698669) + 0.0332467345521454*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.00522301901174534*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.000226447106008666*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.00258093841295267*std::sin(0.452239871025085*x_48 - 1.14887976646423) + 0.0050971180465167*std::sin(0.145920038223267*x_49 + 4.93440008163452) + 0.00973655113105489*std::sin(0.247039973735809*x_49 - 4.34455966949463) + 0.0147007328774429*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 7.28425055641149e-6*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.000430853384712027*std::sin(0.200879991054535*x_51 - 7.59600019454956) + 0.014641758208813*std::sin(0.346159845590591*x_51 + 5.14703989028931) - 0.00118761612939906*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 0.0121609683504121*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.003678341965498*std::sin(0.371679842472076*x_54 - 1.22119987010956) - 0.00107414787417564*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.00612247181469504*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.00336976174751196*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.000459929379334254*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.00543804336542822*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.00072094802787798*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 0.000393315471154743*std::sin(0.337439835071564*x_59 + 1.93647980690002) + 0.126198039923337*std::sin(0.157440036535263*x_6 + 4.9488000869751) - 0.000501490488753436*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.00646572394660527*std::sin(0.193120002746582*x_65 + 4.99616003036499) - 0.0505586933321303*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.0080266825564636*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 0.000468888422069019*std::sin(1.35967981815338*x_67 + 6.00071954727173) - 0.00997307234324649*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.000852600433541762*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.0286064284854532*std::sin(0.176880016922951*x_71 + 1.76879990100861) - 0.00631991089092628*std::sin(0.283279955387115*x_72 + 1.90391993522644) + 0.00728396757723928*std::sin(0.298239946365356*x_74 - 7.49944019317627) + 0.00153985397202427*std::sin(0.372399836778641*x_75 - 7.43207979202271) + 0.0242009758546725*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 0.0489200114613433*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.000179756408555976*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.0386303817577973*std::sin(0.150240033864975*x_83 + 4.93767976760864) + 0.00916622994560716*std::sin(0.276799947023392*x_88 - 7.51471996307373) + 0.00163105505300968*std::sin(0.24679996073246*x_9 - 4.34816026687622) - 0.0348282393309423*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 0.00013342072373807*std::sin(0.329439848661423*x_92 + 4.98511981964111) - 0.00647113488099165*std::sin(0.391039848327637*x_92 - 7.39135980606079) - 0.000112139169459655*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.00326202118865888*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.00569929021689875*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.000332901472479478*std::sin(0.362079858779907*x_95 - 1.19927990436554) - 0.000861565551935898*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.00971657178868393*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.00171193721405858*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.0243455434588981*std::sin(0.406319856643677*x_96 + 2.01399970054626) - 0.00130733385573013*std::sin(0.223999992012978*x_97 + 1.82631993293762) + 0.0120692698692407*std::sin(0.263919949531555*x_97 - 7.51999998092651) + 0.00603560350020951*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 0.00295214869335103*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 0.00202523499853851*std::sin(0.356479853391647*x_98 + 8.17695999145508) + 0.0064306296128529*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 0.00280192594686424*std::sin(0.299839943647385*x_99 - 7.50551986694336) - 0.00592644990772751*std::sin(0.355119854211807*x_99 - 7.43391990661621) - 0.000835173486173224*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 0.000285821120990883*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 0.000209321666016345*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.0118098358961097*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.172178040066774);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00147385717396582*x_1 - 0.00324291573749384*x_10 - 0.00207547795673682*x_100 + 0.000786582596713976*x_101 + 0.000406506966151041*x_102 + 0.0015032264131933*x_103 - 0.000575380244027046*x_104 - 0.00115893549746572*x_105 + 0.000874242246009833*x_106 - 0.000112114839796976*x_107 - 0.00107255870260335*x_108 + 0.00181072818741415*x_109 - 0.0010537276381877*x_11 + 0.00266046641949957*x_110 + 0.000257159879636247*x_111 - 0.000551147462999101*x_112 + 0.00289270890246653*x_113 - 0.000163405800799457*x_114 + 0.000203240754427573*x_115 - 9.11750459996453e-5*x_116 - 0.000221268399314997*x_117 - 0.000463043669153934*x_118 + 0.000140472471990796*x_119 - 0.00407926287281095*x_12 + 0.000640271715682878*x_120 + 0.00318075401753276*x_13 - 0.00027589325156898*x_14 + 0.00505726990497262*x_15 + 0.00086860675768279*x_16 + 0.00117452661386225*x_17 - 0.00241872536107994*x_18 - 0.000635525440922335*x_19 + 0.00207795314644992*x_2 + 0.00881851362630966*x_20 + 0.00289790788730152*x_21 + 0.000594908044865768*x_22 + 0.00419810403618961*x_23 - 0.000134587618064056*x_24 + 0.00269190971928255*x_25 - 0.000518255304276338*x_26 + 0.00448453606547064*x_27 - 0.00193926513318426*x_28 + 0.00301084465381897*x_29 - 0.00188930900138888*x_3 + 0.000569541554006034*x_30 + 0.0110735869152138*x_31 + 0.00643557003687146*x_32 - 0.0020602268207979*x_33 - 0.00220477454874698*x_34 + 0.00269365843801424*x_35 - 0.000953234514688205*x_36 + 0.00181754014575364*x_37 - 0.000133250668840419*x_38 - 0.00108443081349927*x_39 + 0.00309327259354603*x_4 - 3.63492005289999e-5*x_40 - 0.000626216586284582*x_41 - 0.00130649302731637*x_42 - 0.00016090886521815*x_43 + 0.00152029927227892*x_44 + 0.00240362507446334*x_45 + 0.000223522817173568*x_46 + 0.000121519415183347*x_47 - 0.000730549643618298*x_48 - 0.000133370345424727*x_49 - 0.000611900574921455*x_5 - 0.0018296076120567*x_50 - 0.00391323532853389*x_51 - 0.00112071585520471*x_52 - 0.000906457307507358*x_53 + 0.00178611526626616*x_54 - 0.000206930955120516*x_55 + 0.00117692892651622*x_56 - 0.000473868561162198*x_57 + 0.00360639591843303*x_58 - 0.000452371416237869*x_59 + 0.00146379731948299*x_6 + 0.000130203324927048*x_60 + 0.0011136499846332*x_61 + 0.00119914149760743*x_62 + 0.000318423478895814*x_63 - 0.000635457440037292*x_64 - 0.00088490009024346*x_65 - 0.000290820140699127*x_66 - 0.00206401113751872*x_67 + 0.000645552806057848*x_68 - 0.000596412582685052*x_69 - 0.00278655964008693*x_7 - 0.000262348259023556*x_70 + 0.000788061270916709*x_71 - 0.000661546311298456*x_72 + 0.000248594101892958*x_73 + 0.000299961053937866*x_74 - 0.0009175620735066*x_75 + 1.90261700431346e-5*x_76 + 0.00189524247098689*x_77 + 0.00115532110880997*x_78 - 0.000143090035119276*x_79 + 0.00182909444330064*x_8 - 0.000713336766090682*x_80 + 0.000852673424293163*x_81 - 0.000179722072745187*x_82 + 0.00012722271167429*x_83 - 5.39470407954458e-5*x_84 + 0.00198624366543939*x_85 + 0.00121753784643233*x_86 - 0.000777250224971696*x_87 + 0.000375332668628169*x_88 - 0.000269344192166508*x_89 - 0.00666248221860802*x_9 - 1.39551560652022e-5*x_90 - 0.00411134934275981*x_91 + 0.00575195040266164*x_92 + 0.00234487255730617*x_93 - 3.05735151315108e-5*x_94 + 0.000154770943800869*x_95 + 0.000212554232668916*x_96 - 0.0019753391051943*x_97 + 0.000942332557469914*x_98 + 0.000454399225206771*x_99 + 4.17508479056732e-7*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) - 8.74528492086939e-8*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) - 3.15820704940593e-6*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) + 6.86405220085396e-6*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) - 4.22644169835576e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) - 3.2982617192697e-5*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 2.66532130855375e-7*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) + 3.63432980491333e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) + 5.46195375229345e-5*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 9.55326934968591e-8*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) - 2.82539804700476e-6*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 3.41174366514796e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) + 3.36191975880559e-5*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) + 0.000160357270413812*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) - 1.15357631832237e-5*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) + 1.98286790073104e-6*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 1.6195637385496e-7*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) - 3.66319313828242e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 1.13666501197635e-6*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) - 0.00029132512134466*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) + 5.725584328244e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) + 1.53356783970278e-5*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 2.6609894278518e-7*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) - 5.15446749570831e-8*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) + 6.80210577744051e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) + 1.47366836083519e-6*std::pow(-6.0*x_54 - 10.0, 2) + 3.91145912426714e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) - 1.89316319503329e-7*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) + 2.9450450399041e-5*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) - 1.06335016593193e-5*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) - 4.51753186549791e-5*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) - 7.03023270201423e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) + 3.6745400071187e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 1.26287711911433e-7*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 3.41528502682926e-7*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) + 3.15288599465031e-5*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 3.20997414681165e-7*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 1.30595679756786e-7*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) - 1.96492414811767e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 3.21415585222087e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 7.00075980888801e-6*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 1.49473008330947e-5*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 1.92945581818294e-6*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) - 0.000173014056375959*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 3.86648096678877e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) - 2.41309843236203e-7*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) + 1.55870892917705e-5*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) + 1.232631008835e-5*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) - 2.88003073290302e-5*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) - 1.29566048313267e-5*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) - 1.43668141320515e-5*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) - 1.94330788931506e-7*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 5.1983890811424e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) - 2.91902841330776e-6*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 3.17781798318116e-7*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) - 1.60216199795835e-5*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) - 1.21719289936122e-5*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 7.22835883738168e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) - 5.59774724456519e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) + 1.65423860774476e-7*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 1.31200081896951e-5*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) - 3.54294130003426e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 1.87142371467237e-5*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) + 0.000219411493572879*std::exp(0.523359894752502*x_117) + 1.28810725278662e-5*std::exp(0.873679876327515*x_29) - 0.000630373500442892*std::exp(0.669199824333191*x_71) + 0.00086883369561929*std::exp(0.698639869689941*x_71) - 1.80001899769622e-5*std::exp(0.662319839000702*x_72) + 1.51637922802623e-5*std::exp(0.661519825458527*x_73) + 0.000125110163232557*std::exp(0.936639785766602*x_81) - 8.75225705102565e-6*std::exp(0.557839810848236*x_84) + 0.000328338368459868*std::exp(0.783999860286713*x_87) - 9.82661183418304e-6*std::exp(0.646719813346863*x_90) + 0.000291625743207019*std::sin(0.192880004644394*x_1 + 8.19839954376221) + 0.0179457314464946*std::sin(0.297999948263168*x_1 - 7.60376024246216) + 1.03822037761373e-5*std::sin(1.06031978130341*x_1 - 9.03824043273926) - 0.0518060584370785*std::sin(0.296639919281006*x_10 + 8.33568000793457) - 0.0293561792169854*std::sin(0.343679845333099*x_10 - 1.06495988368988) + 0.00064171313568762*std::sin(0.349039852619171*x_10 + 2.1275999546051) + 0.0272650315258533*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.016061401392308*std::sin(0.291599929332733*x_102 - 7.51024007797241) + 8.61404625266127e-5*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.0014043729326128*std::sin(0.290079951286316*x_103 + 5.08432006835938) + 0.00362635410333168*std::sin(0.301279932260513*x_104 - 1.31343984603882) - 0.000391164206039991*std::sin(0.356399834156036*x_104 - 1.21031987667084) + 0.0269826439012787*std::sin(0.303839921951294*x_105 - 7.50559997558594) + 0.0119453548261661*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.000210275519209945*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.00626714323262974*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 0.000435036458521578*std::sin(0.319679945707321*x_106 - 7.47704029083252) + 0.0181545367658768*std::sin(0.391679853200912*x_106 - 7.40991973876953) + 0.0234602423712624*std::sin(0.287759929895401*x_107 - 7.49671983718872) + 0.0100943646666735*std::sin(0.356399834156036*x_107 + 5.16552019119263) + 0.0099872260216225*std::sin(0.330799847841263*x_108 + 4.96007966995239) - 0.018780745265666*std::sin(0.296799927949905*x_109 + 1.88975989818573) - 0.0041107430739307*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.010241359512548*std::sin(0.250399976968765*x_11 - 1.1360799074173) + 0.0380786709474569*std::sin(0.26063996553421*x_11 + 8.29399967193604) + 0.0333149643462027*std::sin(0.279119968414307*x_11 - 1.08031988143921) + 0.0184199041430572*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 8.09149752491499e-5*std::sin(0.257199972867966*x_112 - 4.34687995910645) - 0.00286803980559326*std::sin(0.333999842405319*x_112 + 8.17199993133545) + 0.00661942555533123*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 0.000339077166997092*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.0188473225009345*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.00434636444032664*std::sin(0.309359937906265*x_115 - 7.49728012084961) + 0.00543141418864185*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.0139721420013321*std::sin(0.35607984662056*x_115 - 7.43911981582642) - 0.0102096598438109*std::sin(0.609919846057892*x_116 + 1.98527979850769) + 0.0329266097079067*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.000320110076975564*std::sin(0.303839921951294*x_117 - 7.50871992111206) + 0.0109849810364506*std::sin(0.403199851512909*x_119 - 1.18383979797363) - 0.0368678735827068*std::sin(0.296079933643341*x_12 + 5.11951971054077) - 0.00354732642078246*std::sin(0.300559937953949*x_12 + 8.32791996002197) - 0.0134474449574895*std::sin(0.382879853248596*x_12 - 4.20423984527588) + 0.00192000895033836*std::sin(0.454639852046967*x_120 - 1.17119991779327) + 0.0501089422367639*std::sin(0.23055998980999*x_13 - 4.35663986206055) - 2.24510977891416e-6*std::sin(1.31927990913391*x_13 + 1.20903992652893) - 0.025404495551155*std::sin(0.249839976429939*x_14 + 8.26024055480957) - 0.0248560506544481*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.135215458152406*std::sin(0.202800005674362*x_15 - 4.3919997215271) - 0.000752289803129295*std::sin(0.25383996963501*x_15 + 5.07239961624146) - 0.00870160457345783*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.030179998770684*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.0221351323679774*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.0245265292886609*std::sin(0.34215983748436*x_16 - 7.24799966812134) + 0.0170488492706938*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.0462742214298456*std::sin(0.385039836168289*x_16 - 4.21935987472534) - 0.0116462898522124*std::sin(0.423199862241745*x_16 - 7.38815975189209) - 2.54766854162029e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) - 0.00025439971471355*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.00748524377480066*std::sin(0.284399926662445*x_21 - 4.31175994873047) - 0.034976381588696*std::sin(0.318879842758179*x_21 - 4.26336002349854) - 0.0195052131400905*std::sin(0.333759844303131*x_21 + 8.35000038146973) + 0.0676494269287312*std::sin(0.305279940366745*x_23 + 5.12815999984741) - 0.0826785419511794*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.000422229358940806*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.0518680389730042*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.0428001323798491*std::sin(0.338799834251404*x_24 - 4.25447988510132) - 0.0152221746904298*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.0369723107759047*std::sin(0.368879854679108*x_24 - 1.02383983135223) - 0.000425642456962388*std::sin(0.381999850273132*x_24 + 8.38024044036865) - 0.000557255401237518*std::sin(0.394479840993881*x_24 + 5.38800001144409) + 0.00375185350780946*std::sin(0.407919853925705*x_24 - 7.39991998672485) - 0.000784913272109092*std::sin(1.52239990234375*x_25 - 9.59887981414795) - 0.0129888050010989*std::sin(0.423199862241745*x_26 + 2.22815990447998) + 0.0792408459030994*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.00540734724506723*std::sin(0.325439840555191*x_27 - 4.27992010116577) - 0.00567566006207088*std::sin(0.364719837903976*x_27 - 4.22952032089233) - 0.0126872104227058*std::sin(0.41431987285614*x_27 + 8.41983985900879) + 0.000119353825369366*std::sin(0.271519958972931*x_28 - 1.10407996177673) + 0.0406507939157649*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.0418655633399902*std::sin(0.3574398458004*x_28 - 1.04567980766296) + 0.000462057850996818*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.00628477381340396*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.000229298241806211*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.0249195750050741*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.000177282297889183*std::sin(0.321439832448959*x_3 + 8.31455993652344) + 0.0207373871053232*std::sin(0.329119831323624*x_3 - 7.27343988418579) + 0.0226216642694115*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.0140670248055391*std::sin(0.241119980812073*x_30 + 2.04959988594055) + 0.0144592093809456*std::sin(0.258879989385605*x_30 - 1.12431991100311) - 0.0215553753802571*std::sin(0.282159924507141*x_30 + 8.27752017974854) + 0.000588572102896027*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 0.000219541446481503*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.000109831834211141*std::sin(0.232399985194206*x_33 - 4.37471961975098) - 0.000242968453295706*std::sin(0.247519969940186*x_33 - 1.18367981910706) + 0.0209921703141549*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.014998764235917*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.0168406969422383*std::sin(0.339359849691391*x_34 + 1.96919977664948) + 0.00045196046577718*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.00273631934414856*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 0.000331897946139278*std::sin(0.282239943742752*x_35 + 8.25271987915039) - 0.00250126265031959*std::sin(0.30447992682457*x_35 - 4.34575986862183) + 0.000221770381542789*std::sin(0.343759834766388*x_35 + 8.19143962860107) + 0.00430423714274797*std::sin(0.207520008087158*x_36 - 4.396559715271) - 5.55495913089804e-5*std::sin(0.302719831466675*x_37 + 8.13655948638916) - 0.0143533683081673*std::sin(0.323999851942062*x_38 - 7.47088003158569) - 0.0157790621838279*std::sin(0.377359837293625*x_38 + 5.17280006408691) - 0.00527265667183396*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 0.000622623634417168*std::sin(0.213359996676445*x_40 + 5.00423955917358) + 0.00650616521665461*std::sin(0.229039996862411*x_41 + 5.02951955795288) + 0.0192137443815995*std::sin(0.329839825630188*x_41 + 5.13431978225708) - 0.00720960936417928*std::sin(0.330479830503464*x_41 - 7.44247961044312) - 0.000714262766004167*std::sin(0.244239971041679*x_42 + 5.06047964096069) - 0.00677720647449443*std::sin(0.308959931135178*x_42 - 7.50464010238647) - 0.0207355574014256*std::sin(0.351759850978851*x_43 - 7.43048000335693) - 0.0043385786841374*std::sin(0.357199847698212*x_44 - 4.25239992141724) + 0.043108692883431*std::sin(0.157600030303001*x_45 - 4.46623992919922) - 0.000313552259103983*std::sin(0.233679980039597*x_45 + 1.83839988708496) - 0.00795023768283928*std::sin(0.302559942007065*x_45 + 5.11320018768311) - 0.000443449288182475*std::sin(0.321759849786758*x_45 - 4.27936029434204) + 0.00149868672955941*std::sin(0.32415983080864*x_45 + 1.94247984886169) + 0.000405270578000862*std::sin(0.175040006637573*x_46 - 7.61616039276123) + 0.0124405545654594*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.0124586486844136*std::sin(0.209200009703636*x_46 + 5.00407981872559) - 0.000350205050793635*std::sin(0.221759989857674*x_47 + 1.82455992698669) + 0.0308529506541283*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.00383337042772348*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.00553194099061101*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.0799117588121261*std::sin(0.145920038223267*x_49 + 4.93440008163452) + 0.0208691637269418*std::sin(0.247039973735809*x_49 - 4.34455966949463) + 0.0136422717044853*std::sin(0.489439845085144*x_5 - 3.86071991920471) + 0.000123310167938324*std::sin(0.8711998462677*x_5 - 3.34791970252991) - 0.00052483676480251*std::sin(0.200879991054535*x_51 - 7.59600019454956) - 0.0045950192633823*std::sin(0.299919933080673*x_51 + 5.09696006774902) + 0.000330976661465759*std::sin(0.346159845590591*x_51 + 5.14703989028931) + 0.000762185035476836*std::sin(0.349679857492447*x_51 + 1.93831980228424) + 0.00478006803250221*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 0.000274898454639654*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.00788409773526674*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 0.00096475202120042*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.00541037610723841*std::sin(0.246559977531433*x_55 - 7.53864002227783) - 0.01312280549803*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.00041308818738082*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.0113029018347406*std::sin(0.266799956560135*x_59 + 1.86759984493256) + 0.000353258526957609*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.23193434017078*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.000610882158608319*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.0469184385030909*std::sin(0.212959989905357*x_65 + 5.0129599571228) + 0.000320961553847204*std::sin(1.35967981815338*x_67 + 6.00071954727173) + 0.0458125380431608*std::sin(0.153440043330193*x_69 + 4.9322395324707) - 0.0144330980696133*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.000646647763304506*std::sin(0.176880016922951*x_71 + 1.76879990100861) - 0.0135459931701846*std::sin(0.283279955387115*x_72 + 1.90391993522644) + 0.0156123364325898*std::sin(0.298239946365356*x_74 - 7.49944019317627) + 0.00330049770449615*std::sin(0.372399836778641*x_75 - 7.43207979202271) + 0.051871974035246*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 0.045397742663988*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.0827997255790503*std::sin(0.150240033864975*x_83 + 4.93767976760864) + 0.0196467466681857*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 0.00146494137065429*std::sin(0.24679996073246*x_9 - 4.34816026687622) - 0.0323205861845579*std::sin(0.350239843130112*x_9 + 2.12519979476929) + 0.0138935470722562*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 4.73627640636471e-5*std::sin(0.329439848661423*x_92 + 4.98511981964111) + 0.0297259563266489*std::sin(0.391039848327637*x_92 - 7.39135980606079) + 3.98080663678447e-5*std::sin(0.330639839172363*x_94 - 7.62272024154663) + 0.000100032042606446*std::sin(0.362079858779907*x_95 - 1.19927990436554) + 0.000305845485007381*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.000219642917581802*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.0166649102218019*std::sin(0.406319856643677*x_96 + 2.01399970054626) + 0.020496160146306*std::sin(0.223999992012978*x_97 + 1.82631993293762) + 0.0112002755375268*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.011092594751899*std::sin(0.40175986289978*x_97 - 1.17407977581024) + 0.00930316678989253*std::sin(0.356479853391647*x_98 + 8.17695999145508) + 0.013783305859701*std::sin(0.376399844884872*x_98 + 1.98295974731445) + 0.00179821238053983*std::sin(0.299839943647385*x_99 - 7.50551986694336) + 0.027223878712011*std::sin(0.355119854211807*x_99 - 7.43391990661621) + 0.0130937093440413*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 8.58850828740167e-5*std::sin(0.359679847955704*x_99 + 8.18544006347656) - 0.00354346539698396*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.000266961112293205*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.314961284399033*std::sin(-0.0345370941095231*x_1 - 0.0104312265426617*x_10 + 0.00970115532128054*x_100 + 0.00482815773708862*x_101 + 0.00145049265083068*x_105 + 0.00130487257251604*x_106 - 0.00553569111698021*x_108 + 0.000968675848850381*x_109 - 0.00118841317631956*x_110 + 0.00220107010148448*x_111 + 0.000540771121722762*x_112 - 0.000210246687719018*x_113 - 0.000464646835181165*x_114 + 9.4752860899683e-5*x_115 + 0.00939063076082782*x_116 - 0.000687235675326779*x_117 - 0.00972531472346833*x_118 - 9.83953538405701e-5*x_119 + 0.00537249515494741*x_12 + 0.00485121205722588*x_120 - 0.00193563309285105*x_16 + 2.95590015194921e-5*x_19 - 0.000107657639180371*x_2 + 0.00662769675233259*x_20 + 0.00562012077693762*x_21 + 0.00193803478665922*x_22 + 0.0285605012530016*x_25 - 0.0019452719704332*x_30 - 0.0163461190943879*x_31 + 0.0035346986858502*x_32 + 0.0203960506563609*x_33 + 0.000803925922535611*x_34 + 0.00790716837254214*x_35 + 0.000160638327005941*x_36 + 0.0110476549371918*x_37 - 0.000731041267951244*x_38 + 0.00088571245749033*x_39 + 0.00833011467896694*x_40 - 0.000711137020333455*x_41 + 0.000724068347911172*x_42 - 0.00023419062789574*x_43 - 0.00525030819103203*x_44 - 0.0114961744338429*x_45 + 0.000171095206228705*x_46 + 0.00234220102252851*x_47 - 0.00964216333538062*x_49 - 0.000323891540028264*x_5 + 0.00177196776945408*x_50 + 0.000713816151883422*x_51 + 0.00412567492843675*x_52 - 0.00633145889650144*x_53 + 0.000686484003056373*x_54 - 0.00883379142228371*x_55 - 0.000485607121311417*x_57 - 0.00318069906134604*x_59 - 0.00417722643544011*x_6 + 0.00385283540770023*x_60 - 0.000131373911230986*x_61 - 0.000247721433763853*x_62 - 0.000568399872830302*x_63 + 0.00357866940343195*x_64 + 0.000541801679992717*x_68 + 0.000113837966129198*x_69 + 6.94745480001959e-5*x_7 + 0.000467182013767595*x_70 + 0.000725381182246013*x_71 - 0.000148860237489024*x_73 - 0.00101683838885557*x_74 - 0.00317991107478923*x_75 - 0.000274229130144943*x_76 - 0.000555504185646391*x_77 + 0.00103631302576254*x_78 + 0.00140754024889371*x_79 - 0.000487327382382931*x_8 - 0.00719483922764412*x_80 + 4.27291094799349e-5*x_82 - 0.00601954775117352*x_84 + 8.83108466527018e-5*x_85 + 0.00398480602796374*x_86 + 0.000223266669661606*x_87 - 0.000496991554891171*x_88 - 0.00689072247131026*x_9 + 0.00202330577654017*x_90 - 0.00623219311709173*x_91 + 0.00591186235536667*x_92 - 0.000842684051189539*x_93 - 0.00080545234484841*x_97 + 0.000367353357028987*x_99 - 6.74358162764299e-5*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) - 0.000297052081379805*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) + 0.000398334324081418*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 0.000698598129444342*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 0.000497742643653949*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 8.52898910147677e-5*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) - 7.08747330597126e-5*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 0.000187081977211061*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) - 0.00268769230684576*std::exp(1.36367988586426*x_17) - 0.0122443274888472*std::exp(0.633919835090637*x_72) - 0.0566460453751416*std::sin(0.333999842405319*x_102 + 1.93591976165771) - 0.129881205942151*std::sin(0.229759991168976*x_103 - 7.57151985168457) + 0.0299160504391993*std::sin(0.401439845561981*x_107 + 5.19271993637085) + 0.288373344538018*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.569200832389427*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 0.406735080644705*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.216121167150529*std::sin(0.334719836711884*x_24 + 5.11863994598389) - 0.250120563894285*std::sin(0.334959834814072*x_26 - 4.26191997528076) - 0.341988125742487*std::sin(0.293599933385849*x_27 + 1.90855991840363) + 0.152359794126755*std::sin(0.270719945430756*x_28 - 7.51624011993408) - 0.00670413768367323*std::sin(0.897199869155884*x_29 + 8.85704040527344) + 0.118749122242634*std::sin(0.339759826660156*x_3 - 1.05527985095978) + 0.180223673963753*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.116275824605161*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.187643229382806*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.223104017402997*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.276965911250482*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 0.00620261199425765*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.112558166425525*std::sin(0.388399839401245*x_94 + 1.99583983421326) - 0.196657722203453*std::sin(0.344079852104187*x_95 - 7.42312002182007) - 0.0590715089527905*std::sin(0.359439849853516*x_96 + 5.1733603477478) + 0.101865814083113*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 6.17115082200199) + 0.634414034855576);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000333471011723433*x_1 + 0.00181785826480325*x_10 - 0.00147356251096973*x_100 - 0.00251353187031186*x_101 + 0.00311976176195084*x_102 - 0.00130747653465446*x_103 - 0.00118453279100656*x_104 - 0.000696978931746862*x_105 + 0.000658128112159266*x_106 + 0.000818130374659281*x_107 - 0.000513481487379365*x_108 - 0.00131375351039733*x_109 - 0.00207300046253848*x_11 - 0.00290964064407385*x_110 + 0.00026495839626036*x_111 + 0.000367943088750489*x_112 - 0.00072760142764427*x_113 - 0.0002246485325405*x_114 - 0.000789091874565812*x_115 - 0.000126953281431974*x_116 + 0.000573176733357517*x_117 + 0.000501132683702733*x_118 + 0.00137972098729882*x_119 - 0.00409522955157237*x_12 - 0.000990052727204745*x_120 - 0.0030522599185499*x_13 - 0.00229084319408172*x_14 - 3.26388962391135e-5*x_15 - 0.00193370079261732*x_16 - 0.00238443666459641*x_17 - 0.000358644827555106*x_18 - 0.000862226503171498*x_19 - 0.00682050461393365*x_2 - 0.00466014941547899*x_20 - 0.00152945097476054*x_21 - 0.00555359116103294*x_22 - 0.00272629599456488*x_23 + 3.64293930940985e-5*x_24 + 0.000497521704328856*x_25 - 0.000418163317888995*x_26 - 0.000274911268919432*x_27 + 0.00241767526461741*x_28 + 0.00171922925036579*x_29 + 0.00400713401768208*x_3 + 0.000509419251225513*x_30 - 0.00516453546267521*x_31 - 0.00602062215860883*x_32 - 0.00180772167492573*x_33 + 0.00120895905471175*x_34 + 0.00017153112024311*x_35 + 0.00142386760025824*x_36 - 0.000938037063545456*x_37 + 0.000570192549499705*x_38 + 0.00159011714704563*x_39 + 0.00368094488539254*x_4 - 0.000796647583414533*x_40 - 0.000340187084583642*x_41 + 0.000304397945900164*x_42 - 0.000544280408235516*x_43 - 0.00135139820351932*x_44 - 0.000782644846507338*x_45 - 0.00112617573739989*x_46 - 1.12333594172847e-5*x_47 + 0.00137686721878269*x_48 + 0.000455504728591998*x_49 + 0.000335283989122502*x_5 + 0.00209210391421681*x_50 + 0.00322933646794102*x_51 + 0.00140884313844433*x_52 + 0.00041147805343173*x_53 - 0.00300364624258224*x_54 + 0.000328895315724572*x_55 + 0.00141197119310263*x_56 - 0.000240240838113401*x_57 - 0.00143948372212015*x_58 + 0.00085129777860674*x_59 + 0.000851872708448632*x_6 - 0.000463588406490176*x_60 - 0.000274098145294274*x_61 + 0.000206902373168583*x_62 - 0.001058591060752*x_63 - 0.000455481573260873*x_64 + 0.000418988163415642*x_65 - 0.000361750647748549*x_66 - 0.000581698015775442*x_67 + 0.00136959934964434*x_68 + 0.00120650593336077*x_69 + 0.00293874539544498*x_7 + 0.000776859768186457*x_70 - 0.000242084870016126*x_71 + 0.000206651119544779*x_72 + 0.000202538480257367*x_73 + 0.000114418461381034*x_74 - 0.000773073117281855*x_75 + 0.000420445093020232*x_76 - 0.0015519174443313*x_77 - 0.000287496197154921*x_78 - 0.000966665403858915*x_79 - 0.00145107298732299*x_8 + 0.00124153555401697*x_80 - 0.00027821928402384*x_81 - 0.000510898069504317*x_82 + 0.00080528574983179*x_83 - 0.000563648000286992*x_84 + 0.00083484914228305*x_85 - 0.00155689908445109*x_86 - 0.000879155839559014*x_87 - 0.000659898059051933*x_88 + 0.000624834089327852*x_89 + 0.00171385796799689*x_9 - 0.000641200361103884*x_90 + 0.00119818950843682*x_91 - 0.00347797878524262*x_92 + 0.0022796117801831*x_93 + 0.000951134912459701*x_94 - 0.000649597651786299*x_95 - 0.000806744070111514*x_96 - 0.00207228897631275*x_97 - 0.000915783788371016*x_98 - 0.000223233833391894*x_99 - 3.11284433076643e-5*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 2.36092157883913e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) - 3.31343380190567e-6*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) - 3.05654728162404e-6*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) - 3.73272031494024e-6*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) - 3.19734489952303e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) + 1.79361813739937e-5*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 1.0399765402021e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 1.39456471834066e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 1.57866056167371e-5*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 2.44578547396967e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) + 1.2189550661947e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 2.9702492250734e-5*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 5.65836828340174e-6*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) - 0.000107049335470401*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) + 1.14429962288162e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) + 3.25370266707126e-5*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) - 0.000107914573402067*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) - 5.37154957122752e-6*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 1.74259230924706e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) + 7.51273581872369e-5*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 9.59261982020628e-6*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) - 2.77124179926855e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) - 7.49342233792651e-6*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) + 0.000158424669113145*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) + 4.3314611096663e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) + 1.48420370745208e-5*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 1.57609480376673e-5*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) - 1.31813386811939e-7*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) - 4.57756820949855e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) + 1.82134430536737e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) + 1.24806088210076e-6*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) + 2.85024676031689e-5*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 5.78257368989032e-6*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 5.01026453132228e-5*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) + 7.79702868791201e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) + 2.77982581764348e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 2.98599105448929e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 7.47997735127736e-6*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) - 2.251514108447e-6*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 3.49677508440954e-5*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) + 2.11616366497128e-6*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 7.73513679177676e-6*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) - 5.02483150796088e-7*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) - 1.07802862423417e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) - 4.71125510129296e-6*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) - 5.01332819377177e-6*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 7.31036688352445e-5*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) + 0.000191884908815163*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) - 2.9250310498958e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 1.59082627741279e-6*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 1.31862816088355e-5*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) + 1.19295375520386e-5*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) + 1.56618115797865e-5*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) + 7.04589368660818e-6*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) + 9.66834003975153e-6*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) + 1.44888433400321e-5*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) - 4.39770511691559e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 3.23741037375192e-6*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) + 2.09496483221828e-6*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 2.4813177316521e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 1.77691174535155e-5*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) + 1.34995360143956e-5*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) + 6.11500796686609e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 3.76707900022859e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) + 6.26761754352762e-6*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 6.54972240862251e-6*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) + 8.8292852776111e-6*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) - 1.18830334029363e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) + 2.07554216325709e-5*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) + 9.40958546197643e-5*std::exp(1.36367988586426*x_17) - 0.000960382258179504*std::exp(0.873679876327515*x_29) - 0.000293529127829317*std::exp(0.669199824333191*x_71) - 0.000963598437904809*std::exp(0.698639869689941*x_71) + 0.000428672752596255*std::exp(0.633919835090637*x_72) + 0.000118665591215625*std::exp(0.662319839000702*x_72) + 0.000574529273329868*std::exp(0.661519825458527*x_73) - 0.000138756080093069*std::exp(0.936639785766602*x_81) - 2.23818395422014e-5*std::exp(0.557839810848236*x_84) - 0.000178552735652565*std::exp(0.783999860286713*x_87) + 0.000732648903509396*std::exp(0.646719813346863*x_90) - 0.000471180493224223*std::exp(0.0173920220380792*x_1 - 0.0297994300856725*x_10 - 0.00932691662396081*x_100 + 0.00590338523489485*x_101 + 0.0103450792760491*x_102 - 0.00319767232086393*x_104 - 1.70121875012002e-5*x_105 + 0.00183940423054717*x_106 + 0.0281896574227106*x_107 - 0.0044846965367401*x_108 - 0.0386597686513281*x_109 - 0.00163702225223401*x_11 + 0.00131130116040953*x_110 - 0.00326538038222493*x_111 + 2.4178920208005e-5*x_112 - 0.0118958675871326*x_113 - 0.0470620200098288*x_114 - 0.00743970702960615*x_115 + 0.00640414676416144*x_116 - 1.89871207168196e-5*x_118 - 0.00240511538879421*x_119 - 0.0310246317393049*x_120 + 1.67593485758661e-5*x_13 - 0.0287289357234782*x_14 - 0.00586450496472628*x_15 - 0.0304538847527468*x_16 - 0.0134619754292213*x_17 - 0.00766016018710507*x_18 - 0.0317631198557148*x_2 + 0.0307647181570834*x_20 + 0.00485420244732836*x_21 - 0.00481234871019707*x_22 - 0.0203635002285881*x_23 + 0.0561310727810676*x_24 - 0.00301090567175079*x_25 - 0.00556350858464243*x_26 - 0.000671274153415105*x_27 - 0.0171697703195912*x_28 - 0.178832416317686*x_29 - 0.00546401117777097*x_3 - 0.0688142066558136*x_30 - 0.0131056724458951*x_31 - 0.18245333664096*x_32 - 0.00368194460132672*x_33 + 0.00478794844888538*x_34 - 0.00128120170096396*x_36 - 0.00914442371695197*x_37 - 0.000209384255340823*x_38 - 0.00144652243604586*x_39 + 0.0517862113453264*x_4 + 0.0266176812500356*x_40 - 0.0321196847884936*x_41 - 0.0916304024255848*x_42 - 0.000158050717112904*x_43 + 0.00244173127268873*x_44 - 1.60193757635152e-5*x_46 - 0.00348724567970783*x_47 + 0.0245350606672134*x_48 - 0.000698597597012973*x_49 + 0.12587336296459*x_5 - 0.00843733112293099*x_50 + 0.000491450298089105*x_52 - 0.00105667480556972*x_53 + 0.00102247212042586*x_55 + 0.00466209130430337*x_56 + 0.000635581131697553*x_57 - 0.00666320467469794*x_58 - 0.0482744654919267*x_59 - 0.0720519470898504*x_6 - 0.00309231006482213*x_60 + 0.000895968556636142*x_61 - 0.0941815412770192*x_62 - 0.000157928200722518*x_63 - 0.0022925228000353*x_64 - 0.0020260195242682*x_65 - 0.0177072126967638*x_66 - 0.0130378424638076*x_67 - 0.0535350512292363*x_68 - 0.053775266712019*x_69 - 0.0607758689330832*x_7 - 0.0607017602057481*x_70 - 0.060913366275531*x_71 + 0.00313511202472871*x_72 - 0.00703599632430216*x_73 + 0.0131074125445647*x_74 + 0.00013480482753467*x_75 + 0.0115932688471359*x_76 + 0.0011051282579315*x_77 - 0.000818232495888754*x_78 - 0.0248179793042754*x_79 + 0.00953239783889861*x_8 - 0.00361057550992577*x_80 + 0.00280168045670815*x_81 + 0.000844363613812787*x_82 - 0.00519221768329011*x_83 - 0.000230949118474305*x_84 - 0.0313646813870188*x_85 - 0.0255984464246365*x_86 - 0.00158709114722828*x_87 - 0.00690671989403609*x_88 - 0.000937608538272558*x_89 - 0.00416165495977992*x_9 - 0.000246409052054847*x_90 - 0.232085323183672*x_91 - 0.0581128174787922*x_92 - 0.000503004297755471*x_93 + 0.00087181955783195*x_94 - 0.000606631745349215*x_95 - 1.09885781385578e-5*x_96 + 0.0040657678663332*x_97 + 0.000976771299657326*x_98 - 0.000600945558543522*std::pow(-6.0*x_54 - 10.0, 2) - 0.0894735654644132*std::exp(0.523359894752502*x_117) - 0.572687654035064*std::sin(0.290079951286316*x_103 + 5.08432006835938) + 1.44656023968999*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 0.0103891088077651*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 1.01998707470958*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.611147770904452*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 0.310810575860199*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 0.733290998248037*std::sin(0.299839943647385*x_99 - 7.50551986694336)) + 0.000745764270037048*std::sin(0.192880004644394*x_1 + 8.19839954376221) - 0.00975901615789844*std::sin(0.297999948263168*x_1 - 7.60376024246216) - 0.000774072522752747*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.0438266094976294*std::sin(0.296639919281006*x_10 + 8.33568000793457) - 0.0284112309233883*std::sin(0.343679845333099*x_10 - 1.06495988368988) + 0.0243133758837312*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.030238861499278*std::sin(0.206560000777245*x_102 - 7.59832000732422) - 0.0135875375977563*std::sin(0.291599929332733*x_102 - 7.51024007797241) + 0.00022028397922062*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.00198317271542861*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.00454712879187982*std::sin(0.229759991168976*x_103 - 7.57151985168457) + 0.0016885870938473*std::sin(0.301279932260513*x_104 - 1.31343984603882) - 0.0148205200186852*std::sin(0.356399834156036*x_104 - 1.21031987667084) - 0.0146733533041271*std::sin(0.303839921951294*x_105 - 7.50559997558594) + 0.00400647480125863*std::sin(0.325759828090668*x_105 - 7.45359992980957) - 0.00138623363626475*std::sin(0.357039839029312*x_105 + 1.9761598110199) + 0.00474115577111228*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 0.0164827620800196*std::sin(0.319679945707321*x_106 - 7.47704029083252) - 0.0122173387296133*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.0260190793886087*std::sin(0.287759929895401*x_107 - 7.49671983718872) - 0.0085395760982336*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.00104735810931723*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 0.0110765448462241*std::sin(0.330799847841263*x_108 + 4.96007966995239) + 0.020829183872507*std::sin(0.296799927949905*x_109 + 1.88975989818573) - 0.00310981774711224*std::sin(0.345119833946228*x_109 - 1.21783995628357) - 0.00689206008559391*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.042231957654804*std::sin(0.26063996553421*x_11 + 8.29399967193604) - 0.0281836135941866*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.0100959236422823*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.020428985372114*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.00479256590433179*std::sin(0.257199972867966*x_112 - 4.34687995910645) - 0.00133548320499526*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.00559986587793553*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 0.0128470342218523*std::sin(0.394319832324982*x_113 - 1.17887985706329) - 0.00632139637290492*std::sin(0.328399837017059*x_114 - 7.44743967056274) + 0.00328806763858899*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 0.00602382510505512*std::sin(0.316559851169586*x_115 - 1.27255988121033) - 0.00468625969362777*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.00863711288944685*std::sin(0.609919846057892*x_116 + 1.98527979850769) - 0.0221584031147182*std::sin(0.186160013079643*x_117 - 7.60880041122437) - 0.002110313923742*std::sin(0.303839921951294*x_117 - 7.50871992111206) - 0.00739249015226601*std::sin(0.403199851512909*x_119 - 1.18383979797363) + 0.0200490113804346*std::sin(0.296079933643341*x_12 + 5.11951971054077) + 0.0149141740475565*std::sin(0.382879853248596*x_12 - 4.20423984527588) + 0.000894039093047753*std::sin(0.454639852046967*x_120 - 1.17119991779327) - 0.0337214839785863*std::sin(0.23055998980999*x_13 - 4.35663986206055) + 0.000167390067455171*std::sin(1.31927990913391*x_13 + 1.20903992652893) - 0.00852067374687244*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 0.0135168967997503*std::sin(0.292079925537109*x_14 - 4.27263975143433) - 0.0453512962747319*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.0560889458833294*std::sin(0.25383996963501*x_15 + 5.07239961624146) - 0.00658284982647116*std::sin(0.346319854259491*x_15 + 8.34296035766602) + 0.0255315123494327*std::sin(0.441039860248566*x_15 + 5.44664001464844) - 0.0245494380341637*std::sin(0.333039849996567*x_16 - 1.04951989650726) + 0.0207488207729962*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 0.0092712852637041*std::sin(0.354799836874008*x_16 + 5.1593599319458) - 0.0155203846854704*std::sin(0.385039836168289*x_16 - 4.21935987472534) - 0.0112714065391886*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0199276675523996*std::sin(0.19072000682354*x_18 + 4.97863960266113) - 0.00011845949477164*std::sin(1.75519990921021*x_2 + 3.0064799785614) - 0.00566266086536961*std::sin(0.284399926662445*x_21 - 4.31175994873047) - 0.0117310865615612*std::sin(0.318879842758179*x_21 - 4.26336002349854) - 0.018877358345475*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.0142397568797664*std::sin(0.26503998041153*x_23 + 5.08439970016479) + 0.0226896336068519*std::sin(0.305279940366745*x_23 + 5.12815999984741) + 0.091696390545278*std::sin(0.153600037097931*x_24 + 4.94071960449219) - 0.00278353153891328*std::sin(0.208800002932549*x_24 + 1.8199999332428) - 0.0173965523971579*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.00756638171439949*std::sin(0.334719836711884*x_24 + 5.11863994598389) + 0.0232750158276067*std::sin(0.338799834251404*x_24 - 4.25447988510132) + 0.0102439663866216*std::sin(0.353439837694168*x_24 + 8.3342399597168) - 0.0312776357724378*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.0317348934345553*std::sin(0.381999850273132*x_24 + 8.38024044036865) - 0.0211134216833652*std::sin(0.394479840993881*x_24 + 5.38800001144409) + 0.00363108480886448*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 0.000528217901805701*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.00875669739339724*std::sin(0.334959834814072*x_26 - 4.26191997528076) + 0.0109881990986713*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 0.0430917345352866*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.0119729720844855*std::sin(0.293599933385849*x_27 + 1.90855991840363) + 0.00251789442227456*std::sin(0.325439840555191*x_27 - 4.27992010116577) - 0.00429369290908443*std::sin(0.364719837903976*x_27 - 4.22952032089233) + 0.00853802822220293*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.00533410204789156*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.00706928565763608*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.045084625186988*std::sin(0.324479848146439*x_28 + 8.32696056365967) - 0.035417203146781*std::sin(0.3574398458004*x_28 - 1.04567980766296) - 0.00304609940975812*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.00023471122911913*std::sin(0.897199869155884*x_29 + 8.85704040527344) + 0.00475449347964757*std::sin(0.285119920969009*x_3 - 4.29447984695435) - 0.0170959338041177*std::sin(0.302559942007065*x_3 - 4.27119970321655) - 0.016769961842664*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.0105003689822449*std::sin(0.321439832448959*x_3 + 8.31455993652344) + 0.0200698697688879*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.00415739558963166*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.0191373533527188*std::sin(0.353119850158691*x_3 - 4.22575998306274) - 0.0156013322191929*std::sin(0.241119980812073*x_30 + 2.04959988594055) + 0.0139937807864989*std::sin(0.258879989385605*x_30 - 1.12431991100311) + 0.0117219661540509*std::sin(0.282159924507141*x_30 + 8.27752017974854) - 0.000396087481636951*std::sin(1.43687975406647*x_30 + 6.00695943832397) - 7.36342524738814e-5*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.00650530142572177*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.018115152394159*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.0114156912408946*std::sin(0.281599938869476*x_33 + 2.00543975830078) - 0.00503058903110936*std::sin(0.295999944210052*x_34 - 1.14071989059448) - 0.0113331726190234*std::sin(0.339359849691391*x_34 + 1.96919977664948) + 0.0171239827859407*std::sin(0.351599842309952*x_34 + 8.19431972503662) + 0.0020700526170474*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 0.0125750262395296*std::sin(0.282239943742752*x_35 + 8.25271987915039) - 0.0165346743730102*std::sin(0.343759834766388*x_35 + 8.19143962860107) + 0.00200423871497406*std::sin(0.207520008087158*x_36 - 4.396559715271) - 0.000142055018729914*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.012142584994798*std::sin(0.323999851942062*x_38 - 7.47088003158569) + 0.0175001035855335*std::sin(0.377359837293625*x_38 + 5.17280006408691) - 0.00398881686293767*std::sin(0.328799843788147*x_39 + 1.9366397857666) - 0.0041046234388357*std::sin(0.213359996676445*x_40 + 5.00423955917358) + 0.00492197826342138*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 0.0213094107258523*std::sin(0.329839825630188*x_41 + 5.13431978225708) - 0.00697753869804024*std::sin(0.330479830503464*x_41 - 7.44247961044312) - 0.0270621530771758*std::sin(0.244239971041679*x_42 + 5.06047964096069) + 0.00751640458364861*std::sin(0.308959931135178*x_42 - 7.50464010238647) + 0.0229972097328215*std::sin(0.351759850978851*x_43 - 7.43048000335693) - 0.00328217763711322*std::sin(0.357199847698212*x_44 - 4.25239992141724) - 0.0290105723951976*std::sin(0.157600030303001*x_45 - 4.46623992919922) + 0.0233777137737654*std::sin(0.233679980039597*x_45 + 1.83839988708496) - 0.00266651157741586*std::sin(0.302559942007065*x_45 + 5.11320018768311) - 0.0168015093183351*std::sin(0.321759849786758*x_45 - 4.27936029434204) - 0.0302160143910514*std::sin(0.175040006637573*x_46 - 7.61616039276123) + 0.012040104604954*std::sin(0.176400005817413*x_46 + 4.97695970535278) - 0.00417863368131173*std::sin(0.209200009703636*x_46 + 5.00407981872559) + 0.0261104591080797*std::sin(0.221759989857674*x_47 + 1.82455992698669) - 0.0342181193074945*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.00630961385763504*std::sin(0.241199985146523*x_48 + 5.0479998588562) - 0.0017849828355821*std::sin(0.400319814682007*x_48 - 1.2060798406601) + 0.00185541430149766*std::sin(0.452239871025085*x_48 - 1.14887976646423) + 0.053777688655872*std::sin(0.145920038223267*x_49 + 4.93440008163452) + 0.00699952239277*std::sin(0.247039973735809*x_49 - 4.34455966949463) - 0.0151302507835461*std::sin(0.489439845085144*x_5 - 3.86071991920471) + 5.7418539995721e-5*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.0391305860801762*std::sin(0.200879991054535*x_51 - 7.59600019454956) - 0.00347617746879157*std::sin(0.299919933080673*x_51 + 5.09696006774902) - 0.00218195148282743*std::sin(0.346159845590591*x_51 + 5.14703989028931) + 0.00361616869080198*std::sin(0.296959936618805*x_54 + 1.8899998664856) + 0.00181225796426741*std::sin(0.358159840106964*x_54 - 1.23015987873077) + 0.00264432822353796*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 0.0365527479827896*std::sin(0.192479997873306*x_55 + 4.99200010299683) - 0.00409300297640681*std::sin(0.246559977531433*x_55 - 7.53864002227783) - 0.00440139203186397*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.00407080567220164*std::sin(0.300799936056137*x_56 - 7.48128032684326) - 0.0156511809005702*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.00656937179431411*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.0076064392126022*std::sin(0.266799956560135*x_59 + 1.86759984493256) + 0.013384340871954*std::sin(0.337439835071564*x_59 + 1.93647980690002) + 0.196210560355619*std::sin(0.157440036535263*x_6 + 4.9488000869751) - 0.0455459268392936*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.0078108506443117*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.0520358893519731*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.00969655047688145*std::sin(0.235039979219437*x_67 + 5.03983974456787) + 0.000310630097891154*std::sin(1.35967981815338*x_67 + 6.00071954727173) - 0.0249131834124752*std::sin(0.153440043330193*x_69 + 4.9322395324707) - 0.006720673831105*std::sin(0.166640013456345*x_70 - 7.62864017486572) - 0.00426300162603844*std::sin(0.176880016922951*x_71 + 1.76879990100861) - 0.00454332927603665*std::sin(0.283279955387115*x_72 + 1.90391993522644) + 0.00523638128931319*std::sin(0.298239946365356*x_74 - 7.49944019317627) + 0.00110698770167214*std::sin(0.372399836778641*x_75 - 7.43207979202271) + 0.0173978722179538*std::sin(0.221279993653297*x_8 - 4.37391948699951) + 0.0503493293779801*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.000217152861950714*std::sin(0.525279879570007*x_81 + 8.33559989929199) + 0.0277710473159771*std::sin(0.150240033864975*x_83 + 4.93767976760864) + 0.00658952342548886*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 0.0555040378816314*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.0358458316207554*std::sin(0.350239843130112*x_9 + 2.12519979476929) + 0.0105106056200997*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 0.000121119132969646*std::sin(0.329439848661423*x_92 + 4.98511981964111) - 0.016165186075902*std::sin(0.391039848327637*x_92 - 7.39135980606079) + 0.000101799769903467*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.0039406508093455*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.00688496833926161*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.00592486316976726*std::sin(0.362079858779907*x_95 - 1.19927990436554) + 0.000782127916288723*std::sin(0.157040029764175*x_96 + 1.74959981441498) - 0.00144798786593518*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.0020680879669277*std::sin(0.359439849853516*x_96 + 5.1733603477478) + 0.0161284821546259*std::sin(0.406319856643677*x_96 + 2.01399970054626) - 0.0137931655537743*std::sin(0.223999992012978*x_97 + 1.82631993293762) - 0.0124219031403605*std::sin(0.263919949531555*x_97 - 7.51999998092651) + 0.00938405339401351*std::sin(0.40175986289978*x_97 - 1.17407977581024) - 0.0035663125605094*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 0.00505912814380825*std::sin(0.356479853391647*x_98 + 8.17695999145508) + 0.00462292400757896*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 0.0148045385067366*std::sin(0.355119854211807*x_99 - 7.43391990661621) - 0.00881158711710754*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 0.00508694365419146*std::sin(0.359679847955704*x_99 + 8.18544006347656) - 0.00164999053218338*std::sin(0.36847984790802*x_99 + 1.96631979942322) + 0.00175993132641372*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 0.294328298817315);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00276099385388144*x_1 + 0.000944301187840445*x_10 - 0.000269464751185548*x_100 + 0.000442667477648099*x_101 + 1.81450421166068e-5*x_102 - 0.00081775910300595*x_103 - 0.000926459395278842*x_104 + 1.88696981940094e-5*x_105 - 0.000104149304188674*x_106 + 6.22137649465337e-5*x_107 + 0.000645993955376108*x_108 + 3.34912858787003e-6*x_109 - 0.000780368446553093*x_11 - 2.06513408666703e-5*x_110 - 0.000208171111567304*x_111 + 0.000151062209423547*x_112 - 0.00175811901380606*x_113 + 9.29183195291804e-5*x_114 + 0.000164780412928298*x_115 - 0.00110971548834126*x_116 - 3.83147056522111e-5*x_117 + 0.000819450370057167*x_118 - 0.000196440921851313*x_119 - 1.54153471151176e-5*x_12 - 0.000246850408315801*x_120 - 0.00239007617238113*x_13 - 7.50176682416443e-5*x_14 - 0.00124776212012846*x_15 - 0.000255430427698584*x_16 - 0.00151816035190862*x_17 + 1.35521065264889e-5*x_18 - 0.00156640975523577*x_19 - 0.00253475603415888*x_2 - 0.000939631649074888*x_20 - 0.000848569777561191*x_21 - 0.000124856139257555*x_22 - 0.000577311478491379*x_23 - 8.85116210066898e-5*x_24 - 0.00238861043811731*x_25 + 0.000627950607030008*x_26 - 0.000769563419118398*x_27 + 1.40382353159852e-5*x_28 + 0.00117508172591493*x_29 - 5.18012525679289e-5*x_3 - 0.000497139379094636*x_30 + 0.00515911507631726*x_31 - 0.00140356670396578*x_32 - 0.00073314346187505*x_33 + 0.00109464551801362*x_34 - 0.00220549924218424*x_35 + 0.000626505416663477*x_36 - 0.00108466569959257*x_37 + 6.53991573172038e-5*x_38 - 7.99293641001041e-5*x_39 + 0.000143777442877556*x_4 - 0.000699398072697359*x_40 + 0.000771430764649031*x_41 + 0.000622743333606843*x_42 + 0.000121861867010983*x_43 + 0.000647166197069281*x_44 + 0.000580824050624065*x_45 + 9.1946001984482e-6*x_46 - 2.66792266182823e-5*x_47 - 0.000195672440002939*x_48 + 0.00086866422307828*x_49 - 9.75901523725889e-7*x_5 + 5.60074383073209e-5*x_50 + 0.000980245584165176*x_51 + 0.000937605327039465*x_52 + 0.00102989201940974*x_53 - 0.00018647033366196*x_54 + 0.000666882786092939*x_55 - 0.000121783564729246*x_56 + 0.000406230366252464*x_57 - 0.00159846055125034*x_58 + 0.000605073098335788*x_59 + 0.000278030348847443*x_6 - 0.000424128568481072*x_60 + 0.000471924575871655*x_61 - 0.000910494397752409*x_62 + 0.00162254420926178*x_63 + 0.000863839865343274*x_64 + 0.000338451225473503*x_65 + 7.68845827524865e-5*x_66 + 0.000776863740661725*x_67 - 0.000331800061090488*x_68 - 0.000168643850171832*x_69 + 8.96889480171811e-5*x_7 + 0.000125926063641754*x_70 + 7.77905712248775e-5*x_71 - 0.000139624635863538*x_72 + 4.01992446482536e-5*x_73 + 5.24474718130697e-6*x_74 + 0.000412533413371368*x_75 + 0.000122666919865874*x_76 - 0.000850516797768*x_77 - 0.000502782094435318*x_78 - 0.000119419729459157*x_79 - 0.00086695617580678*x_8 + 0.00017400848732578*x_80 - 0.000443816881461228*x_81 + 6.00938082938476e-5*x_82 - 8.45902390483705e-5*x_83 + 0.0005145812785607*x_84 - 0.000546122001538091*x_85 + 4.47234323055483e-5*x_86 + 4.85188469983329e-5*x_87 + 0.000601416373529394*x_88 + 0.000489990205239517*x_89 + 0.00179468032390463*x_9 - 0.000565245849202685*x_90 + 0.000822144115653301*x_91 - 0.00177234583522904*x_92 - 0.000704658053903459*x_93 - 0.000186637326584766*x_94 - 3.66202041588768e-5*x_95 - 7.63465742734471e-5*x_96 + 0.000953545648529639*x_97 - 0.000573939154448561*x_98 - 0.000295473345104194*x_99 - 1.61393946166892e-6*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) + 5.44411361419389e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) + 5.6677585969991e-8*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 5.12626848092567e-7*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) - 7.87124245827501e-8*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) + 1.51456779028868e-7*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) + 3.78222905705597e-7*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) + 2.39811033610883e-5*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) - 3.21576491021185e-5*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 5.37233449766971e-7*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) - 5.63980359008071e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) - 1.77093131110747e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 6.26340840980755e-7*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 1.92559742527618e-7*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) + 1.83112090866717e-6*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) - 1.66246983801932e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 5.45692635896309e-6*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) + 2.88630104415596e-6*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 1.40708084702522e-5*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) - 4.01829124685547e-5*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) - 1.28508295530349e-6*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 3.26446125495698e-7*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 1.31272468256394e-7*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) - 4.17562954162529e-7*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) + 3.34072439601337e-6*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 2.05179349984022e-7*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 2.48922263709987e-6*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 5.36360297548505e-7*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) - 3.76782026790025e-6*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) + 1.22432397091955e-7*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) + 7.03006950043515e-7*std::pow(-6.0*x_54 - 10.0, 2) - 4.77102306129371e-6*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) + 6.95468592857786e-8*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 4.78027289749945e-6*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 1.21937985452032e-7*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) + 3.18112554631049e-5*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) + 4.95050251126894e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) - 1.31679089317007e-7*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) + 6.88547840695303e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 2.54550860024343e-7*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) - 1.254632182819e-7*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) - 2.22017829221913e-5*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) + 1.17920959421236e-7*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 2.63234182442607e-7*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) - 1.43632315779052e-5*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) + 1.5661895158172e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) + 1.26008008830126e-7*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) + 7.28350053043725e-6*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) - 1.25046695447736e-6*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) + 0.000121831887631346*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) + 1.38557395369744e-7*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) + 8.86470947451859e-8*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) - 2.0007546656547e-6*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) + 3.30262933943638e-7*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) + 1.48577800808015e-7*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) - 2.58591023179221e-7*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) + 7.51213794705218e-7*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 2.05550201580172e-6*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) + 1.16739677113906e-7*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) + 5.72173839449172e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) + 1.12819978093755e-5*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) + 8.57114801229843e-6*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 1.00754918534196e-6*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) - 1.0721005862438e-7*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) - 1.51031839657738e-5*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) - 2.36149525615709e-7*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) + 1.72639964407305e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) + 1.31780670595434e-5*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) + 0.000104669279059328*std::exp(0.523359894752502*x_117) + 0.000216978203666786*std::exp(1.36367988586426*x_17) - 4.97936504386962e-5*std::exp(0.873679876327515*x_29) + 0.00076890142841643*std::exp(0.669199824333191*x_71) - 0.000611809533816149*std::exp(0.698639869689941*x_71) + 0.000988488219753045*std::exp(0.633919835090637*x_72) + 6.61251329377896e-6*std::exp(0.662319839000702*x_72) - 9.82754876910532e-6*std::exp(0.661519825458527*x_73) - 8.80992427306974e-5*std::exp(0.936639785766602*x_81) - 0.000639773779428901*std::exp(0.557839810848236*x_84) - 3.7651679079313e-6*std::exp(0.783999860286713*x_87) + 3.79861904829382e-5*std::exp(0.646719813346863*x_90) + 0.0213173016768803*std::sin(0.192880004644394*x_1 + 8.19839954376221) - 0.000205789815072903*std::sin(0.297999948263168*x_1 - 7.60376024246216) - 4.01339115585222e-5*std::sin(1.06031978130341*x_1 - 9.03824043273926) + 0.00476497119682968*std::sin(0.343679845333099*x_10 - 1.06495988368988) - 0.000415889839440381*std::sin(0.349039852619171*x_10 + 2.1275999546051) - 0.0191993085804815*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.0062967082606362*std::sin(0.310559928417206*x_102 + 1.90255987644196) + 0.0045730521827292*std::sin(0.333999842405319*x_102 + 1.93591976165771) + 0.0104853485957539*std::sin(0.229759991168976*x_103 - 7.57151985168457) + 0.000669949873606743*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 0.00442326469630541*std::sin(0.301279932260513*x_104 - 1.31343984603882) + 0.00025351081316183*std::sin(0.356399834156036*x_104 - 1.21031987667084) - 0.000309419168295132*std::sin(0.303839921951294*x_105 - 7.50559997558594) - 0.00582071634097355*std::sin(0.325759828090668*x_105 - 7.45359992980957) - 7.72463883943241e-5*std::sin(0.357039839029312*x_105 + 1.9761598110199) - 0.000224586400445543*std::sin(0.284959942102432*x_106 + 5.08791971206665) + 0.000281944116184221*std::sin(0.319679945707321*x_106 - 7.47704029083252) + 0.000326766964093974*std::sin(0.391679853200912*x_106 - 7.40991973876953) - 0.0165200774564172*std::sin(0.287759929895401*x_107 - 7.49671983718872) - 0.0024151316981371*std::sin(0.401439845561981*x_107 + 5.19271993637085) - 0.00703273840231308*std::sin(0.330799847841263*x_108 + 4.96007966995239) + 0.0132249003044443*std::sin(0.296799927949905*x_109 + 1.88975989818573) + 0.000147310657481679*std::sin(0.345119833946228*x_109 - 1.21783995628357) + 0.000184336179945963*std::sin(0.250399976968765*x_11 - 1.1360799074173) - 0.026813985274934*std::sin(0.26063996553421*x_11 + 8.29399967193604) - 0.0232804663405367*std::sin(0.282399952411652*x_11 + 8.30943965911865) - 0.0129708056024108*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.000163095650612187*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 0.00349830680021681*std::sin(0.333999842405319*x_112 + 8.17199993133545) - 0.00021975356385562*std::sin(0.394319832324982*x_113 - 1.17887985706329) + 0.00918389781310478*std::sin(0.328399837017059*x_114 - 7.44743967056274) - 0.000155754274067847*std::sin(0.309359937906265*x_115 - 7.49728012084961) - 0.00382465712307211*std::sin(0.316559851169586*x_115 - 1.27255988121033) + 0.00680832645401281*std::sin(0.35607984662056*x_115 - 7.43911981582642) + 0.000592652317760212*std::sin(0.186160013079643*x_117 - 7.60880041122437) - 0.000117594988840821*std::sin(0.303839921951294*x_117 - 7.50871992111206) + 0.000197720765349282*std::sin(0.403199851512909*x_119 - 1.18383979797363) + 0.000422776464104416*std::sin(0.296079933643341*x_12 + 5.11951971054077) - 0.00169223632274341*std::sin(0.300559937953949*x_12 + 8.32791996002197) + 0.00946933236123598*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 0.00234194112450835*std::sin(0.454639852046967*x_120 - 1.17119991779327) + 0.000901920392672541*std::sin(0.23055998980999*x_13 - 4.35663986206055) + 8.67879683822179e-6*std::sin(1.31927990913391*x_13 + 1.20903992652893) + 0.012379068226997*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 0.000285032799185277*std::sin(0.292079925537109*x_14 - 4.27263975143433) + 0.0658876055398467*std::sin(0.202800005674362*x_15 - 4.3919997215271) + 0.00290808513068912*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 0.000311826613293046*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.0155869703066226*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.000195504961671942*std::sin(0.354799836874008*x_16 + 5.1593599319458) + 0.0225484400222692*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.00189037664900251*std::sin(0.423199862241745*x_16 - 7.38815975189209) + 0.0459517534142292*std::sin(0.19072000682354*x_18 + 4.97863960266113) - 1.21535396888838e-5*std::sin(0.931919813156128*x_19 - 1.39031994342804) + 0.000310305404485673*std::sin(1.75519990921021*x_2 + 3.0064799785614) + 0.000268237679184889*std::sin(0.284399926662445*x_21 - 4.31175994873047) + 0.017043243907288*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 0.00316600393101494*std::sin(0.333759844303131*x_21 + 8.35000038146973) - 0.0328358446916587*std::sin(0.26503998041153*x_23 + 5.08439970016479) - 0.0329641212430976*std::sin(0.305279940366745*x_23 + 5.12815999984741) + 0.0582200258378502*std::sin(0.153600037097931*x_24 + 4.94071960449219) - 0.000155109321212345*std::sin(0.208800002932549*x_24 + 1.8199999332428) + 0.0252741878678305*std::sin(0.237119987607002*x_24 + 5.04519987106323) - 0.0174475264535488*std::sin(0.334719836711884*x_24 + 5.11863994598389) + 0.000490803696344481*std::sin(0.338799834251404*x_24 - 4.25447988510132) - 0.000273986820740543*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.0016453825306862*std::sin(0.381999850273132*x_24 + 8.38024044036865) + 0.000361153366604566*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.000608985037436093*std::sin(0.407919853925705*x_24 - 7.39991998672485) - 1.41278034417403e-5*std::sin(1.52239990234375*x_25 - 9.59887981414795) + 0.0201923079199482*std::sin(0.334959834814072*x_26 - 4.26191997528076) - 0.000908681770550209*std::sin(0.274159967899323*x_27 - 7.50144004821777) + 0.0276088036602898*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 0.00659564054922151*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 0.000203390287436938*std::sin(0.364719837903976*x_27 - 4.22952032089233) - 0.000228359516197701*std::sin(0.41431987285614*x_27 + 8.41983985900879) - 0.0123000517419578*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.000240574624681413*std::sin(0.271519958972931*x_28 - 1.10407996177673) - 0.0286252057214852*std::sin(0.324479848146439*x_28 + 8.32696056365967) - 0.000169740635300064*std::sin(0.358319848775864*x_28 - 4.23296022415161) + 0.000541227040027281*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 0.000225218201654941*std::sin(0.285119920969009*x_3 - 4.29447984695435) - 0.000886385545458731*std::sin(0.302559942007065*x_3 - 4.27119970321655) + 0.000448532175506979*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.000357337706984759*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.00336600521219054*std::sin(0.329119831323624*x_3 - 7.27343988418579) - 0.00958665214972205*std::sin(0.339759826660156*x_3 - 1.05527985095978) - 0.00990562397827197*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.00234695788303648*std::sin(0.258879989385605*x_30 - 1.12431991100311) + 0.000247182831558343*std::sin(0.282159924507141*x_30 + 8.27752017974854) + 1.05938213513239e-5*std::sin(1.43687975406647*x_30 + 6.00695943832397) + 0.000106977859063396*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.000221381696075895*std::sin(0.232399985194206*x_33 - 4.37471961975098) + 0.000939229726784344*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.000240724367229549*std::sin(0.281599938869476*x_33 + 2.00543975830078) + 0.00730857754774889*std::sin(0.295999944210052*x_34 - 1.14071989059448) + 0.000303118910937198*std::sin(0.339359849691391*x_34 + 1.96919977664948) - 0.000292912448089533*std::sin(0.351599842309952*x_34 + 8.19431972503662) - 9.80574544350994e-5*std::sin(0.390399843454361*x_34 + 1.79423987865448) + 0.000215100760533052*std::sin(0.282239943742752*x_35 + 8.25271987915039) - 0.00119321624443533*std::sin(0.30447992682457*x_35 - 4.34575986862183) - 0.000857285511925245*std::sin(0.343759834766388*x_35 + 8.19143962860107) - 0.00525011613745935*std::sin(0.207520008087158*x_36 - 4.396559715271) - 0.00406057223528558*std::sin(0.302719831466675*x_37 + 8.13655948638916) + 0.0111111950738314*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.000188948447284087*std::sin(0.328799843788147*x_39 + 1.9366397857666) - 0.000228725755943346*std::sin(0.213359996676445*x_40 + 5.00423955917358) - 0.000233151879967378*std::sin(0.229039996862411*x_41 + 5.02951955795288) - 0.0135298067423481*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.00117023338448728*std::sin(0.330479830503464*x_41 - 7.44247961044312) + 0.00046290875244966*std::sin(0.244239971041679*x_42 + 5.06047964096069) + 0.00477232818506281*std::sin(0.308959931135178*x_42 - 7.50464010238647) + 0.0146014269142056*std::sin(0.351759850978851*x_43 - 7.43048000335693) + 0.000155475267366966*std::sin(0.357199847698212*x_44 - 4.25239992141724) + 0.000775921571629147*std::sin(0.157600030303001*x_45 - 4.46623992919922) + 0.00121208164539957*std::sin(0.233679980039597*x_45 + 1.83839988708496) + 0.00387398106364821*std::sin(0.302559942007065*x_45 + 5.11320018768311) + 0.000287396412829451*std::sin(0.321759849786758*x_45 - 4.27936029434204) + 0.000714941851788918*std::sin(0.32415983080864*x_45 + 1.94247984886169) - 0.00156663208365664*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.0020192983473375*std::sin(0.176400005817413*x_46 + 4.97695970535278) + 0.00607083347787752*std::sin(0.209200009703636*x_46 + 5.00407981872559) + 0.0013537683173012*std::sin(0.221759989857674*x_47 + 1.82455992698669) - 0.0217258256116555*std::sin(0.299439936876297*x_47 - 7.47208023071289) - 0.0145495110936922*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.00467577395854207*std::sin(0.400319814682007*x_48 - 1.2060798406601) - 0.00269559672273758*std::sin(0.452239871025085*x_48 - 1.14887976646423) - 0.00143834696303182*std::sin(0.145920038223267*x_49 + 4.93440008163452) - 0.0101690978707285*std::sin(0.247039973735809*x_49 - 4.34455966949463) - 0.00960652416428803*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 0.000150408232895946*std::sin(0.8711998462677*x_5 - 3.34791970252991) + 0.00202883248638005*std::sin(0.200879991054535*x_51 - 7.59600019454956) + 0.000164664951483474*std::sin(0.299919933080673*x_51 + 5.09696006774902) - 0.000121586915286673*std::sin(0.346159845590591*x_51 + 5.14703989028931) + 0.000363596987897402*std::sin(0.349679857492447*x_51 + 1.93831980228424) - 0.000171296272233755*std::sin(0.296959936618805*x_54 + 1.8899998664856) + 0.000100986138928006*std::sin(0.358159840106964*x_54 - 1.23015987873077) - 0.00384175247946389*std::sin(0.371679842472076*x_54 - 1.22119987010956) - 0.000625249104129514*std::sin(0.192479997873306*x_55 + 4.99200010299683) + 0.000193883696267682*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 0.00639446291159827*std::sin(0.286639958620071*x_55 - 4.2851996421814) - 0.00938698209182691*std::sin(0.300799936056137*x_56 - 7.48128032684326) + 0.000267719593647461*std::sin(0.264799952507019*x_58 + 1.87719988822937) - 0.0151484940214372*std::sin(0.305759936571121*x_58 - 7.48072004318237) - 0.000203443082333697*std::sin(0.266799956560135*x_59 + 1.86759984493256) - 0.000228944405041544*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.00236145341152099*std::sin(0.262399971485138*x_6 + 8.30399990081787) - 0.0180112540426019*std::sin(0.193120002746582*x_65 + 4.99616003036499) + 0.033038714005558*std::sin(0.212959989905357*x_65 + 5.0129599571228) - 0.0223595408399228*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 5.20971257215494e-5*std::sin(1.35967981815338*x_67 + 6.00071954727173) - 0.000525347978154659*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.0176048481010116*std::sin(0.166640013456345*x_70 - 7.62864017486572) - 0.000237551211221445*std::sin(0.176880016922951*x_71 + 1.76879990100861) + 0.00660067322803135*std::sin(0.283279955387115*x_72 + 1.90391993522644) - 0.00760755817775225*std::sin(0.298239946365356*x_74 - 7.49944019317627) - 0.00160826205679755*std::sin(0.372399836778641*x_75 - 7.43207979202271) - 0.0252761053396367*std::sin(0.221279993653297*x_8 - 4.37391948699951) + 0.0319678805225925*std::sin(0.305519938468933*x_8 - 4.23663949966431) + 0.000500738721143097*std::sin(0.525279879570007*x_81 + 8.33559989929199) - 0.0403465382753128*std::sin(0.150240033864975*x_83 + 4.93767976760864) - 0.00957344013992589*std::sin(0.276799947023392*x_88 - 7.51471996307373) + 0.00094941835774975*std::sin(0.24679996073246*x_9 - 4.34816026687622) + 0.0227592954393239*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 0.000497882625393489*std::sin(0.19336000084877*x_91 - 1.18735980987549) + 0.00346213032735915*std::sin(0.329439848661423*x_92 + 4.98511981964111) - 0.000340877666288781*std::sin(0.391039848327637*x_92 - 7.39135980606079) + 0.00290989591866798*std::sin(0.330639839172363*x_94 - 7.62272024154663) - 0.00908685443524584*std::sin(0.388399839401245*x_94 + 1.99583983421326) + 0.0158762367225676*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.000201628821126479*std::sin(0.362079858779907*x_95 - 1.19927990436554) + 0.0223567384645663*std::sin(0.157040029764175*x_96 + 1.74959981441498) - 8.06875768674071e-5*std::sin(0.301839828491211*x_96 + 8.14343929290771) + 0.0047688605826703*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.00270497794068152*std::sin(0.406319856643677*x_96 + 2.01399970054626) + 0.000368914289191937*std::sin(0.223999992012978*x_97 + 1.82631993293762) - 0.00788693554333481*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.00822365763317158*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 0.000106682582372998*std::sin(0.356479853391647*x_98 + 8.17695999145508) - 0.00671631063436126*std::sin(0.376399844884872*x_98 + 1.98295974731445) + 0.000857829234019345*std::sin(0.299839943647385*x_99 - 7.50551986694336) - 0.000312185490037868*std::sin(0.355119854211807*x_99 - 7.43391990661621) + 0.000235676167685165*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 0.000173113610009619*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 0.00432216075607701*std::sin(0.36847984790802*x_99 + 1.96631979942322) + 9.8070292936917e-5*std::sin(0.386799842119217*x_99 - 7.39559984207153) + 1.27282905578613*std::sin(0.00622466132474779*x_1 + 0.000844527723921256*x_100 - 0.0118187840810605*x_101 + 0.000113498605238369*x_103 + 0.000645552456652214*x_104 + 0.000582661622013516*x_105 - 8.06344070308783e-5*x_106 - 0.000335244744899972*x_108 - 0.00412532396585601*x_109 - 0.000730360278763483*x_110 - 0.000744979914915272*x_111 + 6.69011897503898e-5*x_113 - 0.000234725583037234*x_114 - 5.60776009407347e-5*x_115 - 0.000123651678701371*x_117 + 0.00262455775850361*x_118 + 0.000254923639642199*x_119 + 0.00158411842552898*x_12 - 0.000768208086818854*x_120 + 0.000782692133474879*x_13 + 0.00135578732027083*x_14 + 0.00629779716567323*x_17 + 0.00459444195541554*x_18 + 0.00546045553985032*x_19 - 0.0021996428424265*x_2 - 0.0132583806103059*x_20 + 0.000710712080028127*x_21 - 0.00083906084968022*x_22 - 0.0103107871554521*x_23 - 0.00236179305831132*x_25 - 0.00636109816620639*x_27 - 0.00216491296879966*x_29 + 0.000756697630359427*x_30 + 0.00245759650360281*x_31 + 1.2245990219624e-5*x_32 + 0.000270960543500725*x_33 + 0.000321940919270236*x_34 - 0.000981211941774072*x_35 - 0.000774671202213093*x_36 + 0.000381420770444372*x_37 - 0.0027084447353626*x_39 + 0.000290992283087858*x_4 + 6.4920451238394e-5*x_40 + 0.000595430163599419*x_41 - 0.00228763522612368*x_42 + 2.11655640542335e-5*x_43 - 0.00453769501655092*x_44 + 0.000476180573266406*x_45 + 0.000383765930167145*x_46 - 0.000162991218249201*x_47 + 8.05470247335915e-5*x_48 + 5.73215860982452e-5*x_49 - 0.000119331155193986*x_5 + 0.00216797596701238*x_50 + 0.00486443823768457*x_51 - 0.000253006286824108*x_52 - 5.25687919575199e-5*x_53 - 9.90835791810382e-5*x_54 + 0.000117666731504586*x_55 - 0.000237452697427952*x_56 + 0.00014841405440898*x_57 - 0.00147001851215492*x_58 + 0.000521055861618858*x_59 + 0.00094261721328998*x_60 - 0.000120650113586152*x_61 + 0.000884432787457826*x_62 - 0.00022985804319*x_63 - 0.00226482908166706*x_64 + 0.000109017783240694*x_65 + 0.000159477101385588*x_66 - 3.80195894034577e-5*x_67 + 4.22872184984121e-5*x_68 + 0.00449867732150486*x_69 + 0.00620900036208218*x_7 - 0.000138407969319343*x_70 - 0.000179699856286729*x_72 - 0.000241393906910028*x_73 - 0.000892501049627961*x_74 + 1.28703950210891e-5*x_75 - 0.000185187084402371*x_76 - 0.00204663394453055*x_77 - 5.61530727610131e-5*x_78 + 0.000388203871050249*x_79 - 1.2028830657759e-5*x_8 - 0.000861521692613475*x_81 + 8.78323772118422e-5*x_82 + 0.00247218673165914*x_83 - 0.000156951436038263*x_84 - 0.00604834236738351*x_86 - 4.25341971228556e-6*x_87 - 0.00413733211119848*x_88 - 0.00125292930566281*x_89 + 0.00911045085928421*x_9 + 0.000123582299049298*x_90 + 0.00129830641032116*x_91 + 0.000929009426491063*x_92 + 6.0225445078557e-5*x_93 + 6.75545495991978e-6*x_94 - 6.30730840422628e-6*x_95 - 0.000461166730962956*x_96 - 1.75815307587969e-5*x_98 + 2.66036412324584e-5*x_99 - 5.14783741098583e-5*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 1.71683508625911e-5*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) + 2.38725879775062e-5*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 0.171096194257972*std::sin(0.296639919281006*x_10 + 8.33568000793457) - 0.0530448510382477*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.0333379421253917*std::sin(0.356399834156036*x_107 + 5.16552019119263) - 0.11002696949814*std::sin(0.279119968414307*x_11 - 1.08031988143921) - 0.0218615072224939*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 0.0337187193282831*std::sin(0.609919846057892*x_116 + 1.98527979850769) + 0.0996733410754631*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.0810020284547091*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 0.122105828112042*std::sin(0.368879854679108*x_24 - 1.02383983135223) + 0.0428972048963365*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 0.138266426245075*std::sin(0.3574398458004*x_28 - 1.04567980766296) - 0.0747109658801541*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.0474038513332014*std::sin(0.323999851942062*x_38 - 7.47088003158569) + 0.76599309266409*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.0366347258168844*std::sin(0.40175986289978*x_97 - 1.17407977581024) + 4.78024603003325) + 1.04710765209861);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00226376404681336*x_1 + 0.00307731941492462*x_10 + 0.00128726059780502*x_100 + 0.00209798579475396*x_101 - 0.00017612381727589*x_102 - 0.000160221764913498*x_103 + 0.00217526544648985*x_104 + 9.77867512232201e-5*x_105 - 4.16871435674135e-5*x_106 - 1.97078549985425e-5*x_107 + 0.000339957769670395*x_108 - 0.000115679848773579*x_109 - 0.00148890938275424*x_11 - 0.00187654597670469*x_110 + 0.000220034910813934*x_111 + 0.000806727185204682*x_112 - 0.000984045969066454*x_113 + 0.000357173678751783*x_114 - 0.000720571604893178*x_115 + 0.00132761783087897*x_116 + 0.000201565952920199*x_117 - 0.00105262102816143*x_118 + 0.000335816039655454*x_119 + 0.000842933443001699*x_12 - 9.26549306892699e-5*x_120 - 0.0003518223865809*x_13 - 0.000223341822257186*x_14 - 0.00195984345616516*x_15 - 0.000361854552786909*x_16 - 0.00138423374513122*x_17 - 0.000484415446762467*x_18 + 0.00231329648420919*x_19 + 0.00133404070340054*x_2 - 0.00156870672182931*x_20 - 0.0013869907838298*x_21 - 0.000125850567580975*x_22 + 0.00079862357877191*x_23 + 2.28359227355913e-5*x_24 + 0.00031115658487408*x_25 + 0.000861437112110311*x_26 - 0.000480569598144296*x_27 + 0.00138665188979479*x_28 - 0.00319366484836429*x_29 + 0.00174961818573806*x_3 - 0.000446728728770528*x_30 - 0.015624814656672*x_31 - 0.00323131879871399*x_32 - 0.000340711844660378*x_33 - 0.000169879934775356*x_34 - 0.00163104280912544*x_35 - 3.91971432303477e-5*x_36 - 0.00129954395146347*x_37 + 5.66984798442687e-5*x_38 + 0.00250456169207352*x_39 + 0.00212948175918856*x_4 + 4.82777171713191e-5*x_40 + 0.000222963798014994*x_41 + 0.00176667330001999*x_42 + 0.000109494105036222*x_43 + 0.00028858392240735*x_44 - 0.00161821202375036*x_45 - 0.000405704052077446*x_46 - 0.000224379014158567*x_47 + 0.000370694055347002*x_48 + 7.91558841162976e-5*x_49 + 0.000795726554093364*x_5 + 0.00198800188740703*x_50 + 0.00083287558672416*x_51 - 0.000869481076858234*x_52 + 3.36247518815976e-5*x_53 - 0.000965623048396435*x_54 - 0.000347569639949452*x_55 - 0.0015757280925363*x_56 + 0.000237502864420456*x_57 + 0.000987224097766943*x_58 + 0.000180517794190498*x_59 - 0.000492655470092395*x_6 - 4.61102223920666e-5*x_60 - 0.000663504018459984*x_61 - 0.00160963780216393*x_62 - 0.00251011901448411*x_63 + 0.000991338142634489*x_64 + 0.000380353567402683*x_65 - 1.23238095471339e-5*x_66 + 0.0012168339011933*x_67 + 0.000429246536868681*x_68 - 0.000383506288441949*x_69 + 0.000678410940458266*x_7 + 0.000121759933360693*x_70 - 0.00024019420938705*x_71 + 0.000906281579164944*x_72 - 6.39000177187625e-5*x_73 + 0.000327694903135062*x_74 - 1.54956080461882e-5*x_75 - 0.000455909094105941*x_76 + 0.000376911265726152*x_77 + 0.00112016268483417*x_78 + 0.000265660938754575*x_79 - 0.000823492250752043*x_8 + 0.00014649473538857*x_80 - 0.000181233698990028*x_81 - 0.000164052525457045*x_82 - 0.000399113672088609*x_83 - 8.83245003805802e-5*x_84 - 0.000981936059309633*x_85 + 0.000891278214518414*x_86 - 1.99886600536916e-5*x_87 - 0.0001538352307538*x_88 - 0.000328898499188795*x_89 + 0.00214494806427495*x_9 - 0.000194822183470402*x_90 + 0.00285316737155676*x_91 - 0.0035394011920015*x_92 - 0.00178752280118547*x_93 - 1.65967852663929e-5*x_94 + 0.000177831228480691*x_95 - 5.94703131344141e-5*x_96 + 0.00136468045655333*x_97 - 0.000221542507185034*x_98 - 0.000217741807362164*x_99 + 3.00993483424311e-7*std::pow(-5.49760007858276*x_10 - 8.75424003601074, 2) - 1.19301289374513e-6*std::pow(-6.12799978256226*x_104 - 7.34488010406494, 2) - 1.30269389785933e-9*std::pow(-9.97523975372314*x_105 - 9.79600048065186, 2) + 1.08404130250411e-7*std::pow(-9.44519996643066*x_114 - 7.63976001739502, 2) - 3.99963531228098e-6*std::pow(-7.73336029052734*x_115 - 9.56584072113037, 2) + 4.06188243652126e-6*std::pow(-5.7119197845459*x_120 - 9.45071983337402, 2) + 1.92187408480001e-5*std::pow(-5.71407985687256*x_13 - 8.77208042144775, 2) - 5.25517421999085e-6*std::pow(-5.68135976791382*x_13 - 9.13327980041504, 2) + 7.04696718880646e-6*std::pow(-3.91671991348267*x_14 - 6.39064025878906, 2) + 3.45745957866834e-6*std::pow(-5.79527997970581*x_15 - 8.38912010192871, 2) + 1.23589602972542e-5*std::pow(-3.30967974662781*x_15 - 4.75935983657837, 2) - 2.84799461626209e-5*std::pow(-5.74575996398926*x_17 - 8.11312007904053, 2) - 3.1826423317411e-5*std::pow(-5.52623987197876*x_17 - 8.38383960723877, 2) - 1.23925181233001e-6*std::pow(-6.69464015960693*x_18 - 9.9871997833252, 2) - 4.20870083497619e-8*std::pow(-4.50311994552612*x_2 - 8.18400001525879, 2) - 2.67356792365722e-5*std::pow(-5.95016002655029*x_22 - 9.12511920928955, 2) - 1.15396483423576e-6*std::pow(-4.23224020004272*x_22 - 7.6590404510498, 2) - 0.000155120858012476*std::pow(-3.66535997390747*x_22 - 5.90592002868652, 2) + 1.51169282605503e-6*std::pow(-4.0875997543335*x_38 - 5.514479637146, 2) + 8.80560842048406e-6*std::pow(-5.33047962188721*x_4 - 8.87856006622314, 2) + 2.95367153605176e-8*std::pow(-4.91632032394409*x_4 - 8.59344100952148, 2) + 2.10090098448605e-6*std::pow(-4.32719993591309*x_45 - 5.98000001907349, 2) + 3.52056432619506e-6*std::pow(-4.51904010772705*x_46 - 5.54575967788696, 2) + 3.2003179416235e-5*std::pow(-2.93967986106873*x_46 - 3.13727998733521, 2) + 0.000169753115009772*std::pow(-1.50775992870331*x_47 - 1.29191982746124, 2) - 5.50265497114591e-6*std::pow(-5.95959949493408*x_49 - 7.73848009109497, 2) - 5.26390718665052e-7*std::pow(-4.88312005996704*x_49 - 5.90407991409302, 2) + 3.45184025525748e-6*std::pow(-4.58856010437012*x_5 - 8.16967964172363, 2) + 1.44424459289164e-6*std::pow(-6.0926399230957*x_53 - 8.65128040313721, 2) - 6.57998531507375e-6*std::pow(-7.46767997741699*x_54 - 7.87095975875854, 2) - 5.12573342885645e-7*std::pow(-7.02904033660889*x_55 - 7.22119998931885, 2) - 5.33026360066439e-6*std::pow(-6.16079998016357*x_56 - 9.35431957244873, 2) - 1.01087433820764e-6*std::pow(-3.48855996131897*x_57 - 4.92400026321411, 2) + 6.19606720422677e-6*std::pow(-8.36223983764648*x_58 - 9.78456020355225, 2) - 8.03097067155612e-6*std::pow(-4.92119979858398*x_6 - 9.71399974822998, 2) - 1.24978847576692e-6*std::pow(-7.34776020050049*x_60 - 8.57152080535889, 2) - 3.53146939729861e-6*std::pow(-5.1704797744751*x_64 - 8.74720001220703, 2) - 1.50887088353224e-6*std::pow(-6.22160005569458*x_66 - 9.83847999572754, 2) + 1.63820646244417e-6*std::pow(-5.87687969207764*x_66 - 9.51992034912109, 2) + 9.61584796924072e-6*std::pow(-4.13255977630615*x_66 - 5.78527975082397, 2) + 5.60499310412854e-6*std::pow(-3.65975975990295*x_66 - 5.28175973892212, 2) - 9.03778839495294e-6*std::pow(-5.70175981521606*x_67 - 8.05288028717041, 2) + 1.69408949854834e-6*std::pow(-4.50360012054443*x_67 - 6.66224002838135, 2) + 5.50557565592173e-6*std::pow(-4.44704008102417*x_67 - 6.68656015396118, 2) + 2.51873084016122e-5*std::pow(-3.51727986335754*x_68 - 5.47192001342773, 2) - 6.77215236634778e-6*std::pow(-6.91535997390747*x_69 - 8.68976020812988, 2) + 1.1713255148928e-5*std::pow(-5.79999971389771*x_69 - 9.99936008453369, 2) + 2.87410912655117e-8*std::pow(-5.66431999206543*x_7 - 8.90488052368164, 2) - 3.07572996470528e-5*std::pow(-3.50071978569031*x_7 - 6.02687978744507, 2) + 3.71593701061887e-6*std::pow(-7.28943967819214*x_70 - 9.66919994354248, 2) - 6.79415846060405e-6*std::pow(-6.11984014511108*x_70 - 8.69192028045654, 2) + 3.08925767300951e-6*std::pow(-6.01639986038208*x_71 - 8.41504001617432, 2) - 4.23095415664973e-7*std::pow(-5.95440006256104*x_73 - 7.79832029342651, 2) + 1.67817380793524e-5*std::pow(-5.62791967391968*x_73 - 8.23895931243896, 2) + 7.54972320930153e-6*std::pow(-6.88583993911743*x_75 - 8.70464038848877, 2) + 1.3897670678221e-5*std::pow(-5.67560005187988*x_76 - 7.70776033401489, 2) - 1.40098474716583e-7*std::pow(-4.79112005233765*x_76 - 5.78975963592529, 2) + 1.03028622314282e-6*std::pow(-5.87807989120483*x_80 - 8.42711925506592, 2) - 5.18925649551114e-7*std::pow(-5.51575994491577*x_80 - 6.94288015365601, 2) - 8.94725165253881e-6*std::pow(-4.89359998703003*x_82 - 7.13815975189209, 2) - 1.25385106979916e-6*std::pow(-8.0*x_83 - 9.99989986419678, 2) - 2.84821809779688e-6*std::pow(-5.43063974380493*x_83 - 8.8426399230957, 2) - 2.16384538447942e-6*std::pow(-5.74351978302002*x_84 - 7.79296016693115, 2) - 1.43261275942246e-6*std::pow(-6.94912004470825*x_85 - 9.19032001495361, 2) + 5.4149547025411e-5*std::pow(-2.94775986671448*x_87 - 3.57807993888855, 2) + 2.46414674811781e-9*std::pow(-6.8744797706604*x_88 - 9.29599952697754, 2) + 3.30968353797679e-6*std::pow(-5.59311962127686*x_89 - 8.35192012786865, 2) + 1.26915787619999e-5*std::pow(-5.05879974365234*x_89 - 7.60751962661743, 2) + 2.77637921979148e-5*std::pow(-4.4081597328186*x_89 - 5.80687999725342, 2) - 3.32689384691965e-6*std::pow(-6.71512031555176*x_90 - 9.37855911254883, 2) - 0.00100238143932074*std::pow(-0.0233922684552103*x_1 + 0.0400802314331306*x_10 + 0.0125447022232011*x_100 - 0.00794005273836672*x_101 - 0.0139141309208288*x_102 + 0.00430086905350457*x_104 + 2.28813910290099e-5*x_105 - 0.00247399856465229*x_106 - 0.0379150873112213*x_107 + 0.00603191653609258*x_108 + 0.0519973861997284*x_109 + 0.00220179481762204*x_11 - 0.00176369997132985*x_110 + 0.00439193639141794*x_111 - 3.25206460309447e-5*x_112 + 0.0159999410934838*x_113 + 0.0632984137039409*x_114 + 0.0100064054474877*x_115 - 0.00861357696108208*x_116 + 2.55376760693424e-5*x_118 + 0.00323488003391728*x_119 + 0.0417281275737166*x_120 - 2.25413226916774e-5*x_13 + 0.038640416588979*x_14 + 0.00788775877764133*x_15 + 0.0409604729157166*x_16 + 0.0181063560342963*x_17 + 0.0103029149292905*x_18 + 0.0427213940399285*x_2 - 0.0413785438233527*x_20 - 0.00652890196063624*x_21 + 0.00647260868704876*x_22 + 0.0273889064188122*x_23 - 0.0754962890628153*x_24 + 0.0040496679231835*x_25 + 0.00748291866695427*x_26 + 0.000902863690567424*x_27 + 0.0230933399089999*x_28 + 0.240529587752251*x_29 + 0.00734909466149714*x_3 + 0.0925551032594536*x_30 + 0.0176271285460197*x_31 + 0.245399725340134*x_32 + 0.00495221523770328*x_33 - 0.00643979033724845*x_34 + 0.00172321620042812*x_36 + 0.0122992492757189*x_37 + 0.000281621809154962*x_38 + 0.00194557257783964*x_39 - 0.0696524507280305*x_4 - 0.0358007794661705*x_40 + 0.0432009738502009*x_41 + 0.123242885013901*x_42 + 0.000212578203738975*x_43 - 0.00328412839525848*x_44 + 2.1546059309526e-5*x_46 + 0.00469034520140287*x_47 - 0.0329996549242939*x_48 + 0.000939613720343302*x_49 - 0.169299664603749*x_5 + 0.0113482097849791*x_50 - 0.0006610006174166*x_52 + 0.00142122754143393*x_53 - 0.00137522493224781*x_55 - 0.00627051248636817*x_56 - 0.000854856578791316*x_57 + 0.00896200983308786*x_58 + 0.0649291527946829*x_59 + 0.0969098639224433*x_6 + 0.00415915682631328*x_60 - 0.00120507764757724*x_61 + 0.126674166595112*x_62 + 0.000212413419202261*x_63 + 0.00308344300971452*x_64 + 0.0027249961219813*x_65 + 0.0238161998696474*x_66 + 0.0175358972247377*x_67 + 0.0720046402526316*x_68 + 0.0723277300605933*x_69 + 0.0817435395705359*x_7 + 0.0816438633373239*x_70 + 0.0819284734867518*x_71 - 0.00421672545946885*x_72 + 0.00946341457638393*x_73 - 0.0176294689786117*x_74 - 0.000181312483841447*x_75 - 0.0155929458088233*x_76 - 0.00148639743155636*x_77 + 0.00110052265117302*x_78 + 0.0333801804718493*x_79 - 0.0128210744432802*x_8 + 0.00485622381463583*x_80 - 0.00376826002321875*x_81 - 0.0011356690029989*x_82 + 0.00698353242995467*x_83 + 0.000310626548598933*x_84 + 0.0421854943267029*x_85 + 0.0344299086955129*x_86 + 0.00213463748479425*x_87 + 0.00928953778649175*x_88 + 0.00126108342003868*x_89 + 0.00559742563711016*x_9 + 0.000331420158210509*x_90 + 0.31215474385555*x_91 + 0.0781617355461147*x_92 + 0.000676540746179966*x_93 - 0.00117259724583238*x_94 + 0.000815919656126933*x_95 + 1.47796368470212e-5*x_96 - 0.00546845750296311*x_97 - 0.00131375733143058*x_98 + 0.000808271735261032*std::pow(-6.0*x_54 - 10.0, 2) + 0.120341939448206*std::exp(0.523359894752502*x_117) + 0.770264855624134*std::sin(0.290079951286316*x_103 + 5.08432006835938) - 1.94562342373841*std::sin(0.300559937953949*x_12 + 8.32791996002197) - 0.0139733506379843*std::sin(0.931919813156128*x_19 - 1.39031994342804) - 1.37188254592888*std::sin(0.30447992682457*x_35 - 4.34575986862183) + 0.821993710190768*std::sin(0.32415983080864*x_45 + 1.94247984886169) + 0.418040203337004*std::sin(0.349679857492447*x_51 + 1.93831980228424) + 0.986276342638632*std::sin(0.299839943647385*x_99 - 7.50551986694336) - 0.801096612107137, 2) - 4.75481984727943e-5*std::exp(1.36367988586426*x_17) + 9.28632371530063e-6*std::exp(0.873679876327515*x_29) + 8.26066800452831e-5*std::exp(0.669199824333191*x_71) + 0.000154455533147837*std::exp(0.698639869689941*x_71) - 0.00021661546305829*std::exp(0.633919835090637*x_72) - 0.000506801303189069*std::exp(0.662319839000702*x_72) + 2.25879200628038e-7*std::exp(0.661519825458527*x_73) + 2.22412609705747e-5*std::exp(0.936639785766602*x_81) + 0.000245231926131383*std::exp(0.557839810848236*x_84) - 0.000191320475783303*std::exp(0.783999860286713*x_87) - 7.08427798379492e-6*std::exp(0.646719813346863*x_90) - 0.00817114286054618*std::sin(0.192880004644394*x_1 + 8.19839954376221) - 0.0104568524681647*std::sin(0.297999948263168*x_1 - 7.60376024246216) + 7.48481967901772e-6*std::sin(1.06031978130341*x_1 - 9.03824043273926) - 0.0102676170347996*std::sin(0.296639919281006*x_10 + 8.33568000793457) + 0.00100763851948564*std::sin(0.343679845333099*x_10 - 1.06495988368988) + 9.55893139675241e-6*std::sin(0.349039852619171*x_10 + 2.1275999546051) + 0.0048469977647639*std::sin(0.206560000777245*x_102 - 7.59832000732422) + 0.00318326318414497*std::sin(0.291599929332733*x_102 - 7.51024007797241) - 0.00241359359306911*std::sin(0.310559928417206*x_102 + 1.90255987644196) - 0.00100213011784712*std::sin(0.333999842405319*x_102 + 1.93591976165771) - 0.00229773971607295*std::sin(0.229759991168976*x_103 - 7.57151985168457) - 0.000475212033713904*std::sin(0.301279932260513*x_104 - 1.31343984603882) - 5.82676526699863e-6*std::sin(0.356399834156036*x_104 - 1.21031987667084) - 0.0157225982857226*std::sin(0.303839921951294*x_105 - 7.50559997558594) - 0.00936081975506697*std::sin(0.325759828090668*x_105 - 7.45359992980957) + 0.00592037680161994*std::sin(0.357039839029312*x_105 + 1.9761598110199) - 0.00602312792666353*std::sin(0.284959942102432*x_106 + 5.08791971206665) - 6.4802844617446e-6*std::sin(0.319679945707321*x_106 - 7.47704029083252) - 0.0175617065111835*std::sin(0.391679853200912*x_106 - 7.40991973876953) + 0.00417060740335122*std::sin(0.287759929895401*x_107 - 7.49671983718872) + 0.0020006360980521*std::sin(0.356399834156036*x_107 + 5.16552019119263) + 0.000529247451496614*std::sin(0.401439845561981*x_107 + 5.19271993637085) + 0.00177546327636169*std::sin(0.330799847841263*x_108 + 4.96007966995239) - 0.00333871722235006*std::sin(0.296799927949905*x_109 + 1.88975989818573) + 0.00395068861343725*std::sin(0.345119833946228*x_109 - 1.21783995628357) - 0.00990693138328608*std::sin(0.250399976968765*x_11 - 1.1360799074173) + 0.00676937537345202*std::sin(0.26063996553421*x_11 + 8.29399967193604) + 0.00660280487947695*std::sin(0.279119968414307*x_11 - 1.08031988143921) + 0.00510163793133334*std::sin(0.282399952411652*x_11 + 8.30943965911865) + 0.00327456926370707*std::sin(0.335919857025146*x_111 - 1.24431991577148) + 0.00104963050921875*std::sin(0.257199972867966*x_112 - 4.34687995910645) + 0.000375839476772616*std::sin(0.333999842405319*x_112 + 8.17199993133545) + 0.00131192622335966*std::sin(0.378399848937988*x_112 - 1.21479988098145) + 5.05087896331945e-6*std::sin(0.394319832324982*x_113 - 1.17887985706329) + 0.0147694556892028*std::sin(0.328399837017059*x_114 - 7.44743967056274) - 0.00417713590838164*std::sin(0.309359937906265*x_115 - 7.49728012084961) + 0.000965561048660115*std::sin(0.316559851169586*x_115 - 1.27255988121033) + 0.0109490847923726*std::sin(0.35607984662056*x_115 - 7.43911981582642) - 0.00202348683714555*std::sin(0.609919846057892*x_116 + 1.98527979850769) - 0.0318514024100805*std::sin(0.186160013079643*x_117 - 7.60880041122437) + 0.00901280510832413*std::sin(0.303839921951294*x_117 - 7.50871992111206) - 0.0106262701979631*std::sin(0.403199851512909*x_119 - 1.18383979797363) + 0.0214826526307244*std::sin(0.296079933643341*x_12 + 5.11951971054077) - 0.00239059821328036*std::sin(0.382879853248596*x_12 - 4.20423984527588) - 0.000251605698737727*std::sin(0.454639852046967*x_120 - 1.17119991779327) - 0.0484726516846156*std::sin(0.23055998980999*x_13 - 4.35663986206055) - 1.61856212968919e-6*std::sin(1.31927990913391*x_13 + 1.20903992652893) + 0.0199078978635152*std::sin(0.249839976429939*x_14 + 8.26024055480957) + 0.0144834472425788*std::sin(0.292079925537109*x_14 - 4.27263975143433) + 0.105959810343258*std::sin(0.202800005674362*x_15 - 4.3919997215271) - 0.000542346658204532*std::sin(0.25383996963501*x_15 + 5.07239961624146) + 0.00836280192868433*std::sin(0.346319854259491*x_15 + 8.34296035766602) - 0.00598147550376696*std::sin(0.441039860248566*x_15 + 5.44664001464844) + 0.00393503807280055*std::sin(0.333039849996567*x_16 - 1.04951989650726) - 0.00486099536475305*std::sin(0.34215983748436*x_16 - 7.24799966812134) - 0.00993424548378863*std::sin(0.354799836874008*x_16 + 5.1593599319458) + 0.036262183285004*std::sin(0.385039836168289*x_16 - 4.21935987472534) + 0.000399754006726937*std::sin(0.423199862241745*x_16 - 7.38815975189209) - 0.0100697814554132*std::sin(0.19072000682354*x_18 + 4.97863960266113) + 3.33375622899576e-5*std::sin(1.75519990921021*x_2 + 3.0064799785614) + 0.00719380093040706*std::sin(0.284399926662445*x_21 - 4.31175994873047) + 0.0274087801074812*std::sin(0.318879842758179*x_21 - 4.26336002349854) + 0.000669508247155022*std::sin(0.333759844303131*x_21 + 8.35000038146973) + 0.00719558570416827*std::sin(0.26503998041153*x_23 + 5.08439970016479) - 0.0530125811437843*std::sin(0.305279940366745*x_23 + 5.12815999984741) - 0.0146980467508835*std::sin(0.153600037097931*x_24 + 4.94071960449219) + 0.0118880072726877*std::sin(0.208800002932549*x_24 + 1.8199999332428) + 0.0406457046224814*std::sin(0.237119987607002*x_24 + 5.04519987106323) + 0.00382341837407173*std::sin(0.334719836711884*x_24 + 5.11863994598389) + 0.0249393384297759*std::sin(0.338799834251404*x_24 - 4.25447988510132) + 0.0147250997270149*std::sin(0.353439837694168*x_24 + 8.3342399597168) + 0.00732766667434562*std::sin(0.368879854679108*x_24 - 1.02383983135223) - 0.000306857494496496*std::sin(0.381999850273132*x_24 + 8.38024044036865) - 8.30085260011289e-6*std::sin(0.394479840993881*x_24 + 5.38800001144409) - 0.000128780795552193*std::sin(0.407919853925705*x_24 - 7.39991998672485) + 0.000759282194818747*std::sin(1.52239990234375*x_25 - 9.59887981414795) - 0.00442490466035894*std::sin(0.334959834814072*x_26 - 4.26191997528076) - 0.00257429496692847*std::sin(0.423199862241745*x_26 + 2.22815990447998) - 0.0461730878750634*std::sin(0.274159967899323*x_27 - 7.50144004821777) - 0.00605014169096845*std::sin(0.293599933385849*x_27 + 1.90855991840363) - 0.000708600541509404*std::sin(0.325439840555191*x_27 - 4.27992010116577) + 0.00545467453881114*std::sin(0.364719837903976*x_27 - 4.22952032089233) + 0.0122729138596353*std::sin(0.41431987285614*x_27 + 8.41983985900879) + 0.0026954103756449*std::sin(0.270719945430756*x_28 - 7.51624011993408) + 0.00154825996194035*std::sin(0.271519958972931*x_28 - 1.10407996177673) + 0.00722663045735921*std::sin(0.324479848146439*x_28 + 8.32696056365967) + 0.00829747686447238*std::sin(0.3574398458004*x_28 - 1.04567980766296) + 0.0130093916416236*std::sin(0.358319848775864*x_28 - 4.23296022415161) - 0.000118603483129487*std::sin(0.897199869155884*x_29 + 8.85704040527344) - 0.00604007204928572*std::sin(0.285119920969009*x_3 - 4.29447984695435) + 0.000165307484773125*std::sin(0.302559942007065*x_3 - 4.27119970321655) - 0.0241058347159319*std::sin(0.31007993221283*x_3 - 4.25759983062744) - 0.00229970914575355*std::sin(0.321439832448959*x_3 + 8.31455993652344) - 0.000711802100891869*std::sin(0.329119831323624*x_3 - 7.27343988418579) + 0.00210080105467478*std::sin(0.339759826660156*x_3 - 1.05527985095978) + 0.00448346375724051*std::sin(0.353119850158691*x_3 - 4.22575998306274) + 0.00250074303874082*std::sin(0.241119980812073*x_30 + 2.04959988594055) - 0.000496306287880915*std::sin(0.258879989385605*x_30 - 1.12431991100311) + 0.0125601667961707*std::sin(0.282159924507141*x_30 + 8.27752017974854) - 0.000569352480045552*std::sin(1.43687975406647*x_30 + 6.00695943832397) + 0.000172040758871256*std::sin(1.7519998550415*x_30 - 9.99600028991699) - 0.0014247405219676*std::sin(0.232399985194206*x_33 - 4.37471961975098) - 0.000175162720730647*std::sin(0.247519969940186*x_33 - 1.18367981910706) - 0.0122319911348379*std::sin(0.281599938869476*x_33 + 2.00543975830078) + 0.0117535837657679*std::sin(0.295999944210052*x_34 - 1.14071989059448) - 0.0162907696823897*std::sin(0.339359849691391*x_34 + 1.96919977664948) + 6.73238374928855e-6*std::sin(0.351599842309952*x_34 + 8.19431972503662) - 0.00262977896726562*std::sin(0.390399843454361*x_34 + 1.79423987865448) - 4.94393759677186e-6*std::sin(0.282239943742752*x_35 + 8.25271987915039) + 0.00015988044077982*std::sin(0.343759834766388*x_35 + 8.19143962860107) - 0.00056404455491894*std::sin(0.207520008087158*x_36 - 4.396559715271) + 0.00155645945875367*std::sin(0.302719831466675*x_37 + 8.13655948638916) - 0.00284474236013701*std::sin(0.323999851942062*x_38 - 7.47088003158569) - 0.0028050977701076*std::sin(0.377359837293625*x_38 + 5.17280006408691) + 0.00506736234820439*std::sin(0.328799843788147*x_39 + 1.9366397857666) + 0.0175301743883144*std::sin(0.213359996676445*x_40 + 5.00423955917358) - 0.00625284343397333*std::sin(0.229039996862411*x_41 + 5.02951955795288) + 0.00341569295388678*std::sin(0.329839825630188*x_41 + 5.13431978225708) + 0.000247466812765201*std::sin(0.330479830503464*x_41 - 7.44247961044312) - 1.06396275840176e-5*std::sin(0.244239971041679*x_42 + 5.06047964096069) - 0.00120480713921309*std::sin(0.308959931135178*x_42 - 7.50464010238647) - 0.00368623085143116*std::sin(0.351759850978851*x_43 - 7.43048000335693) + 0.00416965329568349*std::sin(0.357199847698212*x_44 - 4.25239992141724) - 0.0417009931050695*std::sin(0.157600030303001*x_45 - 4.46623992919922) - 0.000226048550957562*std::sin(0.233679980039597*x_45 + 1.83839988708496) + 0.00623009889969801*std::sin(0.302559942007065*x_45 + 5.11320018768311) - 6.60560161221077e-6*std::sin(0.321759849786758*x_45 - 4.27936029434204) + 0.000292170839925117*std::sin(0.175040006637573*x_46 - 7.61616039276123) - 0.00042701680934918*std::sin(0.176400005817413*x_46 + 4.97695970535278) + 0.00976305571694172*std::sin(0.209200009703636*x_46 + 5.00407981872559) - 0.000252472568675283*std::sin(0.221759989857674*x_47 + 1.82455992698669) + 0.00548483440098465*std::sin(0.299439936876297*x_47 - 7.47208023071289) + 0.00318835269844617*std::sin(0.241199985146523*x_48 + 5.0479998588562) + 0.000502340285871029*std::sin(0.400319814682007*x_48 - 1.2060798406601) - 0.00433503259320061*std::sin(0.452239871025085*x_48 - 1.14887976646423) + 0.0773022673698203*std::sin(0.145920038223267*x_49 + 4.93440008163452) - 0.0163538448986854*std::sin(0.247039973735809*x_49 - 4.34455966949463) + 0.00242523322942949*std::sin(0.489439845085144*x_5 - 3.86071991920471) - 1.6159060591942e-5*std::sin(0.8711998462677*x_5 - 3.34791970252991) - 0.000378369431978859*std::sin(0.200879991054535*x_51 - 7.59600019454956) + 0.00441610919385699*std::sin(0.299919933080673*x_51 + 5.09696006774902) + 0.00931875738926635*std::sin(0.346159845590591*x_51 + 5.14703989028931) - 0.00459395296855769*std::sin(0.296959936618805*x_54 + 1.8899998664856) - 0.00773985692564064*std::sin(0.358159840106964*x_54 - 1.23015987873077) - 0.00617826920214227*std::sin(0.371679842472076*x_54 - 1.22119987010956) + 1.43709048056985e-5*std::sin(0.192479997873306*x_55 + 4.99200010299683) + 0.00519971958764166*std::sin(0.246559977531433*x_55 - 7.53864002227783) + 0.0102835134439691*std::sin(0.286639958620071*x_55 - 4.2851996421814) + 0.00205704573095364*std::sin(0.300799936056137*x_56 - 7.48128032684326) - 6.15334395446168e-6*std::sin(0.264799952507019*x_58 + 1.87719988822937) + 0.00331961269898508*std::sin(0.305759936571121*x_58 - 7.48072004318237) + 0.0109338094001676*std::sin(0.266799956560135*x_59 + 1.86759984493256) + 5.26212389417159e-6*std::sin(0.337439835071564*x_59 + 1.93647980690002) - 0.0459678472737868*std::sin(0.157440036535263*x_6 + 4.9488000869751) + 0.000440401951348862*std::sin(0.262399971485138*x_6 + 8.30399990081787) + 0.00394695258550824*std::sin(0.193120002746582*x_65 + 4.99616003036499) - 0.00834085103973036*std::sin(0.212959989905357*x_65 + 5.0129599571228) + 0.00489982803641369*std::sin(0.235039979219437*x_67 + 5.03983974456787) - 1.10168705041588e-5*std::sin(1.35967981815338*x_67 + 6.00071954727173) - 0.0266946461857976*std::sin(0.153440043330193*x_69 + 4.9322395324707) + 0.00189137124809509*std::sin(0.166640013456345*x_70 - 7.62864017486572) + 0.0182065816842189*std::sin(0.176880016922951*x_71 + 1.76879990100861) + 0.0106151388815768*std::sin(0.283279955387115*x_72 + 1.90391993522644) - 0.0122344015249185*std::sin(0.298239946365356*x_74 - 7.49944019317627) - 0.0025863914938822*std::sin(0.372399836778641*x_75 - 7.43207979202271) - 0.0406487882821054*std::sin(0.221279993653297*x_8 - 4.37391948699951) - 0.00807051174721833*std::sin(0.305519938468933*x_8 - 4.23663949966431) - 0.000109730948517248*std::sin(0.525279879570007*x_81 + 8.33559989929199) - 0.0648849128547201*std::sin(0.150240033864975*x_83 + 4.93767976760864) - 0.0153959138937839*std::sin(0.276799947023392*x_88 - 7.51471996307373) - 2.1821703941503e-5*std::sin(0.24679996073246*x_9 - 4.34816026687622) - 0.00574574098122223*std::sin(0.350239843130112*x_9 + 2.12519979476929) - 0.0133525927627805*std::sin(0.19336000084877*x_91 - 1.18735980987549) - 0.00132707046771133*std::sin(0.329439848661423*x_92 + 4.98511981964111) - 0.0173211072900342*std::sin(0.391039848327637*x_92 - 7.39135980606079) - 0.00111539329044369*std::sin(0.330639839172363*x_94 - 7.62272024154663) + 0.00199127631660174*std::sin(0.388399839401245*x_94 + 1.99583983421326) - 0.00347908887588077*std::sin(0.344079852104187*x_95 - 7.42312002182007) + 0.00129761744962405*std::sin(0.362079858779907*x_95 - 1.19927990436554) - 0.00856956976351117*std::sin(0.157040029764175*x_96 + 1.74959981441498) + 0.00618411900147584*std::sin(0.301839828491211*x_96 + 8.14343929290771) - 0.00104503920505358*std::sin(0.359439849853516*x_96 + 5.1733603477478) - 0.000572016042657951*std::sin(0.406319856643677*x_96 + 2.01399970054626) - 0.0198268649725174*std::sin(0.223999992012978*x_97 + 1.82631993293762) + 0.0019911112313828*std::sin(0.263919949531555*x_97 - 7.51999998092651) - 0.00219847867741294*std::sin(0.40175986289978*x_97 - 1.17407977581024) + 0.0018021169809058*std::sin(0.346879839897156*x_98 - 7.43207979202271) - 0.00542089036040032*std::sin(0.356479853391647*x_98 + 8.17695999145508) - 0.0108011058406567*std::sin(0.376399844884872*x_98 + 1.98295974731445) - 0.0158631641263257*std::sin(0.355119854211807*x_99 - 7.43391990661621) - 0.0126661386962516*std::sin(0.359599858522415*x_99 + 5.1715202331543) + 0.00111410283441069*std::sin(0.359679847955704*x_99 + 8.18544006347656) + 0.000464349964099902*std::sin(0.36847984790802*x_99 + 1.96631979942322) - 0.00751637842623666*std::sin(0.386799842119217*x_99 - 7.39559984207153) - 0.176114294121764);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
