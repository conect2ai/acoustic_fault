
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000233166335283389*x_1 + 0.0156187176595096*x_10 + 0.00956381395778216*x_100 - 0.00156944407937272*x_101 + 0.00998296670553409*x_102 - 0.0165970705244956*x_103 + 0.000880189248633104*x_104 + 0.00145120369056402*x_105 - 0.00639686993375285*x_106 + 0.0225807606581171*x_107 + 0.0101954354233726*x_108 - 0.000363830417600277*x_109 - 0.00328295769053312*x_11 + 0.00324335294297083*x_110 - 0.00174860829222543*x_111 - 0.00664718769185007*x_112 - 0.0144881918597643*x_113 + 0.00575191744486712*x_114 - 0.00193780142993511*x_115 - 0.0123479074459364*x_116 + 0.00318178880481281*x_117 + 0.0212217389359741*x_118 - 0.00963074955346432*x_119 + 0.00832800166287232*x_12 - 0.00265946326658841*x_120 + 0.0155742189850921*x_13 + 0.0121914760764616*x_14 - 0.00245476421541953*x_15 + 0.00880909899004058*x_16 - 0.00189316756525741*x_17 + 0.00874713527423188*x_18 + 0.00509734311153826*x_19 + 0.00115782611009113*x_2 - 0.0103508495524176*x_20 - 0.00133792207294386*x_21 - 0.00104898344872026*x_22 - 0.00626076605947721*x_23 - 0.000435750853183105*x_24 + 0.00143409755656173*x_25 - 0.00210549872488147*x_26 - 0.00232275525705522*x_27 + 0.00116377120345235*x_28 - 0.00452532122844637*x_29 - 0.0125683041257488*x_3 - 0.00139479084165197*x_30 - 0.0117162719143257*x_32 - 0.0123545437542066*x_33 + 0.00186290174849334*x_34 + 0.0139199603900611*x_35 + 0.00740152296457672*x_36 - 0.00382147237009504*x_37 - 0.00497441628162759*x_38 - 0.0121508956872027*x_39 - 0.000188916431100845*x_4 + 0.0153608871413547*x_40 - 0.00528388836192632*x_41 - 0.00455009417369255*x_42 + 0.0066687196424533*x_43 + 0.00491426005057504*x_44 + 0.0128277301002249*x_45 - 0.0109344467923969*x_46 - 0.00456622593236841*x_47 - 0.0158546817692295*x_48 + 0.0200355465292781*x_49 + 0.00824308509509122*x_5 + 0.0159446631022693*x_50 + 0.00641645890689312*x_51 - 0.0213332737975653*x_52 - 0.00678401326684249*x_53 + 0.00147514237320097*x_54 + 0.000207350384002294*x_55 - 0.00942102246365879*x_56 - 0.0334963927087294*x_57 + 0.00242587251654679*x_58 + 0.000785198412607677*x_59 + 0.00131467182116584*x_6 - 0.00403439647157705*x_60 + 0.00131529710653718*x_61 - 0.0179189651857688*x_62 - 0.0173566912490475*x_63 + 0.0130691891263238*x_64 - 0.0166694144365269*x_65 - 0.0100700376637657*x_66 - 0.011953342618971*x_67 - 0.000216553087655639*x_68 + 0.00253215137565198*x_69 - 0.00466390262323452*x_7 - 0.000750743838159008*x_70 - 0.00287711065387268*x_71 + 0.00384122635386384*x_72 - 0.00296329366331218*x_73 + 0.00264991629597467*x_74 + 0.00743369035167145*x_75 - 0.00437822732295166*x_76 + 0.00357435020628658*x_77 - 5.10558484242019e-5*x_78 - 0.010306467545639*x_79 + 0.0203964131081926*x_8 - 0.00139860854977699*x_80 + 0.00452614149278561*x_81 + 0.00563794834793885*x_82 + 0.00638752627234961*x_83 - 0.00397419383279852*x_84 + 0.00624831645794651*x_85 + 0.00625052750111306*x_86 - 0.00114046202177067*x_87 - 0.00156464613583535*x_88 + 0.0161426279828722*x_89 + 0.00670060249645281*x_9 + 0.00783967105091579*x_90 - 0.0327854309779633*x_91 + 0.00290598482780087*x_92 - 0.0355948309017523*x_93 - 0.00106993967453409*x_94 - 0.000585745404852671*x_95 - 0.00508730454646364*x_96 + 0.0132804206925373*x_97 + 0.00347149720387518*x_98 + 0.00395989082999673*x_99 - 4.13635191301726e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) + 5.91329650907109e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 1.11544158531406e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) + 2.75239952950462e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) - 6.30154973457794e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 4.87467685381393e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 2.50716152547537e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) + 1.28828851011567e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 6.28450632021777e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) + 2.83375308965984e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 1.73799940050747e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.0015257728708603*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) + 3.2976869678126e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) - 6.36279900306213e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) - 0.000191391796119773*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 2.27631494518252e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) - 0.000251511440617014*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 6.76321260738041e-6*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 8.32426276574463e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) + 3.74846452113963e-6*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 1.17803951762657e-5*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 3.719573828043e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 6.11309142847034e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 3.28304493871189e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 7.47180707721698e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 0.000334221341480792*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 8.75039333883459e-6*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) - 5.776177026983e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) + 9.64322904506501e-5*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 1.14691085575277e-5*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) - 5.14993220371829e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) + 5.28010343139274e-6*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) + 3.67575294506306e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) - 3.18205943974732e-6*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 1.61962132673505e-6*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 2.37566248130849e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 4.93025771082417e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 1.57542604755688e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) + 2.51132103140109e-6*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) + 5.23873798937467e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 1.3966339190296e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.000142315367677824*std::exp(0.581919848918915*x_1) + 0.000501318880228395*std::exp(0.848399877548218*x_1) - 0.000399157094860078*std::exp(1.00727987289429*x_1) - 8.0692989690783e-5*std::exp(1.16983985900879*x_1) - 4.42974764202488e-5*std::exp(1.27119994163513*x_1) - 2.16418545780026e-5*std::exp(1.27559983730316*x_1) - 4.1510550599965e-6*std::exp(1.27711987495422*x_1) - 1.84094587950857e-6*std::exp(1.35095977783203*x_1) - 0.000182925949530596*std::exp(1.23759984970093*x_100) - 0.000805797504991018*std::exp(1.47815990447998*x_100) - 0.00157431868080988*std::exp(0.614959836006165*x_104) - 0.00779017702599934*std::exp(0.876879870891571*x_104) - 0.000157807401046082*std::exp(0.973119854927063*x_104) + 0.00571768623115514*std::exp(0.653039813041687*x_106) + 0.000255368050177623*std::exp(0.848959863185883*x_106) - 0.000345913809741496*std::exp(1.05311989784241*x_106) - 0.0124575926803223*std::exp(0.576079845428467*x_109) - 0.000551055427130412*std::exp(0.711199820041656*x_109) - 0.000788553318978367*std::exp(0.828479886054993*x_109) - 0.000175802771080415*std::exp(1.09879982471466*x_109) - 0.000629521423668919*std::exp(1.26071989536285*x_109) + 0.0129462710222316*std::exp(0.654639840126038*x_110) + 0.00269426272084171*std::exp(0.930479824542999*x_110) + 0.00135184189825154*std::exp(0.998239815235138*x_110) + 0.000315385627904055*std::exp(1.11503982543945*x_110) + 5.31837864124815e-5*std::exp(1.34391975402832*x_110) - 0.00029127097924823*std::exp(1.47463989257813*x_110) + 0.00127408286622716*std::exp(0.405039876699448*x_112) - 0.000638758261905529*std::exp(0.421119838953018*x_112) - 7.27391406346405e-5*std::exp(0.89711982011795*x_112) + 0.00281916144483089*std::exp(0.762399852275848*x_114) + 0.00120007581322935*std::exp(1.31567978858948*x_23) - 8.27851428722502e-5*std::exp(1.51271986961365*x_23) + 0.00183393889036397*std::exp(0.536079823970795*x_26) - 0.00323656026476005*std::exp(0.615919828414917*x_26) + 0.0115205155884444*std::exp(0.62095981836319*x_26) - 0.000661574770100303*std::exp(0.918959856033325*x_26) + 4.07294214064302e-5*std::exp(1.03471982479095*x_26) + 0.000185102454317107*std::exp(1.19559991359711*x_26) - 0.000231257014174553*std::exp(1.30039978027344*x_26) + 0.00035313261385624*std::exp(0.533599853515625*x_31) - 0.0306946320135371*std::exp(0.643759846687317*x_31) + 0.0103061235076549*std::exp(0.644639849662781*x_31) - 0.00233312529686467*std::exp(0.649439811706543*x_31) - 0.00132855935694934*std::exp(0.654799818992615*x_31) + 0.00463861077843307*std::exp(0.655919849872589*x_31) + 0.00155582743628987*std::exp(0.658159852027893*x_31) + 0.00408258861828751*std::exp(0.659039855003357*x_31) + 0.00175247334195201*std::exp(0.666559815406799*x_31) - 0.000536295703085652*std::exp(0.540479838848114*x_45) + 0.000282896204088914*std::exp(1.24111986160278*x_45) + 0.00299333775101412*std::exp(0.760639846324921*x_49) - 0.00254717934424264*std::exp(1.0195198059082*x_50) + 0.000111728034373398*std::exp(1.29199981689453*x_52) + 0.00103859528108743*std::exp(0.987999796867371*x_6) - 0.00637510963306723*std::exp(0.698879837989807*x_60) - 0.000480112897050915*std::exp(1.37487983703613*x_60) - 0.000622353833987333*std::exp(0.935359835624695*x_66) + 0.00124433189551297*std::exp(0.659359872341156*x_68) + 0.000266791122210848*std::exp(1.31007981300354*x_68) + 0.000814960902262338*std::exp(0.628559827804565*x_70) + 0.00240648712144136*std::exp(0.78551983833313*x_70) - 0.00803502572340506*std::exp(0.799999833106995*x_72) + 0.0012046806579831*std::exp(0.812319874763489*x_72) + 0.000870635033291717*std::exp(0.835599899291992*x_72) - 0.00482540002515591*std::exp(1.06815981864929*x_72) - 0.00112557224324688*std::exp(0.794799864292145*x_73) + 0.0115173297941852*std::exp(0.678079843521118*x_74) - 0.00534139345903177*std::exp(1.16815984249115*x_74) - 0.00267943829164926*std::exp(1.25239992141724*x_74) - 6.84465366002777e-5*std::exp(1.4819198846817*x_74) - 0.000876826861372043*std::exp(0.930879831314087*x_78) + 0.000454238831157336*std::exp(1.2513599395752*x_81) + 0.000164195428886876*std::exp(1.27559983730316*x_81) + 0.000145059815551346*std::exp(2.05335974693298*x_81) + 0.0023161097279382*std::exp(0.704079866409302*x_87) - 0.0210050782604442*std::sin(0.319919854402542*x_100 + 5.12239980697632) + 0.00614360428289197*std::sin(0.251599967479706*x_102 + 1.81823992729187) + 0.0409716287316799*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.00425619656582745*std::sin(0.377599835395813*x_102 + 5.18224000930786) - 0.0370902584127287*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.0395828392553396*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.0768046479929225*std::sin(0.323119848966599*x_105 + 1.94975972175598) - 0.164895226748621*std::sin(0.194159999489784*x_106 - 7.60576009750366) + 0.037255640225014*std::sin(0.520639836788177*x_106 + 5.37607955932617) - 0.0080530709868971*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.0679835175740454*std::sin(0.247359976172447*x_111 - 7.54960012435913) - 0.00256050959761218*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.0362517052979363*std::sin(0.45007985830307*x_111 - 1.17727982997894) + 0.028895805302743*std::sin(0.601279854774475*x_112 - 0.998639822006226) - 0.0660154705473836*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00378276526320061*std::sin(0.308319926261902*x_115 + 5.10927963256836) + 0.0136249297306463*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0565867197198949*std::sin(0.300239950418472*x_116 + 1.90559983253479) - 0.00387901881999211*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.0167357591508667*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.0641074399914844*std::sin(0.284639924764633*x_119 + 8.28767967224121) + 0.0115810576054464*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.0516125477152528*std::sin(0.304639935493469*x_120 - 7.47384023666382) - 0.0236574834953958*std::sin(0.403279840946198*x_120 + 5.21072006225586) - 0.0102695504816651*std::sin(0.262479960918427*x_20 - 7.53648042678833) - 0.00445327060698006*std::sin(0.316799849271774*x_20 + 1.92847979068756) - 0.0718313432529361*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.0250067793764933*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.0695678367362674*std::sin(0.266799956560135*x_24 + 5.06759977340698) - 0.0810109271040799*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.00839672774732752*std::sin(0.358079850673676*x_24 + 5.16359996795654) - 0.0342455020705863*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.0252531726875122*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.0123148705794768*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.0581813688263165*std::sin(0.315679848194122*x_28 + 5.11208009719849) - 0.0607132275882909*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.0187401264432943*std::sin(0.319759845733643*x_28 - 4.27544021606445) + 0.00543795809918001*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.0269626725519078*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.012803570134197*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.00976086556382175*std::sin(0.309839934110641*x_35 + 8.25224018096924) - 0.00181185128095041*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.0245784129400215*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00329425439674581*std::sin(0.293279945850372*x_36 + 1.89527988433838) - 0.00373666500692833*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.0501817602540526*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.00124661523118709*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.00211831660085709*std::sin(0.5204798579216*x_38 + 2.12431979179382) + 0.0200200419115419*std::sin(0.699439823627472*x_38 - 0.933919847011566) + 0.0447598445006256*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.0311978673482833*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.00608924361086436*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00214815458181846*std::sin(0.41431987285614*x_43 - 1.17959988117218) + 0.0046813839981901*std::sin(0.351759850978851*x_44 + 5.15248012542725) - 0.188794278391567*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.00728813990320462*std::sin(0.214559987187386*x_48 - 7.58031988143921) + 0.00544349167123113*std::sin(0.181600004434586*x_53 - 4.43544006347656) - 0.105354830007315*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00838685078313432*std::sin(0.535439848899841*x_54 - 1.04375982284546) + 0.0468415416075214*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.00533259618719912*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0186849603436194*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.0199139093810234*std::sin(0.410559862852097*x_56 - 7.3808798789978) - 0.133556081432066*std::sin(0.140880048274994*x_58 + 4.90823936462402) - 0.231197467132434*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.0100658832626291*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.00558765966246732*std::sin(0.389679849147797*x_58 + 5.19736003875732) + 0.00168372382580732*std::sin(0.510159850120544*x_58 - 4.10351991653442) - 0.00332389066844918*std::sin(0.271919965744019*x_59 + 5.07471990585327) + 0.0947361115750525*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.00739756305378918*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.0260202725983753*std::sin(0.42399987578392*x_64 - 1.15239989757538) - 0.0251021572203195*std::sin(0.41967985033989*x_65 + 1.98983979225159) - 0.111782750286362*std::sin(0.245919972658157*x_69 - 7.54095983505249) + 0.00674606757521586*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.030519013796696*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.00604923116842854*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.00597949317565158*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0508605747530869*std::sin(0.385759830474854*x_75 - 7.40551996231079) - 0.00969515983133739*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.00817295196541415*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0133645550481176*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.00674628790443679*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.035008704205125*std::sin(0.258879989385605*x_82 + 1.85407984256744) + 0.189393220383645*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.00279951876495643*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.022310837246909*std::sin(0.221039995551109*x_85 - 7.57552003860474) + 0.000976251102533688*std::sin(0.699679851531982*x_86 - 7.12943983078003) + 0.00120730119001126*std::sin(0.90479987859726*x_87 + 8.66631984710693) - 0.00562549095959083*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0172803820823884*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0225494749382483*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.024361610453313*std::sin(0.3503198325634*x_92 - 7.3997597694397) - 0.0674652068473335*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.00260320314056533*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.0259749446291779*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.00225909041732327*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.00630327933717955*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0338933101520739*std::sin(0.365359842777252*x_95 - 7.40423965454102) + 0.00903367693217925*std::sin(0.401599824428558*x_95 + 5.0099196434021) - 0.00280431289588621*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00250101313813077*std::sin(0.427599847316742*x_96 - 1.1937597990036) + 0.00823525165339681*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.00305290541113882*std::sin(0.351279854774475*x_97 + 5.16311979293823) - 0.00239461047002996*std::sin(0.36983984708786*x_98 + 5.1780800819397) + 0.0131087095143259*std::sin(0.384079843759537*x_98 + 8.38000011444092) + 0.0042360570444526*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00244885047528796*std::sin(0.446799844503403*x_98 - 1.14799976348877) - 0.0469255553155747*std::sin(0.408639848232269*x_99 + 5.2050404548645) - 0.029901276887404*std::sin(0.434639871120453*x_99 + 5.23040008544922) - 1.16429674625397*std::sin(0.00166126355460341*x_10 + 0.0118852805074719*x_101 + 0.0141742565423272*x_103 - 0.00471269771959257*x_105 - 0.00633869412229825*x_107 - 0.0098096017545151*x_11 + 0.00777446377768562*x_110 - 0.00300046236229918*x_113 + 0.0010265763511886*x_115 - 0.00677132516662483*x_116 + 0.0145406965481402*x_117 - 0.00434101330405111*x_118 + 0.00934172737970424*x_12 - 0.00894556890190038*x_13 - 0.0023829331247328*x_17 + 0.00736463227860918*x_19 + 0.0173395682705106*x_2 + 0.00329897559714212*x_20 - 0.00760841639292838*x_21 + 0.00293713479720422*x_23 + 0.00107180398762309*x_27 - 0.0114977315698148*x_29 + 0.00705381881211234*x_3 - 0.00711538326185166*x_30 - 0.000560027710215758*x_32 - 0.0183075113024566*x_33 - 0.0146058727427739*x_35 - 0.0112221243817267*x_37 - 0.00202735630182307*x_39 - 0.00553568032578374*x_4 - 0.00504542580836441*x_40 + 0.00725554104532147*x_41 - 0.00678015963403806*x_42 + 0.00274438459781166*x_43 + 0.00307577082342134*x_44 - 0.0103852303670508*x_45 + 0.00575621183065147*x_46 + 0.0067146718411642*x_48 + 0.0090757121999011*x_49 - 0.00158820383041194*x_5 - 0.000672263375812877*x_51 + 0.00462932628900612*x_52 - 0.0178166455905901*x_54 - 0.00196854564705865*x_55 - 0.0105656523415252*x_56 + 0.00144065639770899*x_57 + 0.000342443111757734*x_58 + 0.0100668890515487*x_6 + 0.0171268286589351*x_60 + 0.0189260338625361*x_61 - 0.00349813798779181*x_62 - 0.0153765730891358*x_63 + 0.00348554751123838*x_64 - 0.00871200043914561*x_65 - 0.00326068634780133*x_66 - 0.006371772358987*x_67 + 0.00713511577385449*x_68 - 0.00393240631771908*x_69 + 0.0111994918981239*x_7 + 0.00330927307797559*x_70 + 0.0114752914649253*x_71 + 0.00249561157786244*x_72 - 0.00759679722950934*x_73 - 0.000167214087969177*x_76 + 0.00182356450653504*x_77 + 0.00692211594991538*x_78 - 0.011446034102832*x_8 - 0.0130700970926131*x_80 - 0.000908912615070498*x_81 + 0.00438951172218293*x_82 - 0.00201239002546028*x_83 + 0.0122822648362207*x_84 + 0.00355226634219421*x_86 - 0.00262878348884759*x_88 - 0.00989844745050331*x_9 + 0.0102009047976572*x_91 + 0.0188063775874769*x_93 + 0.00016013415602553*x_94 - 0.00674483460741155*x_95 + 0.000302338163447232*x_96 - 0.000141123173835208*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 7.24611158972187e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 0.000119021288114073*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) + 0.000188769413328878*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 7.95843390907804e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) + 0.000209645934372395*std::exp(1.1522399187088*x_1) + 0.000890689977095479*std::exp(1.55327987670898*x_100) + 0.00801149312467924*std::exp(0.700399816036224*x_114) + 0.0051455567667963*std::exp(0.629919826984406*x_26) + 0.00288730480423868*std::exp(0.594959855079651*x_31) - 0.0119598399375442*std::exp(0.629199862480164*x_47) + 0.000108308542507667*std::exp(1.98231983184814*x_50) - 0.0114317094750798*std::exp(0.623999834060669*x_90) + 0.0723383558506954*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.0373869971384453*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.0028513280412604*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0385373795258712*std::sin(0.421359866857529*x_111 - 1.16935980319977) - 0.0500600741689805*std::sin(0.538319826126099*x_112 - 0.998959839344025) - 0.0674191115214127*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.0664889230806853*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.0292090312083326*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.0943328581807013*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.052696601742956*std::sin(0.427359849214554*x_22 + 5.21424007415771) + 0.0962293024838781*std::sin(0.313599824905396*x_24 + 5.11432027816772) - 0.0325708230264881*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.0875941836527838*std::sin(0.329839825630188*x_28 + 5.12192010879517) + 0.099744278298787*std::sin(0.352799862623215*x_34 + 2.00847983360291) - 0.0611286898932955*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0613160144090501*std::sin(0.482639849185944*x_38 + 5.25967979431152) + 0.100698429014935*std::sin(0.351199835538864*x_53 - 4.25352001190186) - 0.0829585612796908*std::sin(0.362799853086472*x_59 + 8.34911918640137) + 0.146574415168722*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.189140592951768*std::sin(0.212719991803169*x_75 - 7.5798397064209) - 0.12205184031665*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0416608244474372*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.176259782453144*std::sin(0.211520001292229*x_89 + 1.78799998760223) - 0.0756736193695096*std::sin(0.379919856786728*x_92 + 8.19079971313477) - 0.1356790966807*std::sin(0.303999930620193*x_97 + 5.11295986175537) - 0.0597489226147569*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.0847718148965839*std::sin(0.407759845256805*x_99 - 4.20120000839233) + 4.48613460186892) - 2.39880692590684);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000404796301747116*x_1 + 0.00106083193674769*x_10 - 0.0052881450531284*x_100 - 0.0056770949790885*x_101 + 0.000595730728805667*x_102 + 0.0202089006392165*x_103 - 0.000217003702513374*x_104 - 0.00183315719173987*x_105 - 0.00125259030251232*x_106 - 0.00952657469821665*x_107 + 0.00840997179565323*x_108 + 0.00208029386649677*x_109 - 5.58620712094286e-5*x_11 - 0.00180797585925877*x_110 + 0.00440652165477714*x_111 + 0.00733955421344145*x_112 + 0.0133431184751128*x_113 - 0.0030186478760268*x_114 - 0.0017711824118665*x_115 + 0.00313976588898774*x_116 + 0.00955379253623339*x_117 - 0.00805499079791429*x_118 + 0.0170839654553654*x_119 + 0.0238620708397382*x_12 + 0.00229485051127543*x_120 - 0.00145098584359731*x_13 - 0.00368939307410948*x_14 + 0.00247064121865657*x_15 + 0.000819736762160758*x_16 + 0.0182284275987213*x_17 - 0.0190759777118554*x_18 - 0.0142811053621259*x_19 - 0.0180977836816179*x_2 + 0.00936473738128283*x_20 - 0.0041420374278801*x_21 - 0.00805658859104115*x_22 + 0.0161682385969384*x_23 - 0.00261023099629269*x_24 + 0.0146223258786832*x_25 + 0.000353244721357091*x_26 + 0.00667288561609363*x_27 - 0.000306250772558399*x_28 + 0.00903460832268984*x_29 + 0.00438111119828335*x_3 + 0.00549284184946751*x_30 + 0.0186551730485504*x_32 - 0.0218459614269459*x_33 + 0.00817718797763511*x_34 - 0.0173797301621064*x_35 - 0.00081447043614957*x_36 + 0.00973149862783102*x_37 + 0.0101195111536864*x_38 + 0.0146567278942307*x_39 + 0.0142265080298192*x_4 - 0.0121052734152672*x_40 + 0.00348013424769685*x_41 - 0.0246510667878013*x_42 - 0.000698435429620336*x_43 - 0.0111842455789776*x_44 - 0.00843491093995848*x_45 + 0.0099486895845364*x_46 - 0.0054220329409582*x_47 + 0.0142533350869136*x_48 - 0.0140440143259979*x_49 - 0.00770813779773541*x_5 - 0.0141199979386609*x_50 + 0.000567183215989994*x_51 + 0.0126231087264621*x_52 + 0.000996541888545139*x_53 - 0.000306539522870038*x_54 - 0.00286055046104112*x_55 - 0.00205137742019571*x_56 + 0.00823741349628582*x_57 - 0.00124206492465005*x_58 + 0.000328090140046271*x_59 - 0.001331948710776*x_6 + 0.0148677313225154*x_60 + 0.00353610601677429*x_61 + 0.00659520939877749*x_62 - 0.00443724684665597*x_63 - 0.00219644618216918*x_64 - 0.00221710371348108*x_65 + 0.00866434126752768*x_66 + 0.00825697488157137*x_67 - 0.00120503272365646*x_68 - 0.0138426631800133*x_69 + 0.00888037060861202*x_7 + 0.00305990784184653*x_70 + 0.0180780619973442*x_71 - 0.00108354133454804*x_72 - 0.00283103828149524*x_73 + 0.00551676576611405*x_74 - 0.000133368606380921*x_75 + 0.0106711148635348*x_76 + 0.00585023755329013*x_77 + 0.0107045712670499*x_78 + 0.0135683597335978*x_79 - 0.010996231414799*x_8 + 0.00794677668396061*x_80 - 0.00739009170175321*x_81 + 0.00592337610954973*x_82 - 0.00510782715212007*x_83 + 0.00903720749756766*x_84 - 0.00275109905348163*x_85 + 0.00723884621965725*x_86 + 0.00027278997257025*x_87 - 0.0060067508044489*x_88 - 0.00481937700189725*x_89 + 0.00298109683481568*x_9 - 0.0007134193602483*x_90 + 0.00140012136815709*x_91 - 0.0027402554644574*x_92 + 0.0568160881471328*x_93 + 0.0129263899521941*x_94 + 0.00610224883964587*x_95 + 0.0020164328565367*x_96 - 0.0189057311758753*x_97 + 0.00763559014014351*x_98 - 0.00174055183958837*x_99 + 3.66227388495612e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 6.16916483416275e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 1.02659783844733e-5*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 3.16761985922532e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 1.16124154919186e-5*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) - 2.43693987596848e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 6.67879918779908e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 5.20694160373544e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 4.84913574506452e-6*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 1.34118555824828e-5*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 4.30070631431123e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 3.0033989464198e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 3.36148865251254e-6*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.000295101838942569*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 5.20298633594721e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 2.91973050575637e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 0.000105535033983471*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 8.25200847476623e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 0.000202849684016938*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 3.57966050828725e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 0.000266568459516823*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 1.06356131127756e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 5.69658261357008e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 3.90237624715535e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 1.85254749013277e-5*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 3.97310515019052e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 1.06128391110974e-5*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 6.34978257411736e-6*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 5.11321752878576e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 0.000357002332667657*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 1.51914162826626e-5*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 5.11415438667851e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 0.000159945097195677*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 1.80359554619318e-5*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 8.54181107827579e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 5.49690415821944e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 6.09669913799549e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 3.31271460745509e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 3.4790098091348e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) - 1.68612288023352e-5*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 1.62574848579064e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 9.5356795543536e-6*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 1.07811885376917e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 2.61443572072059e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 4.63831263201669e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 2.42467354745118e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.000223800622350982*std::exp(0.581919848918915*x_1) + 9.69607772411197e-5*std::exp(0.848399877548218*x_1) + 0.000423053089040531*std::exp(1.00727987289429*x_1) + 9.16462045748506e-5*std::exp(1.1522399187088*x_1) - 8.6193136027468e-5*std::exp(1.16983985900879*x_1) + 7.34729429162092e-5*std::exp(1.27119994163513*x_1) + 1.91614254564772e-5*std::exp(1.27559983730316*x_1) - 2.84071139369336e-6*std::exp(1.27711987495422*x_1) + 1.91653500572778e-5*std::exp(1.35095977783203*x_1) - 0.000195394436508843*std::exp(1.23759984970093*x_100) + 0.0013365166341432*std::exp(1.47815990447998*x_100) + 0.000389362932784875*std::exp(1.55327987670898*x_100) - 0.00247572350262022*std::exp(0.614959836006165*x_104) - 0.00150670890141358*std::exp(0.876879870891571*x_104) + 0.00164286963367155*std::exp(0.973119854927063*x_104) - 0.00948350262866052*std::exp(0.653039813041687*x_106) + 0.000174757241048362*std::exp(0.848959863185883*x_106) + 0.00360117009801077*std::exp(1.05311989784241*x_106) + 0.0132033806570982*std::exp(0.576079845428467*x_109) + 0.00573681729564825*std::exp(0.711199820041656*x_109) - 0.0012400538776937*std::exp(0.828479886054993*x_109) - 0.000120307952468214*std::exp(1.09879982471466*x_109) + 0.00104414055525327*std::exp(1.26071989536285*x_109) + 0.00250395616482242*std::exp(0.654639840126038*x_110) - 0.00446877400445291*std::exp(0.930479824542999*x_110) + 0.00144398532103136*std::exp(0.998239815235138*x_110) + 0.000215829357511566*std::exp(1.11503982543945*x_110) - 0.000553675094587137*std::exp(1.34391975402832*x_110) + 0.000257887656364391*std::exp(1.47463989257813*x_110) + 0.000871899230988289*std::exp(0.405039876699448*x_112) - 0.0010044909336138*std::exp(0.421119838953018*x_112) + 0.000757258053398392*std::exp(0.89711982011795*x_112) + 0.00350220451473272*std::exp(0.700399816036224*x_114) + 0.000545257909964347*std::exp(0.762399852275848*x_114) + 0.000232108321047023*std::exp(1.31567978858948*x_23) - 5.66527533811927e-5*std::exp(1.51271986961365*x_23) + 0.00125502818582191*std::exp(0.536079823970795*x_26) - 0.00345716871106866*std::exp(0.615919828414917*x_26) - 0.012210204377651*std::exp(0.62095981836319*x_26) + 0.00224936748481689*std::exp(0.629919826984406*x_26) - 0.00114854925322009*std::exp(0.918959856033325*x_26) - 0.000424017689804655*std::exp(1.03471982479095*x_26) - 0.00030701572998579*std::exp(1.19559991359711*x_26) - 4.47277386134145e-5*std::exp(1.30039978027344*x_26) - 0.00367632217575187*std::exp(0.533599853515625*x_31) + 0.00126217819368335*std::exp(0.594959855079651*x_31) + 0.0325322011245752*std::exp(0.643759846687317*x_31) + 0.00199332158643203*std::exp(0.644639849662781*x_31) - 0.00366899866108061*std::exp(0.649439811706543*x_31) - 0.0023064904017597*std::exp(0.654799818992615*x_31) - 0.00769372010497955*std::exp(0.655919849872589*x_31) + 0.00106470684223906*std::exp(0.658159852027893*x_31) - 0.00361467254097029*std::exp(0.659039855003357*x_31) + 0.00187192436079283*std::exp(0.666559815406799*x_31) + 0.00558315972145483*std::exp(0.540479838848114*x_45) - 0.00046921897891086*std::exp(1.24111986160278*x_45) - 0.00522821461279417*std::exp(0.629199862480164*x_47) - 0.00496482760378338*std::exp(0.760639846324921*x_49) - 0.00272079862880258*std::exp(1.0195198059082*x_50) + 4.73468129662361e-5*std::exp(1.98231983184814*x_50) + 7.6459380965123e-5*std::exp(1.29199981689453*x_52) + 0.00180308846165646*std::exp(0.987999796867371*x_6) + 0.00564444177233545*std::exp(0.698879837989807*x_60) - 0.000833516231711132*std::exp(1.37487983703613*x_60) - 0.00097869385184175*std::exp(0.935359835624695*x_66) + 0.000851539606685612*std::exp(0.659359872341156*x_68) - 0.00277745549516633*std::exp(1.31007981300354*x_68) + 0.000557706098090926*std::exp(0.628559827804565*x_70) + 0.00257051662853976*std::exp(0.78551983833313*x_70) + 0.00711411057148467*std::exp(0.799999833106995*x_72) + 0.0020914265970049*std::exp(0.812319874763489*x_72) + 0.00136913297186819*std::exp(0.835599899291992*x_72) + 0.00511427809447822*std::exp(1.06815981864929*x_72) - 0.000217698482643476*std::exp(0.794799864292145*x_73) + 0.00222758266769792*std::exp(0.678079843521118*x_74) + 0.00566116206306291*std::exp(1.16815984249115*x_74) + 0.00237234091494419*std::exp(1.25239992141724*x_74) - 0.000107636847227837*std::exp(1.4819198846817*x_74) - 0.00137887004384066*std::exp(0.930879831314087*x_78) + 0.00078859668458975*std::exp(1.2513599395752*x_81) + 0.000258208510940699*std::exp(1.27559983730316*x_81) - 0.000153743986653071*std::exp(2.05335974693298*x_81) + 0.00247397898627521*std::exp(0.704079866409302*x_87) - 0.00499734368009462*std::exp(0.623999834060669*x_90) - 0.00406262120671644*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.0639586030233802*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.0679566057088253*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.0316225343398508*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.00291266338403007*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.0393107089836819*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.0422808605972197*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.0148548930806906*std::sin(0.323119848966599*x_105 + 1.94975972175598) + 0.145996156848966*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.0394859915665529*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.0163436338436357*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.00860197949874402*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.00124645104023428*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.072053428296503*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0266564396647863*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.0168465206748684*std::sin(0.421359866857529*x_111 - 1.16935980319977) + 0.00701149240659464*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.0218836382973839*std::sin(0.538319826126099*x_112 - 0.998959839344025) + 0.00558877762570119*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.0584492661342289*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00656719756331889*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.0225986617124659*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0109445156405574*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.0403829109760484*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.00323688629929304*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.0123991085388224*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.0294720987804647*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.00792532062700184*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.0551305307064748*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.0392389155063433*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.0290654691914519*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.0127686561514571*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.0412373769366895*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0161495685712908*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.0463612162815685*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.119141328330955*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.00483659574827371*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.0230361898416585*std::sin(0.427359849214554*x_22 + 5.21424007415771) - 0.0743096771841469*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.0420664028994111*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.0858607385381238*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.0145774231720222*std::sin(0.358079850673676*x_24 + 5.16359996795654) + 0.03032053619897*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.00488425101897191*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.0142382551762465*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.0193659739269897*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.0112529389273785*std::sin(0.315679848194122*x_28 + 5.11208009719849) + 0.0537547270018916*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.0200174795095405*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.0382915819409618*std::sin(0.329839825630188*x_28 + 5.12192010879517) - 0.00901953829629798*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.0288004857898594*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.0436029659316165*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.0222280709313528*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.0153496268429201*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.0188624578471648*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.0262537117288212*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00225437289154342*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.0389009224560578*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.0267222564373813*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0531859484958176*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.000853102172725176*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.0268041448887082*std::sin(0.482639849185944*x_38 + 5.25967979431152) - 0.0220529455208138*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.0177254929489025*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.0396298025546294*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.0333243573502722*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.0105714373008407*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00147005691511869*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.0487360134138233*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.20009666293099*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.00498752769178687*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.0566700110928142*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.044020070570393*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.111662016919826*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00895851018983057*std::sin(0.535439848899841*x_54 - 1.04375982284546) - 0.0414729109533565*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.00103138479601705*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0324386573052921*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.00385157672620183*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.118248872313415*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.245038366869087*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.00688843411095631*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.00878697592783243*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.0175285742403196*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.0346036941781*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.0362651310221398*std::sin(0.362799853086472*x_59 + 8.34911918640137) - 0.157131770934828*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.00506240976058787*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.0277938505456037*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.0416350888033699*std::sin(0.41967985033989*x_65 + 1.98983979225159) + 0.0989710391598892*std::sin(0.245919972658157*x_69 - 7.54095983505249) - 0.0702306070092496*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.00590272462312201*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.0041396993426665*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.009403160852479*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0640746450829363*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.0826823450068712*std::sin(0.212719991803169*x_75 - 7.5798397064209) + 0.00983701403135396*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.0160806434681178*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.0055930353687672*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0232019877629357*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.0106089978630405*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.0373949461441555*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.200731461267704*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.00440243420021131*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.0533546618010139*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0387334835256297*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.0101633591362589*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.0182119269400414*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.00209597606025534*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00596226738412036*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0770515303784804*std::sin(0.211520001292229*x_89 + 1.78799998760223) + 0.0184582369440211*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.00436132510189043*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.0260221316832736*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0715040883077069*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.00451937884908035*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.033080536583831*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.0229978888109713*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.00154597416683726*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.00991233667544872*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.00655535194310298*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.014983490780935*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.0291945781340107*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00171153030123162*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.0136592019123252*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0593117834035502*std::sin(0.303999930620193*x_97 + 5.11295986175537) + 0.031782575222609*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.0249293303077427*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.021742445477345*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.0261190945651839*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.00735415008989249*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00167583357629753*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.0370577903809647*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 0.00907593648536911*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.0495950331126709*std::sin(0.434639871120453*x_99 + 5.23040008544922) + 1.10045176512212);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000240875155855466*x_1 + 0.000317625988359161*x_10 + 0.0135947792102447*x_100 - 0.0155298582524869*x_101 + 0.0112027909218723*x_102 + 0.00366149452593828*x_103 + 0.00528397127306994*x_104 + 0.0173710123300696*x_105 - 0.00863229542952753*x_106 + 0.0309340150768328*x_107 + 0.00528036061161294*x_108 - 0.000489414421698853*x_109 + 0.00458998691845596*x_11 + 0.0016779703467818*x_110 + 0.000791770910154571*x_111 + 0.00299210794139315*x_112 - 0.00264885003026937*x_113 + 0.00585557729102264*x_114 - 0.00123801752624927*x_115 - 0.00524945725435249*x_116 + 0.00503870571657963*x_117 + 0.00872231813966694*x_118 + 0.00260904229222945*x_119 + 0.0128846259679536*x_12 + 0.0127211320838559*x_120 + 0.0117540639572007*x_13 + 0.0298061505386177*x_14 - 0.00587450814701823*x_15 + 0.00909471548095143*x_16 + 0.0124556612108718*x_17 - 0.00666059349170994*x_18 - 0.0103421426846809*x_19 - 0.0140334162381873*x_2 + 0.0038454664076083*x_20 - 0.00125855988823088*x_21 - 0.010631629988239*x_22 + 0.0117175451792433*x_23 - 0.00148440298825343*x_24 - 0.0055164855115175*x_25 - 0.00513666773842254*x_26 - 0.00510668065221046*x_27 + 0.00288933848207329*x_28 + 0.0247698518469426*x_29 - 0.0105235793933015*x_3 - 0.00277667640415067*x_30 + 0.0237843484475424*x_32 + 0.00896901916668528*x_33 - 0.0165890937382799*x_34 + 0.00466912146835546*x_35 - 0.000481698737048165*x_36 - 0.00798090824222359*x_37 + 0.00306394125624991*x_38 + 0.00167988480339509*x_39 + 0.0221796741519575*x_4 + 0.0131217490994282*x_40 - 0.0127989819656149*x_41 - 0.00808618115065862*x_42 - 0.00341277764298943*x_43 + 0.0297708444103283*x_44 + 0.00982230781243068*x_45 + 0.0043575452021828*x_46 + 0.010276834364623*x_47 - 0.0135945289116414*x_48 + 0.00562856229352202*x_49 + 0.0065721307642992*x_5 + 0.00131564816882981*x_50 + 0.010329838065289*x_51 - 0.00446374333957222*x_52 - 0.0014207064782709*x_53 + 0.0079086920570951*x_54 - 0.0074346344618306*x_55 + 0.00713347974822745*x_56 - 0.0188328538373209*x_57 + 0.00153513972402862*x_58 + 0.00576559421532442*x_59 - 0.00529419177333368*x_6 + 0.00107946709465305*x_60 + 0.0154832640813224*x_61 - 0.0209138962548027*x_62 + 0.00713394019300719*x_63 + 0.00827153365098564*x_64 - 0.0154575020906225*x_65 + 0.00623549480586386*x_66 + 0.00450788908245949*x_67 - 0.00274905228120809*x_68 - 0.00739759161659014*x_69 - 0.00102336762582572*x_7 - 0.000974230644561933*x_70 + 0.00435722525700877*x_71 - 0.00253981599343235*x_72 + 0.00323553343029224*x_73 - 0.00190549117794359*x_74 + 0.00494552765499641*x_75 + 0.017789728801951*x_76 + 0.00930993385880134*x_77 + 0.00912693311885167*x_78 - 0.00743710049304732*x_79 + 0.0325201728262652*x_8 + 0.0118825321042005*x_80 - 0.00790525652030942*x_81 + 0.00576104099407642*x_82 - 0.00541296929458401*x_83 + 0.00239673661898065*x_84 + 0.00351017806361256*x_85 + 0.0116301508713074*x_86 + 0.000541551564970222*x_87 + 0.00754762338921255*x_88 + 0.02021450274208*x_89 + 0.012166462392814*x_9 + 0.011568529004447*x_90 + 0.0189633688604382*x_91 - 0.00315396048817349*x_92 + 0.0964413715231914*x_93 + 0.0352174350372666*x_94 + 0.00395353020006514*x_95 + 0.00140301007505826*x_96 + 0.00969877977439292*x_97 - 0.00834903824798417*x_98 - 0.00488712973906853*x_99 + 1.64809733843937e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 1.29936654547195e-6*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 6.1087987530915e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 6.67172848269105e-7*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 7.31262541681195e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) - 1.09667224508211e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) - 5.89367053980395e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) + 4.53503703906542e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 2.75200312943822e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 8.44577737399502e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 7.67291955117107e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) + 2.6503332997538e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 1.90772702139781e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.00167477510832627*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 1.09586736020404e-6*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 1.3139377956586e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 9.24070107181983e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 1.7380608288638e-6*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) - 0.000179003616231369*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 0.000212209370243929*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) - 0.000235231908089896*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 6.30500226374838e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 1.01633120041407e-5*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 2.45742289799835e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 0.000109822687184418*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) - 3.46041503582245e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 6.31519918517332e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 3.60365690587421e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 9.12252636629856e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) - 0.000310934695430251*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 9.03969415965073e-6*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 2.30147293671179e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 0.000140048737874089*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 0.000106920718919107*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 7.4792530789982e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 3.4615365846278e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 5.33830066969624e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 2.08609837066018e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 7.32758660025662e-7*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) - 1.06179330548796e-5*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 2.90050899323208e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 5.4117313588531e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 1.92347922108613e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 1.64637487482837e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 2.08733452052235e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 1.44280868209559e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.00132673444924041*std::exp(0.581919848918915*x_1) + 0.000550276124300936*std::exp(0.848399877548218*x_1) - 0.00037332093053585*std::exp(1.00727987289429*x_1) + 1.93027768661008e-6*std::exp(1.1522399187088*x_1) + 7.50707601785564e-5*std::exp(1.16983985900879*x_1) + 6.43332812553893e-5*std::exp(1.27119994163513*x_1) + 8.62302910365283e-6*std::exp(1.27559983730316*x_1) - 5.06813262727868e-6*std::exp(1.27711987495422*x_1) + 1.20688952310122e-5*std::exp(1.35095977783203*x_1) + 0.000170180707645966*std::exp(1.23759984970093*x_100) + 0.00117026073972426*std::exp(1.47815990447998*x_100) + 8.20086968832264e-6*std::exp(1.55327987670898*x_100) - 0.0146765796413612*std::exp(0.614959836006165*x_104) - 0.00855094150759316*std::exp(0.876879870891571*x_104) + 0.00103455566570589*std::exp(0.973119854927063*x_104) - 0.00830380297399579*std::exp(0.653039813041687*x_106) + 0.000311785589052351*std::exp(0.848959863185883*x_106) + 0.00226774593169727*std::exp(1.05311989784241*x_106) - 0.0116512524806425*std::exp(0.576079845428467*x_109) + 0.00361261582458524*std::exp(0.711199820041656*x_109) - 0.007351285180388*std::exp(0.828479886054993*x_109) - 0.000214642240876324*std::exp(1.09879982471466*x_109) + 0.000914254762979525*std::exp(1.26071989536285*x_109) + 0.0142105636217361*std::exp(0.654639840126038*x_110) - 0.0039128811707339*std::exp(0.930479824542999*x_110) - 0.00125765322776927*std::exp(0.998239815235138*x_110) + 0.000385062632957863*std::exp(1.11503982543945*x_110) - 0.000348662909293192*std::exp(1.34391975402832*x_110) + 0.000116054662600859*std::exp(1.47463989257813*x_110) + 0.00155556138158959*std::exp(0.405039876699448*x_112) - 0.00595482135650657*std::exp(0.421119838953018*x_112) + 0.00047686413668374*std::exp(0.89711982011795*x_112) + 7.37643993015813e-5*std::exp(0.700399816036224*x_114) + 0.00309447199142671*std::exp(0.762399852275848*x_114) + 0.00131727148810011*std::exp(1.31567978858948*x_23) - 0.000101074564798746*std::exp(1.51271986961365*x_23) + 0.0022391043704192*std::exp(0.536079823970795*x_26) + 0.0030110551160679*std::exp(0.615919828414917*x_26) + 0.0107748293970284*std::exp(0.62095981836319*x_26) + 4.73767995638281e-5*std::exp(0.629919826984406*x_26) - 0.000683447401033572*std::exp(0.918959856033325*x_26) - 0.00026701443276821*std::exp(1.03471982479095*x_26) - 0.000268824529453373*std::exp(1.19559991359711*x_26) - 0.000253840855583583*std::exp(1.30039978027344*x_26) - 0.00231507105489824*std::exp(0.533599853515625*x_31) + 2.65843459103965e-5*std::exp(0.594959855079651*x_31) - 0.0287078664849137*std::exp(0.643759846687317*x_31) + 0.0113125875047343*std::exp(0.644639849662781*x_31) - 0.0217505513020359*std::exp(0.649439811706543*x_31) - 0.00137248347528156*std::exp(0.654799818992615*x_31) - 0.0067366603237652*std::exp(0.655919849872589*x_31) + 0.00189955075958031*std::exp(0.658159852027893*x_31) - 0.00162667577063925*std::exp(0.659039855003357*x_31) - 0.001630370946437*std::exp(0.666559815406799*x_31) + 0.00351585384743118*std::exp(0.540479838848114*x_45) - 0.0004108505164284*std::exp(1.24111986160278*x_45) - 0.000110118100959031*std::exp(0.629199862480164*x_47) - 0.00434722821682771*std::exp(0.760639846324921*x_49) + 0.00236970634520007*std::exp(1.0195198059082*x_50) + 9.97231658690058e-7*std::exp(1.98231983184814*x_50) + 0.000136411704543858*std::exp(1.29199981689453*x_52) + 0.00107293276235023*std::exp(0.987999796867371*x_6) + 0.00254011298831996*std::exp(0.698879837989807*x_60) - 0.000495986132667058*std::exp(1.37487983703613*x_60) - 0.00580189114247359*std::exp(0.935359835624695*x_66) + 0.0015192376366162*std::exp(0.659359872341156*x_68) - 0.00174903246117503*std::exp(1.31007981300354*x_68) + 0.000995007264181099*std::exp(0.628559827804565*x_70) - 0.00223881675792147*std::exp(0.78551983833313*x_70) + 0.00320149368030341*std::exp(0.799999833106995*x_72) + 0.00124450916507764*std::exp(0.812319874763489*x_72) + 0.00811649163566529*std::exp(0.835599899291992*x_72) - 0.00451306728803203*std::exp(1.06815981864929*x_72) - 0.00123549213098143*std::exp(0.794799864292145*x_73) + 0.0126420764335717*std::exp(0.678079843521118*x_74) - 0.00499566211439345*std::exp(1.16815984249115*x_74) + 0.00106760140574172*std::exp(1.25239992141724*x_74) - 0.000638092565269275*std::exp(1.4819198846817*x_74) - 0.0081742149283215*std::exp(0.930879831314087*x_78) + 0.000469256632256307*std::exp(1.2513599395752*x_81) + 0.0015307112328528*std::exp(1.27559983730316*x_81) + 0.000135670556836702*std::exp(2.05335974693298*x_81) - 0.00215473634821998*std::exp(0.704079866409302*x_87) - 0.000105255433574777*std::exp(0.623999834060669*x_90) - 0.0230563689333406*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.040276315157518*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.0595031484340197*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.000666042556955226*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.00519650266537291*std::sin(0.377599835395813*x_102 + 5.18224000930786) - 0.0346895244071983*std::sin(0.453199863433838*x_102 + 5.23767995834351) + 0.0368249316862697*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.0843051512573956*std::sin(0.323119848966599*x_105 + 1.94975972175598) + 0.0657012241802993*std::sin(0.194159999489784*x_106 - 7.60576009750366) + 0.0348442015828042*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.000344234132475495*std::sin(0.437039852142334*x_108 - 7.37992000579834) + 0.0074919787093636*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 2.62530962583518e-5*std::sin(0.701279819011688*x_109 - 4.15256023406982) - 0.0635831615387911*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0167862197447282*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.000354826073884543*std::sin(0.421359866857529*x_111 - 1.16935980319977) + 0.0397919341907885*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.000460919237225869*std::sin(0.538319826126099*x_112 - 0.998959839344025) + 0.0317176798593815*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.0263033522274949*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00390782902356232*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.0197875027491613*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0621128029332964*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.0254301184291776*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.0183701213857679*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.070367973377139*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.000620749488944039*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.0141396187379423*std::sin(0.243439972400665*x_120 - 7.53664016723633) + 0.0480164783407276*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.0343577933213443*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.000612184944170711*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.000268936964400136*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.000868553028731368*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0957378435270812*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.0291948052298723*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.10432075101983*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.0274488637457183*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.000485194596351781*std::sin(0.427359849214554*x_22 + 5.21424007415771) + 0.0647207447360923*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.000886014202654343*std::sin(0.313599824905396*x_24 + 5.11432027816772) - 0.0757673484437713*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.00867433586566098*std::sin(0.358079850673676*x_24 + 5.16359996795654) + 0.0136448546939235*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.0277193190618624*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.000299890065174736*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.114805332005441*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.0638631805163267*std::sin(0.315679848194122*x_28 + 5.11208009719849) + 0.0241907146443292*std::sin(0.318719834089279*x_28 + 8.29880046844482) + 0.0174344208007584*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.000806507880479356*std::sin(0.329839825630188*x_28 + 5.12192010879517) - 0.00789755345272115*std::sin(0.422799855470657*x_28 + 5.2151198387146) + 0.0250840665672896*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.000918377717858224*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.0132268749167101*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.0909956304033399*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.011878156510393*std::sin(0.327839851379395*x_35 + 5.16975975036621) + 0.0228659286322197*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00402204209517706*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.0244968735822077*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.00056283154961231*std::sin(0.420239865779877*x_36 + 5.22168016433716) - 0.0469336551327915*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.00152202542137496*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.000564556306803517*std::sin(0.482639849185944*x_38 + 5.25967979431152) - 0.0138872855559897*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.00797683042538529*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.0178342128865507*std::sin(0.307359933853149*x_41 + 1.89215993881226) + 0.0290241770290103*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.00629056292378648*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00262273859710295*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.0306902737550197*std::sin(0.351759850978851*x_44 + 5.15248012542725) - 0.176574227532372*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.00889828226842024*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.0356865084423415*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.000927162891024388*std::sin(0.351199835538864*x_53 - 4.25352001190186) - 0.0985355482371285*std::sin(0.285439938306808*x_54 - 1.31799983978271) - 0.00780250262391666*std::sin(0.535439848899841*x_54 - 1.04375982284546) - 0.0186636489532728*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.0058533609606265*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0193027125011523*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.0218586398917934*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.0532143847934874*std::sin(0.140880048274994*x_58 + 4.90823936462402) - 0.216232793250657*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.0122897024126083*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.0520909349832751*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.0110381769924992*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.0217908025887003*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.000763826211230109*std::sin(0.362799853086472*x_59 + 8.34911918640137) - 0.1375853751392*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.00903187987954364*std::sin(0.29351994395256*x_64 + 5.10960006713867) + 0.0242073276935037*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.0364558948065408*std::sin(0.41967985033989*x_65 + 1.98983979225159) + 0.0445389698711586*std::sin(0.245919972658157*x_69 - 7.54095983505249) - 0.0442259512856201*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.0334994058509856*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.0073856659118103*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.0557438013517569*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.00134955788136362*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.00174147839928286*std::sin(0.212719991803169*x_75 - 7.5798397064209) + 0.0558274604421361*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.0140802929342556*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.00997857265644937*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0138064068135809*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.0628922421615951*std::sin(0.381119847297668*x_79 - 7.4282398223877) + 0.0325694964037892*std::sin(0.258879989385605*x_82 + 1.85407984256744) + 0.177134401921601*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.0260985025536452*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.00112377063107954*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0230484662058246*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.00640011876871932*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.000383584637963086*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.00124721633573305*std::sin(0.90479987859726*x_87 + 8.66631984710693) - 0.00526137089080589*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.00162288062553934*std::sin(0.211520001292229*x_89 + 1.78799998760223) - 0.0160763831414835*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0247515865917262*std::sin(0.325839847326279*x_92 + 8.19479942321777) - 0.0226642317122248*std::sin(0.3503198325634*x_92 - 7.3997597694397) - 0.0630983994105603*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.00268926884940317*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.000696751403127724*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.0103495152273518*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.00275818308515*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.0587622965550224*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0372032255033279*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.0131196204798374*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.0183845483521015*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00305355291688756*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.0119600664335973*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0012492411724854*std::sin(0.303999930620193*x_97 + 5.11295986175537) + 0.0200142741659849*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.0156986162404684*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.0190377954734873*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.000550127587580083*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.00437610729505623*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00298986614577555*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.000780521421692128*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 0.0515081592338182*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.0434256623931135*std::sin(0.434639871120453*x_99 + 5.23040008544922) - 0.0330422317482919);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000481205650998726*x_1 + 0.0177004449483892*x_10 + 0.00119021234796438*x_100 - 0.0174102987233092*x_101 + 0.00481761925674433*x_102 + 0.00221349284556212*x_103 - 0.00417855501571912*x_104 - 0.00447152958984071*x_105 - 0.00673897265979044*x_106 - 0.00321023696239105*x_107 + 0.0055836796621502*x_108 + 0.00124150952910561*x_109 - 0.00303789859439404*x_11 - 0.00290426328652797*x_110 - 0.00449932366175726*x_111 - 0.00135479829069577*x_112 + 0.00463929290929947*x_113 + 0.00687844606708709*x_114 + 0.000566967439577631*x_115 + 0.00129675624421719*x_116 + 0.00169278878713151*x_117 - 0.00547203085342908*x_118 - 0.00177750866165916*x_119 - 0.0132821328941016*x_12 - 0.0042521582675126*x_120 + 0.0116392517823973*x_13 + 0.0119451139820848*x_14 - 0.00564057441637577*x_15 - 0.000568430663421538*x_16 + 0.00662579941095893*x_17 - 0.00674027688697069*x_18 - 0.0193528389822008*x_19 + 0.0316802395439165*x_2 + 0.00215777887063879*x_20 - 0.00612295065942072*x_21 - 0.00437991097905645*x_22 + 0.0135523650328442*x_23 + 0.00287756535390402*x_24 + 0.00772141396166781*x_25 - 0.00262483446560516*x_26 - 0.00649980632822134*x_27 - 0.000873521410478278*x_28 - 0.0020515213069865*x_29 - 0.00109650166029348*x_3 - 0.011288146221754*x_30 + 0.031955673649195*x_32 + 0.00470357224201685*x_33 + 0.0143013351336734*x_34 - 0.011320904561671*x_35 - 0.00618117223971247*x_36 - 0.0166779398480396*x_37 + 0.00522264062736899*x_38 - 0.00778696662205201*x_39 + 0.016499445520069*x_4 + 0.00014080544072884*x_40 + 0.00409942852267469*x_41 - 0.00639653741450891*x_42 - 0.0201020545376632*x_43 + 0.0118339078278519*x_44 - 0.00168783605990134*x_45 - 3.72132813938571e-5*x_46 - 0.0203593985352663*x_47 + 0.00947667270921642*x_48 + 0.00723107048114383*x_49 + 0.00168431866525063*x_5 - 0.00107697466596531*x_50 + 0.0179861121094994*x_51 + 0.0136658564430967*x_52 - 0.00686361413795561*x_53 - 0.00377408201411436*x_54 + 0.0041132965030636*x_55 + 0.0088508853213266*x_56 - 0.000501909221916104*x_57 + 0.00257090528586211*x_58 + 0.00239963564274191*x_59 + 0.00537417495189699*x_6 + 0.0193145024368878*x_60 + 0.00369547336289801*x_61 + 0.00193952254261131*x_62 - 0.032048319123678*x_63 + 0.0067870219627538*x_64 - 0.00477440743229361*x_65 - 0.00530130095660327*x_66 + 0.0079129298651173*x_67 + 0.00796134571040465*x_68 - 0.00807338224603889*x_69 + 0.0220636911254676*x_7 + 0.00337248826351073*x_70 + 0.00275858472229575*x_71 + 0.00339629775855628*x_72 - 0.0051503725899499*x_73 - 0.000636878356197376*x_74 + 0.00386687037425005*x_75 - 0.000119199134929653*x_76 - 0.00743288713281569*x_77 + 0.00639236650814917*x_78 + 0.00933733613925661*x_79 - 0.00788191993372656*x_8 - 0.00846640324364218*x_80 - 0.00451144138738226*x_81 + 0.00677706813478122*x_82 + 0.00323493389678958*x_83 + 0.00363009574742501*x_84 + 0.0106885553359679*x_85 + 0.00826773490710866*x_86 - 0.000265665909676536*x_87 + 0.0046566681206787*x_88 - 0.00500145037110536*x_89 - 0.00814914723778339*x_9 + 0.00116890189413084*x_90 - 0.0203377182084943*x_91 - 0.00149601683983665*x_92 + 0.00749274025945894*x_93 + 0.000563015567938108*x_94 - 0.0121374878745524*x_95 - 0.00939640476104057*x_96 - 0.0306013297925065*x_97 + 0.000676167821582631*x_98 - 0.00193950190383773*x_99 - 6.72045317687798e-6*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 5.6366566125682e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 1.22037844474316e-5*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 2.89419814603283e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) + 9.31647236135321e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) + 4.47190484539887e-6*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 7.11225737802934e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) + 3.8932736039555e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 2.33274078646479e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) + 1.07601370219331e-5*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) - 5.55334535848059e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 3.19832139209428e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 1.6170885071501e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.00141962636653913*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 4.75387643611228e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) + 5.35784945894975e-6*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) - 1.21226886920596e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 7.53971394615403e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 0.000216014753732372*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 8.82297606555238e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 0.000283868917096939*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 2.62141506769288e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) - 7.35578956205407e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) + 3.13081980880943e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 4.5660704773261e-5*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) - 2.97072381143653e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 1.26161186042425e-5*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 3.05464676069403e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) + 6.60251148419364e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) - 0.000266933617486399*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 1.80589479951774e-5*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) - 9.38472549422936e-6*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) + 1.83727104444586e-5*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 4.44541606645629e-5*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) - 9.81188072432339e-6*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) + 4.41008640266953e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) + 7.00320859427998e-6*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) - 2.65774283592288e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 3.17870962650501e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) + 1.35275190785871e-5*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) + 2.09926978217023e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 4.58726457508215e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) + 1.39213559236683e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) + 2.09752382263441e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) + 8.51153240920521e-6*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 2.88235492227776e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.000551613073331138*std::exp(0.581919848918915*x_1) + 0.000466442623281683*std::exp(0.848399877548218*x_1) + 0.000450509495677493*std::exp(1.00727987289429*x_1) + 8.37355134641522e-5*std::exp(1.1522399187088*x_1) + 6.44473256810001e-5*std::exp(1.16983985900879*x_1) - 8.43975294879016e-6*std::exp(1.27119994163513*x_1) - 3.51621606214292e-6*std::exp(1.27559983730316*x_1) + 3.66810711544167e-6*std::exp(1.27711987495422*x_1) - 1.53760821104403e-5*std::exp(1.35095977783203*x_1) + 0.000146098047551349*std::exp(1.23759984970093*x_100) - 0.000153524137681284*std::exp(1.47815990447998*x_100) + 0.000355754013512053*std::exp(1.55327987670898*x_100) - 0.00610204491682228*std::exp(0.614959836006165*x_104) - 0.00724822214192366*std::exp(0.876879870891571*x_104) - 0.00131805045608808*std::exp(0.973119854927063*x_104) + 0.00108935910415859*std::exp(0.653039813041687*x_106) - 0.000225657657721792*std::exp(0.848959863185883*x_106) - 0.00288916648822957*std::exp(1.05311989784241*x_106) + 0.0140602882124267*std::exp(0.576079845428467*x_109) - 0.00460256522979525*std::exp(0.711199820041656*x_109) - 0.00305642550670868*std::exp(0.828479886054993*x_109) + 0.000155349275351451*std::exp(1.09879982471466*x_109) - 0.000119939231782236*std::exp(1.26071989536285*x_109) + 0.0120456117961769*std::exp(0.654639840126038*x_110) + 0.000513322960597482*std::exp(0.930479824542999*x_110) - 0.0010796798509969*std::exp(0.998239815235138*x_110) - 0.000278692585162644*std::exp(1.11503982543945*x_110) + 0.000444205490191124*std::exp(1.34391975402832*x_110) - 4.73236566661769e-5*std::exp(1.47463989257813*x_110) - 0.00112585170751122*std::exp(0.405039876699448*x_112) - 0.00247582122517517*std::exp(0.421119838953018*x_112) - 0.000607537142449652*std::exp(0.89711982011795*x_112) + 0.00319990221807934*std::exp(0.700399816036224*x_114) + 0.00262303518108556*std::exp(0.762399852275848*x_114) + 0.00111658772995857*std::exp(1.31567978858948*x_23) + 7.31536361801021e-5*std::exp(1.51271986961365*x_23) - 0.00162057216678666*std::exp(0.536079823970795*x_26) + 0.00258495383884631*std::exp(0.615919828414917*x_26) - 0.0130026541793379*std::exp(0.62095981836319*x_26) + 0.0020552072198132*std::exp(0.629919826984406*x_26) - 0.00136534940836774*std::exp(0.918959856033325*x_26) + 0.000340183236686552*std::exp(1.03471982479095*x_26) + 3.5266545882442e-5*std::exp(1.19559991359711*x_26) - 0.000215168693217228*std::exp(1.30039978027344*x_26) + 0.00294945990915138*std::exp(0.533599853515625*x_31) + 0.00115322985410718*std::exp(0.594959855079651*x_31) + 0.0346435610602693*std::exp(0.643759846687317*x_31) + 0.00958913672388613*std::exp(0.644639849662781*x_31) - 0.00904317247300823*std::exp(0.649439811706543*x_31) - 0.00274186352620006*std::exp(0.654799818992615*x_31) + 0.000883768831979672*std::exp(0.655919849872589*x_31) - 0.00137481715057257*std::exp(0.658159852027893*x_31) + 0.000663310236329538*std::exp(0.659039855003357*x_31) - 0.001399653435185*std::exp(0.666559815406799*x_31) - 0.00447928798880419*std::exp(0.540479838848114*x_45) + 5.3898647634238e-5*std::exp(1.24111986160278*x_45) - 0.00477692706570896*std::exp(0.629199862480164*x_47) + 0.00057030407039843*std::exp(0.760639846324921*x_49) + 0.00203436379536044*std::exp(1.0195198059082*x_50) + 4.32599441843871e-5*std::exp(1.98231983184814*x_50) - 9.87292126835138e-5*std::exp(1.29199981689453*x_52) + 0.00214343943671137*std::exp(0.987999796867371*x_6) - 0.0010357828997011*std::exp(0.698879837989807*x_60) - 0.000990850754237203*std::exp(1.37487983703613*x_60) - 0.00241223781146625*std::exp(0.935359835624695*x_66) - 0.00109956206649448*std::exp(0.659359872341156*x_68) + 0.00222831222096848*std::exp(1.31007981300354*x_68) - 0.000720145563281871*std::exp(0.628559827804565*x_70) - 0.00192199669211635*std::exp(0.78551983833313*x_70) - 0.00130547437173362*std::exp(0.799999833106995*x_72) + 0.00248620427801367*std::exp(0.812319874763489*x_72) + 0.0033745734863364*std::exp(0.835599899291992*x_72) + 0.00544619789994512*std::exp(1.06815981864929*x_72) - 0.00104726729939621*std::exp(0.794799864292145*x_73) + 0.0107160805911649*std::exp(0.678079843521118*x_74) + 0.0060285749756922*std::exp(1.16815984249115*x_74) - 0.000435336256634595*std::exp(1.25239992141724*x_74) - 0.000265298154577544*std::exp(1.4819198846817*x_74) - 0.00339857295577289*std::exp(0.930879831314087*x_78) + 0.000937452193475113*std::exp(1.2513599395752*x_81) + 0.00063641999197341*std::exp(1.27559983730316*x_81) - 0.000163722066295766*std::exp(2.05335974693298*x_81) - 0.00184981469296602*std::exp(0.704079866409302*x_87) - 0.00456598438474114*std::exp(0.623999834060669*x_90) - 0.0195437758130612*std::sin(0.319919854402542*x_100 + 5.12239980697632) + 0.0513130586614618*std::sin(0.251599967479706*x_102 + 1.81823992729187) + 0.00780609760078493*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.0288929493836544*std::sin(0.376959830522537*x_102 + 1.97279977798462) - 0.00376101609884288*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.041861998263926*std::sin(0.453199863433838*x_102 + 5.23767995834351) + 0.0316137516114232*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.0714614248594099*std::sin(0.323119848966599*x_105 + 1.94975972175598) - 0.0267910147337156*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.0420486567946305*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.0149328886898878*std::sin(0.437039852142334*x_108 - 7.37992000579834) + 0.00643177171416729*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.00113886023263189*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.076729740272815*std::sin(0.247359976172447*x_111 - 7.54960012435913) - 0.0213860745477022*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.0153923674781582*std::sin(0.421359866857529*x_111 - 1.16935980319977) + 0.0337297101395826*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.0199946926094317*std::sin(0.538319826126099*x_112 - 0.998959839344025) + 0.0268855528064446*std::sin(0.601279854774475*x_112 - 0.998639822006226) - 0.0107257285669303*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00780682176456329*std::sin(0.308319926261902*x_115 + 5.10927963256836) + 0.00259588243312924*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0526500377903743*std::sin(0.300239950418472*x_116 + 1.90559983253479) - 0.0323986232012771*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.0155714689967078*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.0596475490168609*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.0269281345113735*std::sin(0.366319835186005*x_119 + 5.16383981704712) - 0.0102336777500883*std::sin(0.243439972400665*x_120 - 7.53664016723633) + 0.0412215569726374*std::sin(0.304639935493469*x_120 - 7.47384023666382) - 0.00450732936109095*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.0265566042599718*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.0116664949088668*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.0376778607224075*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0398046844508366*std::sin(0.262479960918427*x_20 - 7.53648042678833) - 0.0371949307554954*std::sin(0.316799849271774*x_20 + 1.92847979068756) - 0.0136856281672382*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.0232670825540896*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.0210477585361817*std::sin(0.427359849214554*x_22 + 5.21424007415771) + 0.0555619645305692*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.0384353270570543*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.0914331534726163*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.017329057545983*std::sin(0.358079850673676*x_24 + 5.16359996795654) - 0.00556396791239586*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.0234963345270022*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.0130092415015711*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.047732326584706*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.0541337487411252*std::sin(0.315679848194122*x_28 + 5.11208009719849) - 0.00986425748593076*std::sin(0.318719834089279*x_28 + 8.29880046844482) + 0.01496723614805*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.0349863400241779*std::sin(0.329839825630188*x_28 + 5.12192010879517) + 0.00103606405176555*std::sin(0.422799855470657*x_28 + 5.2151198387146) + 0.0215343630945111*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.0398392574769625*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.0264238415637741*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.0378330263265783*std::sin(0.309839934110641*x_35 + 8.25224018096924) - 0.0151330760876234*std::sin(0.327839851379395*x_35 + 5.16975975036621) + 0.0196301189178594*std::sin(0.333759844303131*x_35 + 1.99071979522705) - 0.00291098957207965*std::sin(0.293279945850372*x_36 + 1.89527988433838) - 0.0312096453270404*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.0244156522802573*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0566377493858326*std::sin(0.298159927129745*x_37 - 1.32039988040924) + 0.00110157975108602*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.0244904723074526*std::sin(0.482639849185944*x_38 + 5.25967979431152) + 0.0176927580290313*std::sin(0.5204798579216*x_38 + 2.12431979179382) + 0.00325271536597835*std::sin(0.699439823627472*x_38 - 0.933919847011566) + 0.00727226419551354*std::sin(0.307359933853149*x_41 + 1.89215993881226) + 0.0249168995380166*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.0125669017883499*std::sin(0.354479849338531*x_43 + 8.34535980224609) + 0.00189823092990811*std::sin(0.41431987285614*x_43 - 1.17959988117218) + 0.0391001960176512*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.213083059878457*std::sin(0.180400013923645*x_46 + 4.9605598449707) - 0.00644021277744789*std::sin(0.214559987187386*x_48 - 7.58031988143921) + 0.0454655271705711*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.0402203585957513*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.118908950748882*std::sin(0.285439938306808*x_54 - 1.31799983978271) - 0.00669835268131535*std::sin(0.535439848899841*x_54 - 1.04375982284546) + 0.00761048367561407*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.00496161276297004*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0385617782048545*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.0185285184696144*std::sin(0.410559862852097*x_56 - 7.3808798789978) - 0.021699251191052*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.260941508145454*std::sin(0.166080012917519*x_58 - 7.64192008972168) - 0.00889478397303793*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.0216577181328697*std::sin(0.389679849147797*x_58 + 5.19736003875732) + 0.0140629206350319*std::sin(0.510159850120544*x_58 - 4.10351991653442) - 0.0277620414663379*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.0331348077213986*std::sin(0.362799853086472*x_59 + 8.34911918640137) + 0.0180495468734418*std::sin(0.217439994215965*x_64 - 4.37599992752075) - 0.00653690526440652*std::sin(0.29351994395256*x_64 + 5.10960006713867) + 0.0207816935384592*std::sin(0.42399987578392*x_64 - 1.15239989757538) - 0.00478257504809787*std::sin(0.41967985033989*x_65 + 1.98983979225159) - 0.0181616737424586*std::sin(0.245919972658157*x_69 - 7.54095983505249) + 0.056344996403038*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.0283958362964811*std::sin(0.518559873104095*x_70 + 5.33784008026123) - 0.00534544292262*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.0231764612733224*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0585438680297005*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.0755453937856852*std::sin(0.212719991803169*x_75 - 7.5798397064209) + 0.047322255045802*std::sin(0.385759830474854*x_75 - 7.40551996231079) - 0.0018471651296623*std::sin(0.534719824790955*x_75 - 7.24295997619629) - 0.00722208277779959*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0275815949348838*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.0261485506819439*std::sin(0.381119847297668*x_79 - 7.4282398223877) + 0.0279605126817503*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.213759057019096*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.0108509093219062*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.0487492092262826*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0460448158121836*std::sin(0.221039995551109*x_85 - 7.57552003860474) + 0.00815391548445354*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.0166399149923387*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.00249161249793977*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00634922221796398*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0704006182184146*std::sin(0.211520001292229*x_89 + 1.78799998760223) - 0.013801377495411*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0209807303467789*std::sin(0.325839847326279*x_92 + 8.19479942321777) - 0.0194569645890522*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0761447477796287*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.00537245679319518*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.0302251002031884*std::sin(0.379919856786728*x_92 + 8.19079971313477) - 0.00422022600647277*std::sin(0.383839845657349*x_92 - 1.19767987728119) - 0.00199626011084916*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.0244314534964172*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0315353862033493*std::sin(0.365359842777252*x_95 - 7.40423965454102) + 0.00172113645489581*std::sin(0.401599824428558*x_95 + 5.0099196434021) - 0.0234223861931365*std::sin(0.38647985458374*x_96 + 5.19152021408081) - 0.00221003671481011*std::sin(0.427599847316742*x_96 - 1.1937597990036) + 0.00156901690666094*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0541921256947913*std::sin(0.303999930620193*x_97 + 5.11295986175537) - 0.0254986986850525*std::sin(0.351279854774475*x_97 + 5.16311979293823) - 0.020000439784536*std::sin(0.36983984708786*x_98 + 5.1780800819397) + 0.00249752985314065*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.0238645539635867*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.00874231944875782*std::sin(0.439519852399826*x_98 - 7.38319969177246) - 0.00216394283458723*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.0338590465343563*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 0.0436609910051152*std::sin(0.408639848232269*x_99 + 5.2050404548645) - 0.0056969247500452*std::sin(0.434639871120453*x_99 + 5.23040008544922) + 0.325749761493917);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000519466147868813*x_1 + 0.00248148880780464*x_10 + 0.00117269467122962*x_100 + 6.84914223425656e-5*x_101 - 0.00231545987519636*x_102 + 0.00382999824484867*x_103 - 0.0037570215249954*x_104 - 0.00936832302172159*x_105 + 0.000411205370115068*x_106 - 0.00202113625910884*x_107 - 0.00819001610548006*x_108 + 0.00333124851429922*x_109 - 0.00629763016054256*x_11 + 0.00193134879301643*x_110 - 0.00305658500439144*x_111 - 0.00159737728928866*x_112 + 0.00351965066039646*x_113 + 0.0102170243550456*x_114 + 0.00145074709232624*x_115 + 0.00950574816100496*x_116 + 0.00915157463539302*x_117 - 0.00301301121677767*x_118 - 0.0105016865565759*x_119 - 0.0180553218468534*x_12 + 0.000907263385821472*x_120 - 0.00597101662419529*x_13 + 0.00182688738537315*x_14 + 0.000994041602372059*x_15 + 0.000392165705275738*x_16 - 0.00447278632564321*x_17 + 0.000934323229932321*x_18 - 0.00873947329912485*x_19 + 0.0239312014693234*x_2 + 0.00312979706387994*x_20 - 0.00327862541264393*x_21 + 0.0172050320761091*x_22 + 0.00617636896387648*x_23 - 0.00163011295533348*x_24 + 0.00262567632296117*x_25 - 0.000832195480033669*x_26 - 0.00237474512538192*x_27 + 0.000310980331200471*x_28 - 0.0113292115522144*x_29 + 0.00564568193761658*x_3 - 0.00799943934032096*x_30 + 0.0150389526413523*x_32 + 0.00191105310425746*x_33 + 0.00665576243906555*x_34 - 0.0088509468838251*x_35 - 0.00285494801926109*x_36 - 0.0173533585655531*x_37 - 0.0083042325631775*x_38 - 0.00455137192079463*x_39 - 0.0142366877571193*x_4 + 0.00338185327099498*x_40 + 0.00144683691819961*x_41 - 0.00163303922221659*x_42 - 0.00548130649636843*x_43 + 0.00649595813479254*x_44 - 0.00756915510334258*x_45 - 0.00440056218226973*x_46 - 0.00539627640461074*x_47 + 0.00432728687697071*x_48 + 0.00268077696031871*x_49 + 0.000725997352206565*x_5 - 0.00286038886605623*x_50 + 0.00405426646517523*x_51 + 0.0119985721845847*x_52 + 0.00142751162264591*x_53 - 0.0114725471762765*x_54 + 0.00546881929460081*x_55 + 0.000835598703001465*x_56 + 0.00346877600357933*x_57 + 0.00175757459268729*x_58 + 0.00055184447190227*x_59 + 0.0112783105495102*x_6 + 0.01194909556851*x_60 + 0.0170898677493432*x_61 + 0.000266093744091869*x_62 - 0.0157085438351522*x_63 - 0.00160696706412356*x_64 - 0.00394100999012494*x_65 - 0.00861487469669162*x_66 - 0.00560603013400638*x_67 + 0.00874060387341614*x_68 + 0.0040045731391123*x_69 + 0.0101110981567164*x_7 + 0.00245926858343829*x_70 - 0.00104667764140378*x_71 + 0.0010015657045943*x_72 - 0.0045931984640308*x_73 - 0.00571522491001583*x_74 + 0.00050369050032426*x_75 + 0.00490138133541257*x_76 - 0.00564771901177921*x_77 - 0.000618932162621494*x_78 - 0.00325728399159614*x_79 - 0.0127144037493527*x_8 - 0.00946604296473375*x_80 + 0.00807037521142797*x_81 + 0.000180389289575878*x_82 - 0.00446934647169374*x_83 + 0.00700460321928021*x_84 - 0.00226101858397835*x_85 - 0.00273494889225459*x_86 - 1.39155426339768e-5*x_87 + 0.0035854626543946*x_88 - 0.00185359814988232*x_89 - 0.0105047627521306*x_9 - 0.00354347600682868*x_90 - 0.00539197198920576*x_91 + 0.00601301553223976*x_92 - 0.018396582837012*x_93 - 0.014707737157029*x_94 - 0.00556391685363613*x_95 - 0.000870374119380823*x_96 - 0.00663018845803966*x_97 - 0.00441060914736361*x_98 - 0.0050257569722116*x_99 + 4.76983673238074e-6*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 7.08442446771086e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 1.31741031784879e-5*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 3.63756914239563e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 9.1383482302767e-7*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) - 3.17393119688456e-6*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 1.03502601021611e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) + 4.22403916156839e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) + 3.2136354130037e-6*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 1.05544110794351e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 7.1775127521915e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 4.65442355907178e-6*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) + 2.22773697047341e-6*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) + 0.000195570874878805*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 5.97490336121845e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 3.80272973908837e-6*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) - 0.00011736771797904*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 9.47627958044751e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 3.1435995186859e-5*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 3.71825602344933e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 4.13106130825403e-5*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 1.10473974914945e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 9.50711147532979e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 3.07096082609891e-6*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 1.92427350246348e-5*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) - 3.22311118976139e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 1.36192218832012e-5*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) - 4.2081490842624e-6*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 8.53352480625419e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) - 0.000289611819897812*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 1.94948087790491e-5*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 6.66080206312521e-6*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) + 0.000177878286965184*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 1.87342626150541e-5*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) - 9.49952670524867e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 4.32576877921943e-6*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) + 6.78026659036637e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 2.60692873860023e-6*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 3.9951570233227e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) - 1.32688828171315e-6*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 2.71323583519027e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) - 6.31951735608059e-6*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 1.79928859488876e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 2.05742070271652e-6*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 6.04105390897708e-6*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 3.11152997717041e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.000232465623536574*std::exp(0.581919848918915*x_1) - 6.42581696607627e-5*std::exp(0.848399877548218*x_1) + 6.55613289974536e-5*std::exp(1.00727987289429*x_1) + 0.000105242870228969*std::exp(1.1522399187088*x_1) + 6.99226551296877e-5*std::exp(1.16983985900879*x_1) - 8.17107961004714e-5*std::exp(1.27119994163513*x_1) + 2.4956317811871e-6*std::exp(1.27559983730316*x_1) - 4.74090550793519e-6*std::exp(1.27711987495422*x_1) + 1.50821026771255e-6*std::exp(1.35095977783203*x_1) + 0.000158510276200109*std::exp(1.23759984970093*x_100) - 0.00148636809474077*std::exp(1.47815990447998*x_100) + 0.000447128965101674*std::exp(1.55327987670898*x_100) - 0.00257157733385649*std::exp(0.614959836006165*x_104) + 0.000998531148070829*std::exp(0.876879870891571*x_104) + 0.000129285029629588*std::exp(0.973119854927063*x_104) + 0.010546801568742*std::exp(0.653039813041687*x_106) + 0.000291654959555941*std::exp(0.848959863185883*x_106) + 0.000283392774009717*std::exp(1.05311989784241*x_106) + 0.00204615261196142*std::exp(0.576079845428467*x_109) + 0.000451456755208184*std::exp(0.711199820041656*x_109) - 0.00128806566697087*std::exp(0.828479886054993*x_109) - 0.000200783731769173*std::exp(1.09879982471466*x_109) - 0.00116121054396626*std::exp(1.26071989536285*x_109) - 0.00165943018033107*std::exp(0.654639840126038*x_110) + 0.00496981701023415*std::exp(0.930479824542999*x_110) - 0.00117140751883806*std::exp(0.998239815235138*x_110) + 0.000360200825776373*std::exp(1.11503982543945*x_110) - 4.35712606415938e-5*std::exp(1.34391975402832*x_110) + 3.35879307445406e-5*std::exp(1.47463989257813*x_110) + 0.00145512559837433*std::exp(0.405039876699448*x_112) - 0.00104338231398284*std::exp(0.421119838953018*x_112) + 5.95921477056336e-5*std::exp(0.89711982011795*x_112) + 0.00402179290423632*std::exp(0.700399816036224*x_114) - 0.00036135514054546*std::exp(0.762399852275848*x_114) - 0.000153823600613519*std::exp(1.31567978858948*x_23) - 9.45486229755245e-5*std::exp(1.51271986961365*x_23) + 0.00209453521113989*std::exp(0.536079823970795*x_26) + 0.00280456689071117*std::exp(0.615919828414917*x_26) - 0.00189223822510047*std::exp(0.62095981836319*x_26) + 0.00258308449760731*std::exp(0.629919826984406*x_26) - 0.0014739078732507*std::exp(0.918959856033325*x_26) - 3.33679182244986e-5*std::exp(1.03471982479095*x_26) + 0.000341438612866176*std::exp(1.19559991359711*x_26) + 2.96421161024291e-5*std::exp(1.30039978027344*x_26) - 0.000289306839495101*std::exp(0.533599853515625*x_31) + 0.00144943542899433*std::exp(0.594959855079651*x_31) + 0.00504157609574923*std::exp(0.643759846687317*x_31) - 0.00132102072955631*std::exp(0.644639849662781*x_31) - 0.00381105312640887*std::exp(0.649439811706543*x_31) - 0.00295986815820023*std::exp(0.654799818992615*x_31) + 0.00855634700067784*std::exp(0.655919849872589*x_31) + 0.00177690508930747*std::exp(0.658159852027893*x_31) - 0.000470783955625829*std::exp(0.659039855003357*x_31) - 0.00151856548608309*std::exp(0.666559815406799*x_31) + 0.000439364728168881*std::exp(0.540479838848114*x_45) + 0.000521828237586468*std::exp(1.24111986160278*x_45) - 0.00600387451478256*std::exp(0.629199862480164*x_47) + 0.00552148859028806*std::exp(0.760639846324921*x_49) + 0.00220719970251996*std::exp(1.0195198059082*x_50) + 5.43712040872475e-5*std::exp(1.98231983184814*x_50) + 0.000127604198425655*std::exp(1.29199981689453*x_52) + 0.0023138635738538*std::exp(0.987999796867371*x_6) + 0.000735146156328297*std::exp(0.698879837989807*x_60) - 0.00106963295910644*std::exp(1.37487983703613*x_60) - 0.00101658643362931*std::exp(0.935359835624695*x_66) + 0.00142114711847302*std::exp(0.659359872341156*x_68) - 0.000218570852262299*std::exp(1.31007981300354*x_68) + 0.000930764004438573*std::exp(0.628559827804565*x_70) - 0.0020852860912873*std::exp(0.78551983833313*x_70) + 0.000926559481568986*std::exp(0.799999833106995*x_72) + 0.00268388153055614*std::exp(0.812319874763489*x_72) + 0.00142214238131418*std::exp(0.835599899291992*x_72) + 0.000792569248216583*std::exp(1.06815981864929*x_72) + 0.000144273864449414*std::exp(0.794799864292145*x_73) - 0.0014762710146016*std::exp(0.678079843521118*x_74) + 0.000877320880379654*std::exp(1.16815984249115*x_74) + 0.000308979590093277*std::exp(1.25239992141724*x_74) - 0.000111804277144005*std::exp(1.4819198846817*x_74) - 0.00143225644839641*std::exp(0.930879831314087*x_78) + 0.00101198869702587*std::exp(1.2513599395752*x_81) + 0.000268205699643429*std::exp(1.27559983730316*x_81) - 2.38259933598462e-5*std::exp(2.05335974693298*x_81) - 0.00200697163867304*std::exp(0.704079866409302*x_87) - 0.00573875148298374*std::exp(0.623999834060669*x_90) + 0.00269239387509661*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.00503319905455013*std::sin(0.251599967479706*x_102 + 1.81823992729187) + 0.0755759621482227*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.0363140655227232*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.00486098725508189*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.00609205414537325*std::sin(0.453199863433838*x_102 + 5.23767995834351) + 0.0342995993693007*std::sin(0.319119840860367*x_105 + 1.92935979366302) - 0.00984468428401479*std::sin(0.323119848966599*x_105 + 1.94975972175598) + 0.0190149031339573*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.00611921801530077*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.0187683815566057*std::sin(0.437039852142334*x_108 - 7.37992000579834) + 0.00697820352808191*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.00143137498909733*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0111662546387621*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0020977188458827*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.0193458768687661*std::sin(0.421359866857529*x_111 - 1.16935980319977) - 0.0046466796312668*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.0251303031713468*std::sin(0.538319826126099*x_112 - 0.998959839344025) - 0.00370381334687035*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.00761257801424875*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00842753949526422*std::sin(0.308319926261902*x_115 + 5.10927963256836) + 0.0251324442174134*std::sin(0.497439861297607*x_115 - 4.12024021148682) + 0.00725318590564641*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.00317791852442944*std::sin(0.395679831504822*x_117 + 1.99599981307983) + 0.00214516008339465*std::sin(0.631359875202179*x_117 - 3.99463987350464) - 0.00821717856230191*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.0338445905285091*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.0132266855042442*std::sin(0.243439972400665*x_120 - 7.53664016723633) + 0.0447236666789455*std::sin(0.304639935493469*x_120 - 7.47384023666382) - 0.0436384184011649*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.0333776332195156*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.014663018818729*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.047355369812249*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0167748395350041*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.00364837909093926*std::sin(0.316799849271774*x_20 + 1.92847979068756) - 0.132499562423847*std::sin(0.22495998442173*x_21 + 5.03143978118896) - 0.00320532486450917*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.0264538476996662*std::sin(0.427359849214554*x_22 + 5.21424007415771) + 0.0602824095980182*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.0483073903810866*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.0133059993487554*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.0187068849896623*std::sin(0.358079850673676*x_24 + 5.16359996795654) + 0.00394902216083328*std::sin(0.361039847135544*x_24 - 7.44112014770508) + 0.00323690712443825*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.0163506481119662*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.0201157760735376*std::sin(0.301519840955734*x_27 - 4.31599998474121) - 0.00745758521489073*std::sin(0.315679848194122*x_28 + 5.11208009719849) + 0.00700114954389311*std::sin(0.318719834089279*x_28 + 8.29880046844482) + 0.0162388257443742*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.043972535554194*std::sin(0.329839825630188*x_28 + 5.12192010879517) + 0.010030817133454*std::sin(0.422799855470657*x_28 + 5.2151198387146) + 0.0233638840430409*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.0500719184872664*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.0285247921767775*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.0159439260606574*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.00148437427515633*std::sin(0.327839851379395*x_35 + 5.16975975036621) + 0.0212978586891605*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00376235645838075*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.00306129397565773*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.0306867805329311*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.00824232598155512*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.00142375490818369*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.030780817985941*std::sin(0.482639849185944*x_38 + 5.25967979431152) - 0.00173544854481625*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.00230861235459576*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.00516148419970869*std::sin(0.307359933853149*x_41 + 1.89215993881226) + 0.027033794729072*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.0135660918550957*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00245339985657717*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.00383526288945568*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.0310093543565979*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.00832375916732218*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.00445962595758119*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.0505509049283776*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.017304471749404*std::sin(0.285439938306808*x_54 - 1.31799983978271) - 0.00726743273709978*std::sin(0.535439848899841*x_54 - 1.04375982284546) - 0.00540153522860965*std::sin(0.350959837436676*x_55 + 5.14120006561279) - 0.000683522771720195*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.041627812012333*std::sin(0.202319994568825*x_56 + 1.78511989116669) + 0.00255252977312937*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.0154010276795528*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.0379740543290629*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.0114962101712212*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.0091271856914721*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.00137940478877779*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.00272312515577439*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.0416454396088211*std::sin(0.362799853086472*x_59 + 8.34911918640137) + 0.174749528005215*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.00844873096601048*std::sin(0.29351994395256*x_64 + 5.10960006713867) + 0.022547269028557*std::sin(0.42399987578392*x_64 - 1.15239989757538) - 0.0463032528276016*std::sin(0.41967985033989*x_65 + 1.98983979225159) + 0.0128902346699389*std::sin(0.245919972658157*x_69 - 7.54095983505249) - 0.00552677213212771*std::sin(0.261439949274063*x_70 - 7.51576042175293) - 0.00391187334802511*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.00690880582181443*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.00976722775756233*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0735807837183603*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.0949491290572537*std::sin(0.212719991803169*x_75 - 7.5798397064209) - 0.00651921874563912*std::sin(0.385759830474854*x_75 - 7.40551996231079) - 0.0178836198392956*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.0093342999379426*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0297745981227888*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.0110197517657576*std::sin(0.381119847297668*x_79 - 7.4282398223877) + 0.0303359877983528*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.0311077302429311*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.00457288545795847*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.0612703796527492*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0497058233826671*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.000799801858977004*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.0209138553250704*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.00268971975620043*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.000923983735534555*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0884829246359334*std::sin(0.211520001292229*x_89 + 1.78799998760223) - 0.0149739178271405*std::sin(0.355119854211807*x_90 - 1.06399977207184) + 0.00289035191669409*std::sin(0.325839847326279*x_92 + 8.19479942321777) - 0.0211099934784715*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0110811223925502*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.00579961899691016*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.037988377532354*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.00299530232483127*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.00258009928743766*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.0102961175967996*std::sin(0.351119846105576*x_95 - 1.22583997249603) + 0.00434438470205747*std::sin(0.365359842777252*x_95 - 7.40423965454102) + 0.0166634533949527*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.00229745673163589*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00285639838320825*std::sin(0.427599847316742*x_96 - 1.1937597990036) + 0.0151906840539382*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0681113020746032*std::sin(0.303999930620193*x_97 + 5.11295986175537) + 0.00250111822334718*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.00196180460179268*std::sin(0.36983984708786*x_98 + 5.1780800819397) + 0.0241802282392721*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.0299941333367137*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.00943741828064452*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00279682358788375*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.0425556982106211*std::sin(0.407759845256805*x_99 - 4.20120000839233) + 0.00601483489614424*std::sin(0.408639848232269*x_99 + 5.2050404548645) - 0.0551556733325234*std::sin(0.434639871120453*x_99 + 5.23040008544922) - 0.370973006011556);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.82206055201589e-5*x_1 + 0.000335674921818822*x_10 - 0.00769853712640736*x_100 - 0.011545965542121*x_101 - 0.00100385153109922*x_102 + 0.0107108231266498*x_103 - 0.0025869657808721*x_104 - 0.00443783484649474*x_105 + 0.000771172348277347*x_106 - 0.0127408238459386*x_107 + 0.00384690025594999*x_108 - 9.2880145508196e-5*x_109 + 0.00496904545378454*x_11 - 0.00631200435522189*x_110 + 0.00436527737943378*x_111 + 0.00657162747302446*x_112 + 0.0155901672726207*x_113 - 0.0020794626757934*x_114 - 0.00159083683054426*x_115 + 0.0105204347819727*x_116 + 0.00197421618638737*x_117 - 0.012732809782658*x_118 + 0.0103984347104476*x_119 + 0.00506856910895006*x_12 + 0.0013250837422725*x_120 - 0.00272937952737851*x_13 - 0.00995207768738313*x_14 + 0.00142107335923574*x_15 - 0.0052183273741087*x_16 + 0.0126973001165725*x_17 - 0.0132528782282264*x_18 - 0.016271650184464*x_19 - 0.011399093589535*x_2 + 0.0070761739088143*x_20 + 0.000477815517739299*x_21 - 0.00307700271354953*x_22 + 0.0130128502575235*x_23 - 0.00163210848179988*x_24 + 0.0124539851417306*x_25 + 0.000932134126233866*x_26 + 0.00242950429749701*x_27 - 0.00100286967341344*x_28 + 0.00991470755437574*x_29 + 0.00140236860969464*x_3 + 0.00690872451268081*x_30 + 0.0179036746994574*x_32 - 0.00446478438116443*x_33 + 0.0129366978597634*x_34 - 0.0120666266919798*x_35 - 0.00299475270529219*x_36 + 0.0143364772900667*x_37 + 0.00953217942911571*x_38 + 0.0137853992033114*x_39 + 0.0085038919860168*x_4 - 0.0117743633438649*x_40 - 0.00040865009852751*x_41 - 0.0157600840723877*x_42 - 0.00631276650143698*x_43 - 0.0144607918380248*x_44 - 0.00451300289381984*x_45 + 0.00254345971622589*x_46 - 0.00536358803999106*x_47 + 0.0163875394170095*x_48 - 0.0219960755553607*x_49 - 0.00820167605353945*x_5 - 0.014556561404706*x_50 + 0.00294023063080785*x_51 + 0.0135303491881388*x_52 + 0.000844734321106291*x_53 + 0.00816859471425743*x_54 + 0.00224695334096218*x_55 + 0.00663479884263803*x_56 + 0.0160878946806169*x_57 - 0.00111856672231709*x_58 + 0.000698766113107807*x_59 - 0.00335540562912943*x_6 + 0.00424995949070042*x_60 - 0.00764795754331872*x_61 + 0.0108628317720676*x_62 + 0.00403773175030359*x_63 - 0.00604519532923947*x_64 + 0.00988245980226849*x_65 + 0.00718794918476526*x_66 + 0.00974539242654988*x_67 - 0.00372958843238466*x_68 - 0.00811381063545905*x_69 + 0.0032680802305442*x_7 + 0.000758225790300444*x_70 + 0.00697756604587146*x_71 - 0.00192573543475514*x_72 + 0.00202827347837676*x_73 + 0.00249275302224078*x_74 - 0.00242316893303453*x_75 + 0.00687182878420254*x_76 - 0.000166203854236857*x_77 + 0.000730382344028394*x_78 + 0.0127846536208246*x_79 - 0.0160629169235277*x_8 + 0.0092314806797688*x_80 - 0.00266276764613983*x_81 + 0.000341871762923112*x_82 - 0.00304265901969064*x_83 + 0.00146655457210445*x_84 - 0.00332530765138566*x_85 - 0.00190099134514626*x_86 + 0.000423300477674979*x_87 - 0.00380468364628321*x_88 - 0.00852279386718579*x_89 + 0.00330028431370777*x_9 - 0.00322517022703489*x_90 - 0.0123897419919335*x_91 - 0.000493310506793035*x_92 + 0.0214677826929602*x_93 + 0.000440970164702795*x_94 + 0.00755865779707852*x_95 + 0.00279455939543092*x_96 - 0.0218870095680382*x_97 + 0.00640868337830642*x_98 - 0.000356346724248689*x_99 + 3.78189974037563e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) + 2.4661182234163e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) - 1.22291555485954e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) - 1.26625325626449e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 6.96547952625373e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) - 2.51654097256209e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 8.00626582073049e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 3.57480268935292e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) + 2.78725214924506e-6*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 8.04483834856492e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) - 5.37659592852221e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 3.60034935242047e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) + 1.93216213444109e-6*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) + 0.000169622645783017*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) + 2.07988921745302e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 3.01510165229467e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 4.02648289762311e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) - 3.29873313916221e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 0.000243167738125389*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 1.59565740636825e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 0.000319551147789133*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 4.74089506403709e-6*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) - 7.12167273191648e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 2.34076380338063e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 8.25785326970468e-6*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 2.72771773852693e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) - 1.26423469289708e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) - 3.64981432927734e-6*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) + 6.39236965691781e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 0.000245098369839611*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) - 1.80964917094629e-6*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 5.28120499853116e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 6.10239248625178e-5*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 8.03964673385441e-6*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 3.25896102206133e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 3.29721007644815e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 2.32607636388662e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 1.98706684157215e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) - 1.39073111521356e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) - 1.01138771767063e-5*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) + 2.03245514821976e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) - 5.48104749582146e-6*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) + 1.34782731393429e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 1.5682179558645e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 4.78982017452666e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) + 2.88834720431436e-6*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 9.97606113142364e-5*std::exp(0.581919848918915*x_1) - 5.57324333584285e-5*std::exp(0.848399877548218*x_1) + 0.000507138392980464*std::exp(1.00727987289429*x_1) - 3.66354897760891e-5*std::exp(1.1522399187088*x_1) - 5.91755156719461e-5*std::exp(1.16983985900879*x_1) + 2.80321649525871e-5*std::exp(1.27119994163513*x_1) + 1.97873212751117e-5*std::exp(1.27559983730316*x_1) + 3.5513602178819e-6*std::exp(1.27711987495422*x_1) + 1.14959590905405e-5*std::exp(1.35095977783203*x_1) - 0.00013414718471498*std::exp(1.23759984970093*x_100) + 0.000509921792474076*std::exp(1.47815990447998*x_100) - 0.000155647490361459*std::exp(1.55327987670898*x_100) - 0.00110357016648096*std::exp(0.614959836006165*x_104) + 0.000866046620374778*std::exp(0.876879870891571*x_104) + 0.000985443106613519*std::exp(0.973119854927063*x_104) - 0.00361824502277091*std::exp(0.653039813041687*x_106) - 0.000218475525188443*std::exp(0.848959863185883*x_106) + 0.00216009120632204*std::exp(1.05311989784241*x_106) + 0.0158276618746273*std::exp(0.576079845428467*x_109) + 0.00344111726337258*std::exp(0.711199820041656*x_109) - 0.000552762238110775*std::exp(0.828479886054993*x_109) + 0.000150404887043081*std::exp(1.09879982471466*x_109) + 0.000398371415609764*std::exp(1.26071989536285*x_109) - 0.00143925795624924*std::exp(0.654639840126038*x_110) - 0.0017049733555864*std::exp(0.930479824542999*x_110) + 0.000991361724761016*std::exp(0.998239815235138*x_110) - 0.000269822480319282*std::exp(1.11503982543945*x_110) - 0.000332111138998362*std::exp(1.34391975402832*x_110) + 0.000266311393218549*std::exp(1.47463989257813*x_110) - 0.0010900185952744*std::exp(0.405039876699448*x_112) - 0.000447758493896258*std::exp(0.421119838953018*x_112) + 0.000454226381299228*std::exp(0.89711982011795*x_112) - 0.00140000317840192*std::exp(0.700399816036224*x_114) - 0.000313410752212459*std::exp(0.762399852275848*x_114) - 0.000133414375407915*std::exp(1.31567978858948*x_23) + 7.08253344701301e-5*std::exp(1.51271986961365*x_23) - 0.00156899330968416*std::exp(0.536079823970795*x_26) - 0.0023735038620385*std::exp(0.615919828414917*x_26) - 0.0146370835870476*std::exp(0.62095981836319*x_26) - 0.000899182676194429*std::exp(0.629919826984406*x_26) + 0.000136818790638553*std::exp(0.918959856033325*x_26) - 0.000254338689410412*std::exp(1.03471982479095*x_26) - 0.000117135849530561*std::exp(1.19559991359711*x_26) + 2.57092175049952e-5*std::exp(1.30039978027344*x_26) - 0.0022051697052119*std::exp(0.533599853515625*x_31) - 0.00050455462421821*std::exp(0.594959855079651*x_31) + 0.0389982454349925*std::exp(0.643759846687317*x_31) - 0.00114574847313237*std::exp(0.644639849662781*x_31) - 0.00163548048032902*std::exp(0.649439811706543*x_31) + 0.000274756373314816*std::exp(0.654799818992615*x_31) - 0.00293538849162176*std::exp(0.655919849872589*x_31) - 0.00133106007587711*std::exp(0.658159852027893*x_31) - 0.00373274352865672*std::exp(0.659039855003357*x_31) + 0.00128516137657983*std::exp(0.666559815406799*x_31) + 0.00334894878319351*std::exp(0.540479838848114*x_45) - 0.000179021328037916*std::exp(1.24111986160278*x_45) + 0.00208997419896188*std::exp(0.629199862480164*x_47) - 0.0018942329084209*std::exp(0.760639846324921*x_49) - 0.00186795224445259*std::exp(1.0195198059082*x_50) - 1.89268468934604e-5*std::exp(1.98231983184814*x_50) - 9.55869027900005e-5*std::exp(1.29199981689453*x_52) - 0.000214789554776622*std::exp(0.987999796867371*x_6) + 0.00582881388556132*std::exp(0.698879837989807*x_60) + 9.92910686943503e-5*std::exp(1.37487983703613*x_60) - 0.000436259273649823*std::exp(0.935359835624695*x_66) - 0.001064565689372*std::exp(0.659359872341156*x_68) - 0.00166600216812133*std::exp(1.31007981300354*x_68) - 0.000697225087500054*std::exp(0.628559827804565*x_70) + 0.00176477680297742*std::exp(0.78551983833313*x_70) + 0.00734648848460547*std::exp(0.799999833106995*x_72) - 0.000249137298125674*std::exp(0.812319874763489*x_72) + 0.000610300100192947*std::exp(0.835599899291992*x_72) + 0.00613078320730661*std::exp(1.06815981864929*x_72) + 0.000125131692642962*std::exp(0.794799864292145*x_73) - 0.00128040024131753*std::exp(0.678079843521118*x_74) + 0.0067863648923472*std::exp(1.16815984249115*x_74) + 0.00244983192741671*std::exp(1.25239992141724*x_74) - 4.79798383337203e-5*std::exp(1.4819198846817*x_74) - 0.000614640464585951*std::exp(0.930879831314087*x_78) - 9.39401113053237e-5*std::exp(1.2513599395752*x_81) + 0.000115098155793265*std::exp(1.27559983730316*x_81) - 0.000184301876860137*std::exp(2.05335974693298*x_81) + 0.00169849931237842*std::exp(0.704079866409302*x_87) + 0.00199768374641398*std::exp(0.623999834060669*x_90) + 0.00233516863319698*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.0383643127648321*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.0259275143370833*std::sin(0.301519930362701*x_102 - 7.51344013214111) - 0.0126410803248861*std::sin(0.376959830522537*x_102 + 1.97279977798462) - 0.00364131213508352*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.0471240378509496*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.029027737523053*std::sin(0.319119840860367*x_105 + 1.92935979366302) - 0.00853849734111942*std::sin(0.323119848966599*x_105 + 1.94975972175598) + 0.150765028784723*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.0473341592983459*std::sin(0.520639836788177*x_106 + 5.37607955932617) - 0.00653335327262391*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.00590565091488804*std::sin(0.505919814109802*x_109 - 7.33463954925537) + 0.000498267708441791*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0863746437070001*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0159893421706366*std::sin(0.303439915180206*x_111 - 7.50184011459351) - 0.00673438184166963*std::sin(0.421359866857529*x_111 - 1.16935980319977) - 0.00403016090023611*std::sin(0.45007985830307*x_111 - 1.17727982997894) + 0.00874796518662865*std::sin(0.538319826126099*x_112 - 0.998959839344025) - 0.00321239356203691*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.0603584743692198*std::sin(0.307359933853149*x_115 - 7.4868803024292) - 0.00078230517844894*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.00862207756607775*std::sin(0.497439861297607*x_115 - 4.12024021148682) + 0.00629083744925849*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.0242228965894261*std::sin(0.395679831504822*x_117 + 1.99599981307983) + 0.00186054150035892*std::sin(0.631359875202179*x_117 - 3.99463987350464) - 0.00712692812502315*std::sin(0.284639924764633*x_119 + 8.28767967224121) + 0.0117814455989801*std::sin(0.366319835186005*x_119 + 5.16383981704712) - 0.00990796476234056*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.0378496216077351*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.0149708410794007*std::sin(0.403279840946198*x_120 + 5.21072006225586) - 0.0116188957779587*std::sin(0.44735985994339*x_120 - 4.16968011856079) - 0.00510425908046247*std::sin(0.387359857559204*x_16 + 5.19464015960693) + 0.0164846052072231*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.00719877726973658*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.0278088656960494*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.0454560445775593*std::sin(0.22495998442173*x_21 + 5.03143978118896) - 0.00278004423945571*std::sin(0.440559864044189*x_21 - 0.9790398478508) + 0.00920869665404257*std::sin(0.427359849214554*x_22 + 5.21424007415771) - 0.051016979651215*std::sin(0.266799956560135*x_24 + 5.06759977340698) - 0.0168160076075985*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.102926271171059*std::sin(0.329199820756912*x_24 + 8.31216049194336) + 0.00173650838519183*std::sin(0.358079850673676*x_24 + 5.16359996795654) + 0.031310937297719*std::sin(0.361039847135544*x_24 - 7.44112014770508) + 0.00280743618364115*std::sin(0.428159862756729*x_24 + 8.42472076416016) + 0.00569172999971532*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.00863251128328949*std::sin(0.301519840955734*x_27 - 4.31599998474121) - 0.0064681171779079*std::sin(0.315679848194122*x_28 + 5.11208009719849) + 0.0555105910913741*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.0137429118723814*std::sin(0.319759845733643*x_28 - 4.27544021606445) + 0.0153070262452892*std::sin(0.329839825630188*x_28 + 5.12192010879517) - 0.00344122850239366*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.0197728459221436*std::sin(0.287599951028824*x_3 + 5.07695960998535) - 0.0174302473299943*std::sin(0.352799862623215*x_34 + 2.00847983360291) - 0.00264787755033513*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.00684219794033296*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.0113142751429008*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.0180243694736959*std::sin(0.333759844303131*x_35 + 1.99071979522705) - 0.00281833987819845*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.0233339548613832*std::sin(0.366399854421616*x_36 + 5.18304014205933) + 0.0106821985378145*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0637570960904307*std::sin(0.298159927129745*x_37 - 1.32039988040924) + 0.00106651915598711*std::sin(0.472239851951599*x_37 + 5.05007982254028) - 0.010714933374301*std::sin(0.482639849185944*x_38 + 5.25967979431152) - 0.0132280265570689*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.0183044849422254*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.0409242849389694*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.0228786898995081*std::sin(0.390639841556549*x_41 - 1.18031990528107) - 0.00125930277936035*std::sin(0.354479849338531*x_43 + 8.34535980224609) + 0.00183781487199479*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.0292333411477966*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.239867531306109*std::sin(0.180400013923645*x_46 + 4.9605598449707) - 0.0062352365219218*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.0339923939420077*std::sin(0.181600004434586*x_53 - 4.43544006347656) - 0.0175969845429573*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.133855767242141*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00615042548128969*std::sin(0.535439848899841*x_54 - 1.04375982284546) - 0.0428275973054376*std::sin(0.350959837436676*x_55 + 5.14120006561279) - 0.000592833370837908*std::sin(0.565759837627411*x_55 - 4.23424005508423) + 0.00386419463510638*std::sin(0.202319994568825*x_56 + 1.78511989116669) + 0.00221386161833369*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.122111396785162*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.293741770978159*std::sin(0.166080012917519*x_58 - 7.64192008972168) - 0.00861168470667654*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.00391685278153204*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.0105141712402845*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.0207563468167361*std::sin(0.271919965744019*x_59 + 5.07471990585327) + 0.0144969542705397*std::sin(0.362799853086472*x_59 + 8.34911918640137) - 0.0599505552290253*std::sin(0.217439994215965*x_64 - 4.37599992752075) - 0.00632885152299616*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.0190817449549691*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.0158850541550064*std::sin(0.41967985033989*x_65 + 1.98983979225159) + 0.102203865429354*std::sin(0.245919972658157*x_69 - 7.54095983505249) - 0.0421264512606996*std::sin(0.261439949274063*x_70 - 7.51576042175293) - 0.00339284828413885*std::sin(0.518559873104095*x_70 + 5.33784008026123) - 0.00517531051981431*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.00419152129728332*std::sin(0.443199843168259*x_73 - 4.15879964828491) - 0.0256137830882592*std::sin(0.204799994826317*x_74 + 1.79047989845276) - 0.0330521947877102*std::sin(0.212719991803169*x_75 - 7.5798397064209) - 0.00565425262201653*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.00613525513407159*std::sin(0.534719824790955*x_75 - 7.24295997619629) - 0.00699222150829672*std::sin(0.273359954357147*x_76 - 7.51168012619019) + 0.00276389357899574*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.00472903113999629*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.0256733346017235*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.240628501067795*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.00196241423491222*std::sin(0.367759823799133*x_84 - 7.4172797203064) + 0.0213284791878237*std::sin(0.203360006213188*x_85 - 7.59999990463257) + 0.00461405408460916*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.00609629151065445*std::sin(0.699679851531982*x_86 - 7.12943983078003) + 0.00728020179678952*std::sin(0.534559845924377*x_87 + 5.3407998085022) - 0.000249679244462093*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00714731738884183*std::sin(1.34551978111267*x_87 + 8.78791999816895) - 0.0308012815861604*std::sin(0.211520001292229*x_89 + 1.78799998760223) + 0.0126724207970497*std::sin(0.355119854211807*x_90 - 1.06399977207184) + 0.00250686171781706*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.0178653792194111*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0857161178473975*std::sin(0.358079850673676*x_92 - 1.18679988384247) + 0.000538362588138951*std::sin(0.375759840011597*x_92 - 7.39687967300415) + 0.0132239154411972*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.023749100273652*std::sin(0.383839845657349*x_92 - 1.19767987728119) - 0.00193272402334428*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.00441848979644248*std::sin(0.351119846105576*x_95 - 1.22583997249603) + 0.00376797428512252*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.00571665797592647*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.0175117947176095*std::sin(0.38647985458374*x_96 + 5.19152021408081) - 0.00213969663971768*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.00521140144833535*std::sin(0.438799858093262*x_96 - 1.18743991851807) + 0.0237098333156577*std::sin(0.303999930620193*x_97 + 5.11295986175537) + 0.0190641539788831*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.0149533695192566*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.00829540500084018*std::sin(0.384079843759537*x_98 + 8.38000011444092) + 0.0104410851092254*std::sin(0.414159864187241*x_98 - 7.39120006561279) - 0.000876049432492803*std::sin(0.439519852399826*x_98 - 7.38319969177246) - 0.00209506981521131*std::sin(0.446799844503403*x_98 - 1.14799976348877) - 0.0148138191529521*std::sin(0.407759845256805*x_99 - 4.20120000839233) + 0.00521679012615888*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.0189220152870275*std::sin(0.434639871120453*x_99 + 5.23040008544922) + 1.53069872312255);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000678998876948912*x_1 + 0.00884905136234178*x_10 - 0.00437692429039391*x_100 - 0.00576205352800787*x_101 + 0.00337253475102299*x_102 + 0.0070003649174671*x_103 - 0.00616159400231369*x_104 - 0.0160460246083306*x_105 + 0.00236633703715722*x_106 - 0.0221637146716254*x_107 - 0.00204884113435324*x_108 - 0.00339835925868488*x_109 - 0.00196638858249907*x_11 - 0.00305807333171117*x_110 + 0.00109053848569252*x_111 - 0.0021752560372042*x_112 + 0.0144625357568647*x_113 + 0.00335584562833165*x_114 - 0.000146753868908683*x_115 + 0.003227731328848*x_116 + 0.00549907182321852*x_117 - 0.0136587061907028*x_118 - 0.00745265057498828*x_119 - 0.022251322313656*x_12 - 0.00827697565511773*x_120 - 0.00866190378988358*x_13 - 0.0108449681980452*x_14 - 0.00107434939036652*x_15 - 0.00915605884371125*x_16 - 0.00437290142571251*x_17 + 0.00101162013487032*x_18 - 0.00593645936858459*x_19 + 0.0300114041973379*x_2 - 0.00226498778777621*x_20 - 0.00199202261493756*x_21 + 0.00581305765466939*x_22 + 0.0136714427696678*x_23 + 0.00041564539947699*x_24 + 0.00483060713042839*x_25 - 0.000705321746389582*x_26 - 0.00332217624153137*x_27 - 0.00121930589015737*x_28 - 0.00854148860051994*x_29 - 0.00440589007801491*x_3 - 0.00641728347308139*x_30 + 0.0197649015085059*x_32 + 0.00735294799393589*x_33 + 0.0225220756806196*x_34 - 0.0121486728515083*x_35 - 0.00630225643978216*x_36 - 0.00428455595320617*x_37 + 0.00664305268422525*x_38 - 0.00612081266248155*x_39 - 0.00312598245538145*x_4 - 0.0126221245523348*x_40 + 0.00295613876770065*x_41 - 0.00420323797196879*x_42 - 0.0141949280442135*x_43 - 0.00704018116377101*x_44 - 0.0056028274207343*x_45 - 0.00838658463402468*x_46 - 0.00732551757942879*x_47 + 0.023672957394641*x_48 - 0.0118508377438786*x_49 - 0.00771826045375668*x_5 - 0.0110656420761098*x_50 + 0.00760052566297981*x_51 + 0.0147859828534344*x_52 - 0.00249187517606303*x_53 - 0.00839461212328508*x_54 + 0.00810799244595513*x_55 + 0.00624103417551301*x_56 + 0.0145408468469874*x_57 + 0.000423578847866641*x_58 + 0.00271629197323612*x_59 + 0.00630796153766666*x_6 + 0.0107116706620402*x_60 - 0.00113177503798014*x_61 + 0.0117595406375753*x_62 - 0.0151341773047979*x_63 - 0.00015729389047042*x_64 + 0.0133929638437246*x_65 - 0.0073668414793259*x_66 + 0.00395374260236288*x_67 + 0.00306999980785352*x_68 - 0.00268323840123922*x_69 + 0.0133219989602738*x_7 + 0.00166590624058932*x_70 - 0.00139725425980979*x_71 + 0.00173577023603586*x_72 - 0.00294440693527416*x_73 - 0.00282964523433123*x_74 - 0.000244207943897432*x_75 - 0.00539722108848575*x_76 - 0.0158749413059264*x_77 - 0.00856407289824563*x_78 + 0.00656927822202426*x_79 - 0.034432820443267*x_8 - 0.0122075747788076*x_80 + 0.00743758810953659*x_81 - 0.00660023115177126*x_82 + 0.000860403421936431*x_83 + 0.00109279211003275*x_84 + 0.000188670882822028*x_85 - 0.0109043775262936*x_86 + 0.000380456290570777*x_87 + 0.000808257104271717*x_88 - 0.0122294357613163*x_89 - 0.0177282225831531*x_9 - 0.0110652218109396*x_90 - 0.0454794852281709*x_91 + 0.00386725985526778*x_92 - 0.0321432949077809*x_93 - 0.0261578062093388*x_94 - 0.00573986289600816*x_95 - 0.00143813220160864*x_96 - 0.0299698175542189*x_97 + 0.00323585266899492*x_98 + 0.0030292249242639*x_99 - 9.64978804207103e-6*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 2.37556459000387e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) - 1.72199888283411e-5*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 1.21975758055587e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) + 3.84717642267422e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) + 6.42113452272521e-6*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 9.18280394586041e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 4.3544425237671e-6*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) + 9.43301502664678e-6*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) + 4.44332831676131e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) - 9.00889372883814e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 4.12942849764963e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) + 6.53909781827142e-6*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) + 0.000574061075516316*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 2.00351756424217e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) + 7.69324780329895e-6*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) - 9.48018260100332e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 3.17760663818071e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 0.000278901764588181*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 1.32396370678348e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 0.000366509881950752*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 3.9336595546159e-6*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) - 1.19329020938782e-5*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) + 1.292851594994e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 6.8517828334569e-6*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 3.32261418199432e-6*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) - 1.78018074932325e-5*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) - 1.23522205990115e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) + 1.07108995506104e-5*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 2.98552635454346e-5*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) - 2.54818400036552e-5*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) - 1.34753727864531e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) + 0.000143678233693252*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 6.67073047666921e-6*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) - 7.67308501345726e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) + 1.82111638099058e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) + 5.47664779267793e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) - 1.09749754835409e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 1.33966472497057e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) + 5.58610066534418e-6*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) + 3.40553254928615e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) - 1.85497402536231e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) + 2.25838675576217e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) + 8.66158765190013e-6*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) + 1.22215692156945e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) + 4.06710883617605e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 8.27743024407718e-5*std::exp(0.581919848918915*x_1) - 0.000188617625242137*std::exp(0.848399877548218*x_1) + 0.000581663479633682*std::exp(1.00727987289429*x_1) + 3.52902676859359e-5*std::exp(1.1522399187088*x_1) - 7.2081287891839e-6*std::exp(1.16983985900879*x_1) - 6.60005392321045e-5*std::exp(1.27119994163513*x_1) - 5.04887673744162e-6*std::exp(1.27559983730316*x_1) + 5.95057304306577e-6*std::exp(1.27711987495422*x_1) - 6.34945269775871e-6*std::exp(1.35095977783203*x_1) - 1.634037613618e-5*std::exp(1.23759984970093*x_100) - 0.00120058915629291*std::exp(1.47815990447998*x_100) + 0.000149932255118507*std::exp(1.55327987670898*x_100) - 0.000915664504472341*std::exp(0.614959836006165*x_104) + 0.0029309981108041*std::exp(0.876879870891571*x_104) - 0.000544280328635089*std::exp(0.973119854927063*x_104) + 0.0085190039007215*std::exp(0.653039813041687*x_106) - 0.00036607229089573*std::exp(0.848959863185883*x_106) - 0.00119306243431852*std::exp(1.05311989784241*x_106) + 0.0181535711117335*std::exp(0.576079845428467*x_109) - 0.00190059925571619*std::exp(0.711199820041656*x_109) - 0.000458643026265114*std::exp(0.828479886054993*x_109) + 0.000252014780668378*std::exp(1.09879982471466*x_109) - 0.000937948541947153*std::exp(1.26071989536285*x_109) - 0.00487094141525635*std::exp(0.654639840126038*x_110) + 0.00401428719599082*std::exp(0.930479824542999*x_110) + 0.00012075708859657*std::exp(0.998239815235138*x_110) - 0.00045210800349582*std::exp(1.11503982543945*x_110) + 0.000183431756398998*std::exp(1.34391975402832*x_110) - 6.79512592655981e-5*std::exp(1.47463989257813*x_110) - 0.00182640871990981*std::exp(0.405039876699448*x_112) - 0.000371518342820181*std::exp(0.421119838953018*x_112) - 0.000250878495601706*std::exp(0.89711982011795*x_112) + 0.00134859632637452*std::exp(0.700399816036224*x_114) - 0.00106068922968937*std::exp(0.762399852275848*x_114) - 0.000451519898669528*std::exp(1.31567978858948*x_23) + 0.000118673212574149*std::exp(1.51271986961365*x_23) - 0.00262896713387343*std::exp(0.536079823970795*x_26) - 0.00028911486997501*std::exp(0.615919828414917*x_26) - 0.0167880347628485*std::exp(0.62095981836319*x_26) + 0.000866165500595231*std::exp(0.629919826984406*x_26) + 0.00192655824594007*std::exp(0.918959856033325*x_26) + 0.000140476446106197*std::exp(1.03471982479095*x_26) + 0.000275791372000834*std::exp(1.19559991359711*x_26) + 8.70087893245097e-5*std::exp(1.30039978027344*x_26) + 0.00121796020875673*std::exp(0.533599853515625*x_31) + 0.000486027834202965*std::exp(0.594959855079651*x_31) + 0.0447291221751375*std::exp(0.643759846687317*x_31) - 0.00387760489008595*std::exp(0.644639849662781*x_31) - 0.00135700607816358*std::exp(0.649439811706543*x_31) + 0.00386887030768047*std::exp(0.654799818992615*x_31) + 0.0069112472629364*std::exp(0.655919849872589*x_31) - 0.00223029197836186*std::exp(0.658159852027893*x_31) + 0.000952436244736937*std::exp(0.659039855003357*x_31) + 0.000156544621742333*std::exp(0.666559815406799*x_31) - 0.00184969272408084*std::exp(0.540479838848114*x_45) + 0.000421498097080062*std::exp(1.24111986160278*x_45) - 0.00201323223434023*std::exp(0.629199862480164*x_47) + 0.00445989075757912*std::exp(0.760639846324921*x_49) - 0.000227533975786587*std::exp(1.0195198059082*x_50) + 1.82318701729732e-5*std::exp(1.98231983184814*x_50) - 0.000160163095860652*std::exp(1.29199981689453*x_52) - 0.00302447190159636*std::exp(0.987999796867371*x_6) - 0.00148726360807123*std::exp(0.698879837989807*x_60) + 0.00139812686728574*std::exp(1.37487983703613*x_60) - 0.00036197710282604*std::exp(0.935359835624695*x_66) - 0.00178376044813837*std::exp(0.659359872341156*x_68) + 0.000920166980200385*std::exp(1.31007981300354*x_68) - 0.00116825344546476*std::exp(0.628559827804565*x_70) + 0.000214966246353407*std::exp(0.78551983833313*x_70) - 0.00187450915139588*std::exp(0.799999833106995*x_72) - 0.00350812570287403*std::exp(0.812319874763489*x_72) + 0.000506383876436764*std::exp(0.835599899291992*x_72) + 0.00703171509513198*std::exp(1.06815981864929*x_72) + 0.000423488465989889*std::exp(0.794799864292145*x_73) - 0.00433331254932992*std::exp(0.678079843521118*x_74) + 0.0077836359305153*std::exp(1.16815984249115*x_74) - 0.000625092161642591*std::exp(1.25239992141724*x_74) - 3.98102777937563e-5*std::exp(1.4819198846817*x_74) - 0.000509985203957081*std::exp(0.930879831314087*x_78) - 0.00132277953353582*std::exp(1.2513599395752*x_81) + 9.55003125231168e-5*std::exp(1.27559983730316*x_81) - 0.000211385437350658*std::exp(2.05335974693298*x_81) + 0.000206893030891965*std::exp(0.704079866409302*x_87) - 0.00192433060383993*std::exp(0.623999834060669*x_90) + 0.00790300971251116*std::sin(0.319919854402542*x_100 + 5.12239980697632) + 0.0211893924868577*std::sin(0.251599967479706*x_102 + 1.81823992729187) + 0.0610452289393254*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.0121769112745917*std::sin(0.376959830522537*x_102 + 1.97279977798462) - 0.00610129429375077*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.0540490174086042*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.00353584870615646*std::sin(0.319119840860367*x_105 + 1.92935979366302) - 0.0288971967410909*std::sin(0.323119848966599*x_105 + 1.94975972175598) - 0.0384687768530005*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.0542900166583749*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.00629345444231418*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.000719363268661057*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.000479971768294613*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0990675849159552*std::sin(0.247359976172447*x_111 - 7.54960012435913) - 0.00883123982793873*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.00648710142390235*std::sin(0.421359866857529*x_111 - 1.16935980319977) - 0.0136394435437169*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.00842674780739154*std::sin(0.538319826126099*x_112 - 0.998959839344025) - 0.0108718390442017*std::sin(0.601279854774475*x_112 - 0.998639822006226) - 0.0154008970144697*std::sin(0.307359933853149*x_115 - 7.4868803024292) - 0.0110157127200753*std::sin(0.308319926261902*x_115 + 5.10927963256836) + 0.0203003146430059*std::sin(0.497439861297607*x_115 - 4.12024021148682) + 0.0212903465533682*std::sin(0.300239950418472*x_116 + 1.90559983253479) - 0.0133787998796741*std::sin(0.395679831504822*x_117 + 1.99599981307983) + 0.00629670908508914*std::sin(0.631359875202179*x_117 - 3.99463987350464) - 0.0241199634971612*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.0113488415592757*std::sin(0.366319835186005*x_119 + 5.16383981704712) - 0.0166015454387201*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.00461043632780328*std::sin(0.304639935493469*x_120 - 7.47384023666382) - 0.0352482081091419*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.0111922604208439*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.00491683529792622*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.0158793053952718*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.00597303644272973*std::sin(0.262479960918427*x_20 - 7.53648042678833) - 0.0153594037630738*std::sin(0.316799849271774*x_20 + 1.92847979068756) - 0.107024322186739*std::sin(0.22495998442173*x_21 + 5.03143978118896) - 0.0094086209934869*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.00887056163152071*std::sin(0.427359849214554*x_22 + 5.21424007415771) - 0.0062143431381278*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.0161985389988756*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.118051509930514*std::sin(0.329199820756912*x_24 + 8.31216049194336) + 0.0244519377274243*std::sin(0.358079850673676*x_24 + 5.16359996795654) - 0.00798920989617652*std::sin(0.361039847135544*x_24 - 7.44112014770508) + 0.00950132470570048*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.00548273481571203*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.00716264756573729*std::sin(0.301519840955734*x_27 - 4.31599998474121) - 0.021890321817437*std::sin(0.315679848194122*x_28 + 5.11208009719849) - 0.0141639248762483*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.00167401462563836*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.0147449660690621*std::sin(0.329839825630188*x_28 + 5.12192010879517) + 0.00810222603794672*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.00240851673732129*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.0167902243935343*std::sin(0.352799862623215*x_34 + 2.00847983360291) - 0.0372850125704906*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.00567717212446476*std::sin(0.309839934110641*x_35 + 8.25224018096924) - 0.00624910494752796*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.00219553602592141*std::sin(0.333759844303131*x_35 + 1.99071979522705) - 0.00472234194125409*std::sin(0.293279945850372*x_36 + 1.89527988433838) - 0.0128878192308375*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.0102899578571986*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0731263396276281*std::sin(0.298159927129745*x_37 - 1.32039988040924) + 0.00178703362941742*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.0103214907000601*std::sin(0.482639849185944*x_38 + 5.25967979431152) + 0.0073061088898548*std::sin(0.5204798579216*x_38 + 2.12431979179382) + 0.00467052042723405*std::sin(0.699439823627472*x_38 - 0.933919847011566) + 0.0104421243963266*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.00278683745212612*std::sin(0.390639841556549*x_41 - 1.18031990528107) - 0.0177323607553384*std::sin(0.354479849338531*x_43 + 8.34535980224609) + 0.00307939802343117*std::sin(0.41431987285614*x_43 - 1.17959988117218) + 0.0161461706112118*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.27511658521982*std::sin(0.180400013923645*x_46 + 4.9605598449707) - 0.0104476110808653*std::sin(0.214559987187386*x_48 - 7.58031988143921) + 0.0187746925435701*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.0169508391666583*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.153526162524436*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00074917908993283*std::sin(0.535439848899841*x_54 - 1.04375982284546) + 0.0109277681778945*std::sin(0.350959837436676*x_55 + 5.14120006561279) - 0.00200635098511856*std::sin(0.565759837627411*x_55 - 4.23424005508423) + 0.054412087721552*std::sin(0.202319994568825*x_56 + 1.78511989116669) + 0.00749246526487194*std::sin(0.410559862852097*x_56 - 7.3808798789978) - 0.0311575974349074*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.336907761245948*std::sin(0.166080012917519*x_58 - 7.64192008972168) - 0.0144295300186401*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.00324992752633868*std::sin(0.389679849147797*x_58 + 5.19736003875732) + 0.005807191241769*std::sin(0.510159850120544*x_58 - 4.10351991653442) - 0.0114641537302952*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.0139646392054522*std::sin(0.362799853086472*x_59 + 8.34911918640137) + 0.141151030577628*std::sin(0.217439994215965*x_64 - 4.37599992752075) - 0.0106044701060396*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.00232433420471203*std::sin(0.42399987578392*x_64 - 1.15239989757538) - 0.0374006838834916*std::sin(0.41967985033989*x_65 + 1.98983979225159) - 0.0260780482344478*std::sin(0.245919972658157*x_69 - 7.54095983505249) + 0.0232672983174015*std::sin(0.261439949274063*x_70 - 7.51576042175293) - 0.0114825595725465*std::sin(0.518559873104095*x_70 + 5.33784008026123) - 0.00867162478017202*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.0034778280423263*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0246732681112981*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.0318385480525848*std::sin(0.212719991803169*x_75 - 7.5798397064209) - 0.0191359256687219*std::sin(0.385759830474854*x_75 - 7.40551996231079) - 0.0144451970748656*std::sin(0.534719824790955*x_75 - 7.24295997619629) - 0.0117159967634122*std::sin(0.273359954357147*x_76 - 7.51168012619019) + 0.038918645170473*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.00392381570919684*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.0031272511976565*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.275989381138262*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.00162827259431117*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.020545316698986*std::sin(0.203360006213188*x_85 - 7.59999990463257) + 0.0649709290838626*std::sin(0.221039995551109*x_85 - 7.57552003860474) + 0.00336710615215215*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.00701287936333305*std::sin(0.534559845924377*x_87 + 5.3407998085022) - 0.0035157569001563*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00819763117914878*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0296702863504485*std::sin(0.211520001292229*x_89 + 1.78799998760223) + 0.00154361884537275*std::sin(0.355119854211807*x_90 - 1.06399977207184) + 0.00848407786152351*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.00217616953259902*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0983122872531731*std::sin(0.358079850673676*x_92 - 1.18679988384247) + 0.00758073418602837*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.0127383452119321*std::sin(0.379919856786728*x_92 + 8.19079971313477) - 0.00605975302264017*std::sin(0.383839845657349*x_92 - 1.19767987728119) - 0.00323842549541691*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.00366615045681864*std::sin(0.351119846105576*x_95 - 1.22583997249603) + 0.0127521143220596*std::sin(0.365359842777252*x_95 - 7.40423965454102) + 0.0134596278829986*std::sin(0.401599824428558*x_95 + 5.0099196434021) - 0.00967212142428514*std::sin(0.38647985458374*x_96 + 5.19152021408081) - 0.00358522379130447*std::sin(0.427599847316742*x_96 - 1.1937597990036) + 0.0122700228943023*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0228392296544262*std::sin(0.303999930620193*x_97 + 5.11295986175537) - 0.0105295211089704*std::sin(0.351279854774475*x_97 + 5.16311979293823) - 0.00825905100103855*std::sin(0.36983984708786*x_98 + 5.1780800819397) + 0.0195311779925017*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.0100576978958991*std::sin(0.414159864187241*x_98 - 7.39120006561279) - 0.0123357343691105*std::sin(0.439519852399826*x_98 - 7.38319969177246) - 0.00351044816658241*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.0142698690956202*std::sin(0.407759845256805*x_99 - 4.20120000839233) + 0.0176554028899926*std::sin(0.408639848232269*x_99 + 5.2050404548645) - 0.0445510796049551*std::sin(0.434639871120453*x_99 + 5.23040008544922) + 0.562094910008638);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000164224206408669*x_1 + 0.00346895419394694*x_10 + 0.000146975537199483*x_100 - 0.00108643376153439*x_101 + 0.00169827437072137*x_102 - 0.00209063639657533*x_103 + 0.00383456507969366*x_104 + 0.00993853635491661*x_105 - 0.00614368784802361*x_106 + 0.021480409500551*x_107 + 0.00636336219338692*x_108 - 0.000653716515347669*x_109 + 0.00229342497637368*x_11 + 0.00335548510398181*x_110 + 0.0056990234507428*x_111 + 0.00600822408608171*x_112 - 0.00861646662215292*x_113 - 0.000255580530517872*x_114 - 0.00118610245756712*x_115 + 0.00203424255132876*x_116 + 0.0113459879637626*x_117 + 0.00444611671574435*x_118 + 0.00361509857162749*x_119 + 0.0305236610699182*x_12 + 0.0110451372186398*x_120 + 0.00813624566886138*x_13 + 0.00754407794778987*x_14 - 0.00234209953601269*x_15 + 0.00101069836524749*x_16 + 0.0108691231974707*x_17 - 0.00580823694602548*x_18 - 0.00478249737388386*x_19 - 0.00481046044702615*x_2 + 0.00600004411864715*x_20 - 0.0050371735979828*x_21 - 0.00898468832485802*x_22 - 0.00420940773161094*x_23 + 0.000208575027406467*x_24 + 0.00273081695491975*x_25 + 0.000280347581162346*x_26 - 0.00207736508754025*x_27 + 0.00160942767660915*x_28 + 0.0102692596286845*x_29 + 0.00486294050437994*x_3 - 0.00040360596840457*x_30 - 0.00457855169868253*x_32 - 0.0129377262631672*x_33 - 0.00692793795363314*x_34 - 0.00346243412952426*x_35 + 0.00427296362021745*x_36 + 0.00682680188603636*x_37 + 0.001772892309363*x_38 + 0.0140457308314087*x_39 + 0.00357525879691247*x_4 + 0.00620211384911651*x_40 - 9.25028860728136e-5*x_41 - 0.0189610060183955*x_42 + 0.00397375441579222*x_43 + 0.00126586526318677*x_44 + 0.00206870467683927*x_45 + 0.00450246019099319*x_46 - 0.00270471712508304*x_47 - 0.00613444506415365*x_48 + 0.00743701871081359*x_49 + 0.00289468740243601*x_5 + 0.0078586395544479*x_50 + 0.00597701783514838*x_51 - 0.00691893424028007*x_52 - 0.00413896431112518*x_53 + 0.0108909106027236*x_54 - 0.00575004260398145*x_55 - 0.00569995718411168*x_56 - 0.0100630617036105*x_57 + 0.00110438120851545*x_58 + 0.000441807250477527*x_59 - 0.000707719146171593*x_6 + 0.0034536858032454*x_60 + 0.00793402930328986*x_61 - 0.0103742767383499*x_62 - 2.66474539812743e-5*x_63 + 0.00374170261693978*x_64 - 0.0110812146219237*x_65 + 0.00531862566020557*x_66 - 0.0011962314756835*x_67 - 0.00109871746228399*x_68 - 0.00459856635448621*x_69 - 0.00519670613279327*x_7 - 9.40168576086031e-5*x_70 + 0.0105908976979324*x_71 + 0.00253825332653859*x_72 + 0.000263555591345318*x_73 + 0.00377388713989938*x_74 - 0.00148071741448901*x_75 + 0.00678827440293127*x_76 + 0.0153364756540201*x_77 + 0.00743241932733097*x_78 + 0.00362142933178687*x_79 + 0.0258479696699009*x_8 + 0.00759255298673731*x_80 - 0.0109582077434034*x_81 + 0.0124110629935586*x_82 + 0.00571634662111912*x_83 + 0.00544232499709472*x_84 + 0.00370297337921736*x_85 + 0.0081367400182509*x_86 - 0.000806011115810104*x_87 - 0.00263351329274423*x_88 + 0.0125597271125642*x_89 + 0.0215915152899712*x_9 + 0.0126283420446128*x_90 + 0.0232188084251877*x_91 - 0.00265239564966857*x_92 + 0.0459105817966829*x_93 + 0.0207923121047237*x_94 + 0.00523027663053711*x_95 + 0.00240373492439332*x_96 + 0.0110331501461778*x_97 + 0.00260934066957576*x_98 + 0.00472144974465418*x_99 + 3.68224257442569e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 2.97222113317771e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 4.16486550376613e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 1.52611689597375e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) + 8.67759330730143e-8*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) - 2.45022738454044e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) - 3.78648067348217e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 2.66187224680651e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 2.33270604065016e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) + 1.00222583597737e-7*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 1.6626812065153e-5*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) + 1.70274801586344e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 1.61706442086592e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.00141960522142311*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 2.50672925088666e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 2.93565044883976e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 5.2359334950859e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 3.97570735086225e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) - 0.000115003668556954*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 3.87625310062163e-5*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) - 0.000151128412718902*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 1.15168263051665e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 2.20233611893623e-5*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) + 2.91612318112919e-7*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 2.00604021975028e-5*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 2.03111521845166e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 4.30558548395944e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 3.05460126220113e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 1.97680335940312e-5*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 0.000182505331093301*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 6.16309554330501e-6*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 5.14203951052644e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 7.93539225952948e-5*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 1.95303236494449e-5*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 4.23786803730453e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) + 4.1076637989261e-7*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 3.02476912369134e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) - 2.47548756127935e-7*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 1.67614041044607e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) + 1.25998666091346e-7*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 6.28525004102192e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 4.58719624848302e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 4.16807804473133e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) + 1.9536856847986e-7*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 4.66360321036257e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 9.8368015570216e-6*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.000242343611719793*std::exp(0.581919848918915*x_1) + 0.000466435675690669*std::exp(0.848399877548218*x_1) - 0.000239845861578716*std::exp(1.00727987289429*x_1) + 4.41539160219029e-5*std::exp(1.1522399187088*x_1) - 4.40633166487097e-5*std::exp(1.16983985900879*x_1) + 3.6452297239774e-5*std::exp(1.27119994163513*x_1) + 1.92659038670915e-5*std::exp(1.27559983730316*x_1) - 1.09823761546114e-5*std::exp(1.27711987495422*x_1) - 1.43216640418062e-7*std::exp(1.35095977783203*x_1) - 9.98887768109704e-5*std::exp(1.23759984970093*x_100) + 0.00066308901862351*std::exp(1.47815990447998*x_100) + 0.000187589855095243*std::exp(1.55327987670898*x_100) - 0.00268084944957674*std::exp(0.614959836006165*x_104) - 0.00724811418077152*std::exp(0.876879870891571*x_104) - 1.22766486850547e-5*std::exp(0.973119854927063*x_104) - 0.00470507159470056*std::exp(0.653039813041687*x_106) + 0.000675622930649031*std::exp(0.848959863185883*x_106) - 2.69104128789568e-5*std::exp(1.05311989784241*x_106) - 0.00748552910140808*std::exp(0.576079845428467*x_109) - 4.28694334994929e-5*std::exp(0.711199820041656*x_109) - 0.0013427984796938*std::exp(0.828479886054993*x_109) - 0.000465118417636642*std::exp(1.09879982471466*x_109) + 0.000518031813746745*std::exp(1.26071989536285*x_109) + 0.0120454323786449*std::exp(0.654639840126038*x_110) - 0.00221710294759073*std::exp(0.930479824542999*x_110) + 0.000738188507451652*std::exp(0.998239815235138*x_110) + 0.000834410420806016*std::exp(1.11503982543945*x_110) + 4.13744005160035e-6*std::exp(1.34391975402832*x_110) + 0.000259293798747442*std::exp(1.47463989257813*x_110) + 0.00337081948729051*std::exp(0.405039876699448*x_112) - 0.00108771797966668*std::exp(0.421119838953018*x_112) - 5.65875154970393e-6*std::exp(0.89711982011795*x_112) + 0.00168731530948171*std::exp(0.700399816036224*x_114) + 0.00262299611138065*std::exp(0.762399852275848*x_114) + 0.00111657109855635*std::exp(1.31567978858948*x_23) - 0.000219023252136063*std::exp(1.51271986961365*x_23) + 0.00485202110004406*std::exp(0.536079823970795*x_26) - 0.00176736021735285*std::exp(0.615919828414917*x_26) + 0.00692245740517295*std::exp(0.62095981836319*x_26) + 0.0010837151793437*std::exp(0.629919826984406*x_26) - 0.000465961741293706*std::exp(0.918959856033325*x_26) + 3.16855099594649e-6*std::exp(1.03471982479095*x_26) - 0.000152320408064929*std::exp(1.19559991359711*x_26) - 0.000215165488312692*std::exp(1.30039978027344*x_26) + 2.74720007478113e-5*std::exp(0.533599853515625*x_31) + 0.00060810057794652*std::exp(0.594959855079651*x_31) - 0.018443817123454*std::exp(0.643759846687317*x_31) + 0.00958899389517193*std::exp(0.644639849662781*x_31) - 0.00397299336159536*std::exp(0.649439811706543*x_31) - 0.000935733736161531*std::exp(0.654799818992615*x_31) - 0.00381710274578463*std::exp(0.655919849872589*x_31) + 0.00411622633042463*std::exp(0.658159852027893*x_31) - 0.00363438168227764*std::exp(0.659039855003357*x_31) + 0.000956957823483324*std::exp(0.666559815406799*x_31) - 4.17211987171904e-5*std::exp(0.540479838848114*x_45) - 0.000232794672581823*std::exp(1.24111986160278*x_45) - 0.00251888389736052*std::exp(0.629199862480164*x_47) - 0.00246321114105557*std::exp(0.760639846324921*x_49) - 0.00139091599451837*std::exp(1.0195198059082*x_50) + 2.28110614434503e-5*std::exp(1.98231983184814*x_50) + 0.000295596970594034*std::exp(1.29199981689453*x_52) + 0.000731505624982575*std::exp(0.987999796867371*x_6) + 0.00567521830858629*std::exp(0.698879837989807*x_60) - 0.000338154131079534*std::exp(1.37487983703613*x_60) - 0.00105978348197496*std::exp(0.935359835624695*x_66) + 0.00329210784732773*std::exp(0.659359872341156*x_68) + 2.07550524117537e-5*std::exp(1.31007981300354*x_68) + 0.00215612827355607*std::exp(0.628559827804565*x_70) + 0.00131408942027618*std::exp(0.78551983833313*x_70) + 0.00715290053349099*std::exp(0.799999833106995*x_72) + 0.000848483228904795*std::exp(0.812319874763489*x_72) + 0.00148257241575868*std::exp(0.835599899291992*x_72) - 0.00289949055496854*std::exp(1.06815981864929*x_72) - 0.00104725170051113*std::exp(0.794799864292145*x_73) + 0.0107159209767954*std::exp(0.678079843521118*x_74) - 0.00320954113733461*std::exp(1.16815984249115*x_74) + 0.00238527619519209*std::exp(1.25239992141724*x_74) - 0.000116555092820148*std::exp(1.4819198846817*x_74) - 0.00149311625234231*std::exp(0.930879831314087*x_78) + 0.000319930454266265*std::exp(1.2513599395752*x_81) + 0.000279602364197287*std::exp(1.27559983730316*x_81) + 8.71636678625449e-5*std::exp(2.05335974693298*x_81) + 0.00126473782575632*std::exp(0.704079866409302*x_87) - 0.00240765336881213*std::exp(0.623999834060669*x_90) - 0.0195434847115314*std::sin(0.319919854402542*x_100 + 5.12239980697632) + 0.000477942548581973*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.033715464392508*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.0152353142404401*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.0112605472580558*std::sin(0.377599835395813*x_102 + 5.18224000930786) - 0.0222868266648162*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.0216146555809448*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.071460360452496*std::sin(0.323119848966599*x_105 + 1.94975972175598) + 0.146792206519594*std::sin(0.194159999489784*x_106 - 7.60576009750366) + 0.0223862014317132*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.00787414426568246*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.00439747019226772*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.000600523445692376*std::sin(0.701279819011688*x_109 - 4.15256023406982) - 0.0408499950412118*std::sin(0.247359976172447*x_111 - 7.54960012435913) - 0.000199195199820927*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.00811642841719505*std::sin(0.421359866857529*x_111 - 1.16935980319977) + 0.0337292077407465*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.0105432443396739*std::sin(0.538319826126099*x_112 - 0.998959839344025) + 0.0268851523502775*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.0587679630099468*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00266428523064606*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.0112119251151184*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0526492535761727*std::sin(0.300239950418472*x_116 + 1.90559983253479) - 0.000301768807927154*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.015571237062076*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.0596466605758076*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.0141992631400141*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.0306398082060954*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.0281836134928037*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.0194676918418093*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.0140033544408095*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.0061517678123105*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.0198676168497413*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0174876402673502*std::sin(0.262479960918427*x_20 - 7.53648042678833) - 0.000346442805463919*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.0591098565197578*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.0232667359944795*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.0110985282636824*std::sin(0.427359849214554*x_22 + 5.21424007415771) - 0.0379883014673582*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.0202670304742094*std::sin(0.313599824905396*x_24 + 5.11432027816772) - 0.0486779161858058*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.0059140010458995*std::sin(0.358079850673676*x_24 + 5.16359996795654) + 0.0304858600908819*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.0234959845527193*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.00685980097339383*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.0209705407278884*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.0541329424272776*std::sin(0.315679848194122*x_28 + 5.11208009719849) + 0.0540478267221042*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.010233257296229*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.0184483722071236*std::sin(0.329839825630188*x_28 + 5.12192010879517) - 0.00447488392178782*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.0147232712891526*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.0210073259987333*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.00901783759619792*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.0166214194070941*std::sin(0.309839934110641*x_35 + 8.25224018096924) - 0.000140953222081765*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.013421319451033*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00871555313315341*std::sin(0.293279945850372*x_36 + 1.89527988433838) - 0.000290694373265806*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.0128744258654839*std::sin(0.420239865779877*x_36 + 5.22168016433716) - 0.0301532596530419*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.00329814882989675*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.0129138786264556*std::sin(0.482639849185944*x_38 + 5.25967979431152) + 0.00016479473421432*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.0178221418821911*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.0398458855800428*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.0170359471498039*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.00428878893862557*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00568333623977566*std::sin(0.41431987285614*x_43 - 1.17959988117218) + 0.000364188918419827*std::sin(0.351759850978851*x_44 + 5.15248012542725) - 0.113442869850104*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.0192821084585887*std::sin(0.214559987187386*x_48 - 7.58031988143921) + 0.000423477190706734*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.0212082814368588*std::sin(0.351199835538864*x_53 - 4.25352001190186) - 0.0633057016898112*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00457973441260335*std::sin(0.535439848899841*x_54 - 1.04375982284546) - 0.0416990435983312*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.00496153886051232*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0131602307875144*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.0185282424901863*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.118893628845976*std::sin(0.140880048274994*x_58 + 4.90823936462402) - 0.138922134701461*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.0266311370773994*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.00951502037874672*std::sin(0.389679849147797*x_58 + 5.19736003875732) + 0.000130985528911008*std::sin(0.510159850120544*x_58 - 4.10351991653442) - 0.000258582536266256*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.0174720552488027*std::sin(0.362799853086472*x_59 + 8.34911918640137) - 0.0779581406785432*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.0195716074371311*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.0142086631711319*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.0206565107157291*std::sin(0.41967985033989*x_65 + 1.98983979225159) + 0.0995106825643825*std::sin(0.245919972658157*x_69 - 7.54095983505249) + 0.000524811264095145*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.0283954133448742*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.0160043485758865*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.010182259274499*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.030870307300228*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.0398352483320321*std::sin(0.212719991803169*x_75 - 7.5798397064209) + 0.0473215501881036*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.00797812599088558*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.0216230407644422*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.00941295167724172*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.0114880058502461*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.019116897573912*std::sin(0.258879989385605*x_82 + 1.85407984256744) + 0.113802762634111*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.00476719766562912*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.0257055626849765*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0157140160766923*std::sin(0.221039995551109*x_85 - 7.57552003860474) + 7.59475901304753e-5*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.00877426289978936*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.000850328927565241*std::sin(0.90479987859726*x_87 + 8.66631984710693) - 0.00338024989003218*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0371223971300621*std::sin(0.211520001292229*x_89 + 1.78799998760223) + 0.00943614743269259*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0209804178420326*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.0133029320092159*std::sin(0.3503198325634*x_92 - 7.3997597694397) - 0.0405385520419153*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.00183349354168261*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.0159377602275827*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.0231232856858496*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.00597683730322358*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.0107336228348083*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0315349164886301*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.00743379314830139*std::sin(0.401599824428558*x_95 + 5.0099196434021) - 0.000218161911276328*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00661688815339401*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.00677677071863036*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0285756242242498*std::sin(0.303999930620193*x_97 + 5.11295986175537) - 0.000237501200531838*std::sin(0.351279854774475*x_97 + 5.16311979293823) - 0.00018628905414599*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.0107871286190839*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.0125838305399474*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.00298354865672*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00647888227867396*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.0178539479297478*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 0.0436603406813806*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.0246056958777498*std::sin(0.434639871120453*x_99 + 5.23040008544922) - 0.0631972444755735);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000276737995976732*x_1 - 0.0140432507635292*x_10 + 0.012196589134262*x_100 - 0.010410684155526*x_101 + 0.0104064069455494*x_102 + 0.00409918306533048*x_103 + 0.00393317751148063*x_104 + 0.0152119908074629*x_105 + 0.00302393077437471*x_106 + 0.00744668351278365*x_107 - 0.00454500779093655*x_108 + 0.00271033514314116*x_109 + 0.00215181397864445*x_11 - 0.00111659778599715*x_110 + 0.000876070854177281*x_111 + 0.000770897641949563*x_112 + 0.00025442118046971*x_113 + 0.00340789222980737*x_114 - 0.00345956054780784*x_115 - 0.0117091086745893*x_116 + 0.00072724603147006*x_117 + 0.0114941000603998*x_118 + 0.00495477367161057*x_119 + 0.0233539946871749*x_12 + 0.00627707863055847*x_120 - 0.00126285542624027*x_13 + 0.0080518614233161*x_14 + 0.00276729916533547*x_15 + 0.0053390636055316*x_16 - 0.000590679460399609*x_17 - 0.00498016615570999*x_18 + 0.0153591100886121*x_19 - 0.0320410961076992*x_2 - 0.000854193417210029*x_20 - 0.000858149583747312*x_21 - 0.00226510294742672*x_22 + 0.00707626392909221*x_23 - 0.000479438125150927*x_24 - 0.00216222890399142*x_25 - 0.00442544593123184*x_26 + 0.00951459420492805*x_27 + 0.00174253387004437*x_28 + 0.0168821805805279*x_29 - 0.00362756882127483*x_3 + 0.00446808052254005*x_30 - 0.0183318834410334*x_32 + 0.00651183385672936*x_33 - 0.0148736355667691*x_34 + 0.0101672610326958*x_35 + 0.0025020576101735*x_36 + 0.00410608593667243*x_37 + 0.00117092269326421*x_38 - 0.00757938348409303*x_39 + 0.00973624494943967*x_4 + 0.000366780341135021*x_40 - 0.00933925316138528*x_41 - 0.0124921759630492*x_42 + 0.00280417458922408*x_43 + 0.0086971221622374*x_44 + 0.00620537143341235*x_45 - 0.0019929300458183*x_46 + 0.0209526325066301*x_47 - 0.000316710692412093*x_48 - 0.0127420515805693*x_49 - 0.0132012139858084*x_5 - 0.00908641231644536*x_50 - 0.00847297142554613*x_51 - 0.00362452773268305*x_52 + 0.0119172553458334*x_53 - 0.00543405257531237*x_54 - 0.00550346532725317*x_55 + 0.00220532813771506*x_56 - 0.013023055487554*x_57 - 0.00279021775451199*x_58 + 0.00436626051148691*x_59 - 0.0110433560914132*x_6 - 0.0139770417814504*x_60 - 0.0125590473287764*x_61 - 0.00672931545758865*x_62 + 0.018153506871196*x_63 - 0.00479330221218346*x_64 + 0.00821040092376741*x_65 + 0.00752917398755665*x_66 + 0.00660299309496273*x_67 - 0.0115115014287958*x_68 - 0.00181542331173716*x_69 - 0.00844297931942277*x_7 - 0.00148902299621142*x_70 + 0.00368394385046836*x_71 - 0.00263486492951978*x_72 + 0.0024070948155355*x_73 + 0.00475500333794467*x_74 + 0.00822434647849495*x_75 + 0.0115356537519478*x_76 - 0.0034331334978113*x_77 + 0.00296308406776207*x_78 - 0.00201603423045286*x_79 + 0.0071004937964777*x_8 + 0.0068836972297435*x_80 - 0.00268230731273667*x_81 - 0.0117365163589442*x_82 - 0.0148621978298363*x_83 - 0.00381742345106118*x_84 - 0.00461999989209994*x_85 + 0.00135941442672746*x_86 + 0.00204069364437194*x_87 + 0.00243785854155453*x_88 + 0.00995364625261003*x_89 - 0.00522094292721768*x_9 - 0.00405566102546525*x_90 + 0.0206040442699163*x_91 - 0.00367739153190025*x_92 + 0.0704983180612963*x_93 + 0.0192886740388303*x_94 + 0.00612379672847204*x_95 + 0.00931786615237375*x_96 + 0.013175187719095*x_97 - 0.00484680224291143*x_98 + 0.000659113567701446*x_99 - 4.60910820093904e-6*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) + 3.97713481018667e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 7.01831087042488e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) - 2.04209995132564e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 4.62495590737768e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) + 3.06697967447519e-6*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) - 4.51128840305421e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 3.29531940557593e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) + 1.50563094974992e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 5.34163118330276e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) - 7.47945283502735e-7*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) + 2.02868786075807e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) + 1.04372441163507e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) + 0.00091627557032668*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) + 3.35425922793155e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) + 3.67458967880411e-6*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 9.19171047642987e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) - 5.31990164652527e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) - 0.000137017658614525*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 0.000157725201971929*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) - 0.000180057397478747*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 4.68621038901383e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) - 9.90705197359143e-7*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 1.55422599972003e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 8.16260163128115e-5*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 2.51446079065374e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 7.25544135297795e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) - 1.97157383715325e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) + 8.89250893847958e-7*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 0.000225936222106204*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 1.03855743739939e-5*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) - 6.43635393336803e-6*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 0.00013930625405184*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 7.94691203650207e-5*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 7.43960099431712e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 2.18928950454266e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 5.30999908022306e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 1.319377437353e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) - 2.24284670434952e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) - 6.71543657814149e-6*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) + 2.82737490830866e-7*std::pow(-9.99979972839355*x_84 - 8.0, 2) - 2.96077796513434e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) + 1.87498018418206e-6*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 1.04126914330794e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) + 5.83748934741495e-6*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 1.65762210653451e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.000986099052690376*std::exp(0.581919848918915*x_1) - 0.00030105807467779*std::exp(0.848399877548218*x_1) - 0.000285757131005122*std::exp(1.00727987289429*x_1) - 5.90824398819283e-5*std::exp(1.1522399187088*x_1) - 5.45490876208399e-5*std::exp(1.16983985900879*x_1) + 6.39922112729718e-5*std::exp(1.27119994163513*x_1) - 2.41153682076919e-6*std::exp(1.27559983730316*x_1) + 4.94034359341206e-7*std::exp(1.27711987495422*x_1) + 7.63311466301347e-6*std::exp(1.35095977783203*x_1) - 0.000123659362322643*std::exp(1.23759984970093*x_100) + 0.00116405647340777*std::exp(1.47815990447998*x_100) - 0.000251014345604734*std::exp(1.55327987670898*x_100) - 0.0109084084530759*std::exp(0.614959836006165*x_104) + 0.00467825128744009*std::exp(0.876879870891571*x_104) + 0.000654316892345824*std::exp(0.973119854927063*x_104) - 0.00825977944715132*std::exp(0.653039813041687*x_106) - 3.03924157213711e-5*std::exp(0.848959863185883*x_106) + 0.00143426257266265*std::exp(1.05311989784241*x_106) - 0.00891840828936588*std::exp(0.576079845428467*x_109) + 0.00228484134584399*std::exp(0.711199820041656*x_109) - 0.00546386306362039*std::exp(0.828479886054993*x_109) + 2.09230203227405e-5*std::exp(1.09879982471466*x_109) + 0.000909407740569822*std::exp(1.26071989536285*x_109) - 0.00777465118894829*std::exp(0.654639840126038*x_110) - 0.00389213659986698*std::exp(0.930479824542999*x_110) + 0.000913855620417903*std::exp(0.998239815235138*x_110) - 3.75353577283398e-5*std::exp(1.11503982543945*x_110) - 0.000220515955639097*std::exp(1.34391975402832*x_110) - 3.24561228681647e-5*std::exp(1.47463989257813*x_110) - 0.000151633910768862*std::exp(0.405039876699448*x_112) - 0.00442593746017031*std::exp(0.421119838953018*x_112) + 0.000301598328953315*std::exp(0.89711982011795*x_112) - 0.00225779985822453*std::exp(0.700399816036224*x_114) - 0.00169299691326202*std::exp(0.762399852275848*x_114) - 0.000720684035745093*std::exp(1.31567978858948*x_23) + 9.85260480305381e-6*std::exp(1.51271986961365*x_23) - 0.000218264709014158*std::exp(0.536079823970795*x_26) - 0.00218793987122144*std::exp(0.615919828414917*x_26) + 0.00824755346866041*std::exp(0.62095981836319*x_26) - 0.00145012136411515*std::exp(0.629919826984406*x_26) - 0.000785202871777384*std::exp(0.918959856033325*x_26) - 0.000168876416853965*std::exp(1.03471982479095*x_26) - 0.000267399326576341*std::exp(1.19559991359711*x_26) + 0.000138877257946891*std::exp(1.30039978027344*x_26) - 0.00146419390315477*std::exp(0.533599853515625*x_31) - 0.000813700551970719*std::exp(0.594959855079651*x_31) - 0.0219743306442318*std::exp(0.643759846687317*x_31) - 0.00618915788528157*std::exp(0.644639849662781*x_31) - 0.0161661574753792*std::exp(0.649439811706543*x_31) - 0.0015768264896879*std::exp(0.654799818992615*x_31) - 0.00670094517643644*std::exp(0.655919849872589*x_31) - 0.000185165506027661*std::exp(0.658159852027893*x_31) + 0.000454920013512177*std::exp(0.659039855003357*x_31) + 0.0011846855873063*std::exp(0.666559815406799*x_31) + 0.00222364309592142*std::exp(0.540479838848114*x_45) - 0.000408672347125047*std::exp(1.24111986160278*x_45) + 0.00337052338373647*std::exp(0.629199862480164*x_47) - 0.00432418090721525*std::exp(0.760639846324921*x_49) - 0.00172191301583359*std::exp(1.0195198059082*x_50) - 3.0523525154758e-5*std::exp(1.98231983184814*x_50) - 1.32972189200883e-5*std::exp(1.29199981689453*x_52) + 0.00123267699159786*std::exp(0.987999796867371*x_6) - 0.000710374037547056*std::exp(0.698879837989807*x_60) - 0.000569831321536918*std::exp(1.37487983703613*x_60) - 0.0043122716551767*std::exp(0.935359835624695*x_66) - 0.000148093123777572*std::exp(0.659359872341156*x_68) - 0.00110619614056936*std::exp(1.31007981300354*x_68) - 9.69918927641602e-5*std::exp(0.628559827804565*x_70) + 0.00162680398072947*std::exp(0.78551983833313*x_70) - 0.000895337334329654*std::exp(0.799999833106995*x_72) + 0.00142979864857843*std::exp(0.812319874763489*x_72) + 0.00603260488011087*std::exp(0.835599899291992*x_72) - 0.00345451072997703*std::exp(1.06815981864929*x_72) + 0.000675942251184086*std::exp(0.794799864292145*x_73) - 0.00691652612741583*std::exp(0.678079843521118*x_74) - 0.00382391116198873*std::exp(1.16815984249115*x_74) - 0.000298567947400349*std::exp(1.25239992141724*x_74) - 0.00047426406580537*std::exp(1.4819198846817*x_74) - 0.00607550787719446*std::exp(0.930879831314087*x_78) + 0.000539122183639903*std::exp(1.2513599395752*x_81) + 0.00113770536185508*std::exp(1.27559983730316*x_81) + 0.000103848527935137*std::exp(2.05335974693298*x_81) + 0.001565708160931*std::exp(0.704079866409302*x_87) + 0.00322168559972803*std::exp(0.623999834060669*x_90) + 0.0126142235390468*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.0254732289837947*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.0591876859332091*std::sin(0.301519930362701*x_102 - 7.51344013214111) - 0.0203864032636781*std::sin(0.376959830522537*x_102 + 1.97279977798462) - 0.000506547688054654*std::sin(0.377599835395813*x_102 + 5.18224000930786) - 0.0265529686650699*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.0267583067016758*std::sin(0.319119840860367*x_105 + 1.92935979366302) - 0.0461236557468576*std::sin(0.323119848966599*x_105 + 1.94975972175598) - 0.0183741605618941*std::sin(0.194159999489784*x_106 - 7.60576009750366) + 0.0266713657393236*std::sin(0.520639836788177*x_106 + 5.37607955932617) - 0.0105364075740878*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.00544393852011744*std::sin(0.505919814109802*x_109 - 7.33463954925537) + 0.000803561576740055*std::sin(0.701279819011688*x_109 - 4.15256023406982) - 0.0486694967664434*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0106166420055421*std::sin(0.303439915180206*x_111 - 7.50184011459351) - 0.0108606084628377*std::sin(0.421359866857529*x_111 - 1.16935980319977) - 0.0217703123325639*std::sin(0.45007985830307*x_111 - 1.17727982997894) + 0.0141079355124528*std::sin(0.538319826126099*x_112 - 0.998959839344025) - 0.0173528583378802*std::sin(0.601279854774475*x_112 - 0.998639822006226) - 0.00735605802135061*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00448964846025571*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.019682597122042*std::sin(0.497439861297607*x_115 - 4.12024021148682) + 0.0339821410345486*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.0160835773406283*std::sin(0.395679831504822*x_117 + 1.99599981307983) + 0.0100503604131879*std::sin(0.631359875202179*x_117 - 3.99463987350464) - 0.0384985748942178*std::sin(0.284639924764633*x_119 + 8.28767967224121) + 0.0190000612951614*std::sin(0.366319835186005*x_119 + 5.16383981704712) - 0.00137830992167209*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.0348904830325761*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.0341756416925863*std::sin(0.403279840946198*x_120 + 5.21072006225586) - 0.0187379154882672*std::sin(0.44735985994339*x_120 - 4.16968011856079) - 0.00823169233184479*std::sin(0.387359857559204*x_16 + 5.19464015960693) + 0.0265848962873359*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0711574172681841*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.0184645977629611*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.103767683058398*std::sin(0.22495998442173*x_21 + 5.03143978118896) - 0.0150173734720493*std::sin(0.440559864044189*x_21 - 0.9790398478508) + 0.0148509619982885*std::sin(0.427359849214554*x_22 + 5.21424007415771) - 0.0470283978355606*std::sin(0.266799956560135*x_24 + 5.06759977340698) - 0.0271193524258119*std::sin(0.313599824905396*x_24 + 5.11432027816772) - 0.0579958377476463*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.00996581949419687*std::sin(0.358079850673676*x_24 + 5.16359996795654) - 0.00381595250496172*std::sin(0.361039847135544*x_24 - 7.44112014770508) + 0.0151653405619682*std::sin(0.428159862756729*x_24 + 8.42472076416016) + 0.00917911286535684*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.0853293808713456*std::sin(0.301519840955734*x_27 - 4.31599998474121) - 0.0349397789945377*std::sin(0.315679848194122*x_28 + 5.11208009719849) - 0.0067652327719511*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.0126684709947938*std::sin(0.319759845733643*x_28 - 4.27544021606445) + 0.0246858023036083*std::sin(0.329839825630188*x_28 + 5.12192010879517) - 0.00785568370249704*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.0182269760131843*std::sin(0.287599951028824*x_3 + 5.07695960998535) - 0.0281099432898441*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.0151961660158993*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.067632754234331*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.00751247971695629*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.0166151980015132*std::sin(0.333759844303131*x_35 + 1.99071979522705) - 0.000392062942283555*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.0154933356665368*std::sin(0.366399854421616*x_36 + 5.18304014205933) + 0.0172272939920996*std::sin(0.420239865779877*x_36 + 5.22168016433716) - 0.0359251934229346*std::sin(0.298159927129745*x_37 - 1.32039988040924) + 0.000148364873070371*std::sin(0.472239851951599*x_37 + 5.05007982254028) - 0.0172800858073743*std::sin(0.482639849185944*x_38 + 5.25967979431152) - 0.00878317699987109*std::sin(0.5204798579216*x_38 + 2.12431979179382) + 0.00223081936203831*std::sin(0.699439823627472*x_38 - 0.933919847011566) + 0.00498755837750038*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.0210900005822839*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.00722713710723563*std::sin(0.354479849338531*x_43 + 8.34535980224609) + 0.000255660827730735*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.0194104244114555*std::sin(0.351759850978851*x_44 + 5.15248012542725) - 0.135158091984481*std::sin(0.180400013923645*x_46 + 4.9605598449707) - 0.000867391898162827*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.0225703517719695*std::sin(0.181600004434586*x_53 - 4.43544006347656) - 0.0283788421477871*std::sin(0.351199835538864*x_53 - 4.25352001190186) - 0.0754236724039097*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00566957625421034*std::sin(0.535439848899841*x_54 - 1.04375982284546) + 0.00521952043994167*std::sin(0.350959837436676*x_55 + 5.14120006561279) - 0.00320239513106085*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0221766082745751*std::sin(0.202319994568825*x_56 + 1.78511989116669) + 0.011958941611829*std::sin(0.410559862852097*x_56 - 7.3808798789978) - 0.014882061370953*std::sin(0.140880048274994*x_58 + 4.90823936462402) - 0.165514595015716*std::sin(0.166080012917519*x_58 - 7.64192008972168) - 0.00119798270969225*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.0387167316490293*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.00698122479660607*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.0137818492558651*std::sin(0.271919965744019*x_59 + 5.07471990585327) + 0.0233793907054369*std::sin(0.362799853086472*x_59 + 8.34911918640137) - 0.136855951106041*std::sin(0.217439994215965*x_64 - 4.37599992752075) - 0.000880414803259196*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.0175899063267579*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.0362626198614728*std::sin(0.41967985033989*x_65 + 1.98983979225159) - 0.0124558742075832*std::sin(0.245919972658157*x_69 - 7.54095983505249) - 0.0279712227823916*std::sin(0.261439949274063*x_70 - 7.51576042175293) - 0.01832764712654*std::sin(0.518559873104095*x_70 + 5.33784008026123) - 0.000719944207341824*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.041431734690992*std::sin(0.443199843168259*x_73 - 4.15879964828491) - 0.0413076175236104*std::sin(0.204799994826317*x_74 + 1.79047989845276) - 0.05330362234669*std::sin(0.212719991803169*x_75 - 7.5798397064209) - 0.0305434072325267*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.0140056447091098*std::sin(0.534719824790955*x_75 - 7.24295997619629) - 0.000972697068528701*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0158619818621829*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.0467448331145917*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.0236661558890729*std::sin(0.258879989385605*x_82 + 1.85407984256744) + 0.135586875407094*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.0193977842811885*std::sin(0.367759823799133*x_84 - 7.4172797203064) + 0.0343966628285671*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0264800507361772*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.00404783035095101*std::sin(0.699679851531982*x_86 - 7.12943983078003) + 0.011740858048194*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.00143290887793888*std::sin(0.90479987859726*x_87 + 8.66631984710693) - 0.00402729696605152*std::sin(1.34551978111267*x_87 + 8.78791999816895) - 0.0496735509398979*std::sin(0.211520001292229*x_89 + 1.78799998760223) + 0.0116816724717472*std::sin(0.355119854211807*x_90 - 1.06399977207184) + 0.013541683303073*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.0164686378370032*std::sin(0.3503198325634*x_92 - 7.3997597694397) - 0.0482984373811999*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.0030896622334644*std::sin(0.375759840011597*x_92 - 7.39687967300415) + 0.0213263475890028*std::sin(0.379919856786728*x_92 + 8.19079971313477) - 0.00289437003492168*std::sin(0.383839845657349*x_92 - 1.19767987728119) - 0.000268863763762531*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.043675239608042*std::sin(0.351119846105576*x_95 - 1.22583997249603) + 0.0203540203676187*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.0130500653656094*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.0116275237221971*std::sin(0.38647985458374*x_96 + 5.19152021408081) - 0.000297655994811453*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.01189665882297*std::sin(0.438799858093262*x_96 - 1.18743991851807) + 0.0382370976898246*std::sin(0.303999930620193*x_97 + 5.11295986175537) + 0.0126582629711948*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.00992877438410664*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.0189368645021347*std::sin(0.384079843759537*x_98 + 8.38000011444092) + 0.0168384478285461*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.00502764661931215*std::sin(0.439519852399826*x_98 - 7.38319969177246) - 0.000291447898954709*std::sin(0.446799844503403*x_98 - 1.14799976348877) - 0.0238904020357137*std::sin(0.407759845256805*x_99 - 4.20120000839233) + 0.0281803017872712*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.0431954364568661*std::sin(0.434639871120453*x_99 + 5.23040008544922) - 0.272319455120984);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000258289677211648*x_1 + 0.00982469647686687*x_10 + 0.0100975163039901*x_100 - 0.023559030226419*x_101 + 0.0151739772662006*x_102 + 0.00825797942880116*x_103 - 0.00140451261259736*x_104 - 0.000807741161009208*x_105 - 0.00509693464294459*x_106 + 0.00693788608889546*x_107 + 0.00521189768517391*x_108 + 0.000522166329058057*x_109 + 0.00276204399097168*x_11 - 0.00482447066094646*x_110 + 0.000633366835362915*x_111 - 0.00112405535735618*x_112 + 0.017049525740637*x_113 + 0.0109619150408825*x_114 - 0.0027753370652225*x_115 - 0.00179451705895858*x_116 + 0.00640299926179873*x_117 + 0.00461856881785643*x_118 - 0.00119403674228243*x_119 - 0.00557152627224179*x_12 - 0.000338818787844036*x_120 + 0.00831423928345652*x_13 + 0.0171090613564467*x_14 - 0.00223455017936912*x_15 + 0.00618228478272676*x_16 + 0.0117091393262855*x_17 - 0.0109701544505674*x_18 - 0.0199850203482025*x_19 - 0.00304877489029084*x_2 - 0.00167496592657041*x_20 - 0.00128400994422868*x_21 - 0.000274742344611686*x_22 + 0.0281520287114713*x_23 - 0.00324907697231605*x_24 + 0.00670712847352276*x_25 - 0.00603615469530083*x_26 - 0.00112531466711865*x_27 + 0.00184149540464054*x_28 + 0.0156552646969344*x_29 - 0.0171401889107045*x_3 - 0.0039431232338558*x_30 + 0.0424769044753212*x_32 + 0.0105971918301251*x_33 + 0.0106666131885325*x_34 - 0.00113482187651511*x_35 - 0.00430013265838618*x_36 - 0.00848716264266145*x_37 + 0.00717417296146816*x_38 - 0.00679807557851113*x_39 + 0.0211327867577579*x_4 + 0.0012859565283921*x_40 - 0.00965178339677632*x_41 - 0.0171916185164783*x_42 - 0.0138374143333285*x_43 + 0.0141445225711627*x_44 + 0.0059693404270557*x_45 - 0.00691829532611037*x_46 - 0.000853036920767396*x_47 + 0.00817983222054257*x_48 - 0.0101856989760247*x_49 - 0.00333668261934448*x_5 - 0.0135461612400327*x_50 + 0.0125492841648756*x_51 + 0.00917688921692361*x_52 - 0.00166384665296651*x_53 - 0.00101243989163155*x_54 + 0.00137812831461233*x_55 + 0.0113029763413825*x_56 - 0.0120241146260613*x_57 + 0.00118070176390943*x_58 + 0.00711920392505663*x_59 - 0.00272757625878478*x_6 + 0.0093761739322787*x_60 + 0.00609147264615937*x_61 - 0.00342208757738498*x_62 - 0.0111353125138852*x_63 + 0.00628643148997184*x_64 - 0.00279062393426433*x_65 - 0.00204929327568539*x_66 + 0.0102918747067842*x_67 - 0.00200157561421981*x_68 - 0.00982944907616737*x_69 + 0.0112388122909425*x_7 + 0.00126689053530303*x_70 + 0.00284261750056131*x_71 - 0.00148219473086931*x_72 - 0.000910127154027191*x_73 - 0.00132859069349415*x_74 + 0.00856386540719079*x_75 + 0.0137125863089702*x_76 - 0.00908748613999853*x_77 + 0.00131414737255146*x_78 + 0.000870914453828238*x_79 - 0.00245722643267642*x_8 + 0.00508125123875041*x_80 + 0.0026322174220782*x_81 - 0.00341014807038908*x_82 - 0.00694216262948362*x_83 + 0.000127262028066275*x_84 + 0.00127639662789789*x_85 + 0.00259724196191267*x_86 + 0.00078052850858639*x_87 + 0.00674721685139928*x_88 + 0.00561398592288757*x_89 - 0.0066662778408617*x_9 - 0.00433997328044067*x_90 - 0.0408964679846125*x_91 + 0.00189558253619888*x_92 + 0.0472701952279307*x_93 + 0.00475965373866683*x_94 + 0.00149263015887784*x_95 - 0.00170452323477521*x_96 - 0.0244639208143502*x_97 - 0.0011542263444599*x_98 - 0.00342293279336968*x_99 - 8.86216919266998e-6*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) + 6.55044582112771e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) - 9.78426823353638e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) + 5.89703942731078e-6*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 4.48362105478979e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 2.55203212689539e-7*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 1.45779652879799e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 1.13004217442777e-5*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 1.12972136633764e-5*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 2.01624609056989e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 1.01056492266982e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.000887165175547495*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) + 7.06532240674371e-6*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 1.78909046148013e-6*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 0.000136177340962322*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 0.000211694381180023*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 0.000178953120766964*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 6.28970130314515e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 1.49639399282913e-5*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 3.28802357932516e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 0.000109556169816199*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 1.94730280430756e-7*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 6.7717683597242e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 1.90893624798847e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 1.34315404745942e-5*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 1.74974388360886e-6*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 9.69323581045946e-6*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) - 1.23755084616571e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 2.71148107838878e-6*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 0.00010666124403878*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 1.44805683450123e-6*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 4.6315243177003e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 1.0335474261571e-6*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 2.79119260958684e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) - 1.42067587457483e-5*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 4.27056084852166e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 2.8667130154513e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 2.83203226526184e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 2.20284404985952e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) + 1.12240407475485e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) - 1.54711924296687e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.00132351473405402*std::exp(0.581919848918915*x_1) + 0.000291493354533383*std::exp(0.848399877548218*x_1) + 0.000284004606813317*std::exp(1.00727987289429*x_1) - 4.2245077629094e-7*std::exp(1.16983985900879*x_1) + 1.24555549362737e-6*std::exp(1.27119994163513*x_1) - 4.63678577032665e-6*std::exp(1.27559983730316*x_1) - 7.46205883990505e-6*std::exp(1.27711987495422*x_1) + 1.61481412614394e-5*std::exp(1.35095977783203*x_1) - 9.57669429266226e-7*std::exp(1.23759984970093*x_100) + 2.26573969941549e-5*std::exp(1.47815990447998*x_100) - 0.0146409625618601*std::exp(0.614959836006165*x_104) - 0.00452962161066604*std::exp(0.876879870891571*x_104) + 0.0013842320040788*std::exp(0.973119854927063*x_104) - 0.000160769779038642*std::exp(0.653039813041687*x_106) + 0.000459057128540919*std::exp(0.848959863185883*x_106) + 0.00303423643582585*std::exp(1.05311989784241*x_106) + 0.00886371244949468*std::exp(0.576079845428467*x_109) + 0.00483366783305991*std::exp(0.711199820041656*x_109) - 0.00733344510353745*std::exp(0.828479886054993*x_109) - 0.000316028239341522*std::exp(1.09879982471466*x_109) + 1.77008699134049e-5*std::exp(1.26071989536285*x_109) + 0.00752764780622135*std::exp(0.654639840126038*x_110) - 7.57572215036123e-5*std::exp(0.930479824542999*x_110) + 7.07727723966353e-6*std::exp(0.998239815235138*x_110) + 0.000566946494003488*std::exp(1.11503982543945*x_110) - 0.000466509800948756*std::exp(1.34391975402832*x_110) - 6.2405055307046e-5*std::exp(1.47463989257813*x_110) + 0.00229032888682281*std::exp(0.405039876699448*x_112) - 0.00594037021387986*std::exp(0.421119838953018*x_112) + 0.000638042612375676*std::exp(0.89711982011795*x_112) + 0.00163920981023206*std::exp(0.762399852275848*x_114) + 0.000697787652308703*std::exp(1.31567978858948*x_23) - 0.000148817011158411*std::exp(1.51271986961365*x_23) + 0.00329674256565936*std::exp(0.536079823970795*x_26) - 1.69443145135626e-5*std::exp(0.615919828414917*x_26) - 0.0081969719243742*std::exp(0.62095981836319*x_26) - 0.000732858513270767*std::exp(0.918959856033325*x_26) - 0.000357264413738932*std::exp(1.03471982479095*x_26) - 5.20470684766126e-6*std::exp(1.19559991359711*x_26) - 0.000134465078974092*std::exp(1.30039978027344*x_26) - 0.00309755729163214*std::exp(0.533599853515625*x_31) + 0.021839563942462*std::exp(0.643759846687317*x_31) + 0.00599252617837377*std::exp(0.644639849662781*x_31) - 0.021697767129303*std::exp(0.649439811706543*x_31) - 0.00147170974337223*std::exp(0.654799818992615*x_31) - 0.000130428358560747*std::exp(0.655919849872589*x_31) + 0.00279680122439605*std::exp(0.658159852027893*x_31) + 0.00087469808759431*std::exp(0.659039855003357*x_31) + 9.1746969169661e-6*std::exp(0.666559815406799*x_31) + 0.00470420063279747*std::exp(0.540479838848114*x_45) - 7.95446941009508e-6*std::exp(1.24111986160278*x_45) - 8.41666067991532e-5*std::exp(0.760639846324921*x_49) - 1.33352091111139e-5*std::exp(1.0195198059082*x_50) + 0.000200845605396988*std::exp(1.29199981689453*x_52) + 0.00115050244959065*std::exp(0.987999796867371*x_6) - 0.00136587266698133*std::exp(0.698879837989807*x_60) - 0.000531844380766681*std::exp(1.37487983703613*x_60) - 0.0057878111304321*std::exp(0.935359835624695*x_66) + 0.00223684766558991*std::exp(0.659359872341156*x_68) - 0.0023401995554094*std::exp(1.31007981300354*x_68) + 0.00146499772154523*std::exp(0.628559827804565*x_70) + 1.25986452662464e-5*std::exp(0.78551983833313*x_70) - 0.00172151110267425*std::exp(0.799999833106995*x_72) + 0.00133448329028885*std::exp(0.812319874763489*x_72) + 0.0080967945580817*std::exp(0.835599899291992*x_72) + 0.0034333245093433*std::exp(1.06815981864929*x_72) - 0.000654467329864418*std::exp(0.794799864292145*x_73) + 0.00669678567750092*std::exp(0.678079843521118*x_74) + 0.00380045943990877*std::exp(1.16815984249115*x_74) - 0.000574071935397613*std::exp(1.25239992141724*x_74) - 0.000636544044143671*std::exp(1.4819198846817*x_74) - 0.00815437776802424*std::exp(0.930879831314087*x_78) + 0.000503182420970113*std::exp(1.2513599395752*x_81) + 0.00152699650741908*std::exp(1.27559983730316*x_81) - 0.000103211633741632*std::exp(2.05335974693298*x_81) + 1.2125493878612e-5*std::exp(0.704079866409302*x_87) - 0.0122134652530613*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.0538895743317598*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.0011520393795227*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.00765106430759629*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.0263901215655553*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.0002072274337002*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.0446582911000936*std::sin(0.323119848966599*x_105 + 1.94975972175598) - 0.0353289427311805*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.0265077925206178*std::sin(0.520639836788177*x_106 + 5.37607955932617) - 4.21601195218736e-5*std::sin(0.505919814109802*x_109 - 7.33463954925537) + 0.0483710108802429*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0224599056081706*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.0210786619088369*std::sin(0.45007985830307*x_111 - 1.17727982997894) + 0.0168015519698813*std::sin(0.601279854774475*x_112 - 0.998639822006226) - 0.0141438707737485*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.00419035285523539*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.000383105482472495*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0329025165493023*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.0340254130000475*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.00973105695386213*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.0372754617283749*std::sin(0.284639924764633*x_119 + 8.28767967224121) + 0.0208184502568953*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.000270206382638865*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.000665200614444475*std::sin(0.403279840946198*x_120 + 5.21072006225586) - 0.0955055072152502*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.0390625512881056*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.00201975217176097*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.0145402662736526*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.000364207432972017*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.0576401542050546*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.00930146325306946*std::sin(0.358079850673676*x_24 + 5.16359996795654) - 0.00733712797700728*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.0146835323974634*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.114526722769699*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.0338297300169513*std::sin(0.315679848194122*x_28 + 5.11208009719849) - 0.0130078607051602*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 9.81098977011174e-5*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.000152904389412418*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.000141157267738872*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.0141831366569239*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.0907748024801094*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.0158929334942305*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.00012867498981386*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00592184873167013*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.0327767345309813*std::sin(0.366399854421616*x_36 + 5.18304014205933) + 0.0357048672657272*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.00224095225705046*std::sin(0.472239851951599*x_37 + 5.05007982254028) - 0.0185811414055387*std::sin(0.5204798579216*x_38 + 2.12431979179382) + 0.00428931102564261*std::sin(0.699439823627472*x_38 - 0.933919847011566) + 0.00958983479509587*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.000163329718361017*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.0067453509735944*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00386158594744212*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.0410634831492145*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.134329178896335*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.0131013749529062*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.0477484283709494*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.0749611054329379*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 4.39075517904136e-5*std::sin(0.535439848899841*x_54 - 1.04375982284546) + 0.0100358401727124*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.00310065391965773*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.0206982383198683*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.0115790018614573*std::sin(0.410559862852097*x_56 - 7.3808798789978) - 0.0286145041633462*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.164499508075133*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.0180947282307108*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.0519645208583275*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.0147690437220489*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.0291560206354496*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.00266378795707793*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.013298077231317*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.000136223535657907*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.000705821919313103*std::sin(0.41967985033989*x_65 + 1.98983979225159) - 0.0239495494264437*std::sin(0.245919972658157*x_69 - 7.54095983505249) - 0.0591741741983648*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.017745371378386*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.0108742761207892*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.0556085224616506*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0295730325207757*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.000272608296575507*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.0146919391769497*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.0148045668996776*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.062739615456749*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.000183280534344661*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.13475533262667*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.0260351667858418*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.0247147983169262*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.00856333740487705*std::sin(0.699679851531982*x_86 - 7.12943983078003) + 0.00133738618092636*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00400259789612537*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 9.04677203469991e-5*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0131114592965696*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.000127539967066992*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0480022271706648*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.0028836945868526*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.00556515400320699*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.00406100747281971*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.0586196923898005*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0197073660341045*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.000254008734578554*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.0245984639136352*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.0044958948812698*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.000231558629683101*std::sin(0.438799858093262*x_96 - 1.18743991851807) + 0.0267790315758997*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.0210046957743745*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.00036859041348167*std::sin(0.384079843759537*x_98 + 8.38000011444092) + 0.00469248618301605*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00440212574215857*std::sin(0.446799844503403*x_98 - 1.14799976348877) - 0.0272850037605743*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.000840763463368644*std::sin(0.434639871120453*x_99 + 5.23040008544922) - 1.30995166301727*std::sin(0.00135027024664503*x_10 + 0.00966032186632824*x_101 + 0.0115207950143631*x_103 - 0.003830467173354*x_105 - 0.00515207238021082*x_107 - 0.00797321613650925*x_11 + 0.00631906183310841*x_110 - 0.00243876719185478*x_113 + 0.00083439831029719*x_115 - 0.00550371365068256*x_116 + 0.0118186363988073*x_117 - 0.00352836314774254*x_118 + 0.00759292918822575*x_12 - 0.0072709327150879*x_13 - 0.00193684120087719*x_17 + 0.00598595196754409*x_19 + 0.014093551297422*x_2 + 0.00268139789191514*x_20 - 0.00618409899560461*x_21 + 0.00238729472879902*x_23 + 0.000871159203314045*x_27 - 0.00934532320269825*x_29 + 0.00573332367451718*x_3 - 0.00578336308247489*x_30 - 0.000455188914670199*x_32 - 0.0148802926142121*x_33 - 0.0118716114226436*x_35 - 0.00912131047166246*x_37 - 0.00164782938030173*x_39 - 0.00449938507236347*x_4 - 0.00410090760843531*x_40 + 0.00589728292639765*x_41 - 0.00551089428042669*x_42 + 0.00223062792024028*x_43 + 0.00249997769279673*x_44 - 0.00844108541978506*x_45 + 0.00467863244623476*x_46 + 0.00545766599043562*x_48 + 0.0073767128139793*x_49 - 0.00129088751262281*x_5 - 0.000546413741368074*x_51 + 0.00376270311398535*x_52 - 0.0144813183731924*x_54 - 0.00160002824899174*x_55 - 0.00858773188253241*x_56 + 0.00117096138302369*x_57 + 0.000278336777866287*x_58 + 0.00818233851270388*x_6 + 0.0139206371520432*x_60 + 0.0153830259748758*x_61 - 0.00284327651111423*x_62 - 0.0124980344509992*x_63 + 0.00283304300792681*x_64 - 0.00708108893928336*x_65 - 0.00265027650000356*x_66 - 0.00517895827600293*x_67 + 0.00579940161156629*x_68 - 0.00319624856262053*x_69 + 0.00910291485398227*x_7 + 0.00268976765476601*x_70 + 0.0093270839498838*x_71 + 0.00202842592400997*x_72 - 0.00617465497294358*x_73 - 0.000135911130524118*x_76 + 0.00148218799430655*x_77 + 0.00562627596632556*x_78 - 0.00930330364999065*x_8 - 0.0106233373843745*x_80 - 0.000738761563467277*x_81 + 0.0035677825227305*x_82 - 0.00163566483385169*x_83 + 0.0099829895887426*x_84 + 0.00288727188213581*x_86 - 0.00213666767083805*x_88 - 0.00804542966307638*x_9 + 0.00829126612629701*x_91 + 0.0152857696981164*x_93 + 0.000130156582171277*x_94 - 0.00548218220022512*x_95 + 0.00024573959104614*x_96 - 0.000114704510439517*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 5.88961869196422e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 9.67401611938479e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) + 0.000153431237077534*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 6.46859222760976e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) + 0.00017039961343203*std::exp(1.1522399187088*x_1) + 0.000723950255649881*std::exp(1.55327987670898*x_100) + 0.00651171860568391*std::exp(0.700399816036224*x_114) + 0.00418229376390955*std::exp(0.629919826984406*x_26) + 0.00234679305361001*std::exp(0.594959855079651*x_31) - 0.00972092355698377*std::exp(0.629199862480164*x_47) + 8.80328723280184e-5*std::exp(1.98231983184814*x_50) - 0.00929166063368874*std::exp(0.623999834060669*x_90) + 0.0587964079063497*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.0303880439124526*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.00231755124397326*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0313230714134782*std::sin(0.421359866857529*x_111 - 1.16935980319977) - 0.0406886845304655*std::sin(0.538319826126099*x_112 - 0.998959839344025) - 0.0547980602417653*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.0540420057483004*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.023741016688561*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.0766734762400745*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.0428316465714573*std::sin(0.427359849214554*x_22 + 5.21424007415771) + 0.0782149007238075*std::sin(0.313599824905396*x_24 + 5.11432027816772) - 0.0264734714245307*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.0711963009347727*std::sin(0.329839825630188*x_28 + 5.12192010879517) + 0.0810718629724505*std::sin(0.352799862623215*x_34 + 2.00847983360291) - 0.049685223606204*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0498374804346824*std::sin(0.482639849185944*x_38 + 5.25967979431152) + 0.0818473939345665*std::sin(0.351199835538864*x_53 - 4.25352001190186) - 0.0674284803817216*std::sin(0.362799853086472*x_59 + 8.34911918640137) + 0.119135263741441*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.153732930809127*std::sin(0.212719991803169*x_75 - 7.5798397064209) - 0.0992033853214735*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0338617984763445*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.143263445024786*std::sin(0.211520001292229*x_89 + 1.78799998760223) - 0.0615073005167943*std::sin(0.379919856786728*x_92 + 8.19079971313477) - 0.110279580161716*std::sin(0.303999930620193*x_97 + 5.11295986175537) - 0.048563752724391*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.0689022877145362*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 4.89264964015475) + 1.71079681636672);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.63314381754528e-5*x_1 + 0.00430796489604105*x_10 - 0.0153114013054762*x_100 + 0.0247858420726007*x_101 - 0.0166493879909619*x_102 - 0.00132341213276614*x_103 - 0.00129618666932378*x_104 - 0.0154355649890447*x_105 + 0.00101300825886498*x_106 - 0.0103023251503887*x_107 + 0.00839077267687914*x_108 - 9.17145676751288e-6*x_109 - 0.00184207902748187*x_11 + 0.00172378998721323*x_110 - 0.000323277087893*x_111 - 0.000268052811427948*x_112 - 7.48599095012462e-5*x_113 - 0.0115717317345165*x_114 + 0.00300136089539018*x_115 + 0.00940460045048054*x_116 - 0.00722448908387646*x_117 - 0.00411841901815566*x_118 + 0.00657736698672386*x_119 - 0.0100058986834*x_12 - 0.00863815472996137*x_120 - 0.00194283844451298*x_13 - 0.0172510548826653*x_14 + 0.00422660119090786*x_15 + 0.00207010321997739*x_16 + 0.00397343459302353*x_17 + 0.0030267551138066*x_18 - 0.0088701075616923*x_19 - 0.00966013306409757*x_2 - 0.000648042965769366*x_20 + 0.0072298563332706*x_21 + 0.00291509204605239*x_22 - 0.0141575143833501*x_23 - 0.00381860051260514*x_24 + 0.00457362361678984*x_25 + 0.00748085264562184*x_26 + 0.000613185066704173*x_27 - 0.00200468538124742*x_28 - 0.0178659831864463*x_29 + 0.00346137925851059*x_3 + 0.0103599056382958*x_30 + 0.00253275610133937*x_32 - 0.0263543254092805*x_33 + 0.00852993580531862*x_34 - 0.00246011525113821*x_35 + 0.00367763866942191*x_36 + 0.010719601356737*x_37 - 0.00466337258101996*x_38 + 0.0151772868093574*x_39 - 0.0137822773514242*x_4 - 0.00158596675150387*x_40 + 0.0089341516055843*x_41 + 0.0175768691018804*x_42 + 0.0175475236538503*x_43 - 0.0245744391923566*x_44 - 0.00659390372391689*x_45 + 0.00767665107881397*x_46 - 0.0134561017820621*x_47 - 0.0106630398549397*x_48 + 0.00893325484042556*x_49 + 0.0152921889072848*x_5 + 0.00806141414339102*x_50 - 0.00852073542429772*x_51 - 0.0064642314962021*x_52 - 0.00771518638371915*x_53 + 0.00769290969000449*x_54 + 0.00177966548901641*x_55 - 0.0129741662733201*x_56 + 0.0105903739594273*x_57 + 0.000527298714062991*x_58 - 0.00912535246977712*x_59 + 0.00588284658328374*x_6 + 0.00468717372426347*x_60 + 0.00912366902622193*x_61 + 0.0087432428931407*x_62 - 0.00149713344565562*x_63 + 0.00117181624739135*x_64 - 0.0136018409025073*x_65 - 0.00252006837157336*x_66 - 0.0124467582769405*x_67 + 0.00702604561042052*x_68 + 0.00374300292116753*x_69 - 0.00374598990448924*x_7 + 0.000648439566222269*x_70 - 0.0018399051635986*x_71 - 0.00133203805229248*x_72 - 0.000966899240859592*x_73 - 0.00129711151073164*x_74 - 0.00954176706902331*x_75 - 0.0109994756986971*x_76 + 0.0126719743387014*x_77 - 0.00104009556364363*x_78 - 0.0029226435824067*x_79 - 0.00329774689470964*x_8 + 0.00479183641663985*x_80 + 0.00620563619172576*x_81 + 0.0111683760863358*x_82 + 0.01125260351026*x_83 + 0.00205588891568896*x_84 - 0.00408406335257453*x_85 + 0.000461887833211714*x_86 - 0.00234359870853302*x_87 - 0.00998458769111389*x_88 - 0.0106844667452437*x_89 + 0.0117837475450144*x_9 + 0.00307738309355451*x_90 - 0.0141882525625962*x_91 + 0.00425256387594494*x_92 - 0.0857062497231311*x_93 - 0.0168729297548114*x_94 + 0.00450552580222394*x_95 - 0.00724864607283183*x_96 + 0.00310097393481732*x_97 + 0.00948357942110841*x_98 - 0.0045492672026566*x_99 - 1.29600921260888e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) + 9.21396162406223e-7*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) + 6.65448991874118e-6*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) - 1.08709362023952e-5*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) + 1.48962039699295e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) - 2.12021945456358e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 3.22887971885877e-6*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) - 1.25554779274282e-5*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 5.22715445598832e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 6.69869568629507e-6*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 2.23830453629159e-6*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.000196498591265341*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) - 1.09303583316896e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 3.37058183565445e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) + 1.73356998772347e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 4.52430172458564e-5*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) - 0.000277019942109274*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 5.94546719141746e-5*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) + 8.23060433238518e-5*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 6.92372717786875e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) - 3.65320059810911e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) - 0.000143363483012753*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) + 1.61781242724471e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) + 9.5252774387188e-7*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 4.22811099763461e-6*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 6.21469494466297e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) + 0.000145368115997985*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) + 1.36346601757227e-6*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 5.10833245568642e-5*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) - 0.000139575228611284*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) - 2.72808679519045e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) - 5.14591425498605e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) + 1.94716603542253e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) + 3.10119020280054e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) + 7.30865341517057e-6*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) - 1.57846007776536e-5*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 1.97596343966532e-6*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 6.34949482491316e-6*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 1.3103647072602e-5*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) - 2.44749802011443e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 2.17620261609778e-6*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) - 0.00173193059241677*std::exp(0.581919848918915*x_1) + 6.456298681209e-5*std::exp(0.848399877548218*x_1) + 9.43565591247131e-5*std::exp(1.00727987289429*x_1) + 1.92529019117649e-5*std::exp(1.1522399187088*x_1) - 3.50970642198444e-5*std::exp(1.16983985900879*x_1) - 2.34658158014368e-5*std::exp(1.27119994163513*x_1) - 3.45265082861142e-6*std::exp(1.27711987495422*x_1) + 1.79415986203932e-5*std::exp(1.35095977783203*x_1) - 7.95628445885267e-5*std::exp(1.23759984970093*x_100) - 0.000426857179086013*std::exp(1.47815990447998*x_100) + 8.17968009451146e-5*std::exp(1.55327987670898*x_100) + 0.0191589336415192*std::exp(0.614959836006165*x_104) - 0.00100326781302212*std::exp(0.876879870891571*x_104) + 0.00153796864992687*std::exp(0.973119854927063*x_104) + 0.00302884459236074*std::exp(0.653039813041687*x_106) + 0.000212403039059519*std::exp(0.848959863185883*x_106) + 0.00337122715051772*std::exp(1.05311989784241*x_106) + 0.00294484451217002*std::exp(0.576079845428467*x_109) + 0.00537050838985145*std::exp(0.711199820041656*x_109) + 0.00959643107539972*std::exp(0.828479886054993*x_109) - 0.000146224411497806*std::exp(1.09879982471466*x_109) - 0.000333477998401746*std::exp(1.26071989536285*x_109) + 0.00166730190750701*std::exp(0.654639840126038*x_110) + 0.00142723870154937*std::exp(0.930479824542999*x_110) + 0.000587977742550171*std::exp(0.998239815235138*x_110) + 0.000262322815230493*std::exp(1.11503982543945*x_110) - 0.000518321673410729*std::exp(1.34391975402832*x_110) + 0.00105972173344348*std::exp(0.405039876699448*x_112) + 0.00777347515594782*std::exp(0.421119838953018*x_112) + 0.000708905394659096*std::exp(0.89711982011795*x_112) + 0.000735738051672602*std::exp(0.700399816036224*x_114) + 0.000363069276586683*std::exp(0.762399852275848*x_114) + 0.000154553283267*std::exp(1.31567978858948*x_23) - 6.88567576202736e-5*std::exp(1.51271986961365*x_23) + 0.00152538343575795*std::exp(0.536079823970795*x_26) - 0.00140772778278477*std::exp(0.615919828414917*x_26) - 0.0027233292963245*std::exp(0.62095981836319*x_26) + 0.000472543863104801*std::exp(0.629919826984406*x_26) - 0.000103085047972836*std::exp(0.918959856033325*x_26) - 0.000396943190481024*std::exp(1.03471982479095*x_26) + 9.80547978894256e-5*std::exp(1.19559991359711*x_26) - 2.97827274120471e-5*std::exp(1.30039978027344*x_26) - 0.00344158059620432*std::exp(0.533599853515625*x_31) + 0.000265156566721833*std::exp(0.594959855079651*x_31) + 0.00725588971783623*std::exp(0.643759846687317*x_31) + 0.00132728716661409*std::exp(0.644639849662781*x_31) + 0.0283933572566037*std::exp(0.649439811706543*x_31) - 0.000207013041058261*std::exp(0.654799818992615*x_31) + 0.00245722318510031*std::exp(0.655919849872589*x_31) + 0.00129406351143102*std::exp(0.658159852027893*x_31) + 0.000762230643104806*std::exp(0.666559815406799*x_31) + 0.00522666220322182*std::exp(0.540479838848114*x_45) + 0.000149859331784455*std::exp(1.24111986160278*x_45) - 0.00109833575302697*std::exp(0.629199862480164*x_47) + 0.00158566848437164*std::exp(0.760639846324921*x_49) - 0.00110788455560913*std::exp(1.0195198059082*x_50) + 9.94654988826205e-6*std::exp(1.98231983184814*x_50) + 9.29300828061677e-5*std::exp(1.29199981689453*x_52) + 0.000161831510532101*std::exp(0.987999796867371*x_6) - 7.48100793163067e-5*std::exp(1.37487983703613*x_60) + 0.00757383873560749*std::exp(0.935359835624695*x_66) + 0.00103497628627313*std::exp(0.659359872341156*x_68) - 0.00260010860909669*std::exp(1.31007981300354*x_68) + 0.000677845847336061*std::exp(0.628559827804565*x_70) + 0.00104669108641421*std::exp(0.78551983833313*x_70) + 0.000187710549181475*std::exp(0.812319874763489*x_72) - 0.010595338181617*std::exp(0.835599899291992*x_72) + 0.00114067405699909*std::exp(1.06815981864929*x_72) - 0.000144958246662673*std::exp(0.794799864292145*x_73) + 0.00148327390197971*std::exp(0.678079843521118*x_74) + 0.0012626495037052*std::exp(1.16815984249115*x_74) + 0.000832971537911198*std::exp(1.4819198846817*x_74) + 0.0106706906656831*std::exp(0.930879831314087*x_78) + 7.07784423125443e-5*std::exp(1.2513599395752*x_81) - 0.00199820364493555*std::exp(1.27559983730316*x_81) - 3.4290622010586e-5*std::exp(2.05335974693298*x_81) + 0.00100738183295913*std::exp(0.704079866409302*x_87) - 0.00104983472189139*std::exp(0.623999834060669*x_90) - 0.00270516560257641*std::sin(0.319919854402542*x_100 + 5.12239980697632) - 0.0598746999317552*std::sin(0.251599967479706*x_102 + 1.81823992729187) + 0.021704005974999*std::sin(0.301519930362701*x_102 - 7.51344013214111) + 0.00664321621032669*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.00354010254919374*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.00876774885361446*std::sin(0.453199863433838*x_102 + 5.23767995834351) - 0.0172163834389088*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.00989138384976668*std::sin(0.323119848966599*x_105 + 1.94975972175598) - 0.00880684338293634*std::sin(0.520639836788177*x_106 + 5.37607955932617) + 0.00343344692486773*std::sin(0.437039852142334*x_108 - 7.37992000579834) - 0.00350264813185348*std::sin(0.505919814109802*x_109 - 7.33463954925537) - 0.000261852629105311*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0160705919500943*std::sin(0.247359976172447*x_111 - 7.54960012435913) + 0.0249543650225534*std::sin(0.303439915180206*x_111 - 7.50184011459351) + 0.0035390926619646*std::sin(0.421359866857529*x_111 - 1.16935980319977) + 0.00466872177245772*std::sin(0.45007985830307*x_111 - 1.17727982997894) - 0.00459728303606905*std::sin(0.538319826126099*x_112 - 0.998959839344025) + 0.0037213828767745*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.000589421719585669*std::sin(0.308319926261902*x_115 + 5.10927963256836) + 0.00721756897241032*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.00728759235509055*std::sin(0.300239950418472*x_116 + 1.90559983253479) + 0.0378043697448771*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.00215533593479554*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.00825615783878195*std::sin(0.284639924764633*x_119 + 8.28767967224121) - 0.00619145582281805*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.00963257474538887*std::sin(0.243439972400665*x_120 - 7.53664016723633) - 0.0224486527101489*std::sin(0.304639935493469*x_120 - 7.47384023666382) - 0.0125321394104231*std::sin(0.403279840946198*x_120 + 5.21072006225586) + 0.00610603166774252*std::sin(0.44735985994339*x_120 - 4.16968011856079) + 0.00268242078948589*std::sin(0.387359857559204*x_16 + 5.19464015960693) - 0.00866308841641249*std::sin(0.28247994184494*x_18 + 1.89599990844727) + 0.124977006628186*std::sin(0.262479960918427*x_20 - 7.53648042678833) + 0.0434009465828294*std::sin(0.316799849271774*x_20 + 1.92847979068756) - 0.0380514016995488*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.00322052974817511*std::sin(0.440559864044189*x_21 - 0.9790398478508) - 0.00483940939507225*std::sin(0.427359849214554*x_22 + 5.21424007415771) - 0.0302582274237798*std::sin(0.266799956560135*x_24 + 5.06759977340698) + 0.00883724898985501*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.0191501352010878*std::sin(0.329199820756912*x_24 + 8.31216049194336) - 0.00130835866445885*std::sin(0.358079850673676*x_24 + 5.16359996795654) - 0.0032522618227434*std::sin(0.428159862756729*x_24 + 8.42472076416016) - 0.00299115202396693*std::sin(0.784559845924377*x_25 - 3.99927973747253) + 0.149867870534775*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.00749296125957087*std::sin(0.315679848194122*x_28 + 5.11208009719849) - 0.00815093633026502*std::sin(0.319759845733643*x_28 - 4.27544021606445) - 0.00804424007055882*std::sin(0.329839825630188*x_28 + 5.12192010879517) + 0.00288066349154282*std::sin(0.422799855470657*x_28 + 5.2151198387146) - 0.0117272969277657*std::sin(0.287599951028824*x_3 + 5.07695960998535) + 0.00916004792601972*std::sin(0.352799862623215*x_34 + 2.00847983360291) + 0.00199502263562312*std::sin(0.370879858732224*x_34 + 8.18935966491699) - 0.118786480717391*std::sin(0.309839934110641*x_35 + 8.25224018096924) + 0.0176580467706826*std::sin(0.327839851379395*x_35 + 5.16975975036621) - 0.0106902735997688*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00274000465139357*std::sin(0.293279945850372*x_36 + 1.89527988433838) + 0.0364170095815492*std::sin(0.366399854421616*x_36 + 5.18304014205933) - 0.00561377292640347*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0118624428561229*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.0010368754566511*std::sin(0.472239851951599*x_37 + 5.05007982254028) + 0.00563097593364656*std::sin(0.482639849185944*x_38 + 5.25967979431152) - 0.0206448145089627*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.0135693764481991*std::sin(0.390639841556549*x_41 - 1.18031990528107) + 0.000948811832181978*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.00178673315330758*std::sin(0.41431987285614*x_43 - 1.17959988117218) - 0.0456241074864622*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.0446289912439261*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.00606192929559855*std::sin(0.214559987187386*x_48 - 7.58031988143921) - 0.0530515012667042*std::sin(0.181600004434586*x_53 - 4.43544006347656) + 0.00924767266437696*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.0249047790322857*std::sin(0.285439938306808*x_54 - 1.31799983978271) + 0.00364782419967195*std::sin(0.535439848899841*x_54 - 1.04375982284546) + 0.000686765152653904*std::sin(0.565759837627411*x_55 - 4.23424005508423) - 0.00291144723233706*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.00256463803668917*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.0546526612150351*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.008372324550051*std::sin(0.239199981093407*x_58 + 5.04623985290527) + 0.0679999557837509*std::sin(0.389679849147797*x_58 + 5.19736003875732) - 0.0164093346830445*std::sin(0.510159850120544*x_58 - 4.10351991653442) + 0.0323941691579251*std::sin(0.271919965744019*x_59 + 5.07471990585327) - 0.00761852619675382*std::sin(0.362799853086472*x_59 + 8.34911918640137) + 0.0501848033706129*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.00615294228532636*std::sin(0.29351994395256*x_64 + 5.10960006713867) - 0.0113174041747935*std::sin(0.42399987578392*x_64 - 1.15239989757538) - 0.0132974301281295*std::sin(0.41967985033989*x_65 + 1.98983979225159) - 0.0657462221175575*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.00393042983814291*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.00503146373735511*std::sin(0.229439988732338*x_73 + 1.82079994678497) + 0.0727684390451949*std::sin(0.443199843168259*x_73 - 4.15879964828491) + 0.0134607086298416*std::sin(0.204799994826317*x_74 + 1.79047989845276) + 0.0173697872774628*std::sin(0.212719991803169*x_75 - 7.5798397064209) + 0.0065501435245025*std::sin(0.385759830474854*x_75 - 7.40551996231079) - 0.00513584188429429*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.00679787402666065*std::sin(0.273359954357147*x_76 - 7.51168012619019) - 0.00208243400524772*std::sin(0.305519938468933*x_77 - 7.46776008605957) - 0.0821000753298542*std::sin(0.381119847297668*x_79 - 7.4282398223877) - 0.0152268833321112*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.0447705748615431*std::sin(0.193519994616508*x_84 - 7.61144018173218) + 0.0340692103192194*std::sin(0.367759823799133*x_84 - 7.4172797203064) - 0.011208670069379*std::sin(0.203360006213188*x_85 - 7.59999990463257) - 0.0034764229711527*std::sin(0.221039995551109*x_85 - 7.57552003860474) - 0.009514405409382*std::sin(0.699679851531982*x_86 - 7.12943983078003) - 0.00382593523242385*std::sin(0.534559845924377*x_87 + 5.3407998085022) + 0.000188118874410982*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00132980717910135*std::sin(1.34551978111267*x_87 + 8.78791999816895) + 0.0161868738963069*std::sin(0.211520001292229*x_89 + 1.78799998760223) + 0.00751602688180372*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0029040626844024*std::sin(0.325839847326279*x_92 + 8.19479942321777) + 0.0105959763029628*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0159480687196175*std::sin(0.358079850673676*x_92 - 1.18679988384247) - 0.000405625082388691*std::sin(0.375759840011597*x_92 - 7.39687967300415) - 0.00694951120989275*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.00187900432264704*std::sin(0.405679851770401*x_92 - 1.17551982402802) - 0.0767088087164518*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0043649928671537*std::sin(0.365359842777252*x_95 - 7.40423965454102) + 0.00478543285150456*std::sin(0.401599824428558*x_95 + 5.0099196434021) + 0.0273304375451896*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00208022417407842*std::sin(0.427599847316742*x_96 - 1.1937597990036) + 0.00436248098071683*std::sin(0.438799858093262*x_96 - 1.18743991851807) - 0.0124601335470227*std::sin(0.303999930620193*x_97 + 5.11295986175537) + 0.0297531851003143*std::sin(0.351279854774475*x_97 + 5.16311979293823) + 0.0233375355482681*std::sin(0.36983984708786*x_98 + 5.1780800819397) + 0.00694411031318036*std::sin(0.384079843759537*x_98 + 8.38000011444092) - 0.00548706155394453*std::sin(0.414159864187241*x_98 - 7.39120006561279) + 0.000660052594776041*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.00203683774376521*std::sin(0.446799844503403*x_98 - 1.14799976348877) + 0.00778504692672507*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 0.00604336706331342*std::sin(0.408639848232269*x_99 + 5.2050404548645) - 0.0158396800984998*std::sin(0.434639871120453*x_99 + 5.23040008544922) + 3.70825815200806*std::sin(-0.0017559414982552*x_10 - 0.00206881730241496*x_100 - 0.000640372911428364*x_101 - 0.001976459218873*x_102 + 0.000774700917513977*x_103 + 0.000947985579457343*x_105 + 0.00127705961008622*x_107 - 0.00113349105148907*x_108 + 0.00100778548239609*x_11 + 0.00153693197199974*x_111 + 0.0026666671635907*x_112 - 0.000302442467221005*x_113 - 7.44672538326954e-5*x_114 + 0.00466882987480925*x_116 + 0.00250948452723514*x_117 - 0.0032493632445524*x_118 + 0.000768292655097704*x_119 + 0.00379024490455315*x_12 + 0.00370257841192143*x_120 - 0.00164420973684629*x_13 - 0.00205727472322567*x_14 - 0.00216911692817349*x_16 + 0.00173523245758871*x_17 - 0.00163144197258074*x_18 - 0.00228581424498518*x_19 + 0.000117448499575376*x_2 + 0.00351251415453931*x_20 - 0.000687904378359011*x_21 + 0.000560871452374787*x_22 - 0.00100180503482992*x_23 + 0.00133035762593317*x_25 + 0.000683479243255846*x_26 - 0.00060744343595969*x_27 + 0.00198612440977102*x_29 + 0.00400334404444214*x_3 + 0.000804910803675705*x_30 - 0.00112360076805607*x_32 - 0.00120223142169769*x_33 - 0.000638857147562835*x_34 - 0.00335550454148459*x_35 + 2.6398243662733e-5*x_36 + 0.00301256777617011*x_37 + 0.00567410872856116*x_39 - 0.00267134742541306*x_4 - 0.000423857229117153*x_40 - 0.0038853393374884*x_42 - 9.0634150990701e-5*x_43 - 0.00204119391679281*x_44 - 0.00170595482609547*x_45 + 0.00118018726168461*x_46 - 0.000202268547450462*x_47 + 0.00143979432435024*x_48 - 0.00274612366677382*x_49 - 0.000968148436233983*x_5 - 0.000496215254533471*x_50 + 0.000717981302096358*x_51 + 0.00206162990862452*x_52 + 0.000567852910760165*x_53 + 0.0031042908946524*x_54 + 0.000425539860247188*x_56 + 0.0041331794876524*x_57 - 0.000192477551813871*x_59 + 0.000496311516877983*x_6 + 0.000947762623941735*x_61 - 2.86851781088872e-6*x_62 + 0.00313764056767957*x_63 - 0.0023405631464726*x_64 + 0.00124374598385675*x_65 + 0.00211247435917612*x_66 - 0.000221120619027974*x_68 - 0.00167069128460471*x_7 - 0.000113313536599669*x_70 + 0.00178900973616236*x_71 + 0.00090155420509128*x_73 - 0.00195131395520898*x_75 + 0.00247850037560489*x_76 + 0.00293148285504551*x_77 + 0.000473279101743833*x_78 + 0.00194172966171283*x_79 + 0.000893184977004972*x_8 + 0.00194342741576018*x_80 - 0.00167853055945614*x_81 + 0.00181485028590872*x_82 - 0.000141913967890966*x_83 + 0.00162435179176806*x_84 - 0.000879112082855759*x_85 - 0.000527948252514295*x_86 - 0.000849873735363917*x_88 + 0.00039543284815543*x_89 + 0.00431880817208829*x_9 + 0.00186394134902563*x_90 + 0.00896306847990998*x_91 + 0.00795507726403782*x_93 + 0.00215297199526429*x_94 + 0.00207738075939895*x_95 + 0.0020770183513459*x_96 + 0.00141161504287987*x_97 + 0.000109445707794586*x_98 + 0.000411863928119271*x_99 + 1.89638972049651e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) - 1.2618902560069e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) - 1.51188772103614e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 2.64819893666841e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 2.40179972118906e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) + 9.92212254113238e-6*std::exp(1.27559983730316*x_1) + 0.000133538756503524*std::exp(1.47463989257813*x_110) - 0.00187174090878766*std::exp(0.659039855003357*x_31) + 0.00292279105584326*std::exp(0.698879837989807*x_60) + 0.00368381136475291*std::exp(0.799999833106995*x_72) + 0.0012284397797483*std::exp(1.25239992141724*x_74) + 0.075599373443282*std::sin(0.194159999489784*x_106 - 7.60576009750366) + 0.0302660562670738*std::sin(0.307359933853149*x_115 - 7.4868803024292) + 0.0157005060172768*std::sin(0.361039847135544*x_24 - 7.44112014770508) + 0.0278351414767837*std::sin(0.318719834089279*x_28 + 8.29880046844482) - 0.00917857147634793*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.0205210075900171*std::sin(0.307359933853149*x_41 + 1.89215993881226) - 0.0214754014805081*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.0612313423189406*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.0512489418283693*std::sin(0.245919972658157*x_69 - 7.54095983505249) + 0.0119087106274058*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 4.67828972110155) + 4.01563208484799);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000343192612967417*x_1 + 0.00570294408793528*x_10 + 0.00950189910403819*x_100 - 0.0416820534973527*x_101 + 0.0182814962027171*x_102 + 0.00838986235782194*x_103 - 0.000386203895787646*x_104 + 0.0130028828583288*x_105 - 0.0074104904412674*x_106 + 0.0129832495099974*x_107 - 0.00110023816017826*x_108 - 0.00341100528641961*x_109 + 0.0102022956733563*x_11 - 0.00726484983096891*x_110 + 0.00555196033782918*x_111 + 0.00711127875722135*x_112 + 0.0155442414599718*x_113 + 0.0124706716290129*x_114 - 0.00325294544467355*x_115 + 0.00520317994033427*x_116 + 0.0114647072772329*x_117 - 0.00991797752112661*x_118 - 0.0019133989347379*x_119 + 0.00374528491719988*x_12 + 0.0132172999065777*x_120 + 0.00813840644178243*x_13 + 0.0219829275880922*x_14 - 0.00921848313969971*x_15 - 0.00708901617300994*x_16 + 0.0142405030101066*x_17 - 0.0156617417365108*x_18 - 0.0226790331212624*x_19 + 0.0178576005053216*x_2 + 0.00836844236607191*x_20 - 0.00718700617849601*x_21 - 0.0108316337811504*x_22 + 0.0307478777017097*x_23 + 0.00265394808002548*x_24 + 0.00250240100889949*x_25 - 0.00784155814324242*x_26 - 0.00919575074011375*x_27 + 0.00224812898592558*x_28 + 0.0341250704697079*x_29 - 0.00840346980457075*x_3 - 0.0119015328822766*x_30 + 0.0435077416513391*x_32 + 0.0347162931733883*x_33 + 0.00409233156807812*x_34 - 0.0104998982216224*x_35 - 0.0100785887069519*x_36 - 0.00593235921090432*x_37 + 0.0162945870855847*x_38 + 0.00154999042545393*x_39 + 0.0304588968221564*x_4 - 0.00231377496191714*x_40 - 0.0113708679463055*x_41 - 0.0297466624050764*x_42 - 0.032572132046611*x_43 + 0.0260525995422081*x_44 + 0.0062264579480696*x_45 - 0.00453099860396431*x_46 + 0.00176587535846624*x_47 + 0.0212838093795369*x_48 - 0.0199947380989992*x_49 - 0.0123293270220124*x_5 - 0.0162975007500512*x_50 + 0.025347046889216*x_51 + 0.0202234099566178*x_52 - 0.000684528708843738*x_53 + 0.00945373492836916*x_54 - 0.000304002125949606*x_55 + 0.026278272069599*x_56 + 0.00185584713656333*x_57 + 0.00122619293385742*x_58 + 0.0121195376283197*x_59 - 0.00665434392931541*x_6 + 0.00786093475612629*x_60 - 0.00167761525160022*x_61 - 0.0042195237018426*x_62 - 0.00106375232755524*x_63 + 0.00128786125784757*x_64 + 0.0135230053342486*x_65 + 0.00761165065372829*x_66 + 0.0243601486521778*x_67 - 0.00588381821018559*x_68 - 0.0143606281830913*x_69 + 0.0119280512568574*x_7 - 0.000103398532323579*x_70 + 0.00619430175116225*x_71 + 0.000340757807542959*x_72 + 0.00429818197564443*x_73 - 0.00133234735768302*x_74 + 0.00528649948952354*x_75 + 0.019789967834046*x_76 - 0.00959063911137297*x_77 + 0.00189483612258045*x_78 + 0.0133016638908547*x_79 + 0.00433101768975523*x_8 + 0.0052977227524345*x_80 - 0.0125274536219023*x_81 - 0.0030015507567282*x_82 - 0.00589994221556091*x_83 + 0.000986665865776984*x_84 + 0.00754962015629695*x_85 + 0.000622058491599824*x_86 + 0.001905799890984*x_87 + 0.0125472165079986*x_88 + 0.00810916489906232*x_89 + 0.000756982012284108*x_9 + 0.00119686613488837*x_90 - 0.00342294924847637*x_91 - 0.00459790654617498*x_92 + 0.122472967657258*x_93 + 0.0238119521389813*x_94 - 0.000414278890684639*x_95 + 0.00497699387994542*x_96 - 0.0305951215720011*x_97 - 0.00670942380427889*x_98 + 0.00351635772363536*x_99 + 4.48882495640573e-5*std::pow(-8.79199981689453*x_104 - 9.99172019958496, 2) + 2.91607752766518e-5*std::pow(-6.84104013442993*x_104 - 8.85072040557861, 2) - 8.70365645937992e-6*std::pow(-9.02975940704346*x_106 - 9.06752014160156, 2) - 1.49728939588733e-5*std::pow(-8.04415988922119*x_106 - 8.24824047088623, 2) + 6.75876781573807e-6*std::pow(-7.37423992156982*x_107 - 8.19727993011475, 2) - 2.98694113988656e-5*std::pow(-8.60000038146973*x_109 - 9.99384021759033, 2) + 6.20977185725049e-5*std::pow(-6.32600021362305*x_114 - 8.35479927062988, 2) + 4.56845757030617e-5*std::pow(-5.91479969024658*x_114 - 7.29895973205566, 2) - 1.9382426073845e-5*std::pow(-8.77088069915771*x_115 - 9.58775997161865, 2) + 7.80609494409637e-6*std::pow(-7.75000047683716*x_115 - 8.1617603302002, 2) + 1.18601605903398e-6*std::pow(-6.40136003494263*x_115 - 7.4015998840332, 2) - 2.79248136216526e-5*std::pow(-6.18487977981567*x_115 - 6.77871990203857, 2) - 1.34361685732776e-5*std::pow(-9.30527973175049*x_12 - 5.73744010925293, 2) - 0.00117954824906308*std::pow(-1.56175982952118*x_120 - 1.78399980068207, 2) + 2.45937852835209e-5*std::pow(-7.53872013092041*x_14 - 9.39223957061768, 2) - 3.57869443190903e-5*std::pow(-7.99815988540649*x_15 - 6.56272029876709, 2) + 5.76365009062973e-5*std::pow(-4.67928028106689*x_15 - 5.85807991027832, 2) - 3.90060844834506e-5*std::pow(-4.35008001327515*x_15 - 5.72880029678345, 2) + 0.000188604302007115*std::pow(-4.23360013961792*x_15 - 6.44783973693848, 2) + 0.000350285819547061*std::pow(-5.10943984985352*x_19 - 6.74160003662109, 2) + 0.000247848343900227*std::pow(-3.50720000267029*x_21 - 4.54351949691772, 2) - 0.000104074239637227*std::pow(-6.6093602180481*x_24 - 9.41975975036621, 2) + 1.57096020224062e-6*std::pow(-6.16455984115601*x_45 - 7.38488006591797, 2) + 2.27129790546417e-5*std::pow(-7.41720008850098*x_55 - 9.42327976226807, 2) + 0.000181280072322136*std::pow(-6.31696033477783*x_55 - 9.56800079345703, 2) - 3.48591624073312e-5*std::pow(-5.86367988586426*x_55 - 6.47103977203369, 2) - 8.99773038888997e-6*std::pow(-7.15383958816528*x_58 - 9.19583988189697, 2) + 2.53806446753083e-5*std::pow(-8.80399990081787*x_59 - 9.99571990966797, 2) - 1.41008421856055e-6*std::pow(-5.05672025680542*x_66 - 6.61719989776611, 2) - 0.000313226099582619*std::pow(-2.16383981704712*x_66 - 2.56047987937927, 2) - 1.28795194674969e-5*std::pow(-7.29863977432251*x_67 - 8.91287994384766, 2) + 6.26838531550991e-5*std::pow(-7.17431974411011*x_67 - 7.18943977355957, 2) - 8.73518052869561e-5*std::pow(-4.91015958786011*x_7 - 7.46384000778198, 2) + 0.000176489905276517*std::pow(-6.8692798614502*x_70 - 9.90000057220459, 2) + 4.66499212035664e-5*std::pow(-6.36672019958496*x_70 - 8.76352024078369, 2) + 3.19936011044608e-5*std::pow(-4.41687965393066*x_71 - 6.6384801864624, 2) - 3.32962801194089e-5*std::pow(-5.33383989334106*x_76 - 6.5237603187561, 2) - 1.92809746492232e-5*std::pow(-7.15983963012695*x_78 - 9.59960079193115, 2) - 1.64447904954084e-5*std::pow(-7.19999980926514*x_79 - 9.99832057952881, 2) + 9.81373174619251e-6*std::pow(-8.69783973693848*x_82 - 9.30352020263672, 2) - 4.48336545483617e-7*std::pow(-9.99979972839355*x_84 - 8.0, 2) + 3.81149577456662e-5*std::pow(-8.42239952087402*x_84 - 9.00815963745117, 2) - 2.97315413020088e-6*std::pow(-2.10951972007751*x_85 - 3.58319997787476, 2) + 1.52167858769949e-5*std::pow(-6.44575977325439*x_87 - 8.87592029571533, 2) - 5.6851492139174e-5*std::pow(-6.11999988555908*x_87 - 8.97311973571777, 2) + 2.05567601964553e-5*std::pow(-6.24183988571167*x_90 - 8.05368041992188, 2) + 0.00218998936446252*std::exp(0.581919848918915*x_1) + 0.000387560834701597*std::exp(0.848399877548218*x_1) + 0.000393343637467933*std::exp(1.00727987289429*x_1) - 4.33198730850247e-5*std::exp(1.1522399187088*x_1) + 7.56239871233867e-5*std::exp(1.16983985900879*x_1) + 4.01262327886459e-5*std::exp(1.27119994163513*x_1) + 2.34860328558888e-5*std::exp(1.27559983730316*x_1) - 7.83389770370941e-7*std::exp(1.27711987495422*x_1) - 1.11547981756793e-5*std::exp(1.35095977783203*x_1) + 0.000171434838451837*std::exp(1.23759984970093*x_100) + 0.000729920096554296*std::exp(1.47815990447998*x_100) - 0.000184046386978065*std::exp(1.55327987670898*x_100) - 0.0242260637308921*std::exp(0.614959836006165*x_104) - 0.00602244924287314*std::exp(0.876879870891571*x_104) - 0.000956198511260656*std::exp(0.973119854927063*x_104) - 0.00517928395169013*std::exp(0.653039813041687*x_106) + 4.81932220356749e-5*std::exp(0.848959863185883*x_106) - 0.00209598705578285*std::exp(1.05311989784241*x_106) + 0.0122761561351918*std::exp(0.576079845428467*x_109) - 0.00333899662215676*std::exp(0.711199820041656*x_109) - 0.0121344828043004*std::exp(0.828479886054993*x_109) - 3.31776115895165e-5*std::exp(1.09879982471466*x_109) + 0.000570242940070331*std::exp(1.26071989536285*x_109) + 0.0100085350892096*std::exp(0.654639840126038*x_110) - 0.00244055918907486*std::exp(0.930479824542999*x_110) - 0.00126692138558731*std::exp(0.998239815235138*x_110) + 5.95197777555523e-5*std::exp(1.11503982543945*x_110) + 0.000322255211439477*std::exp(1.34391975402832*x_110) + 0.000316091200221999*std::exp(1.47463989257813*x_110) + 0.000240445734778591*std::exp(0.405039876699448*x_112) - 0.00982939385156541*std::exp(0.421119838953018*x_112) - 0.000440746489227792*std::exp(0.89711982011795*x_112) - 0.0016554428609437*std::exp(0.700399816036224*x_114) + 0.00217944427351199*std::exp(0.762399852275848*x_114) + 0.000927757565540855*std::exp(1.31567978858948*x_23) - 1.56232652006481e-5*std::exp(1.51271986961365*x_23) + 0.000346102122335564*std::exp(0.536079823970795*x_26) + 0.00303324480508418*std::exp(0.615919828414917*x_26) - 0.0113527269474021*std::exp(0.62095981836319*x_26) - 0.00106324440183733*std::exp(0.629919826984406*x_26) + 0.000973757955873386*std::exp(0.918959856033325*x_26) + 0.000246790783291361*std::exp(1.03471982479095*x_26) - 0.000167672399691887*std::exp(1.19559991359711*x_26) - 0.000178780742116188*std::exp(1.30039978027344*x_26) + 0.0021397277783462*std::exp(0.533599853515625*x_31) - 0.000596613895956723*std::exp(0.594959855079651*x_31) + 0.0302475851298012*std::exp(0.643759846687317*x_31) + 0.00796748334581923*std::exp(0.644639849662781*x_31) - 0.0359027958081035*std::exp(0.649439811706543*x_31) + 0.00195547850696197*std::exp(0.654799818992615*x_31) - 0.00420181895116367*std::exp(0.655919849872589*x_31) + 0.000293616750545573*std::exp(0.658159852027893*x_31) - 0.00443048030290513*std::exp(0.659039855003357*x_31) - 0.00164238581261781*std::exp(0.666559815406799*x_31) - 0.00324956338857796*std::exp(0.540479838848114*x_45) - 0.000256257463350827*std::exp(1.24111986160278*x_45) + 0.00247130358030852*std::exp(0.629199862480164*x_47) - 0.00271147200966352*std::exp(0.760639846324921*x_49) + 0.00238716967444279*std::exp(1.0195198059082*x_50) - 2.238017316912e-5*std::exp(1.98231983184814*x_50) + 2.10853862275309e-5*std::exp(1.29199981689453*x_52) - 0.0015286864971258*std::exp(0.987999796867371*x_6) + 0.00691835506806776*std::exp(0.698879837989807*x_60) + 0.000706668050762981*std::exp(1.37487983703613*x_60) - 0.00957695784794091*std::exp(0.935359835624695*x_66) + 0.000234831112524912*std::exp(0.659359872341156*x_68) + 0.00161656089755307*std::exp(1.31007981300354*x_68) + 0.00015379994359437*std::exp(0.628559827804565*x_70) - 0.00225531550859448*std::exp(0.78551983833313*x_70) + 0.00871971842605455*std::exp(0.799999833106995*x_72) - 0.00177314406173617*std::exp(0.812319874763489*x_72) + 0.0133975795751989*std::exp(0.835599899291992*x_72) + 0.00475512128576351*std::exp(1.06815981864929*x_72) - 0.000870160162152618*std::exp(0.794799864292145*x_73) + 0.00890384568507451*std::exp(0.678079843521118*x_74) + 0.00526359961874028*std::exp(1.16815984249115*x_74) + 0.00290776261924263*std::exp(1.25239992141724*x_74) - 0.0010532747772415*std::exp(1.4819198846817*x_74) - 0.0134928611871833*std::exp(0.930879831314087*x_78) - 0.000668584558687179*std::exp(1.2513599395752*x_81) + 0.00252668597090412*std::exp(1.27559983730316*x_81) - 0.000142947115895298*std::exp(2.05335974693298*x_81) - 0.00217061547617879*std::exp(0.704079866409302*x_87) + 0.00236217413463249*std::exp(0.623999834060669*x_90) - 0.0162386576381908*std::sin(0.319919854402542*x_100 + 5.12239980697632) + 0.0372257906165025*std::sin(0.251599967479706*x_102 + 1.81823992729187) - 0.0371135614277534*std::sin(0.301519930362701*x_102 - 7.51344013214111) - 0.0149475276208557*std::sin(0.376959830522537*x_102 + 1.97279977798462) + 0.000803232142712162*std::sin(0.377599835395813*x_102 + 5.18224000930786) + 0.0365500634876664*std::sin(0.453199863433838*x_102 + 5.23767995834351) + 0.0370963095756359*std::sin(0.319119840860367*x_105 + 1.92935979366302) + 0.0593763264442346*std::sin(0.323119848966599*x_105 + 1.94975972175598) + 0.178946526936452*std::sin(0.194159999489784*x_106 - 7.60576009750366) - 0.0367130366239403*std::sin(0.520639836788177*x_106 + 5.37607955932617) - 0.00772540605624496*std::sin(0.437039852142334*x_108 - 7.37992000579834) + 0.00754719014564394*std::sin(0.505919814109802*x_109 - 7.33463954925537) + 0.000589179891520171*std::sin(0.701279819011688*x_109 - 4.15256023406982) + 0.0669933828930537*std::sin(0.247359976172447*x_111 - 7.54960012435913) - 0.0155148329487439*std::sin(0.303439915180206*x_111 - 7.50184011459351) - 0.00796311359477522*std::sin(0.421359866857529*x_111 - 1.16935980319977) + 0.0280255576215753*std::sin(0.45007985830307*x_111 - 1.17727982997894) + 0.0103440883130845*std::sin(0.538319826126099*x_112 - 0.998959839344025) + 0.0223388403353247*std::sin(0.601279854774475*x_112 - 0.998639822006226) + 0.071640880160461*std::sin(0.307359933853149*x_115 - 7.4868803024292) - 0.00556777243739905*std::sin(0.308319926261902*x_115 + 5.10927963256836) - 0.012341946907182*std::sin(0.497439861297607*x_115 - 4.12024021148682) - 0.0437462006571074*std::sin(0.300239950418472*x_116 + 1.90559983253479) - 0.023504043512797*std::sin(0.395679831504822*x_117 + 1.99599981307983) - 0.0129381219054024*std::sin(0.631359875202179*x_117 - 3.99463987350464) + 0.0495603376085953*std::sin(0.284639924764633*x_119 + 8.28767967224121) + 0.0139310469499727*std::sin(0.366319835186005*x_119 + 5.16383981704712) + 0.00218558461091357*std::sin(0.243439972400665*x_120 - 7.53664016723633) + 0.0483703312862788*std::sin(0.304639935493469*x_120 - 7.47384023666382) + 0.0214297916414912*std::sin(0.403279840946198*x_120 + 5.21072006225586) - 0.0137388388572277*std::sin(0.44735985994339*x_120 - 4.16968011856079) - 0.00603556433693526*std::sin(0.387359857559204*x_16 + 5.19464015960693) + 0.0194923286080844*std::sin(0.28247994184494*x_18 + 1.89599990844727) - 0.158030764348453*std::sin(0.262479960918427*x_20 - 7.53648042678833) - 0.0269835932688082*std::sin(0.316799849271774*x_20 + 1.92847979068756) + 0.0650673906013054*std::sin(0.22495998442173*x_21 + 5.03143978118896) + 0.0193323025933853*std::sin(0.440559864044189*x_21 - 0.9790398478508) + 0.0108888832323454*std::sin(0.427359849214554*x_22 + 5.21424007415771) + 0.0651976982102856*std::sin(0.266799956560135*x_24 + 5.06759977340698) - 0.0198841975311445*std::sin(0.313599824905396*x_24 + 5.11432027816772) + 0.0798310568748339*std::sin(0.329199820756912*x_24 + 8.31216049194336) + 0.0123589665398264*std::sin(0.358079850673676*x_24 + 5.16359996795654) + 0.0371636813239518*std::sin(0.361039847135544*x_24 - 7.44112014770508) - 0.0195227849411474*std::sin(0.428159862756729*x_24 + 8.42472076416016) + 0.00673022314506688*std::sin(0.784559845924377*x_25 - 3.99927973747253) - 0.189504731877168*std::sin(0.301519840955734*x_27 - 4.31599998474121) + 0.044978995916004*std::sin(0.315679848194122*x_28 + 5.11208009719849) + 0.0658868144957868*std::sin(0.318719834089279*x_28 + 8.29880046844482) + 0.0175629021339905*std::sin(0.319759845733643*x_28 - 4.27544021606445) + 0.0180998927080772*std::sin(0.329839825630188*x_28 + 5.12192010879517) - 0.00492589624096185*std::sin(0.422799855470657*x_28 + 5.2151198387146) + 0.0252689212494313*std::sin(0.287599951028824*x_3 + 5.07695960998535) - 0.0206105092845998*std::sin(0.352799862623215*x_34 + 2.00847983360291) - 0.0188453049378937*std::sin(0.370879858732224*x_34 + 8.18935966491699) + 0.150202976119275*std::sin(0.309839934110641*x_35 + 8.25224018096924) - 0.0109785059888578*std::sin(0.327839851379395*x_35 + 5.16975975036621) + 0.023034436954339*std::sin(0.333759844303131*x_35 + 1.99071979522705) + 0.00062169380027745*std::sin(0.293279945850372*x_36 + 1.89527988433838) - 0.0226414825478388*std::sin(0.366399854421616*x_36 + 5.18304014205933) + 0.012631235115333*std::sin(0.420239865779877*x_36 + 5.22168016433716) + 0.0494508963188844*std::sin(0.298159927129745*x_37 - 1.32039988040924) - 0.000235262025096192*std::sin(0.472239851951599*x_37 + 5.05007982254028) - 0.0126699426355742*std::sin(0.482639849185944*x_38 + 5.25967979431152) + 0.0128354637785765*std::sin(0.5204798579216*x_38 + 2.12431979179382) - 0.0217260198480706*std::sin(0.699439823627472*x_38 - 0.933919847011566) - 0.0485739877225987*std::sin(0.307359933853149*x_41 + 1.89215993881226) + 0.0292380679866319*std::sin(0.390639841556549*x_41 - 1.18031990528107) - 0.00896262928894851*std::sin(0.354479849338531*x_43 + 8.34535980224609) - 0.000405401108934814*std::sin(0.41431987285614*x_43 - 1.17959988117218) + 0.0283657951403793*std::sin(0.351759850978851*x_44 + 5.15248012542725) + 0.186044615395611*std::sin(0.180400013923645*x_46 + 4.9605598449707) + 0.00137542243181124*std::sin(0.214559987187386*x_48 - 7.58031988143921) + 0.0329836154552158*std::sin(0.181600004434586*x_53 - 4.43544006347656) - 0.0208076687861721*std::sin(0.351199835538864*x_53 - 4.25352001190186) + 0.103820407036533*std::sin(0.285439938306808*x_54 - 1.31799983978271) - 0.00786000243713812*std::sin(0.535439848899841*x_54 - 1.04375982284546) - 0.0508330735358014*std::sin(0.350959837436676*x_55 + 5.14120006561279) + 0.00412253659486328*std::sin(0.565759837627411*x_55 - 4.23424005508423) + 0.0275019991875137*std::sin(0.202319994568825*x_56 + 1.78511989116669) - 0.0153950941132822*std::sin(0.410559862852097*x_56 - 7.3808798789978) + 0.144936863211597*std::sin(0.140880048274994*x_58 + 4.90823936462402) + 0.22783022991768*std::sin(0.166080012917519*x_58 - 7.64192008972168) + 0.00189963993821329*std::sin(0.239199981093407*x_58 + 5.04623985290527) - 0.0859844964933219*std::sin(0.389679849147797*x_58 + 5.19736003875732) + 0.0102021464452159*std::sin(0.510159850120544*x_58 - 4.10351991653442) - 0.0201403691315858*std::sin(0.271919965744019*x_59 + 5.07471990585327) + 0.0171420178345498*std::sin(0.362799853086472*x_59 + 8.34911918640137) - 0.0858153460140233*std::sin(0.217439994215965*x_64 - 4.37599992752075) + 0.00139607283889348*std::sin(0.29351994395256*x_64 + 5.10960006713867) + 0.0243857213305273*std::sin(0.42399987578392*x_64 - 1.15239989757538) + 0.0227384285859522*std::sin(0.41967985033989*x_65 + 1.98983979225159) + 0.121308150208881*std::sin(0.245919972658157*x_69 - 7.54095983505249) + 0.0408762816542523*std::sin(0.261439949274063*x_70 - 7.51576042175293) + 0.0235937143558774*std::sin(0.518559873104095*x_70 + 5.33784008026123) + 0.00114161478165504*std::sin(0.229439988732338*x_73 + 1.82079994678497) - 0.0920141420650926*std::sin(0.443199843168259*x_73 - 4.15879964828491) - 0.0302871843502672*std::sin(0.204799994826317*x_74 + 1.79047989845276) - 0.0390827826278886*std::sin(0.212719991803169*x_75 - 7.5798397064209) + 0.0393194184023729*std::sin(0.385759830474854*x_75 - 7.40551996231079) + 0.00878222128557969*std::sin(0.534719824790955*x_75 - 7.24295997619629) + 0.00154240473106226*std::sin(0.273359954357147*x_76 - 7.51168012619019) + 0.0196710068052312*std::sin(0.305519938468933*x_77 - 7.46776008605957) + 0.103813797493501*std::sin(0.381119847297668*x_79 - 7.4282398223877) + 0.0328095142609052*std::sin(0.258879989385605*x_82 + 1.85407984256744) - 0.186634834196253*std::sin(0.193519994616508*x_84 - 7.61144018173218) - 0.0430797911772051*std::sin(0.367759823799133*x_84 - 7.4172797203064) + 0.0252199988906972*std::sin(0.203360006213188*x_85 - 7.59999990463257) + 0.0328388509556978*std::sin(0.221039995551109*x_85 - 7.57552003860474) + 0.0059153743403118*std::sin(0.699679851531982*x_86 - 7.12943983078003) + 0.00860852194955857*std::sin(0.534559845924377*x_87 + 5.3407998085022) - 0.00177700116757874*std::sin(0.90479987859726*x_87 + 8.66631984710693) + 0.00554355942831005*std::sin(1.34551978111267*x_87 + 8.78791999816895) - 0.036421175677565*std::sin(0.211520001292229*x_89 + 1.78799998760223) - 0.0161948565432198*std::sin(0.355119854211807*x_90 - 1.06399977207184) - 0.0174326036257975*std::sin(0.325839847326279*x_92 + 8.19479942321777) - 0.0228312536477595*std::sin(0.3503198325634*x_92 - 7.3997597694397) + 0.0664826210170686*std::sin(0.358079850673676*x_92 - 1.18679988384247) + 0.0038315998182575*std::sin(0.375759840011597*x_92 - 7.39687967300415) + 0.0156367047936575*std::sin(0.379919856786728*x_92 + 8.19079971313477) + 0.028188360696723*std::sin(0.383839845657349*x_92 - 1.19767987728119) + 0.000426336990884327*std::sin(0.405679851770401*x_92 - 1.17551982402802) + 0.0969966556311021*std::sin(0.351119846105576*x_95 - 1.22583997249603) - 0.0262023236933614*std::sin(0.365359842777252*x_95 - 7.40423965454102) - 0.00818302650198712*std::sin(0.401599824428558*x_95 + 5.0099196434021) - 0.0169921042890278*std::sin(0.38647985458374*x_96 + 5.19152021408081) + 0.00047199280174728*std::sin(0.427599847316742*x_96 - 1.1937597990036) - 0.00745978443065958*std::sin(0.438799858093262*x_96 - 1.18743991851807) + 0.0280358465624157*std::sin(0.303999930620193*x_97 + 5.11295986175537) - 0.018498394814183*std::sin(0.351279854774475*x_97 + 5.16311979293823) - 0.0145096044375207*std::sin(0.36983984708786*x_98 + 5.1780800819397) - 0.0118743362384891*std::sin(0.384079843759537*x_98 + 8.38000011444092) + 0.0123461289740091*std::sin(0.414159864187241*x_98 - 7.39120006561279) - 0.00623496305329756*std::sin(0.439519852399826*x_98 - 7.38319969177246) + 0.000462148630596633*std::sin(0.446799844503403*x_98 - 1.14799976348877) - 0.0175166967749734*std::sin(0.407759845256805*x_99 - 4.20120000839233) - 0.0362773238834622*std::sin(0.408639848232269*x_99 + 5.2050404548645) + 0.0270856422085769*std::sin(0.434639871120453*x_99 + 5.23040008544922) + 1.16897077991209);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
