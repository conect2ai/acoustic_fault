
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.240956293584468*x_1 - 0.323787593479047*x_10 + 9.3776485388902*x_100 - 119.405666784683*x_101 + 4.32778294532196*x_102 + 8.36943829359585*x_103 + 0.900946992816097*x_104 + 3.51095563556176*x_105 + 6.93360357582608*x_106 - 5.82015551434089*x_107 + 1.82310848261588*x_108 + 12.2654911753244*x_109 + 1.96929151227649*x_11 + 11.0982904095879*x_110 + 12.9631360535802*x_111 - 6.21550987680732*x_112 - 9.45749967513663*x_113 + 0.557145091002018*x_114 + 19.9677183882107*x_115 + 23.1978281605838*x_116 - 3.13419715300177*x_117 + 20.709365700181*x_118 + 7.22959499842454*x_119 + 3.73959533266479*x_12 + 21.5136289754709*x_120 - 0.834345435953976*x_13 - 1.83553109166555*x_14 - 1.42726373539415*x_15 - 6.8588850332483*x_16 + 2.14891138112766*x_17 + 8.36265121570624*x_18 + 4.76971784096513*x_19 - 6.24597083720139*x_2 + 15.8222946342533*x_20 + 2.93524070584542*x_21 - 0.18002479630099*x_22 + 15.9117574064918*x_23 + 2.83793446637104*x_24 + 16.0522548196661*x_25 + 18.2185789473681*x_26 - 8.37956088225727*x_27 - 2.10847863025661*x_28 - 2.46553135279143*x_29 + 15.5040387283677*x_3 + 0.512273624880988*x_30 + 149.996065583155*x_31 + 55.0889059894061*x_32 - 53.9301116525104*x_33 + 3.03365728046338*x_34 + 13.0389533778129*x_35 - 7.86569380379807*x_36 + 16.830656543082*x_37 + 8.28859440759813*x_38 - 12.1807380736632*x_39 - 91.5580880774321*x_4 + 3.61941115718413*x_40 - 14.0496506596591*x_41 + 23.7044483108235*x_42 - 16.2748646192709*x_43 - 5.22776100355175*x_44 + 10.0782469106168*x_45 + 2.57173191412541*x_46 + 7.86989311192759*x_47 - 25.363803793478*x_48 - 16.6927435741466*x_49 + 6.86532308163101*x_5 - 3.13034173108581*x_50 + 3.33055400880657*x_51 + 28.5406041842756*x_52 + 6.25103785077658*x_53 - 23.4607456143814*x_54 - 21.494995248446*x_55 - 17.8477195253284*x_56 + 12.2057493346516*x_57 - 2.23846004368304*x_58 + 3.67659439914692*x_59 + 0.368094383057021*x_6 - 4.88709665740804*x_60 - 2.00616751927801*x_61 + 3.27806692459641*x_62 - 15.1982861644338*x_63 + 1.66659377660976*x_64 + 3.62324172355379*x_65 + 16.2464280860569*x_66 - 12.5416416487926*x_67 - 10.0307394692*x_68 - 11.4887125821039*x_69 - 4.83847233234661*x_7 - 12.1289518869834*x_70 - 0.192717681523342*x_71 + 7.85319846147568*x_72 - 11.034648926656*x_73 + 5.72230952763387*x_74 - 7.08083817529612*x_75 - 7.80282308384757*x_76 - 2.18849083214387*x_77 + 10.204125180639*x_78 + 1.82885891732091*x_79 + 16.2537153496296*x_8 - 10.2766260217413*x_80 + 6.89425624203943*x_81 + 4.50915789235495*x_82 + 11.4174082956387*x_83 - 30.791630893388*x_84 - 0.0430492565423579*x_85 + 20.3907612454289*x_86 - 0.859967190237853*x_87 + 10.4214231086489*x_88 - 21.6368871697839*x_89 + 81.7794655990527*x_9 - 41.2998526935071*x_90 + 2.00196449396038*x_91 + 7.97655019455078*x_92 + 612.997568029746*x_93 + 14.3679136371754*x_94 - 12.9274340152356*x_95 + 6.06969747073952*x_96 - 9.99476029012725*x_97 - 14.6650411826572*x_98 - 9.58053406278197*x_99 + 0.000352559836605819*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) - 6.51622531313261e-5*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) + 0.0554686720500359*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.110097517069174*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) - 0.021767114082322*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 1.05504031676002e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) + 0.0309134836046397*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) - 0.000381618349834964*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) + 0.0460414310846161*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) + 0.000591456975310717*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.00278081956380145*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) - 0.0010392742629122*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) - 0.00220161424286224*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 1.76960048478867e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.00996968488691542*std::exp(0.497599840164185*x_1) - 1.1219103268185*std::exp(0.678719818592072*x_1) - 0.00136318732813286*std::exp(1.07895982265472*x_1) + 0.107644252910363*std::exp(1.13103985786438*x_1) - 0.0359690258138353*std::exp(1.18119990825653*x_1) + 0.00269258240664135*std::exp(1.18687987327576*x_1) - 0.0925030696827357*std::exp(1.18903994560242*x_1) + 0.17408104540947*std::exp(0.886079907417297*x_108) + 2.83252442517759*std::exp(1.05951988697052*x_108) - 3.51351494358764*std::exp(0.766639888286591*x_15) - 0.136246798683212*std::exp(3.22775983810425*x_17) + 0.000536227480180095*std::exp(3.42799997329712*x_17) - 1.63155470832216e-6*std::exp(3.65799999237061*x_17) + 0.010281202822426*std::exp(4.0492000579834*x_17) + 4.41506106061445*std::exp(0.82207989692688*x_29) + 2.3211001416516*std::exp(0.885519862174988*x_29) - 0.0685466647998501*std::exp(0.991279780864716*x_29) - 1.44093699485225*std::exp(1.08511984348297*x_29) - 0.0031742311755009*std::exp(1.32527983188629*x_29) - 4.13912141055309e-5*std::exp(2.31079983711243*x_29) + 0.000990261606427289*std::exp(1.29527986049652*x_38) - 0.126693906899243*std::exp(1.79503989219666*x_50) + 2.9141813062191*std::exp(1.84271991252899*x_50) - 0.0133017825344183*std::exp(1.87079989910126*x_50) - 0.000292843211038681*std::exp(1.91103982925415*x_50) - 0.032293887134138*std::exp(1.92647981643677*x_50) + 0.0210251781883967*std::exp(1.93199980258942*x_50) - 0.970654727242459*std::exp(1.9819997549057*x_50) + 1.01426311907693*std::exp(1.99463987350464*x_50) - 0.250441671323259*std::exp(0.991679787635803*x_6) - 0.00232374156733103*std::exp(0.749679863452911*x_67) + 0.765161605540982*std::exp(1.43279981613159*x_71) + 0.0261087584039156*std::exp(1.4605598449707*x_71) + 2.02336748180124*std::exp(1.48087978363037*x_71) + 0.00262496535623806*std::exp(1.84319996833801*x_71) + 0.000184118926249208*std::exp(1.88271987438202*x_71) + 0.332811370278739*std::exp(1.89127993583679*x_71) - 0.00248404797227944*std::exp(1.05399990081787*x_77) - 0.132661025083827*std::exp(1.27823996543884*x_77) - 2.18043740758665*std::exp(1.18599987030029*x_78) + 0.000614726020331985*std::exp(1.42031991481781*x_78) + 0.025122211244924*std::exp(1.42575979232788*x_78) + 0.0258145918077085*std::exp(1.79463994503021*x_78) - 0.28131853220367*std::exp(1.83119988441467*x_78) - 0.104579945243307*std::exp(0.928399801254272*x_87) - 0.00129016538793285*std::exp(0.936639785766602*x_87) + 65.4622633582207*std::sin(0.295679867267609*x_100 - 1.27375984191895) + 0.709713805310266*std::sin(0.614319860935211*x_100 - 0.991679787635803) + 0.252058908970304*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0821187070052418*std::sin(0.382559835910797*x_105 - 7.41167974472046) - 0.0248008334626336*std::sin(0.385439842939377*x_105 - 7.41663980484009) - 23.0128028453771*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 41.9697767100435*std::sin(0.493199855089188*x_105 + 2.0623996257782) + 0.136249714776654*std::sin(0.463439851999283*x_106 + 5.25072002410889) - 3.12059910665709*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 0.568776946341225*std::sin(0.350639849901199*x_112 + 1.9696798324585) + 12.484435300017*std::sin(0.355839848518372*x_112 + 1.9748797416687) - 19.6435069540971*std::sin(0.416639864444733*x_112 + 1.99151980876923) - 17.6033475157195*std::sin(0.493919849395752*x_116 + 2.07927989959717) + 19.2501664992518*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 0.60728545528123*std::sin(0.238559976220131*x_120 - 7.54008007049561) - 37.3572708945658*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.0040943722800105*std::sin(0.343759834766388*x_14 + 4.94831991195679) - 0.675035489770683*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 0.319836004901379*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.00769858742540603*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 57.0730504186524*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.23267297487404*std::sin(0.222399994730949*x_27 + 5.02719974517822) + 0.81232351536291*std::sin(0.320479840040207*x_28 + 8.2992000579834) - 2.50955554155102*std::sin(0.321199834346771*x_28 + 5.12680006027222) - 0.0221207520732199*std::sin(0.280239969491959*x_3 - 1.10599982738495) - 0.695896360174184*std::sin(0.328879833221436*x_3 - 4.25367975234985) - 0.0215906066243652*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 0.45353203558193*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 123.239017357972*std::sin(0.298239946365356*x_36 + 1.90175986289978) - 34.093793588868*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0115848028125267*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 0.473082738255274*std::sin(0.369359821081161*x_36 - 7.43367958068848) + 21.3308658046161*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.160353018352031*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.160720650261421*std::sin(0.306479930877686*x_43 - 7.47168016433716) - 0.283949912269596*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 46.9613365477754*std::sin(0.434479862451553*x_46 + 5.22919988632202) + 37.7017823212583*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.00977851766930828*std::sin(0.324799835681915*x_53 + 5.13336038589478) - 0.601787818326074*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.00806754814275307*std::sin(0.286639958620071*x_55 - 7.50279998779297) - 1.91998718484502*std::sin(0.296719938516617*x_55 + 5.11632013320923) - 3.8015256959819*std::sin(0.540319859981537*x_55 - 7.25352001190186) - 3.60903777662535*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.0128088886094416*std::sin(0.222479999065399*x_64 - 4.35383987426758) - 30.0782411622749*std::sin(0.286879926919937*x_68 - 4.28023958206177) + 0.696356672363671*std::sin(0.504639863967896*x_73 + 5.28304004669189) - 0.00954905796538086*std::sin(0.658399820327759*x_73 + 8.62887954711914) + 55.6501837290962*std::sin(0.241759970784187*x_75 - 7.55552005767822) - 14.0710013378475*std::sin(0.534959852695465*x_79 - 1.05399978160858) - 0.468335949157851*std::sin(0.5865598320961*x_79 + 8.38696002960205) + 85.0411975119953*std::sin(0.155680030584335*x_8 - 4.45311975479126) + 14.338603249152*std::sin(0.477839857339859*x_84 - 1.1515998840332) + 12.5709196329623*std::sin(0.700639843940735*x_85 + 8.47208023071289) + 32.2412409249009*std::sin(0.424319863319397*x_86 + 2.02199983596802) + 26.4086387389777*std::sin(0.436799854040146*x_86 - 1.14247989654541) + 0.62209529592609*std::sin(0.725279867649078*x_87 - 7.05223989486694) + 28.4123243711765*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.116450308104374*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0125659384067633*std::sin(0.363519847393036*x_92 + 1.98439979553223) + 0.739532857996975*std::sin(0.367519825696945*x_92 + 1.99647974967957) - 24.1207211277476*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 76.8562112072464*std::sin(0.293919950723648*x_96 - 7.49056005477905) - 0.934707323356739*std::sin(0.330639839172363*x_97 + 5.15528011322021) + 37.22669096156*std::sin(0.374319821596146*x_97 + 5.16991996765137) - 0.0163555395950767*std::sin(0.395039826631546*x_97 - 1.20311987400055) + 27.3681121416197*std::sin(0.479519844055176*x_98 + 2.05647969245911) - 0.00517178004584671*std::sin(0.585759818553925*x_98 - 7.39888000488281) + 2594.91143154703 - 0.000553355328047974*std::exp(-2.43031978607178*x_86) + 6.02558593332637e-5*std::exp(-2.09447979927063*x_23) + 0.118736368984241*std::exp(-2.07295966148376*x_23) - 0.00213131587313919*std::exp(-4.46087980270386*x_111) + 6.43863382710529e-5*std::exp(-4.18079996109009*x_111) + 1.89654386754243e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.218886620271361*x_1 + 8.61371933851698*x_10 + 19.4049886258093*x_100 - 394.87317336385*x_101 - 6.10623918332253*x_102 + 6.91145137759581*x_103 + 8.36659207340061*x_104 + 0.0516001680927763*x_105 + 10.3014735548081*x_106 + 7.00064036456742*x_107 + 6.06227837303809*x_108 + 42.455673467915*x_109 - 5.95184276137004*x_11 - 3.89826127004485*x_110 + 21.3166879463738*x_111 - 28.8942065576907*x_112 - 16.0725643581573*x_113 + 8.42655962872649*x_114 + 33.572804064371*x_115 + 7.21015458545839*x_116 - 12.9994180843913*x_117 + 30.7976537307136*x_118 - 3.89533009800904*x_119 + 15.1366328761074*x_12 + 25.8998956022816*x_120 + 0.412826734275312*x_13 + 0.959870844161107*x_14 - 7.15536699417356*x_15 + 0.504241178023997*x_16 - 0.704901252869017*x_17 + 28.3731410617808*x_18 + 14.2692025946812*x_19 - 13.9704832854887*x_2 + 29.189954626322*x_20 + 1.22162327718435*x_21 + 6.89083723312249*x_22 + 3.77327506663508*x_23 + 17.0936954105416*x_24 + 32.1307998435453*x_25 + 23.5961005761758*x_26 - 19.7792184995832*x_27 - 6.06640455307727*x_28 - 5.33292077283682*x_29 + 22.3206269182349*x_3 + 18.9656697985928*x_30 + 190.283446561237*x_31 + 27.9815862578728*x_32 - 49.2263906061742*x_33 + 27.1445705735429*x_34 + 49.0158455003033*x_35 + 1.23641565487928*x_36 + 17.5552108803478*x_37 + 14.4978099563451*x_38 - 38.7741854659551*x_39 - 142.702638713529*x_4 + 37.9971978974716*x_40 - 27.0227152161493*x_41 + 43.3007843281257*x_42 - 25.5813515388204*x_43 - 11.1495133573396*x_44 + 24.1613231482015*x_45 + 0.51034597739356*x_46 + 1.58488585558489*x_47 - 58.1401617799293*x_48 + 7.21153009005017*x_49 + 5.43723844249238*x_5 - 6.71684891689961*x_50 + 2.33448729737276*x_51 + 29.1639866764866*x_52 + 11.3336606267946*x_53 - 25.8989643424336*x_54 - 35.1746284972162*x_55 - 17.6135062654112*x_56 + 43.2866439631742*x_57 - 7.12313415845098*x_58 + 8.28744892519155*x_59 - 4.58838483497493*x_6 + 11.482498834551*x_60 + 6.87156703013778*x_61 - 21.0164985727643*x_62 - 35.0026742037204*x_63 + 16.2251298905899*x_64 + 14.1996613119317*x_65 + 30.1743574509556*x_66 - 24.1399497443624*x_67 - 6.42956916497515*x_68 - 25.691505053232*x_69 - 13.4351141238424*x_7 - 20.4803301694618*x_70 + 0.155692317076506*x_71 - 16.7790583812829*x_72 - 15.9994753073078*x_73 + 25.8163029477342*x_74 - 10.7724662088744*x_75 - 38.5336875115532*x_76 + 3.91197686629464*x_77 + 20.4639506768804*x_78 - 8.75265573009224*x_79 + 45.6622703436304*x_8 - 7.44714678185485*x_80 + 28.2456719508017*x_81 + 18.7004910421293*x_82 + 29.7951130954347*x_83 - 58.4908937491766*x_84 + 5.75803707171984*x_85 + 44.4538969187729*x_86 - 21.0734750659726*x_87 + 23.464220488644*x_88 - 30.196976748206*x_89 + 2.66626182162927*x_9 - 47.1798834795035*x_90 - 14.2024116470034*x_91 + 24.5397669641087*x_92 + 1116.98092750707*x_93 + 19.2718146308484*x_94 - 9.62628514827903*x_95 + 1.38879794991281*x_96 - 15.8264874669301*x_97 - 31.591478020498*x_98 - 14.815647645213*x_99 + 0.00252612376878963*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) - 9.36438740366335e-6*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.00524577591327961*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.235109070774968*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) - 0.0110109519727471*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 4.44850273490779e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.00292354588086228*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) - 0.000232010201914193*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.00435422412814813*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) + 0.000359584522926483*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.0199248288303697*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) - 0.000631841292974409*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) - 0.00133850210621301*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 7.46139504929189e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.009452571444584*std::exp(0.497599840164185*x_1) - 0.567521292882836*std::exp(0.678719818592072*x_1) - 0.000195901977463453*std::exp(1.07895982265472*x_1) - 0.010180118042321*std::exp(1.13103985786438*x_1) + 0.000587548958516723*std::exp(1.18119990825653*x_1) + 0.00163699305367687*std::exp(1.18687987327576*x_1) - 0.197536795886829*std::exp(1.18903994560242*x_1) + 0.232722063135813*std::exp(0.886079907417297*x_108) - 0.267877125126941*std::exp(1.05951988697052*x_108) + 0.0573927705610479*std::exp(0.766639888286591*x_15) - 0.29094986959922*std::exp(3.22775983810425*x_17) + 0.000326006980540442*std::exp(3.42799997329712*x_17) - 6.87933481481708e-6*std::exp(3.65799999237061*x_17) - 0.00016794199659119*std::exp(4.0492000579834*x_17) - 0.417540570405904*std::exp(0.82207989692688*x_29) - 0.0379148431180432*std::exp(0.885519862174988*x_29) - 0.491143179805123*std::exp(0.991279780864716*x_29) - 0.728901772925342*std::exp(1.08511984348297*x_29) - 0.00300958829776329*std::exp(1.32527983188629*x_29) - 5.94828056683371e-6*std::exp(2.31079983711243*x_29) + 0.000142309279804525*std::exp(1.29527986049652*x_38) - 0.169372072249311*std::exp(1.79503989219666*x_50) - 0.275599568875634*std::exp(1.84271991252899*x_50) - 0.0126118379039171*std::exp(1.87079989910126*x_50) - 0.0012347526483209*std::exp(1.91103982925415*x_50) - 0.0196335193992264*std::exp(1.92647981643677*x_50) + 0.150647342238613*std::exp(1.93199980258942*x_50) - 0.491008249571621*std::exp(1.9819997549057*x_50) - 0.0165678448551796*std::exp(1.99463987350464*x_50) - 0.334805563169941*std::exp(0.991679787635803*x_6) - 0.000333942047992545*std::exp(0.749679863452911*x_67) + 0.387059012882387*std::exp(1.43279981613159*x_71) + 0.187071663671824*std::exp(1.4605598449707*x_71) + 4.32082449401369*std::exp(1.48087978363037*x_71) + 0.00248881211902326*std::exp(1.84319996833801*x_71) + 0.000776324405765996*std::exp(1.88271987438202*x_71) - 0.0314745928710701*std::exp(1.89127993583679*x_71) - 0.000356979484653921*std::exp(1.05399990081787*x_77) - 0.177349276497051*std::exp(1.27823996543884*x_77) + 0.206208037986092*std::exp(1.18599987030029*x_78) + 0.00259194870492124*std::exp(1.42031991481781*x_78) + 0.180002962224283*std::exp(1.42575979232788*x_78) + 0.0345105065882833*std::exp(1.79463994503021*x_78) - 0.142305720244927*std::exp(1.83119988441467*x_78) - 0.0635808373013718*std::exp(0.928399801254272*x_87) - 0.00543989093642205*std::exp(0.936639785766602*x_87) - 6.19088850808531*std::sin(0.295679867267609*x_100 - 1.27375984191895) + 0.948788310750735*std::sin(0.614319860935211*x_100 - 0.991679787635803) + 0.153242731618545*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0778593259173783*std::sin(0.382559835910797*x_105 - 7.41167974472046) - 0.00356409733116165*std::sin(0.385439842939377*x_105 - 7.41663980484009) + 0.375910885502801*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 89.6248658971258*std::sin(0.493199855089188*x_105 + 2.0623996257782) + 0.0828349156945764*std::sin(0.463439851999283*x_106 + 5.25072002410889) - 1.89721178015122*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 4.07533931580122*std::sin(0.350639849901199*x_112 + 1.9696798324585) + 6.31528446883081*std::sin(0.355839848518372*x_112 + 1.9748797416687) + 0.320873912800172*std::sin(0.416639864444733*x_112 + 1.99151980876923) + 0.287548196406548*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 1.82052419890827*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 4.35125633649906*std::sin(0.238559976220131*x_120 - 7.54008007049561) + 0.610225745916269*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.0172636305892947*std::sin(0.343759834766388*x_14 + 4.94831991195679) - 0.410397247272498*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 2.29165449438138*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.0324605483532773*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 121.877333907463*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.220604557031414*std::sin(0.222399994730949*x_27 + 5.02719974517822) + 0.493863418518793*std::sin(0.320479840040207*x_28 + 8.2992000579834) - 3.35492552799141*std::sin(0.321199834346771*x_28 + 5.12680006027222) - 0.00317894612478396*std::sin(0.280239969491959*x_3 - 1.10599982738495) - 0.423079904583173*std::sin(0.328879833221436*x_3 - 4.25367975234985) - 0.00310275957314095*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 3.24959889368223*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 263.17224607389*std::sin(0.298239946365356*x_36 + 1.90175986289978) + 0.556917304869524*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0488465001538088*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 3.38968148276877*std::sin(0.369359821081161*x_36 - 7.43367958068848) + 10.7902746328*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.152035734280487*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.152384297643144*std::sin(0.306479930877686*x_43 - 7.47168016433716) - 0.0408060933124859*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 100.28415255869*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 3.56552796883551*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0412304268417419*std::sin(0.324799835681915*x_53 + 5.13336038589478) - 0.365865303122125*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.0340162450732209*std::sin(0.286639958620071*x_55 - 7.50279998779297) - 2.56675491464589*std::sin(0.296719938516617*x_55 + 5.11632013320923) + 0.0620973855396881*std::sin(0.540319859981537*x_55 - 7.25352001190186) - 4.82477983364434*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.0540077711771379*std::sin(0.222479999065399*x_64 - 4.35383987426758) + 0.491323822901865*std::sin(0.286879926919937*x_68 - 4.28023958206177) + 0.930931688109257*std::sin(0.504639863967896*x_73 + 5.28304004669189) - 0.00137228339768496*std::sin(0.658399820327759*x_73 + 8.62887954711914) - 0.909037894451896*std::sin(0.241759970784187*x_75 - 7.55552005767822) - 7.11785307659729*std::sin(0.534959852695465*x_79 - 1.05399978160858) - 0.284731376713879*std::sin(0.5865598320961*x_79 + 8.38696002960205) - 1.38913595513528*std::sin(0.155680030584335*x_8 - 4.45311975479126) + 7.25322020804361*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 1.18885534809418*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 3.04911437045986*std::sin(0.424319863319397*x_86 + 2.02199983596802) - 0.431381385396387*std::sin(0.436799854040146*x_86 - 1.14247989654541) + 0.831654591655661*std::sin(0.725279867649078*x_87 - 7.05223989486694) - 0.464111307315499*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.110410195466167*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0529833888631238*std::sin(0.363519847393036*x_92 + 1.98439979553223) + 0.449609322455957*std::sin(0.367519825696945*x_92 + 1.99647974967957) + 0.394008574228028*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 164.123523229569*std::sin(0.293919950723648*x_96 - 7.49056005477905) - 0.568268362662479*std::sin(0.330639839172363*x_97 + 5.15528011322021) - 0.608092741146059*std::sin(0.374319821596146*x_97 + 5.16991996765137) - 0.00235043451698301*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 2.58825347999927*std::sin(0.479519844055176*x_98 + 2.05647969245911) - 0.000743230161459257*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 2333.26727234125 - 0.000524653570493443*std::exp(-2.43031978607178*x_86) + 0.000254064561116875*std::exp(-2.09447979927063*x_23) - 0.00193954182400774*std::exp(-2.07295966148376*x_23) + 0.000201562522730285*std::exp(-4.46087980270386*x_111) + 0.000461334056248968*std::exp(-4.18079996109009*x_111) + 1.79817282181715e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.776585847082745*x_1 + 0.589417259810636*x_10 + 13.1783746702894*x_100 - 727.284687982218*x_101 + 0.495414758044622*x_102 + 14.62890329057*x_103 - 3.20051688402902*x_104 - 3.4121368609494*x_105 + 2.91792077039684*x_106 - 20.4100799943127*x_107 + 2.43432539035593*x_108 + 47.6235962416455*x_109 - 13.4542987967369*x_11 - 11.0016774537625*x_110 + 31.0892563262279*x_111 - 26.7742785036835*x_112 + 9.24516174295114*x_113 + 2.28446263579668*x_114 + 13.2929616075461*x_115 - 16.6190570632801*x_116 + 3.60646987339569*x_117 + 4.0172487204947*x_118 - 4.85147044795817*x_119 + 15.9687606568646*x_12 + 23.4136268997695*x_120 + 1.34799500895512*x_13 + 1.37129243754715*x_14 - 8.40162920720105*x_15 + 2.89719672357493*x_16 - 0.538139776652242*x_17 + 17.1696430737899*x_18 + 11.16124509027*x_19 - 4.68946995389539*x_2 + 15.5370618296464*x_20 - 5.76230192843256*x_21 + 19.9764825531817*x_22 - 9.9899223049987*x_23 + 21.0084896336769*x_24 + 15.6610269354628*x_25 + 12.2208641619067*x_26 - 18.7595697986665*x_27 + 2.65211718847423*x_28 - 3.50810180311102*x_29 + 6.86297880194119*x_3 + 12.489610660853*x_30 + 153.666083780364*x_31 + 45.7296026160362*x_32 - 33.5873232859157*x_33 + 26.3948291089584*x_34 + 71.0623309265787*x_35 + 9.23200957396633*x_36 - 13.2854729352869*x_37 + 6.17140598299112*x_38 - 45.620938480121*x_39 - 85.6433804559716*x_4 + 22.0236372891355*x_40 - 14.1559606205411*x_41 + 26.2821128283882*x_42 - 15.6167130077488*x_43 - 18.0634712571313*x_44 + 18.0450163070289*x_45 + 2.74706985067983*x_46 - 11.4900264706985*x_47 - 19.5040779648146*x_48 + 40.0296641448222*x_49 + 1.70167561944305*x_5 - 4.90899464375059*x_50 - 17.3562583713081*x_51 + 10.2163749897632*x_52 + 4.04066366418542*x_53 - 6.25013512084515*x_54 - 22.7348387629911*x_55 + 0.555152278919859*x_56 + 55.8223805646419*x_57 - 13.8323424757637*x_58 + 17.0784581403616*x_59 - 0.600227511088711*x_6 + 12.5172463164321*x_60 + 12.7382228198217*x_61 - 26.7439210079808*x_62 - 37.4398710890871*x_63 + 13.7761644392989*x_64 + 13.883391960042*x_65 + 13.5522740684019*x_66 - 15.6704438739501*x_67 - 4.39827899823081*x_68 - 33.1845893793986*x_69 - 7.99575196743803*x_7 - 8.76089146900679*x_70 - 0.0233130052131628*x_71 + 10.0755893684981*x_72 - 12.0544690232819*x_73 + 19.9266610704374*x_74 - 2.85520495498873*x_75 - 34.8626831178186*x_76 + 4.25053584435501*x_77 + 15.9712510712927*x_78 - 2.59768768571928*x_79 + 60.7409120368515*x_8 - 1.30777092690666*x_80 + 20.5692428632015*x_81 + 19.8378269607763*x_82 + 34.9112369121308*x_83 - 33.5852833413535*x_84 - 2.28146327798895*x_85 + 33.9337728386619*x_86 - 14.1644610385252*x_87 + 37.5198376639746*x_88 - 19.8833874406298*x_89 - 30.7827566263942*x_9 - 32.107277457746*x_90 + 10.8975337667997*x_91 + 21.1445165366997*x_92 + 146.881384404165*x_93 + 27.1108770036762*x_94 + 7.20294379140259*x_95 - 5.67383847611533*x_96 - 13.1452149856263*x_97 - 23.545412197123*x_98 - 9.54722118202029*x_99 + 0.00103404197563961*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) - 0.000403935297381837*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.0530928919143262*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.175267924988484*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.0510618196061482*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 1.4172196293787e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.0295894273840898*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 0.000253839569551419*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.0440694293519659*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 0.000393417098747963*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.00815601738227909*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.000691289954106214*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.00146443904484181*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 2.37707744752566e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) - 0.0101085481018198*std::exp(0.497599840164185*x_1) + 2.63180422106604*std::exp(0.678719818592072*x_1) - 0.00845028298310613*std::exp(1.07895982265472*x_1) - 0.103033739113366*std::exp(1.13103985786438*x_1) - 0.0418288974244943*std::exp(1.18119990825653*x_1) - 0.00179101439796893*std::exp(1.18687987327576*x_1) - 0.147258734892012*std::exp(1.18903994560242*x_1) + 0.545440198963351*std::exp(0.886079907417297*x_108) - 2.7112044978287*std::exp(1.05951988697052*x_108) - 4.08591705917777*std::exp(0.766639888286591*x_15) - 0.216895842224368*std::exp(3.22775983810425*x_17) - 0.000356680313746502*std::exp(3.42799997329712*x_17) - 2.19164265318343e-6*std::exp(3.65799999237061*x_17) + 0.0119561586261883*std::exp(4.0492000579834*x_17) - 4.22595946546014*std::exp(0.82207989692688*x_29) + 2.69924073672796*std::exp(0.885519862174988*x_29) - 0.201044252163048*std::exp(0.991279780864716*x_29) + 3.38018464995898*std::exp(1.08511984348297*x_29) + 0.00321844360055539*std::exp(1.32527983188629*x_29) - 0.000256580636415643*std::exp(2.31079983711243*x_29) + 0.0061385479669015*std::exp(1.29527986049652*x_38) - 0.396964239409421*std::exp(1.79503989219666*x_50) - 2.78936393087385*std::exp(1.84271991252899*x_50) + 0.0134870570247999*std::exp(1.87079989910126*x_50) - 0.000393371836527372*std::exp(1.91103982925415*x_50) + 0.0214807972751226*std::exp(1.92647981643677*x_50) + 0.0616658919558444*std::exp(1.93199980258942*x_50) + 2.2769851986287*std::exp(1.9819997549057*x_50) + 1.17950116828012*std::exp(1.99463987350464*x_50) - 0.784697464988001*std::exp(0.991679787635803*x_6) - 0.0144046774924539*std::exp(0.749679863452911*x_67) - 1.79493449264435*std::exp(1.43279981613159*x_71) + 0.0765758016607744*std::exp(1.4605598449707*x_71) + 3.22106646421158*std::exp(1.48087978363037*x_71) - 0.00266152730704336*std::exp(1.84319996833801*x_71) + 0.000247324156504116*std::exp(1.88271987438202*x_71) - 0.31855671781954*std::exp(1.89127993583679*x_71) - 0.0153984033420581*std::exp(1.05399990081787*x_77) - 0.415660738630124*std::exp(1.27823996543884*x_77) + 2.08704703625363*std::exp(1.18599987030029*x_78) + 0.000825752124221909*std::exp(1.42031991481781*x_78) + 0.0736823036856041*std::exp(1.42575979232788*x_78) + 0.0808836829916477*std::exp(1.79463994503021*x_78) + 0.659923777167885*std::exp(1.83119988441467*x_78) + 0.069563028863136*std::exp(0.928399801254272*x_87) - 0.00173305956547567*std::exp(0.936639785766602*x_87) - 62.6584474531858*std::sin(0.295679867267609*x_100 - 1.27375984191895) + 2.22371389294523*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.167661028308236*std::sin(0.654959857463837*x_100 - 7.17583990097046) - 0.0832625011961196*std::sin(0.382559835910797*x_105 - 7.41167974472046) - 0.153738269606124*std::sin(0.385439842939377*x_105 - 7.41663980484009) - 26.7619193984155*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 66.813093265106*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.0906286843003391*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 2.07571657473742*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 1.66819693064051*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 29.2862885159324*std::sin(0.355839848518372*x_112 + 1.9748797416687) - 22.843716749321*std::sin(0.416639864444733*x_112 + 1.99151980876923) - 20.4711859969122*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 18.4256621170887*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 1.78114063700993*std::sin(0.238559976220131*x_120 - 7.54008007049561) - 43.4433075945801*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.00549990808221862*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.449010688897492*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 0.938064464667511*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.0103413955319541*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 90.8565005453795*std::sin(0.449439853429794*x_16 - 1.14679980278015) - 0.235913771115732*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.540330022299479*std::sin(0.320479840040207*x_28 + 8.2992000579834) - 7.86307590624511*std::sin(0.321199834346771*x_28 + 5.12680006027222) - 0.137124671686811*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.462886631618754*std::sin(0.328879833221436*x_3 - 4.25367975234985) - 0.133838344875687*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 1.33018884568332*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 196.188319454837*std::sin(0.298239946365356*x_36 + 1.90175986289978) - 39.6481629005392*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.015561689622264*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 1.38753016797378*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 50.0384579066843*std::sin(0.380159854888916*x_36 + 1.96855986118317) + 0.162586502750039*std::sin(0.385199844837189*x_41 - 7.4157600402832) - 0.162959255237402*std::sin(0.306479930877686*x_43 - 7.47168016433716) - 1.76018149684002*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 74.7593245562755*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 36.086976301765*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0131353342303813*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.400288824767573*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.0108370148583317*std::sin(0.286639958620071*x_55 - 7.50279998779297) - 6.01580826703824*std::sin(0.296719938516617*x_55 + 5.11632013320923) - 4.42084890530014*std::sin(0.540319859981537*x_55 - 7.25352001190186) - 11.3080334410819*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.0172059854770033*std::sin(0.222479999065399*x_64 - 4.35383987426758) - 34.9784192320845*std::sin(0.286879926919937*x_68 - 4.28023958206177) + 2.18186259756247*std::sin(0.504639863967896*x_73 + 5.28304004669189) - 0.0591938029090067*std::sin(0.658399820327759*x_73 + 8.62887954711914) + 64.7163990180478*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 33.0080932765707*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.311521172373121*std::sin(0.5865598320961*x_79 + 8.38696002960205) + 98.8956316469699*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 33.6358402746161*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 12.0324942471038*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 30.8603154960225*std::sin(0.424319863319397*x_86 + 2.02199983596802) + 30.7109857979064*std::sin(0.436799854040146*x_86 - 1.14247989654541) + 1.94918281416543*std::sin(0.725279867649078*x_87 - 7.05223989486694) + 33.0411006365446*std::sin(0.356879830360413*x_92 + 2.00383973121643) + 0.118072291581625*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0168796341606341*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.491912148418088*std::sin(0.367519825696945*x_92 + 1.99647974967957) - 28.0503335030359*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 122.349976814712*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.621735576185061*std::sin(0.330639839172363*x_97 + 5.15528011322021) + 43.2914543124905*std::sin(0.374319821596146*x_97 + 5.16991996765137) - 0.10138660701101*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 26.1959078184428*std::sin(0.479519844055176*x_98 + 2.05647969245911) - 0.0320594272055373*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 8403.96975229751 + 0.000561062763208541*std::exp(-2.43031978607178*x_86) + 8.09407804380689e-5*std::exp(-2.09447979927063*x_23) + 0.138080231155116*std::exp(-2.07295966148376*x_23) + 0.00204002942752609*std::exp(-4.46087980270386*x_111) + 0.000188842203556039*std::exp(-4.18079996109009*x_111) - 1.92295996610937e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.00007803279593*x_1 - 5.82528876717619*x_10 - 19.7444283899993*x_100 + 377.292623839077*x_101 - 1.91445228074062*x_102 - 8.53945934385598*x_103 - 7.57014166377979*x_104 - 1.0097366129699*x_105 - 6.4035710171994*x_106 - 3.7408622556449*x_107 - 7.34468442940381*x_108 - 40.8521070711056*x_109 + 6.87207615885082*x_11 - 3.0576178111227*x_110 - 22.738278422504*x_111 + 26.2275936147105*x_112 + 10.6824412658328*x_113 - 4.32145131240436*x_114 - 31.9722865546428*x_115 - 15.8155288353227*x_116 + 9.02243647065864*x_117 - 27.4575877905552*x_118 - 2.66110476769252*x_119 - 17.2969654039514*x_12 - 29.4803265272541*x_120 - 2.99904053384995*x_13 + 1.76991414695821*x_14 + 6.9530529966677*x_15 + 2.9513816998838*x_16 - 0.385380521083654*x_17 - 25.0693811110884*x_18 - 13.7148216431436*x_19 + 14.5740893683866*x_2 - 34.6710066196783*x_20 + 1.99278978015005*x_21 - 3.96969764160012*x_22 - 11.0036969340265*x_23 - 15.0305811911199*x_24 - 31.2421630150819*x_25 - 25.3913718069812*x_26 + 22.4491050816007*x_27 + 7.38886301783269*x_28 + 5.88810653192901*x_29 - 23.3360800071326*x_3 - 9.73523858739485*x_30 - 249.430569560857*x_31 - 51.0650976500762*x_32 + 60.1918669601277*x_33 - 19.2277036444832*x_34 - 48.1708737726426*x_35 + 4.42185654438395*x_36 - 19.9155723823153*x_37 - 14.2702042098369*x_38 + 50.3406946294288*x_39 + 165.258318053232*x_4 - 32.8448059804776*x_40 + 23.3071100055004*x_41 - 41.843009726389*x_42 + 23.9769750028647*x_43 + 15.2099878617752*x_44 - 21.0229527986625*x_45 + 0.231299826498374*x_46 - 3.5212076813718*x_47 + 37.2714105480948*x_48 - 9.23132493093228*x_49 - 9.96932014360663*x_5 + 6.84828683489747*x_50 - 0.741545023880323*x_51 - 33.564856493438*x_52 - 12.1887170385974*x_53 + 29.5272949698212*x_54 + 37.8454685422335*x_55 + 22.3991289508595*x_56 - 44.3115710809068*x_57 + 4.6197321465515*x_58 - 7.59082775793333*x_59 + 2.52546308809393*x_6 - 8.46755410178477*x_60 - 7.39446753805236*x_61 + 11.7366377245311*x_62 + 35.3623345831014*x_63 - 17.5121464803771*x_64 - 13.5162934879219*x_65 - 26.696111171535*x_66 + 22.6888604124886*x_67 + 12.8502106050279*x_68 + 27.9259721548885*x_69 + 15.8618069064382*x_7 + 23.1951936656159*x_70 + 0.225637684826312*x_71 + 4.50947106372865*x_72 + 17.4932399088582*x_73 - 23.5680414163937*x_74 + 8.76133436414201*x_75 + 36.2479892156982*x_76 - 3.74833542175666*x_77 - 20.5366870839664*x_78 + 8.88569866565704*x_79 - 40.4734980327422*x_8 + 11.1579413121673*x_80 - 29.155512106105*x_81 - 19.5120762342895*x_82 - 31.8320997359261*x_83 + 66.2526263673611*x_84 - 4.83675702631357*x_85 - 47.4968825996456*x_86 + 14.8663940628734*x_87 - 27.7526592724028*x_88 + 29.6897346465754*x_89 - 29.5838364237817*x_9 + 48.4325046251738*x_90 + 4.0698281216918*x_91 - 24.1351391273748*x_92 - 1023.85020214293*x_93 - 21.1856263716378*x_94 + 11.5616182748299*x_95 - 0.649425211494253*x_96 + 18.7251684080395*x_97 + 29.8948280718371*x_98 + 12.1475355171371*x_99 + 0.00602453956235248*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) - 0.000673604309506669*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.0244475473601233*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) + 0.233793417555265*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.00126947972116064*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 2.91708706126072e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.0136249675097519*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 0.000244445347886736*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.0202925367665851*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 0.000378857322118787*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.0475186216307916*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.00066570634996239*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.00141024235271075*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 4.89277859412069e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.00809823559196888*std::exp(0.497599840164185*x_1) + 0.065430924994025*std::exp(0.678719818592072*x_1) - 0.014091729717273*std::exp(1.07895982265472*x_1) - 0.0474436807987271*std::exp(1.13103985786438*x_1) + 0.00913674643724185*std::exp(1.18119990825653*x_1) - 0.00172473164193963*std::exp(1.18687987327576*x_1) + 0.196431394378238*std::exp(1.18903994560242*x_1) + 0.299601481303717*std::exp(0.886079907417297*x_108) - 1.24842136063343*std::exp(1.05951988697052*x_108) + 0.892492760553788*std::exp(0.766639888286591*x_15) + 0.289321735340306*std::exp(3.22775983810425*x_17) - 0.000343480110418532*std::exp(3.42799997329712*x_17) - 4.51109502999986e-6*std::exp(3.65799999237061*x_17) - 0.00261160098537417*std::exp(4.0492000579834*x_17) - 1.94591668392282*std::exp(0.82207989692688*x_29) - 0.589599050012621*std::exp(0.885519862174988*x_29) - 1.17132483929451*std::exp(0.991279780864716*x_29) + 0.0840368772597506*std::exp(1.08511984348297*x_29) - 0.00257838358726018*std::exp(1.32527983188629*x_29) - 0.000427875017473807*std::exp(2.31079983711243*x_29) + 0.0102366700593375*std::exp(1.29527986049652*x_38) - 0.218046037636579*std::exp(1.79503989219666*x_50) - 1.28441123370523*std::exp(1.84271991252899*x_50) - 0.0108048519064262*std::exp(1.87079989910126*x_50) - 0.000809683884424759*std::exp(1.91103982925415*x_50) + 0.0206858251929795*std::exp(1.92647981643677*x_50) + 0.35927807041483*std::exp(1.93199980258942*x_50) + 0.0566095481386649*std::exp(1.9819997549057*x_50) - 0.257640142594227*std::exp(1.99463987350464*x_50) - 0.431021628645074*std::exp(0.991679787635803*x_6) - 0.0240213046467154*std::exp(0.749679863452911*x_67) - 0.0446249851023603*std::exp(1.43279981613159*x_71) + 0.446146246953691*std::exp(1.4605598449707*x_71) - 4.29664547514989*std::exp(1.48087978363037*x_71) + 0.00213222264461654*std::exp(1.84319996833801*x_71) + 0.000509071481878688*std::exp(1.88271987438202*x_71) - 0.146684992377995*std::exp(1.89127993583679*x_71) - 0.0256784463203948*std::exp(1.05399990081787*x_77) - 0.228315722328617*std::exp(1.27823996543884*x_77) + 0.961017179925883*std::exp(1.18599987030029*x_78) + 0.00169965952167363*std::exp(1.42031991481781*x_78) + 0.429288137287284*std::exp(1.42575979232788*x_78) + 0.044428099145707*std::exp(1.79463994503021*x_78) + 0.0164067763171819*std::exp(1.83119988441467*x_78) + 0.0669886055218033*std::exp(0.928399801254272*x_87) - 0.00356718572763453*std::exp(0.936639785766602*x_87) - 28.8521741120343*std::sin(0.295679867267609*x_100 - 1.27375984191895) + 1.22145008304899*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.161456145171853*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0667038771415038*std::sin(0.382559835910797*x_105 - 7.41167974472046) - 0.256374626367178*std::sin(0.385439842939377*x_105 - 7.41663980484009) + 5.84564468041754*std::sin(0.404799848794937*x_105 + 5.20832014083862) + 89.1233316815623*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.0872746526534982*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 1.99889741824973*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 9.71925573932544*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 0.728104671274963*std::sin(0.355839848518372*x_112 + 1.9748797416687) + 4.9897860205251*std::sin(0.416639864444733*x_112 + 1.99151980876923) + 4.47155070393691*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 8.484417235664*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 10.3772888205458*std::sin(0.238559976220131*x_120 - 7.54008007049561) + 9.48938438081673*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.0113205535487796*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.432393476897137*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 5.46535499773181*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.0212858688069877*std::sin(0.387759834527969*x_16 - 7.41447973251343) + 121.195317232242*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.18899700319387*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.520333218765127*std::sin(0.320479840040207*x_28 + 8.2992000579834) - 4.31906044620831*std::sin(0.321199834346771*x_28 + 5.12680006027222) - 0.22866971613181*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.445755891794662*std::sin(0.328879833221436*x_3 - 4.25367975234985) - 0.223189422835411*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 7.74995166058146*std::sin(0.309759914875031*x_35 - 4.32407999038696) - 261.699553371128*std::sin(0.298239946365356*x_36 + 1.90175986289978) + 8.66040544765961*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0320308881611824*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 8.08403390563037*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 1.24403728814704*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.130252514019009*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.130551136277098*std::sin(0.306479930877686*x_43 - 7.47168016433716) - 2.93528654086531*std::sin(0.111440062522888*x_44 + 1.70383989810944) - 99.7229697520716*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 16.6168771451493*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0270366799432338*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.38547473586722*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.0223060104239372*std::sin(0.286639958620071*x_55 - 7.50279998779297) - 3.30438620305084*std::sin(0.296719938516617*x_55 + 5.11632013320923) + 0.965652407118735*std::sin(0.540319859981537*x_55 - 7.25352001190186) - 6.21131991374866*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.035415370046215*std::sin(0.222479999065399*x_64 - 4.35383987426758) + 7.6403865981883*std::sin(0.286879926919937*x_68 - 4.28023958206177) + 1.19846184324748*std::sin(0.504639863967896*x_73 + 5.28304004669189) - 0.0987118506207281*std::sin(0.658399820327759*x_73 + 8.62887954711914) - 14.1360964444885*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 0.820634779018725*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.299992241120651*std::sin(0.5865598320961*x_79 + 8.38696002960205) - 21.6019155594599*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 0.836241588376183*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 5.54057167277993*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 14.2101700893369*std::sin(0.424319863319397*x_86 + 2.02199983596802) - 6.70824495385556*std::sin(0.436799854040146*x_86 - 1.14247989654541) + 1.07065460075294*std::sin(0.725279867649078*x_87 - 7.05223989486694) - 7.21721530117877*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.0945909565330666*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0347436356285769*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.47370721776068*std::sin(0.367519825696945*x_92 + 1.99647974967957) + 6.12707483289363*std::sin(0.344559848308563*x_95 + 5.15463972091675) - 163.205099958811*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.598726075224185*std::sin(0.330639839172363*x_97 + 5.15528011322021) - 9.45621484923583*std::sin(0.374319821596146*x_97 + 5.16991996765137) - 0.169072759552174*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 12.0623622850726*std::sin(0.479519844055176*x_98 + 2.05647969245911) - 0.0534624442724829*std::sin(0.585759818553925*x_98 - 7.39888000488281) + 1091.7772472588 - 0.000449482793431617*std::exp(-2.43031978607178*x_86) + 0.000166601773253554*std::exp(-2.09447979927063*x_23) - 0.0301610641862451*std::exp(-2.07295966148376*x_23) + 0.000939367102586319*std::exp(-4.46087980270386*x_111) + 0.00110023321409313*std::exp(-4.18079996109009*x_111) + 1.54053605746554e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.810324212676303*x_1 - 2.98077233469995*x_10 - 3.30009384660448*x_100 - 103.558004176787*x_101 + 1.26096970037068*x_102 + 1.40433898884181*x_103 - 3.81700067875151*x_104 - 1.6189945702123*x_105 - 2.13021225883107*x_106 - 10.6299188528339*x_107 - 1.4804324970028*x_108 + 0.175712950752098*x_109 - 2.98228428525059*x_11 - 2.89855523869632*x_110 + 2.19092644193478*x_111 + 1.8538921610543*x_112 + 10.2329256068962*x_113 - 2.51478979170528*x_114 - 9.20236182117423*x_115 - 11.9360549535866*x_116 + 5.7263076424036*x_117 - 11.0548674924967*x_118 - 2.21481082402029*x_119 - 0.353710331362192*x_12 - 3.203195408647*x_120 + 0.0589619747853834*x_13 + 0.553010859650783*x_14 - 0.107936805445157*x_15 + 1.56308371877835*x_16 - 0.88230116484267*x_17 - 5.26526054573094*x_18 - 1.79820192219401*x_19 + 4.96153387402051*x_2 - 8.55821583973834*x_20 - 2.048347907388*x_21 + 5.22290183243259*x_22 - 6.57762491128632*x_23 + 1.48387018304685*x_24 - 7.64156879478215*x_25 - 5.69427546040941*x_26 + 2.09026649978616*x_27 + 3.81099813128862*x_28 + 1.09880408289566*x_29 - 7.45467770051271*x_3 - 1.0948737125181*x_30 - 19.0500617206984*x_31 - 0.00705991597411515*x_32 + 10.6433618898657*x_33 - 0.816145066638551*x_34 + 5.48076709282828*x_35 + 4.17458741792565*x_36 - 12.8569901680865*x_37 - 3.90579610282968*x_38 + 2.45467083055666*x_39 + 32.5403998928105*x_4 - 7.17815994251133*x_40 + 5.20239573078605*x_41 - 9.09280753566139*x_42 + 4.66981026286766*x_43 - 1.62049247425679*x_44 - 2.56229819485051*x_45 + 0.839185663011794*x_46 - 4.59403003750351*x_47 + 11.1305836539028*x_48 + 10.9016156226441*x_49 - 2.3308268100537*x_5 + 0.963215840242216*x_50 - 6.56869626399131*x_51 - 9.62261103806935*x_52 - 3.2760220818993*x_53 + 9.95156106976306*x_54 + 7.3804702118936*x_55 + 8.55747858670572*x_56 + 2.00319714789565*x_57 - 2.16816057506296*x_58 + 2.28878775420326*x_59 + 1.09002223254627*x_6 + 0.818675931714869*x_60 + 1.87924483305388*x_61 - 1.66172760353375*x_62 + 1.13852792414002*x_63 - 2.47021368912732*x_64 - 1.0710188403767*x_65 - 7.76945884654522*x_66 + 4.80426135631172*x_67 + 2.36204880771748*x_68 - 1.18463298847533*x_69 + 2.2470645625768*x_7 + 5.53474964724065*x_70 + 0.033888188994907*x_71 + 8.64154439196087*x_72 + 2.69733447444053*x_73 - 3.43642592646411*x_74 + 3.5690894541741*x_75 + 2.80671514744916*x_76 + 0.0687322825554422*x_77 - 2.87290504434275*x_78 + 2.7622075566039*x_79 - 7.36896826084196*x_8 + 3.66693712018741*x_80 - 4.60524138886921*x_81 + 0.0778308185666856*x_82 + 0.498604175803198*x_83 + 13.2280881388128*x_84 - 3.06735342158172*x_85 - 6.64712530755138*x_86 + 2.01209618398959*x_87 + 3.45200023215389*x_88 + 5.07747074492943*x_89 - 12.7353468039322*x_9 + 10.5466438893406*x_90 + 8.4620621001258*x_91 - 2.50759518252484*x_92 - 410.786603697033*x_93 + 0.813685362053838*x_94 + 7.09121702070033*x_95 - 2.77241388869329*x_96 + 3.25215298970137*x_97 + 5.0805957174944*x_98 + 2.94809537706955*x_99 - 0.00154068865584309*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) + 0.000266210970784772*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.0246804549218681*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) + 0.0360091902630017*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.0209900230551196*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 3.65274226567189e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.0137547702222615*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 7.59045625240481e-5*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.0204858602599525*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 0.000117641835048476*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) + 0.0121521986087303*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.000206713482994118*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.000437904954055384*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 6.12668007227571e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.00343441633534158*std::exp(0.497599840164185*x_1) + 1.08185786763631*std::exp(0.678719818592072*x_1) + 0.00556910488120138*std::exp(1.07895982265472*x_1) - 0.0478956685524376*std::exp(1.13103985786438*x_1) - 0.0148595761527244*std::exp(1.18119990825653*x_1) - 0.000535559387341952*std::exp(1.18687987327576*x_1) + 0.0302546390217365*std::exp(1.18903994560242*x_1) + 0.215698828989334*std::exp(0.886079907417297*x_108) - 1.26031485534078*std::exp(1.05951988697052*x_108) - 1.45150839331027*std::exp(0.766639888286591*x_15) + 0.0445617396932408*std::exp(3.22775983810425*x_17) - 0.000106656591104817*std::exp(3.42799997329712*x_17) - 5.64874038192793e-6*std::exp(3.65799999237061*x_17) + 0.00424738543301551*std::exp(4.0492000579834*x_17) - 1.96445509612159*std::exp(0.82207989692688*x_29) + 0.958896259561874*std::exp(0.885519862174988*x_29) + 0.299549347054765*std::exp(0.991279780864716*x_29) + 1.38949520954121*std::exp(1.08511984348297*x_29) - 0.00109347803114605*std::exp(1.32527983188629*x_29) + 0.000169097825190095*std::exp(2.31079983711243*x_29) - 0.00404557072399887*std::exp(1.29527986049652*x_38) - 0.156982785196232*std::exp(1.79503989219666*x_50) - 1.29664759771808*std::exp(1.84271991252899*x_50) - 0.00458227714752798*std::exp(1.87079989910126*x_50) - 0.00101387668052441*std::exp(1.91103982925415*x_50) + 0.00642331108076382*std::exp(1.92647981643677*x_50) - 0.0918801580855046*std::exp(1.93199980258942*x_50) + 0.93600212808765*std::exp(1.9819997549057*x_50) + 0.419013851941084*std::exp(1.99463987350464*x_50) - 0.310315089776109*std::exp(0.991679787635803*x_6) + 0.00949331044838801*std::exp(0.749679863452911*x_67) - 0.737845158547737*std::exp(1.43279981613159*x_71) - 0.114095434914882*std::exp(1.4605598449707*x_71) - 0.661775365727584*std::exp(1.48087978363037*x_71) + 0.000904263675475003*std::exp(1.84319996833801*x_71) + 0.000637453349542079*std::exp(1.88271987438202*x_71) - 0.1480824349687*std::exp(1.89127993583679*x_71) + 0.0101482191053727*std::exp(1.05399990081787*x_77) - 0.164376470142392*std::exp(1.27823996543884*x_77) + 0.97017262463673*std::exp(1.18599987030029*x_78) + 0.0021282937539018*std::exp(1.42031991481781*x_78) - 0.109784217758255*std::exp(1.42575979232788*x_78) + 0.0319861200894275*std::exp(1.79463994503021*x_78) + 0.271275395280031*std::exp(1.83119988441467*x_78) + 0.020801135469285*std::exp(0.928399801254272*x_87) - 0.00446678820453196*std::exp(0.936639785766602*x_87) - 29.1270437921901*std::sin(0.295679867267609*x_100 - 1.27375984191895) + 0.879386014502074*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.0501349613401814*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0282887405143645*std::sin(0.382559835910797*x_105 - 7.41167974472046) + 0.101320221985774*std::sin(0.385439842939377*x_105 - 7.41663980484009) - 9.50708251422752*std::sin(0.404799848794937*x_105 + 5.20832014083862) + 13.7269006157342*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.027100308459016*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 0.620692663511013*std::sin(0.149040028452873*x_109 + 1.74471986293793) + 2.48555875612331*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 12.0387380608405*std::sin(0.355839848518372*x_112 + 1.9748797416687) - 8.11515410513844*std::sin(0.416639864444733*x_112 + 1.99151980876923) - 7.27232047669443*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 8.56524681345664*std::sin(0.551679849624634*x_118 + 8.38271999359131) - 2.65384117719679*std::sin(0.238559976220131*x_120 - 7.54008007049561) - 15.4330899754931*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.0141754646159097*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.134265748912255*std::sin(0.429439842700958*x_14 - 1.18527984619141) - 1.39768530989158*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.0266539157111162*std::sin(0.387759834527969*x_16 - 7.41447973251343) + 18.6666728380795*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.080152569992326*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.161572579222891*std::sin(0.320479840040207*x_28 + 8.2992000579834) - 3.1095182724977*std::sin(0.321199834346771*x_28 + 5.12680006027222) + 0.0903711366768277*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.138415012810422*std::sin(0.328879833221436*x_3 - 4.25367975234985) + 0.0882053040388387*std::sin(0.343599855899811*x_34 + 1.99671983718872) + 1.98193778681531*std::sin(0.309759914875031*x_35 - 4.32407999038696) - 40.307332463096*std::sin(0.298239946365356*x_36 + 1.90175986289978) - 14.0848774940738*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0401087031467599*std::sin(0.356559842824936*x_36 + 1.97815978527069) - 2.06737447782518*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 20.5693489422275*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.0552393613134481*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.055366005339746*std::sin(0.306479930877686*x_43 - 7.47168016433716) + 1.16003634262303*std::sin(0.111440062522888*x_44 + 1.70383989810944) - 15.3594717462268*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 16.7751832640691*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0338550140870365*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.119696657936119*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.0279313251003279*std::sin(0.286639958620071*x_55 - 7.50279998779297) - 2.37900103639353*std::sin(0.296719938516617*x_55 + 5.11632013320923) - 1.57049181338276*std::sin(0.540319859981537*x_55 - 7.25352001190186) - 4.47185516588131*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.0443467117386311*std::sin(0.222479999065399*x_64 - 4.35383987426758) - 12.4259666470843*std::sin(0.286879926919937*x_68 - 4.28023958206177) + 0.862835574283506*std::sin(0.504639863967896*x_73 + 5.28304004669189) + 0.0390112967076337*std::sin(0.658399820327759*x_73 + 8.62887954711914) + 22.9902846775886*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 13.5686633227096*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.0931528459008457*std::sin(0.5865598320961*x_79 + 8.38696002960205) + 35.1323429522047*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 13.8267117836416*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 5.59335574228068*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 14.3455479257609*std::sin(0.424319863319397*x_86 + 2.02199983596802) + 10.9099751675977*std::sin(0.436799854040146*x_86 - 1.14247989654541) + 0.770820433295325*std::sin(0.725279867649078*x_87 - 7.05223989486694) + 11.737740684292*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.0401154946164967*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0435055737653432*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.147094389152658*std::sin(0.367519825696945*x_92 + 1.99647974967957) - 9.96478732316755*std::sin(0.344559848308563*x_95 + 5.15463972091675) - 25.1370785275416*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.185914934379072*std::sin(0.330639839172363*x_97 + 5.15528011322021) + 15.3791446040349*std::sin(0.374319821596146*x_97 + 5.16991996765137) + 0.0668181940323513*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 12.1772783274598*std::sin(0.479519844055176*x_98 + 2.05647969245911) + 0.0211285601790877*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 2455.76696593162 - 0.000190623133975928*std::exp(-2.43031978607178*x_86) + 0.000208616789941173*std::exp(-2.09447979927063*x_23) + 0.0490525410988652*std::exp(-2.07295966148376*x_23) + 0.0009483162907492*std::exp(-4.46087980270386*x_111) - 0.000281368694518647*std::exp(-4.18079996109009*x_111) + 6.53332709434799e-6*std::exp(-4.17871999740601*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.55202794035007*x_1 - 4.72144091147615*x_10 - 14.0375298101491*x_100 + 240.624738858242*x_101 + 2.41950362677407*x_102 - 2.67902603851002*x_103 - 8.54075300207108*x_104 - 0.769689400383606*x_105 - 11.0766955409125*x_106 - 0.579210599193202*x_107 - 5.61888629520896*x_108 - 27.5517902953872*x_109 + 4.15882040904623*x_11 - 5.50952056820953*x_110 - 14.9111023946106*x_111 + 17.7212703944435*x_112 + 8.44139521343772*x_113 - 2.9220464044395*x_114 - 25.016892664514*x_115 - 7.99703695969937*x_116 + 10.5946203422431*x_117 - 25.1374135517124*x_118 + 2.9868634254699*x_119 - 10.9598762300692*x_12 - 20.8556937363768*x_120 - 0.353538321583439*x_13 + 0.167708892180821*x_14 + 3.97569781890299*x_15 + 2.15924372851436*x_16 + 3.1494325272401*x_17 - 17.9839898296135*x_18 - 8.93032659904254*x_19 + 6.96086490284991*x_2 - 17.0579557308468*x_20 - 2.44380643988981*x_21 - 4.0885374024008*x_22 - 8.14160340431063*x_23 - 12.6829459559075*x_24 - 23.291618591612*x_25 - 20.2456092968584*x_26 + 12.5079719933991*x_27 + 3.80514055234469*x_28 + 3.5312950802791*x_29 - 16.3408022696333*x_3 - 13.6555421462586*x_30 - 221.550642263192*x_31 - 29.5991574908887*x_32 + 45.4663941923727*x_33 - 13.3576094988145*x_34 - 28.746950413819*x_35 + 0.938675318910092*x_36 - 16.157301295188*x_37 - 10.3726448509498*x_38 + 19.6484783639401*x_39 + 108.457934844563*x_4 - 19.8263136453473*x_40 + 21.4319918423078*x_41 - 28.4485645863573*x_42 + 21.0089333959969*x_43 + 9.2227017496773*x_44 - 18.7510560396596*x_45 - 1.10102701147689*x_46 - 7.2000131922975*x_47 + 55.3841559828366*x_48 + 6.40647951645634*x_49 - 6.21188178170173*x_5 + 4.50856291271101*x_50 - 6.20270880950843*x_51 - 25.4104810333999*x_52 - 9.07357751160094*x_53 + 19.895588598519*x_54 + 24.6514482954441*x_55 + 16.3062760718734*x_56 - 26.1261812184985*x_57 + 3.13415034929501*x_58 - 2.82752652593541*x_59 + 3.74294849120039*x_6 - 5.90803704229144*x_60 - 2.90705111812086*x_61 + 5.15571680408137*x_62 + 23.4684665578016*x_63 - 6.56035895974337*x_64 - 6.80060963578444*x_65 - 20.376059659832*x_66 + 15.0867140831209*x_67 + 5.83934738188811*x_68 + 17.6416766544312*x_69 + 13.212196426225*x_7 + 16.8800655133201*x_70 + 0.0129278857438895*x_71 + 8.59948135810934*x_72 + 11.8445861585267*x_73 - 14.5270400673016*x_74 + 6.96215755353507*x_75 + 23.3581009099883*x_76 - 1.34268131606283*x_77 - 14.083172596007*x_78 + 4.12680547718458*x_79 + 21.1320372860633*x_8 + 6.17126477054242*x_80 - 16.0281718185016*x_81 - 14.5761683674478*x_82 - 21.5455469037314*x_83 + 44.3892646973692*x_84 - 3.35081536727566*x_85 - 31.4399649149216*x_86 + 14.3447681166492*x_87 - 16.494625131759*x_88 + 25.8440988061899*x_89 - 54.7595566575184*x_9 + 30.111090863093*x_90 + 6.60090332301936*x_91 - 15.6961778380617*x_92 - 827.482980768678*x_93 - 12.174185901548*x_94 + 10.6682384557989*x_95 - 2.89183038239109*x_96 + 8.08174624899567*x_97 + 19.1562077822174*x_98 + 8.55642104360528*x_99 + 0.00822280609510446*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) + 6.21216891539803e-5*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.00953532720046367*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) + 0.158296257515544*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.0218602946246521*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 1.14206148022252e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.00531417411274078*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 0.00014826438439543*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.00791473986926156*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 0.000229789800146534*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.0648574729292772*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.000403773452915272*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.000855359760701614*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 1.91555954493437e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.00782273128167698*std::exp(0.497599840164185*x_1) + 1.12671299437945*std::exp(0.678719818592072*x_1) + 0.00129957905670091*std::exp(1.07895982265472*x_1) - 0.0185045564426687*std::exp(1.13103985786438*x_1) + 0.017411772203123*std::exp(1.18119990825653*x_1) - 0.00104610816835011*std::exp(1.18687987327576*x_1) + 0.132999273092386*std::exp(1.18903994560242*x_1) - 0.210993262320487*std::exp(0.886079907417297*x_108) - 0.486924352056055*std::exp(1.05951988697052*x_108) + 1.70081119646241*std::exp(0.766639888286591*x_15) + 0.195893230875275*std::exp(3.22775983810425*x_17) - 0.000208332322801555*std::exp(3.42799997329712*x_17) - 1.76612756465331e-6*std::exp(3.65799999237061*x_17) - 0.00497689213059892*std::exp(4.0492000579834*x_17) - 0.758969888174161*std::exp(0.82207989692688*x_29) - 1.12359081216842*std::exp(0.885519862174988*x_29) - 1.59872417272951*std::exp(0.991279780864716*x_29) + 1.44710535002033*std::exp(1.08511984348297*x_29) - 0.00249066623404061*std::exp(1.32527983188629*x_29) + 3.94598408251404e-5*std::exp(2.31079983711243*x_29) - 0.000944054582821412*std::exp(1.29527986049652*x_38) + 0.153558135349669*std::exp(1.79503989219666*x_50) - 0.500961556303487*std::exp(1.84271991252899*x_50) - 0.0104372677285544*std::exp(1.87079989910126*x_50) - 0.000316997318262696*std::exp(1.91103982925415*x_50) + 0.0125466537386085*std::exp(1.92647981643677*x_50) + 0.490373393131282*std::exp(1.93199980258942*x_50) + 0.974809900664058*std::exp(1.9819997549057*x_50) - 0.490981281361357*std::exp(1.99463987350464*x_50) + 0.303545426954421*std::exp(0.991679787635803*x_6) + 0.00221531246055893*std::exp(0.749679863452911*x_67) - 0.768437105136605*std::exp(1.43279981613159*x_71) + 0.608938499081957*std::exp(1.4605598449707*x_71) - 2.90916188188467*std::exp(1.48087978363037*x_71) + 0.00205968381533422*std::exp(1.84319996833801*x_71) + 0.000199305306260615*std::exp(1.88271987438202*x_71) - 0.0572118493981576*std::exp(1.89127993583679*x_71) + 0.0023681387392563*std::exp(1.05399990081787*x_77) + 0.160790523743568*std::exp(1.27823996543884*x_77) + 0.374827508088073*std::exp(1.18599987030029*x_78) + 0.000665429460428228*std::exp(1.42031991481781*x_78) + 0.585929111313451*std::exp(1.42575979232788*x_78) - 0.0312883285378285*std::exp(1.79463994503021*x_78) + 0.282522799030183*std::exp(1.83119988441467*x_78) + 0.0406308585745737*std::exp(0.928399801254272*x_87) - 0.00139657998776705*std::exp(0.936639785766602*x_87) - 11.2532728355294*std::sin(0.295679867267609*x_100 - 1.27375984191895) - 0.860201814299041*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.0979286215823413*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0644345920043943*std::sin(0.382559835910797*x_105 - 7.41167974472046) + 0.0236435910836346*std::sin(0.385439842939377*x_105 - 7.41663980484009) + 11.1399647845053*std::sin(0.404799848794937*x_105 + 5.20832014083862) + 60.3434006398958*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.0529350333760146*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 1.21239899940223*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 13.2656702650977*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 12.5378786020341*std::sin(0.355839848518372*x_112 + 1.9748797416687) + 9.50896669054746*std::sin(0.416639864444733*x_112 + 1.99151980876923) + 8.5213727650701*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 3.30919471207445*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 14.1638100108887*std::sin(0.238559976220131*x_120 - 7.54008007049561) + 18.0837894891316*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.00443208168674607*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.262261291626046*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 7.45958324650958*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.00833357741027597*std::sin(0.387759834527969*x_16 - 7.41447973251343) + 82.0586197288384*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.1825672706403*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.315599724141406*std::sin(0.320479840040207*x_28 + 8.2992000579834) + 3.04168273714595*std::sin(0.321199834346771*x_28 + 5.12680006027222) + 0.0210885661270084*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.270366048930471*std::sin(0.328879833221436*x_3 - 4.25367975234985) + 0.0205831580234277*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 10.5777958783144*std::sin(0.309759914875031*x_35 - 4.32407999038696) - 177.190873572591*std::sin(0.298239946365356*x_36 + 1.90175986289978) + 16.5040157212522*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0125403331398659*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 11.033779857243*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 21.4221788577167*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.125821285928513*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.126109748971261*std::sin(0.306479930877686*x_43 - 7.47168016433716) + 0.270700403034895*std::sin(0.111440062522888*x_44 + 1.70383989810944) - 67.5201768516738*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 6.48111478402739*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0105850631358693*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.233803485758403*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.00873297051052388*std::sin(0.286639958620071*x_55 - 7.50279998779297) + 2.3271020620947*std::sin(0.296719938516617*x_55 + 5.11632013320923) + 1.84023053016063*std::sin(0.540319859981537*x_55 - 7.25352001190186) + 4.37429964035955*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.013865383201874*std::sin(0.222479999065399*x_64 - 4.35383987426758) + 14.5601798085586*std::sin(0.286879926919937*x_68 - 4.28023958206177) - 0.844012429354681*std::sin(0.504639863967896*x_73 + 5.28304004669189) + 0.00910348525615289*std::sin(0.658399820327759*x_73 + 8.62887954711914) - 26.9389648518159*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 14.1312364030394*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.181955456864606*std::sin(0.5865598320961*x_79 + 8.38696002960205) - 41.1664738050843*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 14.3999838631351*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 2.16100056988745*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 5.54242187897683*std::sin(0.424319863319397*x_86 + 2.02199983596802) - 12.7838102788089*std::sin(0.436799854040146*x_86 - 1.14247989654541) - 0.754004639924653*std::sin(0.725279867649078*x_87 - 7.05223989486694) - 13.7537480796013*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.0913729449126912*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.013602394135311*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.287319475016158*std::sin(0.367519825696945*x_92 + 1.99647974967957) + 11.676282360971*std::sin(0.344559848308563*x_95 + 5.15463972091675) - 110.502497465837*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.363147647243167*std::sin(0.330639839172363*x_97 + 5.15528011322021) - 18.0205787683419*std::sin(0.374319821596146*x_97 + 5.16991996765137) + 0.0155923667130307*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 4.70470798172204*std::sin(0.479519844055176*x_98 + 2.05647969245911) + 0.00493045738816535*std::sin(0.585759818553925*x_98 - 7.39888000488281) + 609.132713471381 - 0.000434191259172566*std::exp(-2.43031978607178*x_86) + 6.52258447464431e-5*std::exp(-2.09447979927063*x_23) - 0.0574775257934381*std::exp(-2.07295966148376*x_23) + 0.000366383283875839*std::exp(-4.46087980270386*x_111) + 0.00150169225137408*std::exp(-4.18079996109009*x_111) + 1.4881265765148e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0699990257654737*x_1 + 9.70796069964467*x_10 + 21.2481942535395*x_100 - 474.632467973196*x_101 - 4.33760067864539*x_102 + 7.09619176595558*x_103 + 9.23266690152669*x_104 - 1.21023078949815*x_105 + 6.10283709071344*x_106 + 9.89527336059677*x_107 + 7.72818794002941*x_108 + 50.2327966550676*x_109 - 9.82474723592208*x_11 - 7.57901068255676*x_110 + 23.3941013297429*x_111 - 34.1265823970337*x_112 - 12.7601288016168*x_113 + 8.45806788731132*x_114 + 32.8345872460596*x_115 + 3.58660852257889*x_116 - 12.1188515988274*x_117 + 26.7932878918004*x_118 - 3.76443472170706*x_119 + 20.0002503662428*x_12 + 26.03345812977*x_120 + 2.95762470369497*x_13 + 0.225625046957313*x_14 - 9.00413200368987*x_15 + 2.12973187122612*x_16 - 0.564998028069171*x_17 + 31.5209710202495*x_18 + 16.5128345511904*x_19 - 16.6161694711835*x_2 + 35.9375460526899*x_20 - 2.90589950791862*x_21 + 7.58488782656861*x_22 + 0.975750682844787*x_23 + 19.880675991793*x_24 + 33.871843697061*x_25 + 22.6774596116239*x_26 - 24.7305689171691*x_27 - 7.99095767410904*x_28 - 6.34112516708003*x_29 + 22.3358177965722*x_3 + 17.8109684370109*x_30 + 204.319334319737*x_31 + 26.0331276133679*x_32 - 44.607341669836*x_33 + 30.1706473764514*x_34 + 60.5174302323568*x_35 + 1.87548176221398*x_36 + 15.1135002202873*x_37 + 14.834259651556*x_38 - 56.8674795049134*x_39 - 159.565973352292*x_4 + 46.3796589715533*x_40 - 25.3537514479803*x_41 + 45.0382987245441*x_42 - 23.9163968673157*x_43 - 15.2882655527094*x_44 + 24.3619543577155*x_45 - 1.26366362766195*x_46 - 2.05112497627446*x_47 - 44.7733477934336*x_48 + 23.1387586263337*x_49 + 6.7155423656939*x_5 - 7.33380259597061*x_50 - 1.43098658695817*x_51 + 26.5415607427025*x_52 + 12.2015873721435*x_53 - 24.8235184312758*x_54 - 38.2018378636277*x_55 - 17.023136427912*x_56 + 54.0205136563105*x_57 - 7.18583141720445*x_58 + 9.61525163823493*x_59 - 4.50509070639437*x_6 + 16.0472312145764*x_60 + 11.2538814945267*x_61 - 25.0790628897849*x_62 - 40.0616031643571*x_63 + 22.9978896881408*x_64 + 17.4773250422107*x_65 + 29.4449138173217*x_66 - 25.1377363222886*x_67 - 8.10059408813959*x_68 - 30.6913070992948*x_69 - 16.4953181412841*x_7 - 22.5867021693288*x_70 - 0.0193891194606615*x_71 - 16.950132646029*x_72 - 16.8108494919066*x_73 + 30.7316882766408*x_74 - 9.25505663412951*x_75 - 46.8082445385143*x_76 + 6.56787796251785*x_77 + 22.3142267221244*x_78 - 12.9887117112155*x_79 + 62.271662967604*x_8 - 7.4631550828917*x_80 + 35.8859812520866*x_81 + 23.1169637337559*x_82 + 35.7366372695978*x_83 - 67.6314597070232*x_84 + 6.94851729189997*x_85 + 51.3631093560054*x_86 - 22.926918030933*x_87 + 29.8212660669418*x_88 - 27.9326520882892*x_89 - 30.0176622412605*x_9 - 43.8082069420379*x_90 - 12.3661562773267*x_91 + 28.8102371673986*x_92 + 1085.63190709378*x_93 + 20.5963347165751*x_94 - 6.58132069521361*x_95 - 2.38801964122738*x_96 - 19.0559179250437*x_97 - 34.2380412237868*x_98 - 13.1649336693586*x_99 - 0.00107672737202861*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) - 0.000301007052889656*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.0162009417441956*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.259222516479453*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.00869095852210089*std::pow(-9.0*x_24 - 9.99987983703613, 2) + 4.43442179383999e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.00902901635245815*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) - 7.38218659460558e-5*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.0134474923457407*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) + 0.000114413936235325*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) + 0.008492698912739*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) - 0.000201041604396302*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) - 0.000425889561054363*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) + 7.43777733559506e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.0241675661519973*std::exp(0.497599840164185*x_1) + 0.447945284754814*std::exp(0.678719818592072*x_1) - 0.00629703517695792*std::exp(1.07895982265472*x_1) - 0.0314400580732329*std::exp(1.13103985786438*x_1) + 0.0145951176794705*std::exp(1.18119990825653*x_1) + 0.000520864517017453*std::exp(1.18687987327576*x_1) - 0.217796723700563*std::exp(1.18903994560242*x_1) - 0.186362490358409*std::exp(0.886079907417297*x_108) - 0.827305963984826*std::exp(1.05951988697052*x_108) + 1.42567564480756*std::exp(0.766639888286591*x_15) - 0.320790504246715*std::exp(3.22775983810425*x_17) + 0.000103730109350259*std::exp(3.42799997329712*x_17) + 6.85755950885785e-6*std::exp(3.65799999237061*x_17) - 0.00417179397230415*std::exp(4.0492000579834*x_17) - 1.28952333626373*std::exp(0.82207989692688*x_29) - 0.941830615279272*std::exp(0.885519862174988*x_29) + 0.209343386818583*std::exp(0.991279780864716*x_29) + 0.575323104746905*std::exp(1.08511984348297*x_29) - 0.00769467067272424*std::exp(1.32527983188629*x_29) - 0.000191200377131236*std::exp(2.31079983711243*x_29) + 0.00457436189537096*std::exp(1.29527986049652*x_38) + 0.135632181823368*std::exp(1.79503989219666*x_50) - 0.851155793516942*std::exp(1.84271991252899*x_50) - 0.0322449217790172*std::exp(1.87079989910126*x_50) + 0.00123084425929421*std::exp(1.91103982925415*x_50) - 0.00624706597029304*std::exp(1.92647981643677*x_50) - 0.0642114685415416*std::exp(1.93199980258942*x_50) + 0.387553441482467*std::exp(1.9819997549057*x_50) - 0.411556589202384*std::exp(1.99463987350464*x_50) + 0.26811037035963*std::exp(0.991679787635803*x_6) - 0.010734168437206*std::exp(0.749679863452911*x_67) - 0.305506175568839*std::exp(1.43279981613159*x_71) - 0.0797368613901665*std::exp(1.4605598449707*x_71) + 4.76398037265153*std::exp(1.48087978363037*x_71) + 0.0063631924793174*std::exp(1.84319996833801*x_71) - 0.000773867089482631*std::exp(1.88271987438202*x_71) - 0.0972054571060938*std::exp(1.89127993583679*x_71) - 0.0114746793341451*std::exp(1.05399990081787*x_77) + 0.14202028112807*std::exp(1.27823996543884*x_77) + 0.636848478819014*std::exp(1.18599987030029*x_78) - 0.00258374435412286*std::exp(1.42031991481781*x_78) - 0.076723919416657*std::exp(1.42575979232788*x_78) - 0.0276358152925512*std::exp(1.79463994503021*x_78) + 0.112322087605818*std::exp(1.83119988441467*x_78) - 0.0202303864626425*std::exp(0.928399801254272*x_87) + 0.00542267193302796*std::exp(0.936639785766602*x_87) - 19.1198071977105*std::sin(0.295679867267609*x_100 - 1.27375984191895) - 0.759784225147862*std::sin(0.614319860935211*x_100 - 0.991679787635803) + 0.0487593403109726*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.199064394349147*std::sin(0.382559835910797*x_105 - 7.41167974472046) - 0.114563653511939*std::sin(0.385439842939377*x_105 - 7.41663980484009) + 9.33788330551721*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 98.8170435126402*std::sin(0.493199855089188*x_105 + 2.0623996257782) + 0.0263567204873148*std::sin(0.463439851999283*x_106 + 5.25072002410889) - 0.603661875857508*std::sin(0.149040028452873*x_109 + 1.74471986293793) + 1.73706033165984*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 4.98466213545593*std::sin(0.355839848518372*x_112 + 1.9748797416687) + 7.97072728954104*std::sin(0.416639864444733*x_112 + 1.99151980876923) + 7.14289371845361*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 5.6224678632854*std::sin(0.551679849624634*x_118 + 8.38271999359131) - 1.85466636991675*std::sin(0.238559976220131*x_120 - 7.54008007049561) + 15.1584245765234*std::sin(0.300959825515747*x_14 - 4.31983995437622) + 0.017208985649316*std::sin(0.343759834766388*x_14 + 4.94831991195679) - 0.130581717195287*std::sin(0.429439842700958*x_14 - 1.18527984619141) - 0.976787896071731*std::sin(0.532079875469208*x_15 - 7.26839971542358) - 0.0323578002837293*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 134.377415099982*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.564023795720001*std::sin(0.222399994730949*x_27 + 5.02719974517822) + 0.157139292913674*std::sin(0.320479840040207*x_28 + 8.2992000579834) + 2.68660507705539*std::sin(0.321199834346771*x_28 + 5.12680006027222) - 0.102183427817379*std::sin(0.280239969491959*x_3 - 1.10599982738495) - 0.134617132104217*std::sin(0.328879833221436*x_3 - 4.25367975234985) - 0.0997345020744189*std::sin(0.343599855899811*x_34 + 1.99671983718872) + 1.38509922600429*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 290.16392974527*std::sin(0.298239946365356*x_36 + 1.90175986289978) + 13.8342064682136*std::sin(0.349679857492447*x_36 - 1.20887982845306) + 0.0486918852797666*std::sin(0.356559842824936*x_36 + 1.97815978527069) - 1.44480760604395*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 8.51677761449226*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.388712604525875*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.38960378299245*std::sin(0.306479930877686*x_43 - 7.47168016433716) - 1.31166315087804*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 110.569576510107*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 11.0117000545473*std::sin(0.412479877471924*x_51 - 1.18431985378265) + 0.0410999192878175*std::sin(0.324799835681915*x_53 + 5.13336038589478) - 0.116412378156472*std::sin(0.501439809799194*x_54 - 1.13007986545563) + 0.0339085727234963*std::sin(0.286639958620071*x_55 - 7.50279998779297) + 2.0554425806802*std::sin(0.296719938516617*x_55 + 5.11632013320923) + 1.54254149616265*std::sin(0.540319859981537*x_55 - 7.25352001190186) + 3.86365595557761*std::sin(0.19752000272274*x_58 - 4.41599988937378) - 0.0538368192212853*std::sin(0.222479999065399*x_64 - 4.35383987426758) + 12.2048195474351*std::sin(0.286879926919937*x_68 - 4.28023958206177) - 0.745484744385206*std::sin(0.504639863967896*x_73 + 5.28304004669189) - 0.0441104114407914*std::sin(0.658399820327759*x_73 + 8.62887954711914) - 22.5811225640116*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 5.61813056747731*std::sin(0.534959852695465*x_79 - 1.05399978160858) - 0.0905968847446706*std::sin(0.5865598320961*x_79 + 8.38696002960205) - 34.5070865058915*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 5.72497601804031*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 3.6716353414928*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 9.41681938074367*std::sin(0.424319863319397*x_86 + 2.02199983596802) - 10.7158084332032*std::sin(0.436799854040146*x_86 - 1.14247989654541) - 0.665984216238689*std::sin(0.725279867649078*x_87 - 7.05223989486694) - 11.5288420623586*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.28228781114502*std::sin(0.358479857444763*x_92 + 2.00711965560913) + 0.0528156794065691*std::sin(0.363519847393036*x_92 + 1.98439979553223) + 0.143058360609142*std::sin(0.367519825696945*x_92 + 1.99647974967957) + 9.78744226199623*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 180.956492086023*std::sin(0.293919950723648*x_96 - 7.49056005477905) - 0.180813733808866*std::sin(0.330639839172363*x_97 + 5.15528011322021) - 15.105439280267*std::sin(0.374319821596146*x_97 + 5.16991996765137) - 0.075551911349845*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 7.99350649777643*std::sin(0.479519844055176*x_98 + 2.05647969245911) - 0.0238902461929369*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 3871.05165223119 - 0.00134139159340042*std::exp(-2.43031978607178*x_86) - 0.000253260365115279*std::exp(-2.09447979927063*x_23) - 0.0481795444538127*std::exp(-2.07295966148376*x_23) + 0.000622501369206386*std::exp(-4.46087980270386*x_111) - 0.00019663763595014*std::exp(-4.18079996109009*x_111) + 4.59742207490949e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.46669649038535*x_1 + 2.8343343439613*x_10 + 11.9152254118972*x_100 - 419.785811539371*x_101 + 1.07287958228951*x_102 + 9.60779905346622*x_103 + 0.295993483572046*x_104 - 0.731785517935655*x_105 + 3.39224861245559*x_106 - 3.03756948929094*x_107 + 2.01837844437149*x_108 + 32.4526408973092*x_109 - 4.21021196318509*x_11 - 5.24713569301761*x_110 + 19.0394726782536*x_111 - 20.7961281669729*x_112 - 3.50919529185246*x_113 + 4.68549177628163*x_114 + 16.5789526072778*x_115 + 4.21073776948304*x_116 - 0.755755805520479*x_117 + 13.1379644509224*x_118 + 2.82627563924087*x_119 + 10.0879195104298*x_12 + 20.176445181842*x_120 + 1.95146600969589*x_13 - 0.0693683306688594*x_14 - 5.91485152266679*x_15 - 1.52912488035403*x_16 + 2.86762346987204*x_17 + 17.3468736889227*x_18 + 7.65997174760469*x_19 - 9.86055786270325*x_2 + 21.7742094144336*x_20 - 3.62395081966931*x_21 + 7.65687738984434*x_22 - 1.36549125607185*x_23 + 11.2957367594271*x_24 + 16.0533415249596*x_25 + 13.7059099627952*x_26 - 15.6774962899088*x_27 - 1.33607344728329*x_28 - 4.0550775787389*x_29 + 11.7065490356424*x_3 + 5.74337522328755*x_30 + 98.4949132364009*x_31 + 36.6417620738593*x_32 - 34.5641038572788*x_33 + 18.268663784287*x_34 + 44.5698933582611*x_35 + 0.337896867922687*x_36 + 3.0790034049289*x_37 + 7.71932515485002*x_38 - 41.1357891003813*x_39 - 86.7819132316297*x_4 + 18.5635384229529*x_40 - 12.4994045944374*x_41 + 29.1309593049279*x_42 - 16.1464400803772*x_43 - 10.7579107285561*x_44 + 12.582465417167*x_45 + 1.02030646620979*x_46 - 5.67794538575995*x_47 - 15.4596343633965*x_48 + 20.0271696508999*x_49 + 4.45743486110802*x_5 - 4.46957152150235*x_50 - 7.73105764112775*x_51 + 16.0567266479949*x_52 + 4.97224140135456*x_53 - 15.0138664482757*x_54 - 23.3162819550596*x_55 - 7.70258578498034*x_56 + 37.6578928711086*x_57 - 8.48864963776112*x_58 + 11.5998583055182*x_59 - 0.54714964355312*x_6 + 5.63634343568993*x_60 + 6.35965940137179*x_61 - 17.4232980085732*x_62 - 27.3242460423673*x_63 + 13.6727183263959*x_64 + 10.3741765119702*x_65 + 17.2060991085345*x_66 - 17.4341434473111*x_67 - 5.83633026592598*x_68 - 21.5932041385742*x_69 - 6.2598823930365*x_7 - 9.43733244777911*x_70 - 0.395240374763527*x_71 - 0.523567521353844*x_72 - 11.1919820107407*x_73 + 17.3501034080152*x_74 - 5.60696803049375*x_75 - 24.3171552851382*x_76 + 2.37554179299505*x_77 + 13.887648884637*x_78 - 5.1825487817385*x_79 + 86.886267576643*x_8 - 4.75578405897765*x_80 + 17.6361825031719*x_81 + 10.7691660086154*x_82 + 22.159962177161*x_83 - 34.9158628021545*x_84 + 0.586480570023006*x_85 + 30.4378175373781*x_86 - 9.71606385660467*x_87 + 23.6789768052412*x_88 - 19.2714156259141*x_89 - 19.7243775382484*x_9 - 33.2281206655518*x_90 + 1.8306926223266*x_91 + 17.7933741508015*x_92 + 519.920644241764*x_93 + 19.7194151392428*x_94 - 1.55123011297864*x_95 - 0.227460352427785*x_96 - 15.1826912231025*x_97 - 22.4202733899149*x_98 - 10.2544110554925*x_99 + 0.00663855651900786*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) + 5.25767542339631e-5*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.00775748973601369*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.155938584493864*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.0188860765693723*std::pow(-9.0*x_24 - 9.99987983703613, 2) + 9.23825555494588e-6*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.00432335988774162*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 0.000343941520754506*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.00643905678412685*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 0.000533062971519065*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.0523616870860384*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.000936667669732402*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.00198425089132189*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) + 1.54951628377936e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.0104899700378859*std::exp(0.497599840164185*x_1) + 0.973417250267082*std::exp(0.678719818592072*x_1) + 0.00109990004461093*std::exp(1.07895982265472*x_1) - 0.0150544290359022*std::exp(1.13103985786438*x_1) - 0.0178258767037622*std::exp(1.18119990825653*x_1) - 0.00242674621935123*std::exp(1.18687987327576*x_1) - 0.131018374725018*std::exp(1.18903994560242*x_1) - 0.383324721772012*std::exp(0.886079907417297*x_108) - 0.396138547097397*std::exp(1.05951988697052*x_108) - 1.74126162063383*std::exp(0.766639888286591*x_15) - 0.192975586498755*std::exp(3.22775983810425*x_17) - 0.000483286233702488*std::exp(3.42799997329712*x_17) + 1.42863918164218e-6*std::exp(3.65799999237061*x_17) + 0.00509525764827476*std::exp(4.0492000579834*x_17) - 0.617461886065977*std::exp(0.82207989692688*x_29) + 1.15031319325449*std::exp(0.885519862174988*x_29) - 1.29070546674908*std::exp(0.991279780864716*x_29) + 1.25021839429427*std::exp(1.08511984348297*x_29) - 0.00333988388820882*std::exp(1.32527983188629*x_29) + 3.33968760577687e-5*std::exp(2.31079983711243*x_29) - 0.000799001547775326*std::exp(1.29527986049652*x_38) + 0.278978716483049*std::exp(1.79503989219666*x_50) - 0.407558550373895*std::exp(1.84271991252899*x_50) - 0.0139959589314255*std::exp(1.87079989910126*x_50) + 0.00025642246823461*std::exp(1.91103982925415*x_50) + 0.0291055413262838*std::exp(1.92647981643677*x_50) + 0.395895445918127*std::exp(1.93199980258942*x_50) + 0.842181440855882*std::exp(1.9819997549057*x_50) + 0.502658298265175*std::exp(1.99463987350464*x_50) + 0.551470056687075*std::exp(0.991679787635803*x_6) + 0.00187493193402292*std::exp(0.749679863452911*x_67) - 0.663886843958201*std::exp(1.43279981613159*x_71) + 0.491617167667631*std::exp(1.4605598449707*x_71) + 2.86583266745934*std::exp(1.48087978363037*x_71) + 0.00276195368757991*std::exp(1.84319996833801*x_71) - 0.000161220160611106*std::exp(1.88271987438202*x_71) - 0.04654484583004*std::exp(1.89127993583679*x_71) + 0.00200427660904691*std::exp(1.05399990081787*x_77) + 0.292118251074573*std::exp(1.27823996543884*x_77) + 0.304941874110772*std::exp(1.18599987030029*x_78) - 0.000538272896484344*std::exp(1.42031991481781*x_78) + 0.473040890980292*std::exp(1.42575979232788*x_78) - 0.056843473102268*std::exp(1.79463994503021*x_78) + 0.244083957087213*std::exp(1.83119988441467*x_78) + 0.0942548633286666*std::exp(0.928399801254272*x_87) + 0.00112970825593395*std::exp(0.936639785766602*x_87) - 9.15512878403754*std::sin(0.295679867267609*x_100 - 1.27375984191895) - 1.56278270456384*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.227173364458128*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0864042129521545*std::sin(0.382559835910797*x_105 - 7.41167974472046) + 0.020010777146309*std::sin(0.385439842939377*x_105 - 7.41663980484009) - 11.4049067732017*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 59.4446427667911*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.122797905611499*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 2.81250522380005*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 10.709835644769*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 10.8320285413024*std::sin(0.355839848518372*x_112 + 1.9748797416687) - 9.73511862138175*std::sin(0.416639864444733*x_112 + 1.99151980876923) - 8.72403673129212*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 2.69220378846989*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 11.4349350081056*std::sin(0.238559976220131*x_120 - 7.54008007049561) - 18.5138765893244*std::sin(0.300959825515747*x_14 - 4.31983995437622) + 0.0035851575393803*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.608389856031287*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 6.02238024555641*std::sin(0.532079875469208*x_15 - 7.26839971542358) - 0.00674111850686474*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 80.836434208047*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.244815414202084*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.732123560985451*std::sin(0.320479840040207*x_28 + 8.2992000579834) + 5.52601621545709*std::sin(0.321199834346771*x_28 + 5.12680006027222) + 0.0178483291988102*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.627191151865058*std::sin(0.328879833221436*x_3 - 4.25367975234985) + 0.0174205765408948*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 8.53982143960875*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 174.551783117347*std::sin(0.298239946365356*x_36 + 1.90175986289978) - 16.8965310326784*std::sin(0.349679857492447*x_36 - 1.20887982845306) + 0.0101440075071673*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 8.90795311885167*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 18.507568957162*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.168721316378316*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.169108133791124*std::sin(0.306479930877686*x_43 - 7.47168016433716) + 0.229107558973845*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 66.5145276854791*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 5.27272744374983*std::sin(0.412479877471924*x_51 - 1.18431985378265) + 0.00856236901496268*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.542373859894623*std::sin(0.501439809799194*x_54 - 1.13007986545563) + 0.00706419179064745*std::sin(0.286639958620071*x_55 - 7.50279998779297) + 4.22779258767311*std::sin(0.296719938516617*x_55 + 5.11632013320923) - 1.88399676692637*std::sin(0.540319859981537*x_55 - 7.25352001190186) + 7.94706510599994*std::sin(0.19752000272274*x_58 - 4.41599988937378) - 0.0112158544530553*std::sin(0.222479999065399*x_64 - 4.35383987426758) - 14.9064648344883*std::sin(0.286879926919937*x_68 - 4.28023958206177) - 1.53337043134144*std::sin(0.504639863967896*x_73 + 5.28304004669189) + 0.00770474392283311*std::sin(0.658399820327759*x_73 + 8.62887954711914) + 27.5796547515893*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 12.2086009045247*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.422097571165058*std::sin(0.5865598320961*x_79 + 8.38696002960205) + 42.1455368136775*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 12.4407837362907*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 1.75808751896909*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 4.50905143944403*std::sin(0.424319863319397*x_86 + 2.02199983596802) + 13.0878478753277*std::sin(0.436799854040146*x_86 - 1.14247989654541) - 1.36984762278762*std::sin(0.725279867649078*x_87 - 7.05223989486694) + 14.0808537247922*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.122527467695663*std::sin(0.358479857444763*x_92 + 2.00711965560913) + 0.0110031198282439*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.666519458347338*std::sin(0.367519825696945*x_92 + 1.99647974967957) - 11.9539796005171*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 108.856667291501*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.842424528051968*std::sin(0.330639839172363*x_97 + 5.15528011322021) + 18.449162526792*std::sin(0.374319821596146*x_97 + 5.16991996765137) + 0.0131966152846363*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 3.82752716418328*std::sin(0.479519844055176*x_98 + 2.05647969245911) + 0.00417289758036124*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 3310.95987660627 - 0.000582233127462839*std::exp(-2.43031978607178*x_86) - 5.27618725427515e-5*std::exp(-2.09447979927063*x_23) + 0.0588445148534256*std::exp(-2.07295966148376*x_23) + 0.000298072053990513*std::exp(-4.46087980270386*x_111) + 0.00121236823167194*std::exp(-4.18079996109009*x_111) + 1.99551827080983e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.203631702771807*x_1 - 6.15700803298191*x_10 - 13.7174420923977*x_100 + 278.042149951446*x_101 + 1.79706007234211*x_102 - 6.64159541236772*x_103 - 4.24481735197096*x_104 + 0.348788252144991*x_105 + 0.118466547695546*x_106 - 7.89218687240105*x_107 - 5.25883543810412*x_108 - 31.478104304553*x_109 + 7.56152756841251*x_11 + 6.25982754890256*x_110 - 15.5068962799345*x_111 + 20.9160793449131*x_112 + 9.5296210485692*x_113 - 5.22536800313002*x_114 - 21.4686043421551*x_115 - 3.68432361762237*x_116 + 6.96768466425807*x_117 - 14.5651542431406*x_118 + 1.53937922749693*x_119 - 13.8524025013245*x_12 - 16.1151870915308*x_120 - 1.75777061524082*x_13 + 0.262782408866762*x_14 + 5.89437364818199*x_15 - 2.76557441710771*x_16 - 0.598653548449909*x_17 - 19.3348251898247*x_18 - 12.5817154449379*x_19 + 11.8627704025212*x_2 - 26.367884650627*x_20 + 2.48041977454411*x_21 - 3.92845999988495*x_22 - 2.56327633764811*x_23 - 11.5930410517808*x_24 - 23.0586672948437*x_25 - 13.5125080993058*x_26 + 17.1379381979902*x_27 + 6.81343636071169*x_28 + 3.94349317273665*x_29 - 15.5198940104021*x_3 - 9.36878280218444*x_30 - 111.177941499713*x_31 - 18.394191988406*x_32 + 27.3217417887438*x_33 - 19.5862990898672*x_34 - 39.1379654824388*x_35 - 0.460047924518913*x_36 - 10.0188591805431*x_37 - 9.89672861621001*x_38 + 39.4152334968415*x_39 + 112.45449904633*x_4 - 34.8055297434564*x_40 + 14.8981010231587*x_41 - 28.3743274687476*x_42 + 11.7641768074767*x_43 + 9.96340126139538*x_44 - 14.5086502298132*x_45 + 1.49780052316108*x_46 + 2.0759791614166*x_47 + 15.3321780267885*x_48 - 18.3113895855706*x_49 - 3.96427396966198*x_5 + 4.69228235718149*x_50 + 2.38941869064314*x_51 - 17.54231178378*x_52 - 8.43970662009445*x_53 + 17.1840890608311*x_54 + 25.971863076805*x_55 + 11.7717028635908*x_56 - 35.1753175376569*x_57 + 3.53425289929237*x_58 - 5.9751124921459*x_59 + 2.1019812567411*x_6 - 11.0862101425619*x_60 - 8.51967622871084*x_61 + 17.2127289153699*x_62 + 25.489960234864*x_63 - 16.8107572380885*x_64 - 13.2061899925816*x_65 - 18.2965712261568*x_66 + 15.3982794632388*x_67 + 7.42021459940566*x_68 + 20.2076394974141*x_69 + 9.46024193757078*x_7 + 15.9132430212054*x_70 - 0.200064657558183*x_71 + 7.65210450720583*x_72 + 11.078461797099*x_73 - 20.4572644905588*x_74 + 5.89757055512415*x_75 + 32.4588371398291*x_76 - 5.13973954186195*x_77 - 14.4211879922874*x_78 + 8.73959329254651*x_79 - 46.4624099833679*x_8 + 6.51484481099958*x_80 - 26.6043826310011*x_81 - 15.5311354489461*x_82 - 23.4234327815807*x_83 + 45.5071428960823*x_84 - 5.28886558128439*x_85 - 33.1017430449854*x_86 + 12.7710633474035*x_87 - 18.6939174679009*x_88 + 14.0110817073133*x_89 + 29.9994705890953*x_9 + 33.2536232612623*x_90 + 8.3798274965177*x_91 - 18.0515635337761*x_92 - 635.976979127201*x_93 - 13.6283509482463*x_94 + 3.88660784320016*x_95 + 3.37479869790192*x_96 + 13.6270789262323*x_97 + 22.4512760218466*x_98 + 8.48699606324481*x_99 - 6.81150242626318e-5*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) + 0.000655938227609721*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) + 0.00226828984366579*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) + 0.169867429471817*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) - 0.0133362535802292*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 4.13650225447495e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) + 0.00126415034471134*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 0.000351084369342608*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) + 0.00188278007490185*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 0.000544133423510821*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) + 0.000537257998193691*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.000956120032818986*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.00202545907010306*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 6.93808215531285e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.00173991034442679*std::exp(0.497599840164185*x_1) - 0.687370891526716*std::exp(0.678719818592072*x_1) + 0.0137221571837521*std::exp(1.07895982265472*x_1) + 0.00440191474901928*std::exp(1.13103985786438*x_1) - 0.0205389869870999*std::exp(1.18119990825653*x_1) - 0.0024771439752504*std::exp(1.18687987327576*x_1) + 0.142721280947563*std::exp(1.18903994560242*x_1) - 0.111519024058302*std::exp(0.886079907417297*x_108) + 0.115830903248772*std::exp(1.05951988697052*x_108) - 2.00628279672701*std::exp(0.766639888286591*x_15) + 0.210212674020069*std::exp(3.22775983810425*x_17) - 0.000493322941060408*std::exp(3.42799997329712*x_17) - 6.39684533573041e-6*std::exp(3.65799999237061*x_17) + 0.00587075924920708*std::exp(4.0492000579834*x_17) + 0.180545843136866*std::exp(0.82207989692688*x_29) + 1.32539162589165*std::exp(0.885519862174988*x_29) + 0.0132433058198417*std::exp(0.991279780864716*x_29) - 0.882831829879081*std::exp(1.08511984348297*x_29) - 0.000553967123384659*std::exp(1.32527983188629*x_29) + 0.000416653481338021*std::exp(2.31079983711243*x_29) - 0.00996820109459362*std::exp(1.29527986049652*x_38) + 0.0811620864195954*std::exp(1.79503989219666*x_50) + 0.119170111978428*std::exp(1.84271991252899*x_50) - 0.00232142833935755*std::exp(1.87079989910126*x_50) - 0.00114815195535767*std::exp(1.91103982925415*x_50) + 0.0297099942993134*std::exp(1.92647981643677*x_50) - 0.00406209208688169*std::exp(1.93199980258942*x_50) - 0.594699762788802*std::exp(1.9819997549057*x_50) + 0.579163225382757*std::exp(1.99463987350464*x_50) + 0.160436828167052*std::exp(0.991679787635803*x_6) + 0.0233913170869992*std::exp(0.749679863452911*x_67) + 0.468798443503234*std::exp(1.43279981613159*x_71) - 0.00504424647251653*std::exp(1.4605598449707*x_71) - 3.12181638750755*std::exp(1.48087978363037*x_71) + 0.000458109200931188*std::exp(1.84319996833801*x_71) + 0.000721876066177473*std::exp(1.88271987438202*x_71) + 0.0136097119898378*std::exp(1.89127993583679*x_71) + 0.0250049982303511*std::exp(1.05399990081787*x_77) + 0.0849847150970605*std::exp(1.27823996543884*x_77) - 0.0891649978913558*std::exp(1.18599987030029*x_78) + 0.0024101596200575*std::exp(1.42031991481781*x_78) - 0.00485364426349044*std::exp(1.42575979232788*x_78) - 0.0165372288412423*std::exp(1.79463994503021*x_78) - 0.172357955588287*std::exp(1.83119988441467*x_78) + 0.0962123130020064*std::exp(0.928399801254272*x_87) - 0.00505835838787544*std::exp(0.936639785766602*x_87) + 2.67695947335611*std::sin(0.295679867267609*x_100 - 1.27375984191895) - 0.454653697320908*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.231891215742888*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.014331364472401*std::sin(0.382559835910797*x_105 - 7.41167974472046) + 0.249650893929928*std::sin(0.385439842939377*x_105 - 7.41663980484009) - 13.1407411650301*std::sin(0.404799848794937*x_105 + 5.20832014083862) + 64.7543947858687*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.125348126488568*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 2.8709142781148*std::sin(0.149040028452873*x_109 + 1.74471986293793) + 0.109888454320377*std::sin(0.350639849901199*x_112 + 1.9696798324585) + 7.64895127288419*std::sin(0.355839848518372*x_112 + 1.9748797416687) - 11.2168101465795*std::sin(0.416639864444733*x_112 + 1.99151980876923) - 10.0518409207427*std::sin(0.493919849395752*x_116 + 2.07927989959717) + 0.787200333906318*std::sin(0.551679849624634*x_118 + 8.38271999359131) - 0.117328348909672*std::sin(0.238559976220131*x_120 - 7.54008007049561) - 21.3317009125647*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.0160528274587023*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.62102466852684*std::sin(0.429439842700958*x_14 - 1.18527984619141) - 0.0617927369256136*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.0301838931987546*std::sin(0.387759834527969*x_16 - 7.41447973251343) + 88.0569573666283*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.040606109465226*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.747328028688068*std::sin(0.320479840040207*x_28 + 8.2992000579834) + 1.60766029498263*std::sin(0.321199834346771*x_28 + 5.12680006027222) + 0.222672578234199*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.640216422625453*std::sin(0.328879833221436*x_3 - 4.25367975234985) + 0.217336012210365*std::sin(0.343599855899811*x_34 + 1.99671983718872) + 0.0876229859446052*std::sin(0.309759914875031*x_35 - 4.32407999038696) - 190.143208007846*std::sin(0.298239946365356*x_36 + 1.90175986289978) - 19.4681942871325*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0454205988059551*std::sin(0.356559842824936*x_36 + 1.97815978527069) - 0.0914002074221475*std::sin(0.369359821081161*x_36 - 7.43367958068848) + 13.0689734238695*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.0279848238490394*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.0280489830044534*std::sin(0.306479930877686*x_43 - 7.47168016433716) + 2.85830512656897*std::sin(0.111440062522888*x_44 + 1.70383989810944) - 72.4557804416192*std::sin(0.434479862451553*x_46 + 5.22919988632202) + 1.54174539910142*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0383386869126799*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.553637676926289*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.0316304794712163*std::sin(0.286639958620071*x_55 - 7.50279998779297) + 1.22997363989127*std::sin(0.296719938516617*x_55 + 5.11632013320923) - 2.17074232716265*std::sin(0.540319859981537*x_55 - 7.25352001190186) + 2.31200570798565*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.0502198785852897*std::sin(0.222479999065399*x_64 - 4.35383987426758) - 17.1752386907625*std::sin(0.286879926919937*x_68 - 4.28023958206177) - 0.44609691029727*std::sin(0.504639863967896*x_73 + 5.28304004669189) + 0.0961230138026528*std::sin(0.658399820327759*x_73 + 8.62887954711914) + 31.7772965372328*std::sin(0.241759970784187*x_75 - 7.55552005767822) - 8.62100695845949*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.430863535313916*std::sin(0.5865598320961*x_79 + 8.38696002960205) + 48.5601155312475*std::sin(0.155680030584335*x_8 - 4.45311975479126) + 8.78496102854031*std::sin(0.477839857339859*x_84 - 1.1515998840332) + 0.514064755385985*std::sin(0.700639843940735*x_85 + 8.47208023071289) + 1.31844655071541*std::sin(0.424319863319397*x_86 + 2.02199983596802) + 15.0798270215662*std::sin(0.436799854040146*x_86 - 1.14247989654541) - 0.398523918039178*std::sin(0.725279867649078*x_87 - 7.05223989486694) + 16.2239690213793*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.0203229187261882*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0492673424166339*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.680361484635862*std::sin(0.367519825696945*x_92 + 1.99647974967957) - 13.7733832416366*std::sin(0.344559848308563*x_95 + 5.15463972091675) - 118.580031450803*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.859919684896009*std::sin(0.330639839172363*x_97 + 5.15528011322021) + 21.2571373266988*std::sin(0.374319821596146*x_97 + 5.16991996765137) + 0.164638623406313*std::sin(0.395039826631546*x_97 - 1.20311987400055) + 1.1191688662592*std::sin(0.479519844055176*x_98 + 2.05647969245911) + 0.0520603274724577*std::sin(0.585759818553925*x_98 - 7.39888000488281) + 2037.59861807397 - 9.65716239113987e-5*std::exp(-2.43031978607178*x_86) + 0.00023624547234631*std::exp(-2.09447979927063*x_23) + 0.0678006891286104*std::exp(-2.07295966148376*x_23) - 8.71562626255837e-5*std::exp(-4.46087980270386*x_111) - 1.2439525261121e-5*std::exp(-4.18079996109009*x_111) + 3.30985014193084e-6*std::exp(-4.17871999740601*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.841896591317845*x_1 + 10.5060795717901*x_10 + 24.2123080298927*x_100 - 487.254109645251*x_101 + 0.521662417087674*x_102 + 13.1747837210269*x_103 + 6.34940093483397*x_104 - 0.420188406188913*x_105 - 4.6865616345805*x_106 + 17.0685094905486*x_107 + 9.36673217249787*x_108 + 55.4708119752752*x_109 - 13.2653059699493*x_11 - 11.6254613192596*x_110 + 26.9221136718661*x_111 - 36.8212535273107*x_112 - 15.4252956925563*x_113 + 8.95657592393727*x_114 + 35.9856854375115*x_115 + 10.8792332660153*x_116 - 9.65316392396993*x_117 + 22.0593602593167*x_118 + 1.64834168001052*x_119 + 25.2357421696596*x_12 + 28.5424783704674*x_120 + 4.8577539616503*x_13 - 1.67308142752969*x_14 - 10.8731158701927*x_15 + 3.90279069134185*x_16 + 3.41934320093236*x_17 + 33.7816626631076*x_18 + 21.9924075849409*x_19 - 23.6356211478307*x_2 + 52.6863682069195*x_20 - 7.4956562701748*x_21 + 4.79800363418163*x_22 + 5.21119996550614*x_23 + 18.5145535251045*x_24 + 39.4681032711549*x_25 + 22.5108021611848*x_26 - 32.7930277289582*x_27 - 13.3827563612239*x_28 - 7.48559357426214*x_29 + 27.54374753573*x_3 + 10.6828073953911*x_30 + 177.907982289932*x_31 + 37.4091318601572*x_32 - 47.07708663295*x_33 + 33.05055981711*x_34 + 70.6232383498231*x_35 - 1.67359881123386*x_36 + 17.6559553873781*x_37 + 17.0508711461968*x_38 - 82.6825771939456*x_39 - 205.574456241023*x_4 + 61.7993235258834*x_40 - 22.284505352276*x_41 + 50.221817188638*x_42 - 17.9449801501758*x_43 - 19.1608533056677*x_44 + 22.171537751712*x_45 - 3.78865287761042*x_46 - 6.11135056267234*x_47 - 4.3738819631612*x_48 + 40.7330979817145*x_49 + 8.85065558985787*x_5 - 8.78096692534329*x_50 - 7.36831611426126*x_51 + 30.1228901383818*x_52 + 14.5543043696377*x_53 - 31.4980109466537*x_54 - 47.1120048441617*x_55 - 21.5307582725218*x_56 + 65.0418050067488*x_57 - 5.56444482544863*x_58 + 11.4438037068763*x_59 - 2.30965301777556*x_6 + 19.0666566698024*x_60 + 16.0671248426948*x_61 - 29.9578424512486*x_62 - 45.3504443187756*x_63 + 33.9445941191632*x_64 + 24.447469240142*x_65 + 30.8434538060706*x_66 - 27.5095384285611*x_67 - 16.0934911421131*x_68 - 36.4785175906184*x_69 - 16.4233500740637*x_7 - 27.9639614034877*x_70 + 0.196718646570926*x_71 - 10.6808262209939*x_72 - 19.6146670089092*x_73 + 37.0685680198582*x_74 - 9.44244533780025*x_75 - 57.8142699514815*x_76 + 9.72520580763436*x_77 + 25.5368300591168*x_78 - 17.5012282023278*x_79 + 113.29528430836*x_8 - 12.9862051534221*x_80 + 49.6217059855734*x_81 + 26.6484262162207*x_82 + 41.2235646647836*x_83 - 83.3309325743875*x_84 + 9.49184860523064*x_85 + 60.4012873975873*x_86 - 19.3413947402938*x_87 + 35.2578877963269*x_88 - 21.4230151510241*x_89 - 71.3609320948121*x_9 - 59.0869520649952*x_90 - 11.4212311467191*x_91 + 32.8058642142447*x_92 + 1071.46322780806*x_93 + 25.1985354297598*x_94 - 5.7558224097476*x_95 - 7.09087351509976*x_96 - 27.7136664569089*x_97 - 40.3002071399157*x_98 - 13.9262846166094*x_99 + 0.000780758829434894*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) + 0.000639331086919131*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) + 0.0059625814084185*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.301716275061736*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.0363979680994892*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 5.23343616056508e-6*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) + 0.00332303182676167*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 4.45002755548552e-5*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) + 0.00494920413372211*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 6.89694255833099e-5*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.00615824379885544*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.00012118911760051*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.000256728850997948*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 8.777950017386e-6*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.0040718602744867*std::exp(0.497599840164185*x_1) + 1.87600690342278*std::exp(0.678719818592072*x_1) + 0.0133747375863925*std::exp(1.07895982265472*x_1) + 0.0115711733741787*std::exp(1.13103985786438*x_1) + 0.0440011847927692*std::exp(1.18119990825653*x_1) - 0.000313980339523803*std::exp(1.18687987327576*x_1) - 0.253499646126585*std::exp(1.18903994560242*x_1) - 0.331531805177316*std::exp(0.886079907417297*x_108) + 0.304481013376707*std::exp(1.05951988697052*x_108) + 4.29810974323052*std::exp(0.766639888286591*x_15) - 0.373376963278445*std::exp(3.22775983810425*x_17) - 6.25291489217419e-5*std::exp(3.42799997329712*x_17) - 8.09318589330805e-7*std::exp(3.65799999237061*x_17) - 0.0125770741643911*std::exp(4.0492000579834*x_17) + 0.47459511872405*std::exp(0.82207989692688*x_29) - 2.83941958239109*std::exp(0.885519862174988*x_29) - 0.151799519440535*std::exp(0.991279780864716*x_29) + 2.40946864033761*std::exp(1.08511984348297*x_29) - 0.00129643273304682*std::exp(1.32527983188629*x_29) + 0.000406104587109034*std::exp(2.31079983711243*x_29) - 0.00971582471059592*std::exp(1.29527986049652*x_38) + 0.241284509525284*std::exp(1.79503989219666*x_50) + 0.313258685218722*std::exp(1.84271991252899*x_50) - 0.00543276949032206*std::exp(1.87079989910126*x_50) - 0.00014526233980634*std::exp(1.91103982925415*x_50) + 0.00376576985050122*std::exp(1.92647981643677*x_50) + 0.0465611558851106*std::exp(1.93199980258942*x_50) + 1.62308423910372*std::exp(1.9819997549057*x_50) - 1.24075584259578*std::exp(1.99463987350464*x_50) + 0.476958184563539*std::exp(0.991679787635803*x_6) + 0.0227990922745842*std::exp(0.749679863452911*x_67) - 1.27946808217692*std::exp(1.43279981613159*x_71) + 0.0578189615858903*std::exp(1.4605598449707*x_71) + 5.54492885890016*std::exp(1.48087978363037*x_71) + 0.00107209929673881*std::exp(1.84319996833801*x_71) + 9.13305995202266e-5*std::exp(1.88271987438202*x_71) + 0.0357754172867928*std::exp(1.89127993583679*x_71) + 0.0243719180009938*std::exp(1.05399990081787*x_77) + 0.252648696009736*std::exp(1.27823996543884*x_77) - 0.234385195610393*std::exp(1.18599987030029*x_78) + 0.000304929520942417*std::exp(1.42031991481781*x_78) + 0.055634210729264*std::exp(1.42575979232788*x_78) - 0.0491630677067359*std::exp(1.79463994503021*x_78) + 0.470407924643543*std::exp(1.83119988441467*x_78) + 0.0121950015843091*std::exp(0.928399801254272*x_87) - 0.000639975372225808*std::exp(0.936639785766602*x_87) + 7.03683827333431*std::sin(0.295679867267609*x_100 - 1.27375984191895) - 1.35162733243199*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.0293924307101204*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0335392647450376*std::sin(0.382559835910797*x_105 - 7.41167974472046) + 0.243330195814597*std::sin(0.385439842939377*x_105 - 7.41663980484009) + 28.1517379936799*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 115.015897099396*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.0158879934742488*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 0.363891097486613*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 1.25958086181958*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 20.8758991234029*std::sin(0.355839848518372*x_112 + 1.9748797416687) + 24.0300525218231*std::sin(0.416639864444733*x_112 + 1.99151980876923) + 21.5343098536901*std::sin(0.493919849395752*x_116 + 2.07927989959717) + 2.06928849448317*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 1.3448596010337*std::sin(0.238559976220131*x_120 - 7.54008007049561) + 45.699435633674*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.00203097792611619*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.0787154635438597*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 0.708290505243025*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.00381881764870566*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 156.405599664044*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.095029266630048*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.0947245337887214*std::sin(0.320479840040207*x_28 + 8.2992000579834) + 4.77936858045708*std::sin(0.321199834346771*x_28 + 5.12680006027222) + 0.217034921090557*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.0811480365102052*std::sin(0.328879833221436*x_3 - 4.25367975234985) + 0.211833467031589*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 1.00436608043949*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 337.72984395419*std::sin(0.298239946365356*x_36 + 1.90175986289978) + 41.7071988481066*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.00574654115003685*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 1.04766194726545*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 35.668493772514*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.0654920484175592*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.0656421981749945*std::sin(0.306479930877686*x_43 - 7.47168016433716) + 2.78593813624041*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 128.694996147942*std::sin(0.434479862451553*x_46 + 5.22919988632202) + 4.05273712213974*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.00485054904104893*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.0701740986843182*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.00400183741859671*std::sin(0.286639958620071*x_55 - 7.50279998779297) + 3.65655442734578*std::sin(0.296719938516617*x_55 + 5.11632013320923) + 4.65043550273246*std::sin(0.540319859981537*x_55 - 7.25352001190186) + 6.87329747028643*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.00635373831316341*std::sin(0.222479999065399*x_64 - 4.35383987426758) + 36.7949428064206*std::sin(0.286879926919937*x_68 - 4.28023958206177) - 1.32618909826145*std::sin(0.504639863967896*x_73 + 5.28304004669189) + 0.0936893571767213*std::sin(0.658399820327759*x_73 + 8.62887954711914) - 68.0772960237819*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 23.5288819586235*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.0546123602252931*std::sin(0.5865598320961*x_79 + 8.38696002960205) - 104.031548313004*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 23.9763535799962*std::sin(0.477839857339859*x_84 - 1.1515998840332) + 1.35130568156761*std::sin(0.700639843940735*x_85 + 8.47208023071289) + 3.46575853753526*std::sin(0.424319863319397*x_86 + 2.02199983596802) - 32.305890053666*std::sin(0.436799854040146*x_86 - 1.14247989654541) - 1.18476067262561*std::sin(0.725279867649078*x_87 - 7.05223989486694) - 34.7570140353193*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.0475611204266101*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.00623322496824993*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.0862364610532147*std::sin(0.367519825696945*x_92 + 1.99647974967957) + 29.5070629149103*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 210.620278986301*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.108995632601274*std::sin(0.330639839172363*x_97 + 5.15528011322021) - 45.5396962014149*std::sin(0.374319821596146*x_97 + 5.16991996765137) + 0.160470278481552*std::sin(0.395039826631546*x_97 - 1.20311987400055) + 2.94192362297645*std::sin(0.479519844055176*x_98 + 2.05647969245911) + 0.0507422564310978*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 3342.76705554819 - 0.000226003690539032*std::exp(-2.43031978607178*x_86) + 2.98893974108058e-5*std::exp(-2.09447979927063*x_23) - 0.145251109672489*std::exp(-2.07295966148376*x_23) - 0.000229104897070251*std::exp(-4.46087980270386*x_111) + 0.000142586298496363*std::exp(-4.18079996109009*x_111) + 7.74594354852944e-6*std::exp(-4.17871999740601*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.151644256838406*x_1 + 5.63842136307756*x_10 + 17.5908777731734*x_100 - 375.455064584425*x_101 - 2.93805644616117*x_102 + 6.6571644636485*x_103 + 7.42286412186005*x_104 + 0.814706451255716*x_105 + 13.549955654656*x_106 - 0.320300172750066*x_107 + 4.86597164818702*x_108 + 36.9421419586857*x_109 - 2.94484082158937*x_11 + 2.89957686173087*x_110 + 20.9549437138934*x_111 - 24.5788358998759*x_112 - 12.8292528785596*x_113 + 5.9196251875395*x_114 + 31.1124889067373*x_115 + 12.2905966896945*x_116 - 10.3804211219463*x_117 + 31.8505419523081*x_118 - 0.360248147155807*x_119 + 12.0032222393872*x_12 + 28.0969162513813*x_120 + 0.46878452624574*x_13 + 0.213189817820875*x_14 - 5.75938345131167*x_15 - 3.68540184033601*x_16 - 0.549740108818646*x_17 + 24.2824029348829*x_18 + 10.3742027697265*x_19 - 11.0620311074001*x_2 + 24.1542112405882*x_20 + 2.08887096585415*x_21 + 6.23879445805153*x_22 + 7.21190500074691*x_23 + 14.8209305979888*x_24 + 27.8953109867321*x_25 + 25.2304712639021*x_26 - 16.6866587397695*x_27 - 3.41131953585871*x_28 - 5.04294500671412*x_29 + 20.8104581024737*x_3 + 15.0146299128176*x_30 + 219.888227663201*x_31 + 43.1123000642965*x_32 - 58.5108923328607*x_33 + 20.1496141575805*x_34 + 41.9292867818626*x_35 - 1.68145351321572*x_36 + 18.0644162490568*x_37 + 13.2844027343802*x_38 - 31.2714926005897*x_39 - 130.784082045772*x_4 + 23.9650433113523*x_40 - 25.8688631217581*x_41 + 40.9955814397176*x_42 - 28.2363204198007*x_43 - 10.5898253796531*x_44 + 22.3724944297874*x_45 + 2.02064958083865*x_46 + 4.54601410869694*x_47 - 63.4143309517182*x_48 - 3.19461233892288*x_49 + 7.00411435533495*x_5 - 5.94179487858024*x_50 + 3.58393435506572*x_51 + 31.7282069379953*x_52 + 10.1347548312775*x_53 - 26.452504152458*x_54 - 32.6669534265478*x_55 - 18.659088041982*x_56 + 36.588993703446*x_57 - 7.17660461634594*x_58 + 8.15176928884476*x_59 - 3.68348843856655*x_6 + 5.60069921385209*x_60 + 3.52315325108686*x_61 - 12.818006076204*x_62 - 32.0348348502757*x_63 + 10.5335366036459*x_64 + 9.92621703255961*x_65 + 28.1024783394853*x_66 - 22.9917059863925*x_67 - 6.79744834045568*x_68 - 23.4688786561037*x_69 - 12.6924785989812*x_7 - 18.2965616443235*x_70 - 0.248716939027302*x_71 - 9.76278955719529*x_72 - 15.9409154481532*x_73 + 20.1651435472162*x_74 - 10.3004947084481*x_75 - 28.7510713352091*x_76 + 1.26294955396471*x_77 + 18.7709445186277*x_78 - 5.13350380029352*x_79 + 33.7852947062177*x_8 - 7.77601238180497*x_80 + 19.9164405468739*x_81 + 15.004076509576*x_82 + 26.6003388514537*x_83 - 52.6762742808212*x_84 + 3.04474136864531*x_85 + 40.3006008674729*x_86 - 16.9669049937582*x_87 + 22.5437704661736*x_88 - 34.0252355814478*x_89 + 44.6912202523512*x_9 - 45.4835611624967*x_90 - 7.34670741882092*x_91 + 21.4023620440972*x_92 + 1069.76983146559*x_93 + 19.8775509927808*x_94 - 11.9792050472812*x_95 + 4.58502702428231*x_96 - 14.3735780649851*x_97 - 28.0604541342535*x_98 - 14.4113686297897*x_99 + 0.000581246835400306*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) - 0.000279152212615059*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) + 0.0100612707154041*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.210325770208051*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) - 0.0206049822452838*std::pow(-9.0*x_24 - 9.99987983703613, 2) + 7.07848862270959e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) + 0.00560728994957588*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) - 0.00044684284202885*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) + 0.00835129605859467*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) + 0.000692546141714419*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.00458459076575422*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) - 0.00121690234625237*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) - 0.00257790424846499*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) + 0.000118726239171457*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) + 0.00547542056543467*std::exp(0.497599840164185*x_1) - 1.06201227583357*std::exp(0.678719818592072*x_1) - 0.00583983426862443*std::exp(1.07895982265472*x_1) + 0.0195252190013063*std::exp(1.13103985786438*x_1) - 0.0269156647482642*std::exp(1.18119990825653*x_1) + 0.00315278648288486*std::exp(1.18687987327576*x_1) - 0.176714061275391*std::exp(1.18903994560242*x_1) - 0.00625381733928806*std::exp(0.886079907417297*x_108) + 0.51378181586894*std::exp(1.05951988697052*x_108) - 2.62916740639792*std::exp(0.766639888286591*x_15) - 0.260280282737196*std::exp(3.22775983810425*x_17) + 0.000627877069646321*std::exp(3.42799997329712*x_17) + 1.0946445606603e-5*std::exp(3.65799999237061*x_17) + 0.00769343628625281*std::exp(4.0492000579834*x_17) + 0.800832666695371*std::exp(0.82207989692688*x_29) + 1.73688199350155*std::exp(0.885519862174988*x_29) - 0.113009276313866*std::exp(0.991279780864716*x_29) - 1.3640063208754*std::exp(1.08511984348297*x_29) - 0.00174330992954371*std::exp(1.32527983188629*x_29) - 0.000177318131972755*std::exp(2.31079983711243*x_29) + 0.00424223695802544*std::exp(1.29527986049652*x_38) + 0.00455144642476698*std::exp(1.79503989219666*x_50) + 0.52859327530307*std::exp(1.84271991252899*x_50) - 0.00730543186389796*std::exp(1.87079989910126*x_50) + 0.00196474703823717*std::exp(1.91103982925415*x_50) - 0.0378134130956168*std::exp(1.92647981643677*x_50) + 0.0346631040091974*std::exp(1.93199980258942*x_50) - 0.918832112768443*std::exp(1.9819997549057*x_50) + 0.758974296965886*std::exp(1.99463987350464*x_50) + 0.00899705342943944*std::exp(0.991679787635803*x_6) - 0.00995480617833636*std::exp(0.749679863452911*x_67) + 0.724310133043734*std::exp(1.43279981613159*x_71) + 0.0430441349888481*std::exp(1.4605598449707*x_71) + 3.86535805123007*std::exp(1.48087978363037*x_71) + 0.00144164930568295*std::exp(1.84319996833801*x_71) - 0.00123529281675496*std::exp(1.88271987438202*x_71) + 0.0603675042106371*std::exp(1.89127993583679*x_71) - 0.0106415517325075*std::exp(1.05399990081787*x_77) + 0.00476581362988431*std::exp(1.27823996543884*x_77) - 0.39550200545515*std::exp(1.18599987030029*x_78) - 0.0041243268829444*std::exp(1.42031991481781*x_78) + 0.0414176666433396*std::exp(1.42575979232788*x_78) - 0.000927382653717154*std::exp(1.79463994503021*x_78) - 0.266299121665998*std::exp(1.83119988441467*x_78) - 0.122454279182199*std::exp(0.928399801254272*x_87) + 0.00865599245338953*std::exp(0.936639785766602*x_87) + 11.873973703499*std::sin(0.295679867267609*x_100 - 1.27375984191895) - 0.0254962881865827*std::sin(0.614319860935211*x_100 - 0.991679787635803) + 0.295139684167939*std::sin(0.654959857463837*x_100 - 7.17583990097046) + 0.0451001673817717*std::sin(0.382559835910797*x_105 - 7.41167974472046) - 0.106245674498685*std::sin(0.385439842939377*x_105 - 7.41663980484009) - 17.2205077087692*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 80.1773359380453*std::sin(0.493199855089188*x_105 + 2.0623996257782) + 0.15953690330339*std::sin(0.463439851999283*x_106 + 5.25072002410889) - 3.6539578724513*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 0.937712597362913*std::sin(0.350639849901199*x_112 + 1.9696798324585) + 11.8178995491259*std::sin(0.355839848518372*x_112 + 1.9748797416687) - 14.6992595905476*std::sin(0.416639864444733*x_112 + 1.99151980876923) - 13.172605859068*std::sin(0.493919849395752*x_116 + 2.07927989959717) + 3.49172116994012*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 1.00119954804013*std::sin(0.238559976220131*x_120 - 7.54008007049561) - 27.9544901914319*std::sin(0.300959825515747*x_14 - 4.31983995437622) + 0.0274700095728989*std::sin(0.343759834766388*x_14 + 4.94831991195679) - 0.790409520008443*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 0.527296777437113*std::sin(0.532079875469208*x_15 - 7.26839971542358) - 0.0516514512630396*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 109.030009095337*std::sin(0.449439853429794*x_16 - 1.14679980278015) + 0.127785622724967*std::sin(0.222399994730949*x_27 + 5.02719974517822) + 0.951162197542661*std::sin(0.320479840040207*x_28 + 8.2992000579834) + 0.0901551453964579*std::sin(0.321199834346771*x_28 + 5.12680006027222) - 0.0947643242707315*std::sin(0.280239969491959*x_3 - 1.10599982738495) - 0.814835836568763*std::sin(0.328879833221436*x_3 - 4.25367975234985) - 0.09249320459724*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 0.747714382252199*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 235.430752077844*std::sin(0.298239946365356*x_36 + 1.90175986289978) - 25.5124262465156*std::sin(0.349679857492447*x_36 - 1.20887982845306) + 0.0777248922170405*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 0.779946596131509*std::sin(0.369359821081161*x_36 - 7.43367958068848) + 20.1920249748496*std::sin(0.380159854888916*x_36 + 1.96855986118317) - 0.088066997540369*std::sin(0.385199844837189*x_41 - 7.4157600402832) + 0.088268903552446*std::sin(0.306479930877686*x_43 - 7.47168016433716) - 1.21642887519805*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 89.7130066357862*std::sin(0.434479862451553*x_46 + 5.22919988632202) + 6.83859599244131*std::sin(0.412479877471924*x_51 - 1.18431985378265) + 0.0656061431678045*std::sin(0.324799835681915*x_53 + 5.13336038589478) - 0.704642685959559*std::sin(0.501439809799194*x_54 - 1.13007986545563) + 0.0541268867497024*std::sin(0.286639958620071*x_55 - 7.50279998779297) + 0.0689750519337209*std::sin(0.296719938516617*x_55 + 5.11632013320923) - 2.84468619457588*std::sin(0.540319859981537*x_55 - 7.25352001190186) + 0.1296537654201*std::sin(0.19752000272274*x_58 - 4.41599988937378) - 0.0859375427186735*std::sin(0.222479999065399*x_64 - 4.35383987426758) - 22.5075835951563*std::sin(0.286879926919937*x_68 - 4.28023958206177) - 0.0250164365782235*std::sin(0.504639863967896*x_73 + 5.28304004669189) - 0.0409077423098502*std::sin(0.658399820327759*x_73 + 8.62887954711914) + 41.6430985977806*std::sin(0.241759970784187*x_75 - 7.55552005767822) - 13.3197598746073*std::sin(0.534959852695465*x_79 - 1.05399978160858) - 0.548381823453917*std::sin(0.5865598320961*x_79 + 8.38696002960205) + 63.6364291285129*std::sin(0.155680030584335*x_8 - 4.45311975479126) + 13.5730746966999*std::sin(0.477839857339859*x_84 - 1.1515998840332) + 2.2801956653069*std::sin(0.700639843940735*x_85 + 8.47208023071289) + 5.84812726097675*std::sin(0.424319863319397*x_86 + 2.02199983596802) + 19.7616157422572*std::sin(0.436799854040146*x_86 - 1.14247989654541) - 0.02234861549229*std::sin(0.725279867649078*x_87 - 7.05223989486694) + 21.2609760812418*std::sin(0.356879830360413*x_92 + 2.00383973121643) - 0.0639553224678871*std::sin(0.358479857444763*x_92 + 2.00711965560913) + 0.0843075384257338*std::sin(0.363519847393036*x_92 + 1.98439979553223) + 0.865930488363558*std::sin(0.367519825696945*x_92 + 1.99647974967957) - 18.0495642756915*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 146.822946127663*std::sin(0.293919950723648*x_96 - 7.49056005477905) - 1.0944632956317*std::sin(0.330639839172363*x_97 + 5.15528011322021) + 27.8567770724326*std::sin(0.374319821596146*x_97 + 5.16991996765137) - 0.0700664088038409*std::sin(0.395039826631546*x_97 - 1.20311987400055) + 4.96420727321515*std::sin(0.479519844055176*x_98 + 2.05647969245911) - 0.0221556771532578*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 1299.18334291003 - 0.00030390661064556*std::exp(-2.43031978607178*x_86) - 0.000404269304183487*std::exp(-2.09447979927063*x_23) + 0.0888505659715904*std::exp(-2.07295966148376*x_23) - 0.000386592020092852*std::exp(-4.46087980270386*x_111) + 0.00010615036506528*std::exp(-4.18079996109009*x_111) + 1.04159513699572e-5*std::exp(-4.17871999740601*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0493792984575528*x_1 + 10.8109745617245*x_10 + 22.0207803811342*x_100 - 587.721233495907*x_101 - 6.26080812803062*x_102 + 9.77752867839597*x_103 + 7.10464332085671*x_104 - 2.78887946827244*x_105 + 1.41513688305157*x_106 + 10.3942876800589*x_107 + 8.03684628366928*x_108 + 58.0286537935353*x_109 - 14.7194231768037*x_11 - 16.4759770019012*x_110 + 27.0312052441367*x_111 - 38.6376402751631*x_112 - 10.5639365990493*x_113 + 9.75942859003877*x_114 + 31.3920247515885*x_115 - 7.21655323036798*x_116 - 10.7416445584421*x_117 + 20.0889070060882*x_118 - 7.49917996165581*x_119 + 23.5444608098231*x_12 + 24.0448420740519*x_120 + 2.95547957352478*x_13 + 1.24450270170038*x_14 - 10.8770625737258*x_15 + 6.96510726584433*x_16 - 0.49523387411827*x_17 + 33.5158095672393*x_18 + 20.0754291399873*x_19 - 17.5155705923202*x_2 + 38.2275488992531*x_20 - 5.24182724049538*x_21 + 11.7900237431859*x_22 - 5.65950246426713*x_23 + 23.4018763798515*x_24 + 34.8659271032674*x_25 + 18.9641362619538*x_26 - 27.9375095696349*x_27 - 8.5319367060919*x_28 - 6.30655413484919*x_29 + 20.7956180630352*x_3 + 20.6440782097364*x_30 + 165.37192738624*x_31 + 16.583699772329*x_32 - 33.0471766972672*x_33 + 37.8600367829891*x_34 + 74.4104936449633*x_35 + 6.78364281035286*x_36 + 7.45060433447159*x_37 + 14.4716786375685*x_38 - 66.3198094265928*x_39 - 160.860223211716*x_4 + 57.5724341925405*x_40 - 24.1879827888229*x_41 + 44.6253172091106*x_42 - 19.600975602169*x_43 - 17.597532862082*x_44 + 25.3107259602896*x_45 - 2.09401070864168*x_46 - 8.35755025208248*x_47 - 31.8354542459946*x_48 + 41.4225183914491*x_49 + 4.08418663967717*x_5 - 7.89244431280175*x_50 - 7.56875282424692*x_51 + 20.3436819455322*x_52 + 11.9344738393027*x_53 - 20.363457028059*x_54 - 38.6728823590968*x_55 - 11.8597876153191*x_56 + 64.7993691824686*x_57 - 9.12292095008476*x_58 + 12.4652844165833*x_59 - 4.48300156009922*x_6 + 22.2637390434453*x_60 + 16.1557687259546*x_61 - 35.7138510040897*x_62 - 44.5048453862899*x_63 + 28.3346151566348*x_64 + 22.1339843942468*x_65 + 28.4419235111144*x_66 - 25.0755187063641*x_67 - 7.38333735981636*x_68 - 35.4480315780268*x_69 - 15.7018022205364*x_7 - 22.3077061766069*x_70 + 0.38150300173009*x_71 - 17.394109217973*x_72 - 16.4725574040902*x_73 + 35.5782782699999*x_74 - 8.31370324276683*x_75 - 56.5290824460676*x_76 + 9.32530054847485*x_77 + 23.4933928779891*x_78 - 15.1034263035002*x_79 + 81.5330592857019*x_8 - 5.80652811159222*x_80 + 42.9042366976089*x_81 + 27.3319563707243*x_82 + 40.9479285144374*x_83 - 68.3270440599771*x_84 + 7.76828677726566*x_85 + 53.8518860206529*x_86 - 25.7517083897969*x_87 + 34.6639053565312*x_88 - 22.4299475849995*x_89 - 80.4068844070024*x_9 - 44.3441585600146*x_90 - 13.508148057166*x_91 + 31.6757356352741*x_92 + 921.150940093029*x_93 + 22.8182762369561*x_94 - 0.378844082935155*x_95 - 7.22328563849679*x_96 - 20.4435894094079*x_97 - 36.8349167350696*x_98 - 13.217979712022*x_99 + 0.00154008437624234*std::pow(-6.27288007736206*x_106 - 8.69944000244141, 2) + 3.55145934269468e-5*std::pow(-4.7338399887085*x_117 - 5.72255992889404, 2) - 0.0430217722772976*std::pow(-6.29176044464111*x_13 - 8.52624034881592, 2) - 0.275855434416623*std::pow(-5.16672039031982*x_14 - 8.75191974639893, 2) + 0.0331106222773844*std::pow(-9.0*x_24 - 9.99987983703613, 2) - 1.91739865317796e-5*std::pow(-6.5906400680542*x_26 - 6.99119997024536, 2) - 0.0239766484897473*std::pow(-8.56256008148193*x_44 - 8.58551979064941, 2) + 6.28096789273309e-5*std::pow(-5.31583976745605*x_6 - 8.65456008911133, 2) - 0.0357099582563734*std::pow(-6.90768003463745*x_66 - 8.88016033172607, 2) - 9.73465315141738e-5*std::pow(-7.39599990844727*x_71 - 9.9919605255127, 2) - 0.0121474323467762*std::pow(-2.81767988204956*x_73 - 3.42447996139526, 2) + 0.000171051740041283*std::pow(-5.78359985351563*x_74 - 4.78336000442505, 2) + 0.000362358580963986*std::pow(-5.12735986709595*x_78 - 5.93928003311157, 2) - 3.21601888790062e-5*std::pow(-5.67176008224487*x_85 - 8.53552055358887, 2) - 0.00153936231450244*std::exp(0.497599840164185*x_1) + 1.70657207565026*std::exp(0.678719818592072*x_1) + 0.000742961475347303*std::exp(1.07895982265472*x_1) - 0.0834894069843962*std::exp(1.13103985786438*x_1) + 0.0308697079324783*std::exp(1.18119990825653*x_1) - 0.000443165892100475*std::exp(1.18687987327576*x_1) - 0.231771570799091*std::exp(1.18903994560242*x_1) + 0.18490999437167*std::exp(0.886079907417297*x_108) - 2.1969197438141*std::exp(1.05951988697052*x_108) + 3.01540499557342*std::exp(0.766639888286591*x_15) - 0.341373909595231*std::exp(3.22775983810425*x_17) - 8.82564370311042e-5*std::exp(3.42799997329712*x_17) - 2.96513863084406e-6*std::exp(3.65799999237061*x_17) - 0.00882363981625499*std::exp(4.0492000579834*x_17) - 3.42434286814689*std::exp(0.82207989692688*x_29) - 1.99203847848607*std::exp(0.885519862174988*x_29) - 0.29943185961877*std::exp(0.991279780864716*x_29) + 2.19185328756143*std::exp(1.08511984348297*x_29) + 0.000490114973994595*std::exp(1.32527983188629*x_29) + 2.25589519969952e-5*std::exp(2.31079983711243*x_29) - 0.000539710286992415*std::exp(1.29527986049652*x_38) - 0.134575074250958*std::exp(1.79503989219666*x_50) - 2.26025321857033*std::exp(1.84271991252899*x_50) + 0.0020538525521568*std::exp(1.87079989910126*x_50) - 0.00053220447552394*std::exp(1.91103982925415*x_50) + 0.00531517596857662*std::exp(1.92647981643677*x_50) + 0.0918441214047425*std::exp(1.93199980258942*x_50) + 1.47649256184972*std::exp(1.9819997549057*x_50) - 0.870471344279392*std::exp(1.99463987350464*x_50) - 0.266020737214024*std::exp(0.991679787635803*x_6) + 0.00126648071586377*std::exp(0.749679863452911*x_67) - 1.16391069603481*std::exp(1.43279981613159*x_71) + 0.114050685092395*std::exp(1.4605598449707*x_71) + 5.06965943043077*std::exp(1.48087978363037*x_71) - 0.000405305964240715*std::exp(1.84319996833801*x_71) + 0.000334612218705483*std::exp(1.88271987438202*x_71) - 0.258130120196703*std::exp(1.89127993583679*x_71) + 0.00135385057374766*std::exp(1.05399990081787*x_77) - 0.140913385164309*std::exp(1.27823996543884*x_77) + 1.69115787609762*std::exp(1.18599987030029*x_78) + 0.00111718464662816*std::exp(1.42031991481781*x_78) + 0.109741158855327*std::exp(1.42575979232788*x_78) + 0.0274204237149569*std::exp(1.79463994503021*x_78) + 0.427922214410073*std::exp(1.83119988441467*x_78) + 0.0172125705847495*std::exp(0.928399801254272*x_87) - 0.00234470791106456*std::exp(0.936639785766602*x_87) - 50.7728503832467*std::sin(0.295679867267609*x_100 - 1.27375984191895) + 0.753862520969662*std::sin(0.614319860935211*x_100 - 0.991679787635803) - 0.0414857911052881*std::sin(0.654959857463837*x_100 - 7.17583990097046) - 0.0126794822818766*std::sin(0.382559835910797*x_105 - 7.41167974472046) + 0.0135168978165891*std::sin(0.385439842939377*x_105 - 7.41663980484009) + 19.7502847650448*std::sin(0.404799848794937*x_105 + 5.20832014083862) - 105.157602958871*std::sin(0.493199855089188*x_105 + 2.0623996257782) - 0.0224250244852297*std::sin(0.463439851999283*x_106 + 5.25072002410889) + 0.513612167849926*std::sin(0.149040028452873*x_109 + 1.74471986293793) - 2.48458388527768*std::sin(0.350639849901199*x_112 + 1.9696798324585) - 18.9904559695867*std::sin(0.355839848518372*x_112 + 1.9748797416687) + 16.8586529304705*std::sin(0.416639864444733*x_112 + 1.99151980876923) + 15.1077262769557*std::sin(0.493919849395752*x_116 + 2.07927989959717) - 14.9305229208266*std::sin(0.551679849624634*x_118 + 8.38271999359131) + 2.65280030363618*std::sin(0.238559976220131*x_120 - 7.54008007049561) + 32.0611419291246*std::sin(0.300959825515747*x_14 - 4.31983995437622) - 0.0074409894774543*std::sin(0.343759834766388*x_14 + 4.94831991195679) + 0.111102525325069*std::sin(0.429439842700958*x_14 - 1.18527984619141) + 1.39713711819962*std::sin(0.532079875469208*x_15 - 7.26839971542358) + 0.0139911820679778*std::sin(0.387759834527969*x_16 - 7.41447973251343) - 142.999692779877*std::sin(0.449439853429794*x_16 - 1.14679980278015) - 0.0359257101088864*std::sin(0.222399994730949*x_27 + 5.02719974517822) - 0.133698442978777*std::sin(0.320479840040207*x_28 + 8.2992000579834) - 2.66566586828612*std::sin(0.321199834346771*x_28 + 5.12680006027222) + 0.0120562055243148*std::sin(0.280239969491959*x_3 - 1.10599982738495) + 0.114535967592075*std::sin(0.328879833221436*x_3 - 4.25367975234985) + 0.0117672667726839*std::sin(0.343599855899811*x_34 + 1.99671983718872) - 1.98116044314501*std::sin(0.309759914875031*x_35 - 4.32407999038696) + 308.782192145181*std::sin(0.298239946365356*x_36 + 1.90175986289978) + 29.2603268113458*std::sin(0.349679857492447*x_36 - 1.20887982845306) - 0.0210538734465477*std::sin(0.356559842824936*x_36 + 1.97815978527069) + 2.06656362469187*std::sin(0.369359821081161*x_36 - 7.43367958068848) - 32.44703169355*std::sin(0.380159854888916*x_36 + 1.96855986118317) + 0.0247591971328801*std::sin(0.385199844837189*x_41 - 7.4157600402832) - 0.0248159610841325*std::sin(0.306479930877686*x_43 - 7.47168016433716) + 0.154757780820564*std::sin(0.111440062522888*x_44 + 1.70383989810944) + 117.664232936629*std::sin(0.434479862451553*x_46 + 5.22919988632202) - 29.2416860459591*std::sin(0.412479877471924*x_51 - 1.18431985378265) - 0.0177711849598193*std::sin(0.324799835681915*x_53 + 5.13336038589478) + 0.0990468610007509*std::sin(0.501439809799194*x_54 - 1.13007986545563) - 0.0146617202183011*std::sin(0.286639958620071*x_55 - 7.50279998779297) - 2.03942260748887*std::sin(0.296719938516617*x_55 + 5.11632013320923) + 3.26258455094532*std::sin(0.540319859981537*x_55 - 7.25352001190186) - 3.83354289602992*std::sin(0.19752000272274*x_58 - 4.41599988937378) + 0.0232784902892353*std::sin(0.222479999065399*x_64 - 4.35383987426758) + 25.8140580344805*std::sin(0.286879926919937*x_68 - 4.28023958206177) + 0.739674489342399*std::sin(0.504639863967896*x_73 + 5.28304004669189) + 0.00520440738240549*std::sin(0.658399820327759*x_73 + 8.62887954711914) - 47.7606740587668*std::sin(0.241759970784187*x_75 - 7.55552005767822) + 21.4038300438006*std::sin(0.534959852695465*x_79 - 1.05399978160858) + 0.0770823274338162*std::sin(0.5865598320961*x_79 + 8.38696002960205) - 72.9849327310312*std::sin(0.155680030584335*x_8 - 4.45311975479126) - 21.8108874870794*std::sin(0.477839857339859*x_84 - 1.1515998840332) - 9.75006651101469*std::sin(0.700639843940735*x_85 + 8.47208023071289) - 25.0064635359821*std::sin(0.424319863319397*x_86 + 2.02199983596802) - 22.6646940338595*std::sin(0.436799854040146*x_86 - 1.14247989654541) + 0.660793582654333*std::sin(0.725279867649078*x_87 - 7.05223989486694) - 24.3843177616362*std::sin(0.356879830360413*x_92 + 2.00383973121643) + 0.0179804294560341*std::sin(0.358479857444763*x_92 + 2.00711965560913) - 0.0228369598718621*std::sin(0.363519847393036*x_92 + 1.98439979553223) - 0.121717997541494*std::sin(0.367519825696945*x_92 + 1.99647974967957) + 20.7011338085203*std::sin(0.344559848308563*x_95 + 5.15463972091675) + 192.567499200459*std::sin(0.293919950723648*x_96 - 7.49056005477905) + 0.153841310032526*std::sin(0.330639839172363*x_97 + 5.15528011322021) - 31.9490742736202*std::sin(0.374319821596146*x_97 + 5.16991996765137) + 0.008914061609055*std::sin(0.395039826631546*x_97 - 1.20311987400055) - 21.2268411104957*std::sin(0.479519844055176*x_98 + 2.05647969245911) + 0.00281871262572323*std::sin(0.585759818553925*x_98 - 7.39888000488281) - 6432.57429445593 + 8.54404475355221e-5*std::exp(-2.43031978607178*x_86) + 0.000109507192944514*std::exp(-2.09447979927063*x_23) - 0.101903149962338*std::exp(-2.07295966148376*x_23) + 0.00165305897466721*std::exp(-4.46087980270386*x_111) + 0.000281258337788401*std::exp(-4.18079996109009*x_111) - 2.9283454699026e-6*std::exp(-4.17871999740601*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
