
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000111539384714824*x_1 + 0.0020518643595781*x_10 + 0.00305668343342212*x_100 - 0.000879748172674378*x_101 + 0.00185563552994727*x_102 - 0.000707661189884273*x_103 - 0.00308360982833099*x_104 - 0.00105638136449118*x_105 - 0.00217027041209889*x_106 - 0.000574423011129665*x_107 + 0.000553542464981759*x_108 - 0.000543673699546358*x_109 - 0.00146105801718383*x_11 - 0.00458856048016568*x_110 - 0.00521134451432508*x_111 + 0.000453418190166481*x_112 + 0.00187666747336901*x_113 - 0.00188444694374707*x_114 - 0.000867144346973851*x_115 + 0.000157168341441239*x_116 - 0.000358514259558892*x_117 - 0.000253904105528109*x_118 - 0.000750365752769649*x_119 - 0.00248285965545524*x_12 - 0.0010036510525666*x_120 - 0.000119183162787434*x_13 - 0.00149108645811623*x_14 + 0.000220420610424137*x_15 + 0.000592409935657797*x_16 - 1.19738395229639e-5*x_17 - 0.000671540586141738*x_18 - 0.00160025448118035*x_19 + 0.00104777906173539*x_2 - 9.23740740747052e-5*x_20 - 0.00330284217914597*x_21 + 0.000625229407765991*x_22 + 0.000503411597276723*x_23 - 0.000328218561768307*x_24 - 0.0018051793592896*x_25 + 0.000527672919703867*x_26 - 0.00282477390337895*x_27 + 0.000708942512494268*x_28 - 0.00143422175803752*x_29 - 0.00149155235557364*x_3 - 0.000367196899495088*x_30 + 4.00994956798357e-5*x_31 + 0.000183251969386868*x_32 - 0.00159591688357877*x_33 + 0.00393680744861637*x_34 + 0.00178674979612057*x_35 + 0.00192693436809908*x_36 - 0.00177416131222843*x_37 + 0.000196040672465012*x_38 - 4.6233897238472e-6*x_39 - 0.00216793026816482*x_4 + 0.00147455717784924*x_40 - 0.000737823593600405*x_41 + 0.00361278025962609*x_42 + 0.00412804911945903*x_43 - 0.00177631720979573*x_44 - 0.00286057643063292*x_45 + 0.00134826666381865*x_46 + 0.00541738352252015*x_47 - 9.8524122160471e-5*x_48 - 0.00323260100918048*x_49 - 0.000814601842855577*x_5 + 0.00191423435208793*x_50 + 0.00370061335903813*x_51 + 7.69021599702437e-5*x_52 - 0.00133544318584809*x_53 + 0.000449220557230699*x_54 - 0.000554940892278501*x_55 + 0.00186239713780369*x_56 + 0.000506178871387009*x_57 + 0.00229541378079047*x_58 + 0.00213572377234533*x_59 + 0.00120099083560428*x_6 - 0.00310838941887768*x_60 - 0.000977399893569451*x_61 - 0.000208904529021126*x_62 + 0.000229522013828341*x_63 + 0.00168496408289489*x_64 - 0.00294107157520347*x_65 + 0.00105751660006767*x_66 - 0.000182684393994317*x_67 - 0.00087168057519639*x_68 + 0.00163467845012755*x_69 - 0.00189637178803137*x_7 - 0.000584292239472259*x_70 + 9.45953918638758e-5*x_71 - 0.000621681338830517*x_72 - 0.000379380037331481*x_73 - 0.000928565764435486*x_74 + 1.81985157457605e-5*x_75 + 0.000978707675810373*x_76 + 0.00125425773655244*x_77 - 0.000530743000943961*x_78 - 0.000203663834487232*x_79 + 0.00060076789161214*x_8 + 0.000274826162382516*x_80 + 0.000864949023719606*x_81 - 0.000102410764394744*x_82 + 0.00162843501344875*x_83 + 0.00021790690921906*x_84 + 0.00253354513348478*x_85 - 0.00201890886516286*x_86 - 0.000272219456552442*x_87 + 0.0013877288260936*x_88 + 8.57755784960767e-5*x_89 + 0.000447364561123373*x_9 - 0.000463846438440965*x_90 - 0.000432410365907813*x_91 - 0.000575888839814739*x_92 + 0.000970093544779369*x_93 + 0.000194049057205817*x_94 - 0.0015727371958489*x_95 - 0.00178166384764273*x_96 + 0.00211599350860293*x_97 - 0.000574675477385558*x_98 + 0.00334111673433093*x_99 + 0.00275699972144682*std::exp(0.0138073734182719*x_10 + 0.0126361941737204*x_100 - 0.0258988520492138*x_101 + 0.0272184911920259*x_102 + 0.00658532728914406*x_103 - 0.0779187046618396*x_104 + 0.0597025994584924*x_105 + 0.0501009166611008*x_106 + 0.000504625531311895*x_107 - 0.0362994661676764*x_11 + 0.0616849851142437*x_110 - 0.00687235385392861*x_111 + 0.0270768362649428*x_112 - 0.034196597513173*x_113 + 0.0700626392168189*x_114 + 0.0840656297039941*x_115 - 0.138155305693381*x_116 + 0.0655176970086359*x_117 - 0.0131249019506516*x_118 - 0.0407755421776296*x_120 - 0.00302398453903786*x_14 + 0.0293551165009213*x_15 + 0.0322691946954672*x_17 - 0.0798677851172222*x_18 - 0.0429063537610145*x_19 + 0.0122137764464362*x_2 - 0.0207717900196795*x_22 + 0.0179670413512332*x_23 - 0.0363619360305897*x_25 - 0.0418184915575745*x_26 - 0.00402425414245512*x_27 - 0.0694998926124682*x_28 - 0.0548301317482251*x_29 - 0.0109087403258848*x_31 + 0.0166516580558146*x_32 - 0.00129134384613318*x_33 - 0.0862226789660401*x_34 - 0.104515603461713*x_35 + 0.085320867157928*x_36 - 0.09853161965911*x_37 + 0.0932802122876642*x_38 - 0.132592667715191*x_39 - 0.0105682000276318*x_4 + 0.0929032949949497*x_40 + 0.0606747608259495*x_41 - 0.0254731998227778*x_42 + 0.110306598036191*x_43 + 0.0729690969811062*x_44 + 0.0798059435968311*x_46 + 0.0745728954554584*x_48 - 0.0710632825756535*x_49 - 0.091374380402639*x_5 + 0.101713377833676*x_50 - 0.0606429282151071*x_51 - 0.11957487549922*x_52 - 0.0795230542685809*x_53 + 0.00930701851165425*x_54 - 0.00395482757486722*x_55 - 0.0381525986208275*x_56 - 0.00667116750189037*x_57 - 0.113561110481645*x_58 + 0.0666013132533925*x_59 - 0.0226339109532427*x_6 + 0.0979484748879383*x_60 - 0.0284118645690168*x_61 + 0.0142974379452237*x_62 - 0.00825806233433754*x_63 + 0.00170925062036517*x_64 - 0.0241692036648863*x_65 - 0.0309732771120172*x_66 + 0.00505179307864354*x_67 + 0.0155500083655264*x_68 + 0.0174416640492863*x_69 + 0.0432217618998483*x_7 - 0.0287215977046741*x_70 + 0.04298501713474*x_71 + 0.0344943316036788*x_72 - 0.0254654442792146*x_73 + 0.0383284266187474*x_74 + 0.0336879224483114*x_75 + 0.00842931632546247*x_76 + 0.00382377921155105*x_77 - 0.0346032098440979*x_78 + 0.00103810355449729*x_79 - 0.028001667976192*x_8 + 0.0121662524805989*x_80 - 0.0281887124419875*x_81 - 0.058861889778664*x_82 + 0.0229615342650114*x_83 + 0.0345492292995845*x_84 + 0.0371807714533232*x_85 + 0.0252588814437244*x_86 - 0.0514676467812167*x_87 + 0.0111004871257084*x_88 + 0.0481626527087738*x_89 - 0.0466774731280986*x_90 + 0.016036651795676*x_91 + 0.00577149310308382*x_94 + 0.00508121404093971*x_95 - 0.0401685370397737*x_98 - 0.0819053546524998*x_99 - 0.794845903446578*std::sin(0.205040007829666*x_1 + 5.0) - 0.585578226675715*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.780749412262843*std::sin(0.240079984068871*x_109 + 1.97479975223541) - 0.383947727694075*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.431061843284681*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.28508479509825*std::sin(0.304799944162369*x_13 + 5.14416027069092) - 0.634009404412964*std::sin(0.325119823217392*x_16 - 1.13359987735748) + 0.286383376666379*std::sin(0.281359940767288*x_20 + 8.36528015136719) + 0.56663124970779*std::sin(0.262799948453903*x_21 + 1.99535977840424) - 0.565552303638967*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.536618015129925*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.241301131653771*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.626789044809399*std::sin(0.23463998734951*x_45 + 8.18991947174072) - 0.766529733369637*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.439169561308248*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.336206822574241*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.571988292266624*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.509245347615838*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.36587837232759*std::sin(0.259119987487793*x_97 - 1.18703985214233)) + 0.0093260599887568*std::sin(0.307839930057526*x_1 + 8.32415962219238) + 0.0076614640553988*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.01057444615875*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.000538933011731061*std::sin(0.259839981794357*x_107 + 1.96935975551605) - 0.0148586184641893*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.00675991115892043*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0180760400849075*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.00025839428964016*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.000715448644218885*std::sin(0.219039991497993*x_111 + 1.98207986354828) - 0.00527652401646919*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.000377850004442084*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.000420844707849582*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.000335298220654152*std::sin(0.287439942359924*x_120 - 1.23167991638184) - 0.00913171455248267*std::sin(0.280479967594147*x_13 + 5.16919994354248) + 0.000990575107401083*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.000315997251474584*std::sin(0.318079918622971*x_15 + 1.9463198184967) - 0.00639364950151869*std::sin(0.383039832115173*x_15 + 1.8076798915863) + 0.00753072523363846*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.000330245966263327*std::sin(0.290319949388504*x_17 - 4.35184001922607) + 0.00611149433610378*std::sin(0.363919854164124*x_17 - 1.17343986034393) - 0.00677339084071311*std::sin(0.417999863624573*x_17 - 4.41599988937378) + 0.00495656319975734*std::sin(0.3435198366642*x_18 - 7.59256029129028) - 0.0110205233327219*std::sin(0.215680003166199*x_19 - 7.37871980667114) + 0.00656685011569415*std::sin(0.402639865875244*x_2 - 7.39831972122192) - 0.00768660329703626*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.00893600124516381*std::sin(0.32247993350029*x_20 - 1.21759986877441) - 0.010644111320963*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.000314803255260281*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.000456775313995878*std::sin(0.297039926052094*x_24 - 4.36775970458984) + 0.0169917804531932*std::sin(0.334879845380783*x_24 + 2.03159976005554) - 0.00886121546508929*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.000447294943303589*std::sin(0.370959848165512*x_25 - 4.38535976409912) + 0.00696935950499624*std::sin(0.361759841442108*x_26 - 7.5729603767395) + 0.0140405221479243*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.0111907048228501*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.000245425147586198*std::sin(0.377439826726913*x_29 - 1.18831992149353) + 0.00878734601546106*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.000279233578276786*std::sin(0.331919848918915*x_3 + 1.97167980670929) + 0.00148863518882227*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.00341578670506928*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.000110460827860458*std::sin(0.477279841899872*x_31 - 1.14671981334686) - 0.00606970577466319*std::sin(0.489679843187332*x_31 + 2.03039979934692) + 0.00677110415035737*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.000316329695881283*std::sin(0.3018399477005*x_32 - 1.16751992702484) - 0.00548520483604274*std::sin(0.316399842500687*x_32 + 2.01391983032227) + 0.00250702330760984*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.000550860585653983*std::sin(0.244719967246056*x_34 - 1.19687986373901) - 0.00732169535751008*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.00048574806001854*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 0.00872867468222182*std::sin(0.251839965581894*x_35 - 1.2047199010849) - 0.00910724935753382*std::sin(0.231999978423119*x_36 - 7.42991971969604) + 0.00615248130741315*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.0122584065936653*std::sin(0.244319975376129*x_37 + 1.98031985759735) + 0.0224606185635286*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.000371183878751835*std::sin(0.259759962558746*x_4 - 4.17920017242432) + 0.0116640895964608*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.00395879466797275*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.000464529932275897*std::sin(0.251679986715317*x_41 + 5.15888023376465) - 0.00533181164666809*std::sin(0.256479978561401*x_41 + 1.97903978824615) + 0.0145314838132557*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.00038918689662008*std::sin(0.212159991264343*x_44 + 1.99047982692719) + 0.00778346559083399*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.000454934766793994*std::sin(0.208719998598099*x_45 + 1.98703980445862) + 0.000610992435545373*std::sin(0.1891999989748*x_47 - 1.16887986660004) + 0.0098045800194971*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.0137408144038079*std::sin(0.226239994168282*x_48 - 1.20207989215851) + 0.00700118841977744*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.000542290423133799*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.000263986368872311*std::sin(0.262319952249527*x_5 - 1.16559982299805) + 0.00953802967411688*std::sin(0.34895983338356*x_5 - 1.15559983253479) + 0.0126027776924285*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.00374834613144364*std::sin(0.213519990444183*x_52 + 5.18127965927124) - 0.0225962691829901*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.010054624238639*std::sin(0.169600024819374*x_54 + 2.01831984519958) + 0.0158754944318258*std::sin(0.177920013666153*x_54 - 4.17063999176025) + 0.023688462254021*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.000462507270088289*std::sin(0.391919851303101*x_6 - 7.40383958816528) - 0.0104737318450134*std::sin(0.44599986076355*x_6 + 5.16472005844116) + 0.0323671454092625*std::sin(0.118000060319901*x_61 + 8.06375980377197) + 0.00793852666992021*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.000318421308293963*std::sin(0.306159943342209*x_8 - 4.22975969314575) + 0.00982220134391482*std::sin(0.312239944934845*x_8 - 1.22175979614258) - 0.00884949170732459*std::sin(0.386799842119217*x_8 - 4.39431953430176) + 0.00950345320223577*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.000351845500407601*std::sin(0.345599830150604*x_91 + 5.19392013549805) - 0.0078447278759201*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.00476655699465041*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.00828050112107412*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.000461377660017965*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.000260007590429448*std::sin(0.275039941072464*x_94 + 5.18503999710083) + 0.0100896433484962*std::sin(0.275359958410263*x_94 - 7.40887975692749) - 0.017848558185973*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.00026912819335457*std::sin(0.255679965019226*x_95 - 7.42280006408691) + 0.00795246048993953*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.00396248132202154*std::sin(0.314479917287827*x_95 - 4.43727970123291) + 0.0184337137281797*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.00847289866495136*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.000292170303129776*std::sin(0.282879948616028*x_97 - 1.22967994213104) - 0.0120684158545819*std::sin(0.251599967479706*x_98 + 1.98239982128143) - 0.0594586371251453);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000367909907900981*x_1 + 0.000150722339894853*x_10 - 0.00341166029492866*x_100 - 0.000176100806427225*x_101 - 0.00123053296187278*x_102 + 0.000557501692622061*x_103 + 0.000979919638270987*x_104 + 0.0057616122676081*x_105 + 0.00425083914632968*x_106 - 0.00199180470513128*x_107 + 0.000992208429663252*x_108 + 0.00089506823387757*x_109 - 0.000598408589127957*x_11 + 0.00120999806385012*x_110 + 0.00191951852106445*x_111 + 0.00121834059316429*x_112 - 0.0034522867471154*x_113 + 0.00410733478046441*x_114 - 6.48407597438004e-5*x_115 - 0.00140244966227816*x_116 - 0.000419837302329762*x_117 - 8.95323579768732e-5*x_118 - 0.00225214393351562*x_119 + 0.00166435587587652*x_12 + 0.00286185490569675*x_120 - 0.000208045365221885*x_13 - 0.00251113885063808*x_14 + 9.14295609367873e-5*x_15 - 0.000141988634126999*x_16 + 0.000411062053039226*x_17 + 0.000350795616430158*x_18 + 0.00049327703551051*x_19 - 0.00122339350802653*x_2 - 0.000257943440518862*x_20 + 0.00204898178485637*x_21 - 0.0012840642544267*x_22 - 0.000148984351850619*x_23 + 0.00113719518785384*x_24 + 0.000323122838652109*x_25 - 0.0012930604381656*x_26 + 0.00622740197615607*x_27 - 0.00100728872218333*x_28 - 0.00198164214259089*x_29 - 0.000916337490356509*x_3 - 0.000914414912710655*x_30 - 0.000168785550132476*x_31 + 0.000319587268144334*x_32 + 0.00190333804449179*x_33 - 0.00337952756711393*x_34 - 0.000201599827616593*x_35 - 0.00187027089477134*x_36 + 0.00264237490102368*x_37 + 0.00186917328481021*x_38 - 0.0028530419786397*x_39 - 0.00146325054991854*x_4 + 0.00126002227916765*x_40 - 0.000864730725574908*x_41 - 0.00459622429324927*x_42 + 0.00263636572701026*x_43 + 0.00219988680141676*x_44 + 0.00233613584415145*x_45 - 0.000721008490483917*x_46 - 0.00219116831978363*x_47 + 0.00288812872356552*x_48 + 0.00150906589640605*x_49 + 0.000784621341708788*x_5 + 0.000607701202253731*x_50 - 0.00475217713686232*x_51 - 0.000153531786593202*x_52 + 0.000959909287451727*x_53 - 5.21092517528725e-6*x_54 + 0.00243433003341675*x_55 - 0.00205577679156596*x_56 + 0.000703500965996805*x_57 + 0.000924416739375533*x_58 + 0.00199021797732079*x_59 + 3.96629470037531e-5*x_6 + 0.00630051588738665*x_60 + 0.00056138584145345*x_61 + 0.000402841441099748*x_62 - 0.000990798917366427*x_63 - 0.00166663384258337*x_64 + 0.00250775141862423*x_65 - 0.00204172620619745*x_66 + 2.03326288404078e-5*x_67 - 0.000396351028008869*x_68 + 0.000487878735926894*x_69 - 0.00187376275980201*x_7 - 0.000668308084322959*x_70 + 0.00150965003577884*x_71 + 0.00136977054076573*x_72 - 7.04096289089861e-5*x_73 + 0.00330520317603617*x_74 - 0.00123538579352337*x_75 + 0.000453386609266367*x_76 - 0.00121589489438536*x_77 - 0.000251615619698754*x_78 + 0.00181064881063457*x_79 - 0.00108775625839838*x_8 - 0.00161290333876982*x_80 - 0.00179197588027489*x_81 + 1.89918739647842e-5*x_82 - 0.00136600075733851*x_83 + 0.000181744713655486*x_84 - 0.000702722777800438*x_85 + 0.00261192041386429*x_86 + 0.000332358273389531*x_87 - 0.000985034333646096*x_88 + 0.00272249769799449*x_89 - 0.000276611194040009*x_9 - 0.0015548938459484*x_90 + 0.00108814041025623*x_91 + 0.00126935559340148*x_92 + 0.00131344324433256*x_93 - 0.000167160102207109*x_94 + 0.00136423578968494*x_95 + 0.0014219876060099*x_96 - 0.00162211728191935*x_97 - 0.00331804344707853*x_98 - 0.00198178931028369*x_99 - 0.00988117701521773*std::sin(0.205040007829666*x_1 + 5.0) - 0.00771511068440441*std::sin(0.307839930057526*x_1 + 8.32415962219238) + 0.00470683226019292*std::sin(0.47751984000206*x_1 + 2.21951985359192) + 0.0130190174531151*std::sin(0.265039950609207*x_10 + 1.99079978466034) - 0.0107271794278719*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.0122919953556762*std::sin(0.267919957637787*x_107 + 8.17055988311768) - 0.0083226487740608*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.00727965268355808*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.00970593559537023*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.0149536513982238*std::sin(0.242559969425201*x_109 - 7.4312801361084) - 0.00514320304708056*std::sin(0.321519911289215*x_11 - 7.46135997772217) - 0.0142406306737683*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 0.00436507666314128*std::sin(0.206640005111694*x_116 - 0.982479810714722) + 0.0075209065064567*std::sin(0.264559954404831*x_116 - 7.45655965805054) + 0.00837669356692817*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.00477307040960393*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.00535877251116543*std::sin(0.317439913749695*x_12 + 8.15423965454102) + 0.00667393552911203*std::sin(0.287439942359924*x_120 - 1.23167991638184) - 0.00561008292092825*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.00354404962332703*std::sin(0.304799944162369*x_13 + 5.14416027069092) - 0.00121957352832184*std::sin(0.367359846830368*x_13 - 4.36799955368042) + 0.0062897598430541*std::sin(0.318079918622971*x_15 + 1.9463198184967) - 0.00392794843342094*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.00788172792632166*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 0.00622989545224908*std::sin(0.358639866113663*x_16 + 5.01695966720581) - 0.00657337305068535*std::sin(0.290319949388504*x_17 - 4.35184001922607) - 0.00752433273874218*std::sin(0.363919854164124*x_17 - 1.17343986034393) - 0.00416124311090358*std::sin(0.417999863624573*x_17 - 4.41599988937378) + 0.00304507224723754*std::sin(0.3435198366642*x_18 - 7.59256029129028) - 0.0067704755085435*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 0.00543251657737064*std::sin(0.402639865875244*x_2 - 7.39831972122192) - 0.00472227659207*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.00356019302205092*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.00739242925367508*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0070441121435471*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.00880548667683391*std::sin(0.310959935188293*x_22 - 7.38231992721558) - 0.00626599397355227*std::sin(0.294319927692413*x_23 - 7.36359977722168) - 0.0090918734699842*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 0.00703069915739509*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.0140566827877503*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.00733056169421374*std::sin(0.302479922771454*x_25 - 7.40503978729248) - 0.00890317165501788*std::sin(0.370959848165512*x_25 - 4.38535976409912) + 0.00428163676208632*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.0116152139884002*std::sin(0.263279944658279*x_28 + 5.00895977020264) - 0.0137777410952903*std::sin(0.303279936313629*x_28 - 1.16655993461609) - 0.00488505906478573*std::sin(0.377439826726913*x_29 - 1.18831992149353) - 0.00667100072361378*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.00726945218164736*std::sin(0.313919931650162*x_3 + 2.07631993293762) + 0.00555799817650912*std::sin(0.331919848918915*x_3 + 1.97167980670929) - 0.0018327737655141*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.00299975024782086*std::sin(0.309359908103943*x_30 - 7.39224004745483) + 0.00420543885342098*std::sin(0.394639849662781*x_31 - 7.40343999862671) - 0.00219866494428387*std::sin(0.477279841899872*x_31 - 1.14671981334686) - 0.00372893310514616*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 0.00560148852126363*std::sin(0.2483199685812*x_32 - 7.37487983703613) - 0.00629637697491061*std::sin(0.3018399477005*x_32 - 1.16751992702484) + 0.00675325935961769*std::sin(0.316399842500687*x_32 + 2.01391983032227) + 0.00154019363609732*std::sin(0.333439826965332*x_33 - 4.55327987670898) + 0.0109645915418551*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 0.00605697262818167*std::sin(0.240719974040985*x_35 + 1.94935977458954) - 0.0096685608102252*std::sin(0.250799983739853*x_35 - 1.22103989124298) - 0.0107465456180301*std::sin(0.251839965581894*x_35 - 1.2047199010849) - 0.00559505269067403*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 0.00508972431312327*std::sin(0.261919975280762*x_36 + 1.94783973693848) + 0.0150922712163277*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.0185808539154498*std::sin(0.238239988684654*x_38 + 1.96679985523224) + 0.00738822076479399*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.00964927765615851*std::sin(0.303679943084717*x_4 + 2.03975987434387) + 0.0048739778993521*std::sin(0.426239848136902*x_4 - 4.41856002807617) + 0.00924622508674122*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 0.0044108141114289*std::sin(0.256479978561401*x_41 + 1.97903978824615) + 0.00892743949539329*std::sin(0.256719976663589*x_42 - 7.44375991821289) + 0.00774656140957198*std::sin(0.212159991264343*x_44 + 1.99047982692719) + 0.0047817840916741*std::sin(0.199760004878044*x_45 + 2.01159977912903) + 0.00905523834159105*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 0.00779196757019856*std::sin(0.23463998734951*x_45 + 8.18991947174072) - 0.0121614845305457*std::sin(0.1891999989748*x_47 - 1.16887986660004) - 0.00952916275973749*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.00811097292487003*std::sin(0.224879994988441*x_48 - 1.18455982208252) - 0.0169173779749366*std::sin(0.226239994168282*x_48 - 1.20207989215851) + 0.00430119090497804*std::sin(0.228159993886948*x_48 + 4.98759984970093) + 0.0107940069439943*std::sin(0.240479975938797*x_49 + 1.96463978290558) - 0.00525451045633628*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.00789046550586846*std::sin(0.34895983338356*x_5 - 1.15559983253479) + 0.00774253591504638*std::sin(0.203359991312027*x_51 - 1.19439995288849) - 0.00461487845065068*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.0186930727457828*std::sin(0.225999996066093*x_53 + 5.17560005187988) - 0.0123790245353927*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.0131332199083902*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.0195966044024418*std::sin(0.188320010900497*x_57 - 4.20039987564087) + 0.00920596505490767*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.00866453792496158*std::sin(0.44599986076355*x_6 + 5.16472005844116) + 0.0198848057082925*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 0.00656725476818375*std::sin(0.405279844999313*x_7 + 1.97679972648621) + 0.00633800942487376*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.00812555040651313*std::sin(0.312239944934845*x_8 - 1.22175979614258) - 0.00543669888067848*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.00545956411949221*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.00786186164657948*std::sin(0.369359821081161*x_9 + 5.02807950973511) - 0.00700330046889979*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 0.00648965843289888*std::sin(0.358959853649139*x_91 + 1.99783980846405) + 0.00586847649257473*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.00417957633445015*std::sin(0.284799933433533*x_92 + 2.00287985801697) - 0.00508713863635121*std::sin(0.319119840860367*x_92 + 8.22360038757324) - 0.00918348075789092*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.0071107085562258*std::sin(0.247999966144562*x_93 - 1.21095979213715) - 0.00517531495461103*std::sin(0.275039941072464*x_94 + 5.18503999710083) + 0.00619858795435812*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.0147654638859095*std::sin(0.286959946155548*x_94 - 7.42695951461792) - 0.0053568557805365*std::sin(0.255679965019226*x_95 - 7.42280006408691) + 0.00488560636861313*std::sin(0.281039953231812*x_95 + 1.96631979942322) + 0.0048785168239146*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.0152495418117603*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.00633071567979262*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.00454844007792215*std::sin(0.259119987487793*x_97 - 1.18703985214233) + 0.00520533836420416*std::sin(0.268079966306686*x_97 - 1.19311988353729) - 0.00581549691139137*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.00998376208342752*std::sin(0.251599967479706*x_98 + 1.98239982128143) - 0.0091719409118351);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000900453473780106*x_1 + 0.00108479844681657*x_10 - 0.0027388261727102*x_100 + 6.62863111217503e-6*x_101 + 0.000627869400765965*x_102 + 0.00193267810188084*x_103 - 1.8062482362971e-5*x_104 + 0.0067705759360097*x_105 + 0.00397118642416726*x_106 - 0.000126292284409406*x_107 + 0.00218193034047509*x_108 + 0.00133616652001942*x_109 - 0.00142369292716385*x_11 + 0.00159033619071279*x_110 + 0.00192121883991579*x_111 + 0.00127615982131929*x_112 - 0.00349065387250748*x_113 + 0.007247459020562*x_114 + 0.00267040752527362*x_115 - 0.0060263030997888*x_116 + 0.000321876132142474*x_117 - 0.0006696259649592*x_118 - 0.00158956824800302*x_119 + 0.00278556711415095*x_12 - 0.00078179674906282*x_120 - 0.00048363085983916*x_13 - 0.00110456785686133*x_14 + 0.00119785514223881*x_15 - 0.000258813975445338*x_16 + 0.00141699772122087*x_17 - 0.0023053265696838*x_18 - 0.00134677116587759*x_19 - 3.28906921158609e-5*x_2 - 0.00110739082711541*x_20 + 0.00376690276034116*x_21 - 0.00309556624005335*x_22 + 0.000615771513059496*x_23 + 0.000228256228491871*x_24 - 0.00108562515701052*x_25 - 0.0037029417443646*x_26 + 0.00528932906962178*x_27 - 0.00412298859722207*x_28 - 0.00253075065010912*x_29 + 0.000201593125246987*x_3 - 0.00182849557309107*x_30 - 0.000501227556859148*x_31 + 0.000702630499187756*x_32 + 0.000933926325308648*x_33 - 0.00565962203779431*x_34 - 0.00480707015547639*x_35 + 0.00193480195515644*x_36 - 0.00320119068037613*x_37 + 0.00164703892880275*x_38 - 0.00742841380486945*x_39 - 0.000168643057992422*x_4 + 0.00650006808265441*x_40 + 0.00259007295999429*x_41 - 0.00477164827178209*x_42 + 0.00616746196345287*x_43 + 0.0041795527476737*x_44 + 0.00177897759783401*x_45 + 0.00187379808751458*x_46 - 0.00206050431157787*x_47 + 0.00673265736424135*x_48 - 0.00168014695997146*x_49 - 0.00354889395257246*x_5 + 0.00180544191983632*x_50 - 0.00546901072420659*x_51 - 0.00325562409834654*x_52 - 0.00335048388400555*x_53 - 0.000333784687613907*x_54 + 0.00419630989093307*x_55 - 0.00494000590114567*x_56 + 0.00236837343148079*x_57 - 0.00197215628926284*x_58 + 0.00496899604572641*x_59 - 0.00120829254171539*x_6 + 0.00815437788195538*x_60 - 0.000930438348498251*x_61 + 0.000586722196437921*x_62 - 0.00147838235314079*x_63 - 0.00138553117015669*x_64 + 0.00235141878406457*x_65 - 0.00247379046217407*x_66 + 0.00218026569498989*x_67 + 5.81899105903079e-5*x_68 + 0.00121310327824331*x_69 + 0.00123703525332031*x_7 - 0.00275777863713679*x_70 + 0.00320807819044095*x_71 + 0.00155002047878792*x_72 + 0.000195521676477656*x_73 + 0.00371718079079094*x_74 - 5.92837011684227e-5*x_75 - 0.000856919081389343*x_76 - 0.000672826988511158*x_77 - 0.000422286870627886*x_78 + 0.000652603358059547*x_79 - 0.00145669076691487*x_8 - 0.000607863112714094*x_80 - 0.00262759434061277*x_81 - 0.00142440212144563*x_82 + 0.000114614340175142*x_83 + 0.000172426314094166*x_84 + 0.000661572906400347*x_85 + 0.00193497654711466*x_86 - 0.00195284958148312*x_87 - 0.000670768829748048*x_88 + 0.00371226972857362*x_89 + 0.00189100462854609*x_9 - 0.00351888551001382*x_90 + 0.000917542316111474*x_91 + 0.00179515664267101*x_92 + 0.000672747053927286*x_93 + 0.000176700611088455*x_94 + 0.00119066225831218*x_95 + 0.00174556790393727*x_96 - 0.00137553969297856*x_97 - 0.00388657307451542*x_98 - 0.00522747470044126*x_99 - 0.0347214364692591*std::sin(0.205040007829666*x_1 + 5.0) - 0.00574421433256262*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.00103549733076671*std::sin(0.47751984000206*x_1 + 2.21951985359192) + 0.00410974127356224*std::sin(0.265039950609207*x_10 + 1.99079978466034) - 0.0190088599789773*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.00915189150048064*std::sin(0.267919957637787*x_107 + 8.17055988311768) - 0.00262722845985092*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0255799483989776*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.0341056562017214*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.0111336028994966*std::sin(0.242559969425201*x_109 - 7.4312801361084) - 0.00911389869282713*std::sin(0.321519911289215*x_11 - 7.46135997772217) - 0.0252347932007783*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 0.00324997747366555*std::sin(0.206640005111694*x_116 - 0.982479810714722) + 0.0133272552824798*std::sin(0.264559954404831*x_116 - 7.45655965805054) + 0.0148437337299322*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.0167720769231368*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.018830173673955*std::sin(0.317439913749695*x_12 + 8.15423965454102) + 0.011826399179265*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 0.00123421136953009*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.0124534246933071*std::sin(0.304799944162369*x_13 + 5.14416027069092) - 0.00038498540181993*std::sin(0.367359846830368*x_13 - 4.36799955368042) + 0.0111456291900329*std::sin(0.318079918622971*x_15 + 1.9463198184967) + 0.000864143843109879*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.0276955786785622*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 0.00463841106252883*std::sin(0.358639866113663*x_16 + 5.01695966720581) - 0.0116481996735697*std::sin(0.290319949388504*x_17 - 4.35184001922607) - 0.00237522231795037*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.000915468386340034*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.000669912163786569*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.00148949631717508*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 0.00404472999314143*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.00103889506485837*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.0125101509307104*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.00550396485655782*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0247522832449852*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.00655604369701447*std::sin(0.310959935188293*x_22 - 7.38231992721558) - 0.0111035154089895*std::sin(0.294319927692413*x_23 - 7.36359977722168) - 0.0161110523879616*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 0.0247051513956293*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.010465773213196*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.00545790193713698*std::sin(0.302479922771454*x_25 - 7.40503978729248) - 0.0157766675291464*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 0.000941954842102508*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.00864800019043419*std::sin(0.263279944658279*x_28 + 5.00895977020264) - 0.00434924919946403*std::sin(0.303279936313629*x_28 - 1.16655993461609) - 0.00865646038419696*std::sin(0.377439826726913*x_29 - 1.18831992149353) - 0.0234412082138206*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.00541240341452352*std::sin(0.313919931650162*x_3 + 2.07631993293762) + 0.00984892718641068*std::sin(0.331919848918915*x_3 + 1.97167980670929) - 0.000578555641112006*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.0105408128498203*std::sin(0.309359908103943*x_30 - 7.39224004745483) + 0.00132753993852363*std::sin(0.394639849662781*x_31 - 7.40343999862671) - 0.00389609536668944*std::sin(0.477279841899872*x_31 - 1.14671981334686) + 0.000820360714708837*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 0.00417053649179259*std::sin(0.2483199685812*x_32 - 7.37487983703613) - 0.0111573549315261*std::sin(0.3018399477005*x_32 - 1.16751992702484) + 0.00213181592399283*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 0.000338840713005838*std::sin(0.333439826965332*x_33 - 4.55327987670898) + 0.0194295608409666*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 0.00450966297257037*std::sin(0.240719974040985*x_35 + 1.94935977458954) - 0.0171329583769495*std::sin(0.250799983739853*x_35 - 1.22103989124298) - 0.00339238519601723*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.00123090473728813*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 0.00378950718196885*std::sin(0.261919975280762*x_36 + 1.94783973693848) + 0.0047642097533786*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.0138342029995929*std::sin(0.238239988684654*x_38 + 1.96679985523224) + 0.013092132461851*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.00718428046967946*std::sin(0.303679943084717*x_4 + 2.03975987434387) + 0.00153857909873258*std::sin(0.426239848136902*x_4 - 4.41856002807617) + 0.0163845677411997*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 0.00328403086793761*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.00196402575172334*std::sin(0.256719976663589*x_42 - 7.44375991821289) + 0.0137271220401611*std::sin(0.212159991264343*x_44 + 1.99047982692719) - 0.00105198664186693*std::sin(0.199760004878044*x_45 + 2.01159977912903) + 0.0160461339226166*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 0.0273801700488223*std::sin(0.23463998734951*x_45 + 8.18991947174072) - 0.0215504884701553*std::sin(0.1891999989748*x_47 - 1.16887986660004) - 0.0334844946971294*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.00603894990388755*std::sin(0.224879994988441*x_48 - 1.18455982208252) - 0.00534034513391134*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.000946256729582344*std::sin(0.228159993886948*x_48 + 4.98759984970093) + 0.0191272801942124*std::sin(0.240479975938797*x_49 + 1.96463978290558) - 0.00931113851447746*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.00587477314369853*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.00170334841570652*std::sin(0.203359991312027*x_51 - 1.19439995288849) - 0.00145678861783644*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.0139177544922352*std::sin(0.225999996066093*x_53 + 5.17560005187988) - 0.00390771333111396*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.0097782174639398*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.0145904706338968*std::sin(0.188320010900497*x_57 - 4.20039987564087) + 0.0163132258462478*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.00645110160690311*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.00437463289437631*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 0.00488958882226373*std::sin(0.405279844999313*x_7 + 1.97679972648621) + 0.0112311287895335*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.00604980343307362*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.00119606709309292*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.019184344985709*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.00585347640471246*std::sin(0.369359821081161*x_9 + 5.02807950973511) - 0.0124100430033016*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 0.0048318151882187*std::sin(0.358959853649139*x_91 + 1.99783980846405) + 0.00185251461113092*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.0146865999811088*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.00111916426759724*std::sin(0.319119840860367*x_92 + 8.22360038757324) - 0.0162733830472538*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.0249862961675695*std::sin(0.247999966144562*x_93 - 1.21095979213715) - 0.00917080188513492*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 0.0013636817558902*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.0109934896270286*std::sin(0.286959946155548*x_94 - 7.42695951461792) - 0.00949249727241623*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 0.00107482741559785*std::sin(0.281039953231812*x_95 + 1.96631979942322) + 0.00154001191082299*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.011353905371338*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.0222454816812143*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.0159827491154732*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.001145168062915*std::sin(0.268079966306686*x_97 - 1.19311988353729) - 0.0103052220986989*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.00743331775763717*std::sin(0.251599967479706*x_98 + 1.98239982128143) - 0.105280801493175);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000132896065648169*x_1 + 0.00134698364181667*x_10 + 0.00267085537486098*x_100 - 0.0013185038649682*x_101 + 0.00332183075148848*x_102 + 0.000768464161189314*x_103 - 0.00552187986419184*x_104 + 0.000715977467439476*x_105 - 0.000206267907484633*x_106 + 0.00210123249440867*x_107 + 0.000333396951795014*x_108 - 9.53343663106117e-5*x_109 - 0.00177368076866529*x_11 + 0.00276445562320992*x_110 - 0.00141270011221608*x_111 + 0.000226947256783578*x_112 + 6.53094544832015e-5*x_113 + 0.00313821804701165*x_114 + 0.00646467126107888*x_115 - 0.00909913343498931*x_116 + 0.00360633525350194*x_117 - 0.000792987888845178*x_118 + 0.00126131538160358*x_119 - 0.000392752034854593*x_12 - 0.00571238919294331*x_120 - 8.8810982660424e-5*x_13 + 0.00145116587693162*x_14 + 0.00207369333641105*x_15 - 6.5196041985392e-5*x_16 + 0.0020376026027808*x_17 - 0.00569415439890251*x_18 - 0.00375382369365798*x_19 + 0.0017745131896065*x_2 - 0.000372234569867992*x_20 + 7.55355448819797e-6*x_21 - 0.00159466382903274*x_22 + 0.00138428119641236*x_23 - 0.00102471880184038*x_24 - 0.00263410513847431*x_25 - 0.00262499513914541*x_26 - 0.00411917384846644*x_27 - 0.00496941243535877*x_28 - 0.00179609118801762*x_29 + 0.00123574807087566*x_3 - 0.000285141740209324*x_30 - 0.000665148447749046*x_31 + 0.000903683694904984*x_32 - 0.00146477810261635*x_33 - 0.00392591776163809*x_34 - 0.00810530513291451*x_35 + 0.00722728617964507*x_36 - 0.0104496757084821*x_37 + 0.00371717867005813*x_38 - 0.00778298870620115*x_39 + 0.00112623362502364*x_4 + 0.00727446131671435*x_40 + 0.00558630411447182*x_41 + 0.00101285972092502*x_42 + 0.00660938298125553*x_43 + 0.00365459388500776*x_44 - 0.00185559661854129*x_45 + 0.00591403149406681*x_46 + 0.00103644142983642*x_47 + 0.00472699210267084*x_48 - 0.00618812553384877*x_49 - 0.00746180971082626*x_5 + 0.00590663391559175*x_50 - 0.00106431809320674*x_51 - 0.00785559603767532*x_52 - 0.00687383199155569*x_53 + 0.000233796109289008*x_54 - 0.000234706778265364*x_55 - 0.00230167714722628*x_56 + 0.000266436635838137*x_57 - 0.00789422328868556*x_58 + 0.00447748768471525*x_59 - 0.00202606757640654*x_6 + 0.0028579747479817*x_60 - 0.00259828554028242*x_61 + 0.000662254668171092*x_62 - 0.000152327008930284*x_63 + 0.00113956656303165*x_64 - 0.00269244733559479*x_65 - 0.000796978539888335*x_66 + 0.00147011406496327*x_67 + 0.00153709035013863*x_68 + 0.00122783634180821*x_69 + 0.00508382317077328*x_7 - 0.0023427163234569*x_70 + 0.00245315109306042*x_71 + 0.00121315817078417*x_72 - 0.00114777700473379*x_73 + 0.000526987039339176*x_74 + 0.00281883636709156*x_75 - 0.000650986060996685*x_76 + 0.00110586272945665*x_77 - 0.00163490263945206*x_78 - 0.00157691653756003*x_79 - 0.00119889582231929*x_8 + 0.00210838931581807*x_80 - 0.000907704344512141*x_81 - 0.00408416622251806*x_82 + 0.00285705605665627*x_83 + 0.00136362136306619*x_84 + 0.00306399786888035*x_85 - 0.000491983460617485*x_86 - 0.00442568043150922*x_87 + 0.00125734788744327*x_88 + 0.00150100333040681*x_89 + 0.001357998394396*x_9 - 0.00277466788012404*x_90 + 0.000256721779995462*x_91 - 0.000350842314268548*x_92 - 0.00172037814400302*x_93 + 0.000551909389647434*x_94 - 0.000710589080372985*x_95 - 0.000278129163588229*x_96 + 0.00129331983696419*x_97 - 0.000784579909827571*x_98 - 0.00496102144430775*x_99 - 0.00118882278911769*std::pow(-0.148317800029798*x_1 + 0.229853293090483*x_10 - 0.289480625463952*x_100 + 0.103195530463644*x_101 + 0.0994335267551267*x_102 + 0.205396743096556*x_103 + 0.253748200300232*x_104 + 0.481499822625466*x_105 - 0.0227275738207197*x_106 + 0.395104673307376*x_108 + 0.185542767528994*x_109 - 0.463789506728001*x_110 - 0.0951556261195626*x_112 - 0.117914475577494*x_113 + 0.457626266559365*x_114 - 0.0879202590796083*x_115 - 0.487249683900278*x_117 - 0.290818342100367*x_119 + 0.238753148556701*x_12 - 0.0881123677667572*x_13 - 0.263297597353918*x_14 - 0.0185316385436267*x_16 + 0.146544820563655*x_18 - 0.0755229100503493*x_19 - 0.0250197505251471*x_2 - 0.185267063713315*x_20 + 0.392041757277866*x_21 - 0.323979696187915*x_22 - 0.210213445572776*x_26 + 0.527101654587109*x_27 - 0.154640924698993*x_28 - 0.341095366984296*x_30 + 0.0416056280773425*x_33 - 0.163967671522336*x_36 - 0.153066900943209*x_37 - 0.421027217931042*x_38 - 0.189369421685606*x_39 + 0.506152954453284*x_40 - 0.260866534780428*x_42 + 0.461903127189601*x_43 - 0.15558409328937*x_46 + 0.540087055467015*x_48 - 0.262532364478104*x_50 - 0.128959279865636*x_51 + 0.300195020100938*x_52 - 0.0742058218900765*x_53 - 0.106032733021213*x_54 + 0.660662948058772*x_55 - 0.340192456836458*x_56 + 0.45168357406999*x_57 + 0.581844382166475*x_58 + 0.492696678239295*x_59 + 0.306075911599522*x_60 - 0.0279786665492177*x_61 - 0.0208035307989252*x_62 - 0.13751641426178*x_63 - 0.0900864889535971*x_64 + 0.303992338194371*x_65 - 0.0749028954164821*x_66 + 0.313732916793216*x_67 - 0.0850666957695965*x_68 + 0.189472835666595*x_69 - 0.124873165335464*x_7 - 0.273948633481462*x_70 + 0.202297171904041*x_71 - 0.0520268828147987*x_72 + 0.185946623636442*x_73 + 0.202015283248124*x_74 - 0.248325579687128*x_75 - 0.178663190693642*x_76 - 0.0356992538483271*x_77 + 0.169990401640933*x_78 + 0.0281661954836381*x_79 - 0.107037536352125*x_80 - 0.118643680395644*x_81 + 0.125990138483543*x_82 + 0.0162910262464522*x_83 - 0.264654736340948*x_84 + 0.0174721048461194*x_85 - 0.0593354015230103*x_86 - 0.0475181973748679*x_87 - 0.0805172771334055*x_88 + 0.177352853127835*x_89 + 0.343858019852213*x_9 - 0.248390211597598*x_90 + 0.227849778150416*x_92 + 0.19660842878329*x_96 - 0.31734180186501*x_98 - 0.0316713455249802*x_99 - 2.95430943221923*std::sin(0.259839981794357*x_107 + 1.96935975551605) - 1.41645931961661*std::sin(0.321519911289215*x_11 - 7.46135997772217) - 3.92192838789967*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 2.07128865329997*std::sin(0.264559954404831*x_116 - 7.45655965805054) + 2.30697593733598*std::sin(0.222159996628761*x_118 - 4.2247200012207) + 1.83802935489727*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 1.73222578737222*std::sin(0.318079918622971*x_15 + 1.9463198184967) - 1.81033403381675*std::sin(0.290319949388504*x_17 - 4.35184001922607) - 1.72568056894772*std::sin(0.294319927692413*x_23 - 7.36359977722168) - 2.50393943063249*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 2.45197017295573*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 1.34536540281471*std::sin(0.377439826726913*x_29 - 1.18831992149353) + 1.53069560806028*std::sin(0.331919848918915*x_3 + 1.97167980670929) - 0.605521388624354*std::sin(0.477279841899872*x_31 - 1.14671981334686) - 1.73404817276153*std::sin(0.3018399477005*x_32 - 1.16751992702484) + 3.01969370703067*std::sin(0.244719967246056*x_34 - 1.19687986373901) - 2.66276150125887*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 2.03474645311111*std::sin(0.259759962558746*x_4 - 4.17920017242432) + 2.54644850212976*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 2.13343494377479*std::sin(0.212159991264343*x_44 + 1.99047982692719) + 2.49384996526182*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 3.34932296974797*std::sin(0.1891999989748*x_47 - 1.16887986660004) + 2.97271400562454*std::sin(0.240479975938797*x_49 + 1.96463978290558) - 1.44711383893841*std::sin(0.262319952249527*x_5 - 1.16559982299805) + 2.53536072340964*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 1.7455139210917*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 1.92873781696784*std::sin(0.345599830150604*x_91 + 5.19392013549805) - 2.52916845533022*std::sin(0.240719974040985*x_93 + 1.95935988426208) - 1.42530307131683*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 1.47530016309391*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 1.60161182106503*std::sin(0.282879948616028*x_97 - 1.22967994213104) - 17.7091185371409, 2) - 0.05038332339766*std::sin(0.205040007829666*x_1 + 5.0) + 0.00612358275876829*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.00634750727399115*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.0101395651127361*std::sin(0.265039950609207*x_10 + 1.99079978466034) - 0.00975631509513322*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.00648190537104095*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0371183609820462*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.0494897815538853*std::sin(0.240079984068871*x_109 + 1.97479975223541) - 0.011868905791319*std::sin(0.242559969425201*x_109 - 7.4312801361084) - 0.0034646175911833*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.0243375004492395*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.0273239481519995*std::sin(0.317439913749695*x_12 + 8.15423965454102) + 0.00756560679874878*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.0180708227404938*std::sin(0.304799944162369*x_13 + 5.14416027069092) + 0.000949837055270998*std::sin(0.367359846830368*x_13 - 4.36799955368042) + 0.00529712551345088*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.0401882940091709*std::sin(0.325119823217392*x_16 - 1.13359987735748) + 0.00494474829213243*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.00586015511609236*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.00561174043500404*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.00410650245657504*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.0091304810036076*std::sin(0.215680003166199*x_19 - 7.37871980667114) + 0.00431185840498124*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.00636833508418546*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.0181531366265207*std::sin(0.281359940767288*x_20 + 8.36528015136719) + 0.00586746634947515*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0359173587955298*std::sin(0.262799948453903*x_21 + 1.99535977840424) - 0.00698902823336314*std::sin(0.310959935188293*x_22 - 7.38231992721558) - 0.0358489670626437*std::sin(0.297839939594269*x_24 - 1.1561598777771) + 0.0111569702478206*std::sin(0.334879845380783*x_24 + 2.03159976005554) - 0.00581836127037234*std::sin(0.302479922771454*x_25 - 7.40503978729248) - 0.00577410007188506*std::sin(0.361759841442108*x_26 - 7.5729603767395) + 0.00921914500365493*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.0107304797343742*std::sin(0.303279936313629*x_28 - 1.16655993461609) - 0.0340148938052853*std::sin(0.28655993938446*x_3 - 7.32575988769531) + 0.00576985786285744*std::sin(0.313919931650162*x_3 + 2.07631993293762) + 0.00142741408860299*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.0152954841933715*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.00327531023254672*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00502873879940891*std::sin(0.489679843187332*x_31 + 2.03039979934692) + 0.00444597361403849*std::sin(0.2483199685812*x_32 - 7.37487983703613) - 0.00525962218321273*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 0.00207706367426017*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.004807497218574*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.00836970220090857*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.00754533743485508*std::sin(0.231999978423119*x_36 - 7.42991971969604) + 0.00403977976799843*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.0117542715683518*std::sin(0.244319975376129*x_37 + 1.98031985759735) + 0.0147478631654426*std::sin(0.238239988684654*x_38 + 1.96679985523224) + 0.00765875600582933*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.0037959866362029*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.00350091999321238*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.0120393045688869*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.00644858529615681*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.039730613204154*std::sin(0.23463998734951*x_45 + 8.18991947174072) - 0.0485884311447296*std::sin(0.208880007266998*x_47 - 1.20455992221832) + 0.00643778371967774*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.013175714383315*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.00580047026257395*std::sin(0.228159993886948*x_48 + 4.98759984970093) + 0.00626276413999653*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.0104413754990879*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.00359419293400969*std::sin(0.213519990444183*x_52 + 5.18127965927124) - 0.0148369326970082*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.00964112121062861*std::sin(0.169600024819374*x_54 + 2.01831984519958) + 0.0104240058617304*std::sin(0.177920013666153*x_54 - 4.17063999176025) + 0.0155540774148283*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.00687715539288917*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.0268161136615721*std::sin(0.118000060319901*x_61 + 8.06375980377197) + 0.00521251472803638*std::sin(0.405279844999313*x_7 + 1.97679972648621) + 0.0064493540546875*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.0073317857497203*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.0278378764208968*std::sin(0.309999912977219*x_9 + 1.95135986804962) + 0.00624006088832053*std::sin(0.369359821081161*x_9 + 5.02807950973511) - 0.00515092551689848*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.00457052920647133*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.0213113221025692*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.0068603782146928*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.0362569285241104*std::sin(0.247999966144562*x_93 - 1.21095979213715) - 0.0083592488437541*std::sin(0.275359958410263*x_94 - 7.40887975692749) - 0.0117195389380148*std::sin(0.286959946155548*x_94 - 7.42695951461792) - 0.00658859722384887*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.00379952167418169*std::sin(0.314479917287827*x_95 - 4.43727970123291) + 0.0121037578250662*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.0322798078551171*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.0231921285336653*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.00701977918563363*std::sin(0.268079966306686*x_97 - 1.19311988353729) - 0.00792424060555664*std::sin(0.251599967479706*x_98 + 1.98239982128143) - 0.0374307901201127);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000671665925813658*x_1 + 0.0020708995279562*x_10 + 0.000839461378392586*x_100 - 0.00433231597456461*x_101 + 0.00174333739217753*x_102 - 0.00247138476644875*x_103 - 0.00991223172260491*x_104 + 0.00406548803361999*x_105 + 0.00170585009730411*x_106 - 0.00376690444146481*x_107 - 0.000562935514665128*x_108 - 0.000306014455954471*x_109 - 0.00145437710854609*x_11 + 0.0023271311122347*x_110 - 0.00408435134473094*x_111 - 0.000511340864738968*x_112 - 0.0019354075349157*x_113 - 0.000312811563919242*x_114 + 0.00583065637085544*x_115 - 0.00552922256638626*x_116 + 0.0021766731048788*x_117 + 0.000568758321217202*x_118 - 0.00346811225053623*x_119 - 0.00426076392325157*x_12 + 0.00169479854298724*x_120 + 0.000136517231331321*x_13 - 0.00673366058378913*x_14 + 0.000885441386507505*x_15 + 0.000129614407897699*x_16 + 0.00142684709828234*x_17 - 0.00265760310509954*x_18 - 0.00324141387779788*x_19 - 0.00131446661835318*x_2 + 0.00121741197756464*x_20 - 0.00421831924219121*x_21 + 0.000456184799524931*x_22 + 0.000364019645639764*x_23 + 0.00192128719898779*x_24 - 0.000877450092308256*x_25 + 0.00173075493909777*x_26 - 0.000815293225452983*x_27 - 0.00166637498547101*x_28 - 0.00342239039699528*x_29 - 0.00217913592220142*x_3 - 0.0001776163330716*x_30 - 0.000452949192329128*x_31 + 0.00100905405871011*x_32 + 0.00152725117815882*x_33 - 0.0016787094021732*x_34 - 0.00204258090080871*x_35 + 0.000751265380518434*x_36 - 0.00411474106731529*x_37 + 0.00938882592000871*x_38 - 0.00387549518750402*x_39 - 0.00363780639163963*x_4 + 0.00177214985585754*x_40 - 0.000467124732216357*x_41 - 2.15975658631959e-5*x_42 + 0.00879360205610426*x_43 + 0.00201658629109671*x_44 - 0.00253293807087572*x_45 + 0.00352796316449641*x_46 + 0.00192886820119744*x_47 + 0.0018070162244093*x_48 - 0.00268168601627273*x_49 - 0.000916724574618642*x_5 + 0.0104413112939418*x_50 - 0.00255897062395968*x_51 - 0.00589944541071519*x_52 + 0.000160048825075207*x_53 + 0.00133941871810801*x_54 - 0.00210786980156831*x_55 + 0.00368227634034508*x_56 - 0.00288155923003684*x_57 - 0.00364768914492865*x_58 + 0.00493634249836776*x_59 - 4.18568185037941e-7*x_6 + 0.00479046636015495*x_60 - 0.000646349094317867*x_61 + 0.00110239541164828*x_62 + 0.000316714029659808*x_63 + 0.000733311149525296*x_64 - 0.00391160027206296*x_65 - 0.00177156587083753*x_66 - 0.00333726685835906*x_67 + 0.0016857011900658*x_68 + 0.00245898714268685*x_69 - 0.00192606408535145*x_7 + 0.000305228580792504*x_70 + 0.00165771223462179*x_71 + 0.00290315298288572*x_72 - 0.00319688281807625*x_73 + 0.00279707762257612*x_74 - 0.000290964556708715*x_75 + 0.00303738120671799*x_76 - 7.63739853967542e-5*x_77 - 0.00261298564554418*x_78 + 0.00191034645982033*x_79 - 0.00235709973617175*x_8 - 0.000122703617579456*x_80 - 0.000313312913043619*x_81 - 0.0043865636448149*x_82 + 0.00124010765587614*x_83 + 0.00152477658244296*x_84 + 0.00271181752296873*x_85 + 0.00216984518404262*x_86 - 0.00282871517279846*x_87 + 0.00124689676802238*x_88 + 0.00235465230487949*x_89 - 0.00351489905243757*x_9 - 0.00180915480700617*x_90 + 0.00215233416283031*x_91 - 0.00107405139227817*x_92 - 0.0021344660232914*x_93 - 0.000101740870184528*x_94 - 0.00105646102918363*x_95 + 9.1694314112741e-5*x_96 + 0.00257237885105122*x_97 - 0.00411483288171974*x_98 + 0.000214453310115987*x_99 - 0.0353862449239298*std::sin(0.205040007829666*x_1 + 5.0) + 0.00760604003641403*std::sin(0.307839930057526*x_1 + 8.32415962219238) + 0.0111932856244618*std::sin(0.47751984000206*x_1 + 2.21951985359192) + 0.0195460965105594*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.0082758827478271*std::sin(0.259839981794357*x_107 + 1.96935975551605) - 0.0121182200265356*std::sin(0.267919957637787*x_107 + 8.17055988311768) - 0.012495205321532*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0260697255422918*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.0347586743628528*std::sin(0.240079984068871*x_109 + 1.97479975223541) - 0.014742247503381*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.00396791585822759*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0109864657810237*std::sin(0.219039991497993*x_111 + 1.98207986354828) - 0.00430336637023014*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.00580228389236081*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.00646251274535898*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.0170932104842659*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.0191907134423038*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.00514885653557542*std::sin(0.287439942359924*x_120 - 1.23167991638184) - 0.013341299846596*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.0126918693795759*std::sin(0.304799944162369*x_13 + 5.14416027069092) - 0.00183100621626392*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.0048524698708646*std::sin(0.318079918622971*x_15 + 1.9463198184967) - 0.00934102732006765*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.0282258636187836*std::sin(0.325119823217392*x_16 - 1.13359987735748) + 0.00614182170169839*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.00507127386010271*std::sin(0.290319949388504*x_17 - 4.35184001922607) - 0.0112966538695151*std::sin(0.363919854164124*x_17 - 1.17343986034393) - 0.00989582379790579*std::sin(0.417999863624573*x_17 - 4.41599988937378) + 0.00724146549659591*std::sin(0.3435198366642*x_18 - 7.59256029129028) - 0.0161008215273524*std::sin(0.215680003166199*x_19 - 7.37871980667114) + 0.00535571559193435*std::sin(0.402639865875244*x_2 - 7.39831972122192) - 0.0112300136845291*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.0127496817495262*std::sin(0.281359940767288*x_20 + 8.36528015136719) + 0.00728792044208392*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0252262131524716*std::sin(0.262799948453903*x_21 + 1.99535977840424) - 0.00868100108265387*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.00483413480424995*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.00701426496140897*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 0.0251781788735183*std::sin(0.297839939594269*x_24 - 1.1561598777771) + 0.0138579595855863*std::sin(0.334879845380783*x_24 + 2.03159976005554) - 0.0072269275213771*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.0068686839067185*std::sin(0.370959848165512*x_25 - 4.38535976409912) + 0.0101821311168339*std::sin(0.361759841442108*x_26 - 7.5729603767395) + 0.0114510065041417*std::sin(0.263279944658279*x_28 + 5.00895977020264) - 0.0206852059393782*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.00376876105300653*std::sin(0.377439826726913*x_29 - 1.18831992149353) - 0.0238900350767887*std::sin(0.28655993938446*x_3 - 7.32575988769531) + 0.00716668193084718*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.0042879250347872*std::sin(0.331919848918915*x_3 + 1.97167980670929) - 0.00275163414073068*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.0107426369162833*std::sin(0.309359908103943*x_30 - 7.39224004745483) + 0.00631383389677803*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00169624209262069*std::sin(0.477279841899872*x_31 - 1.14671981334686) - 0.00886775032826461*std::sin(0.489679843187332*x_31 + 2.03039979934692) + 0.00552229873284492*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.00485757490408788*std::sin(0.3018399477005*x_32 - 1.16751992702484) + 0.0101390031681955*std::sin(0.316399842500687*x_32 + 2.01391983032227) + 0.00366272395802544*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.00845904317983528*std::sin(0.244719967246056*x_34 - 1.19687986373901) - 0.0059713435352963*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.00745917192340033*std::sin(0.250799983739853*x_35 - 1.22103989124298) - 0.0161343218535194*std::sin(0.251839965581894*x_35 - 1.2047199010849) - 0.0133055565587674*std::sin(0.231999978423119*x_36 - 7.42991971969604) + 0.0050177694764873*std::sin(0.261919975280762*x_36 + 1.94783973693848) + 0.0226587751971478*std::sin(0.244319975376129*x_37 + 1.98031985759735) + 0.0183181712580423*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.00569991852710404*std::sin(0.259759962558746*x_4 - 4.17920017242432) + 0.00951286315614054*std::sin(0.303679943084717*x_4 + 2.03975987434387) + 0.00731754471903523*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.00713334527425426*std::sin(0.251679986715317*x_41 + 5.15888023376465) - 0.00434845721559445*std::sin(0.256479978561401*x_41 + 1.97903978824615) + 0.0212302828405749*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.00597637378544138*std::sin(0.212159991264343*x_44 + 1.99047982692719) + 0.0113715280625747*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.00698600142493398*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 0.0279044158862575*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.00938243092613913*std::sin(0.1891999989748*x_47 - 1.16887986660004) - 0.0341256195306234*std::sin(0.208880007266998*x_47 - 1.20455992221832) + 0.00799630586318597*std::sin(0.224879994988441*x_48 - 1.18455982208252) - 0.0253988984802078*std::sin(0.226239994168282*x_48 - 1.20207989215851) + 0.0102286326903826*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.00832743932814498*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.00405378811142877*std::sin(0.262319952249527*x_5 - 1.16559982299805) + 0.0077789158183947*std::sin(0.34895983338356*x_5 - 1.15559983253479) + 0.0184124717355481*std::sin(0.203359991312027*x_51 - 1.19439995288849) - 0.0069285458680552*std::sin(0.213519990444183*x_52 + 5.18127965927124) - 0.0184288036198148*std::sin(0.225999996066093*x_53 + 5.17560005187988) - 0.0185852434061738*std::sin(0.169600024819374*x_54 + 2.01831984519958) + 0.0129475519556927*std::sin(0.177920013666153*x_54 - 4.17063999176025) + 0.0193195618002007*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.0071022851707929*std::sin(0.391919851303101*x_6 - 7.40383958816528) - 0.00854204496216804*std::sin(0.44599986076355*x_6 + 5.16472005844116) + 0.0472879205325077*std::sin(0.118000060319901*x_61 + 8.06375980377197) + 0.00647441167592175*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.00488969381071347*std::sin(0.306159943342209*x_8 - 4.22975969314575) + 0.00801067725894982*std::sin(0.312239944934845*x_8 - 1.22175979614258) - 0.0129289764456428*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.0195516660426909*std::sin(0.309999912977219*x_9 + 1.95135986804962) + 0.00775071633975498*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.0054029574053573*std::sin(0.345599830150604*x_91 + 5.19392013549805) - 0.00639791234143407*std::sin(0.358959853649139*x_91 + 1.99783980846405) + 0.00881063477385301*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.0149678030887755*std::sin(0.284799933433533*x_92 + 2.00287985801697) - 0.0120976896180236*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.00708493882108102*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.0254647067010108*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.00399268978722897*std::sin(0.275039941072464*x_94 + 5.18503999710083) + 0.0147408196438755*std::sin(0.275359958410263*x_94 - 7.40887975692749) - 0.0145567204498406*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.00413274622978267*std::sin(0.255679965019226*x_95 - 7.42280006408691) + 0.0116184271096873*std::sin(0.281039953231812*x_95 + 1.96631979942322) + 0.00732435923156448*std::sin(0.314479917287827*x_95 - 4.43727970123291) + 0.0150339548325187*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.0226714140677671*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.0162887694827542*std::sin(0.259119987487793*x_97 - 1.18703985214233) + 0.0123787795828776*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.00448658203982082*std::sin(0.282879948616028*x_97 - 1.22967994213104) - 0.00984261888479235*std::sin(0.251599967479706*x_98 + 1.98239982128143) - 0.232678838148751);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00156045416919343*x_1 - 0.00364116181994307*x_10 + 0.00259714728855722*x_100 - 0.000538757466195496*x_101 - 0.00107777273887944*x_102 - 0.000905738405381353*x_103 - 0.00203389018358272*x_104 - 0.00423140136291158*x_105 + 0.00252007881726432*x_106 + 0.00188823865511902*x_107 - 0.00468520969906261*x_108 - 0.00184633150712993*x_109 - 0.000442142482345727*x_11 + 0.00960255454439662*x_110 + 0.00333581587583786*x_111 + 0.00209261352538108*x_112 - 9.38199466384278e-5*x_113 - 0.00132840647564104*x_114 + 0.00368449243504156*x_115 - 0.00481422457984112*x_116 + 0.00819387232070053*x_117 - 0.000675953586857806*x_118 + 0.00514428366958805*x_119 - 0.000302346592124791*x_12 - 0.00253002139763811*x_120 + 0.00103673832485131*x_13 + 0.00616767529083883*x_14 + 0.00102085808026249*x_15 - 0.000117561079546114*x_16 + 0.0010532252629084*x_17 - 0.00440010645956872*x_18 + 0.000524144125776502*x_19 + 0.000972389896628452*x_2 + 0.00176730162184287*x_20 - 0.0016657315665541*x_21 + 0.00235146994756199*x_22 + 0.000527145827383891*x_23 - 0.000649427624122164*x_24 - 0.000616906183540174*x_25 - 0.000300478615112931*x_26 - 0.00545659695702541*x_27 - 0.00133029913171265*x_28 - 0.000483023058534367*x_29 + 0.00163818272820523*x_3 + 0.00421021626428342*x_30 - 0.000378840683785202*x_31 + 0.000338315393209008*x_32 - 0.000528497890792641*x_33 - 0.00511707138951962*x_34 - 0.00534913655020091*x_35 + 0.0050922436638561*x_36 - 0.00134902150256306*x_37 + 0.00580378332514235*x_38 - 0.00261838380856529*x_39 + 0.0020386002357872*x_4 - 0.00265347600768037*x_40 + 0.00365580355989533*x_41 + 0.000614778151620315*x_42 - 0.00518581090472812*x_43 + 0.00344991528670867*x_44 + 0.00187807653376849*x_45 + 0.00393375799978229*x_46 - 0.00303961888716547*x_47 - 0.00341407964683204*x_48 - 0.0012072644976676*x_49 - 0.00389243386376876*x_5 + 0.00344806140349797*x_50 - 0.00177859450881904*x_51 - 0.00731249906413962*x_52 - 0.00259237251872586*x_53 + 0.000974131916858635*x_54 - 0.00702382519473755*x_55 + 0.000144328621964056*x_56 - 0.00482211697097753*x_57 - 0.0122228552620177*x_58 - 0.00527850429017501*x_59 - 0.00173809348405314*x_6 + 0.000329593078085656*x_60 - 0.000463752943523095*x_61 + 0.000613787788096852*x_62 + 0.00108482168529598*x_63 + 0.000275727324479722*x_64 - 0.0022360715697559*x_65 - 0.000295543500872782*x_66 - 0.00208588372383758*x_67 + 0.0016919809804477*x_68 - 0.00298193909307539*x_69 + 0.00544379166683865*x_7 + 0.00197191571315471*x_70 - 0.00100221488433372*x_71 + 0.00141287761194003*x_72 - 0.00208179120020407*x_73 - 0.00138293885803627*x_74 + 0.00471838619790792*x_75 + 0.000838282488340748*x_76 + 0.000175724909250416*x_77 - 0.00242675803147802*x_78 - 0.00109465634320406*x_79 - 0.000730855710406088*x_8 + 0.00197335680811398*x_80 - 8.43112350754809e-5*x_81 - 0.00282628228653402*x_82 - 5.65146920917383e-5*x_83 + 0.00400194955602582*x_84 - 0.000435539007969565*x_85 + 0.00178035647249988*x_86 - 0.000999889741020299*x_87 + 0.000495796662591712*x_88 - 0.000908110343140028*x_89 - 0.00288552910094998*x_9 + 0.00158345794576012*x_90 + 0.000123761157784187*x_91 - 0.00212194743163731*x_92 - 5.67226363424561e-5*x_93 + 0.000244034408003547*x_94 + 0.00115900077572218*x_95 - 0.00154824469450005*x_96 - 0.00163212546773685*x_97 + 0.00378287620190949*x_98 - 0.0051015530649015*x_99 - 0.0257562834351486*std::sin(0.205040007829666*x_1 + 5.0) - 0.00589631488312402*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.00841464132413409*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.00310691558625206*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.0318934609382126*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.00939422363770788*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.00198615350875377*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0189751481567837*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.0252994990184522*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.0114284086001032*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.0152914889307395*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0423394612892611*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 0.00333603334387473*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.0223607463170037*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.0249051254213243*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.0124414889173981*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.0139681804555769*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.0198425787070209*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 0.0100294280672596*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.00923792241208335*std::sin(0.304799944162369*x_13 + 5.14416027069092) + 0.000291044390820516*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.0187003686490009*std::sin(0.318079918622971*x_15 + 1.9463198184967) + 0.00702219143997642*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.0205445179371269*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 0.00476123114470114*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.0195435918671795*std::sin(0.290319949388504*x_17 - 4.35184001922607) + 0.00179563985887055*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.00743926409634628*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.00544382917217633*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.0121039203967496*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 0.00415183004603144*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.008442251934849*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.00928000180733136*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.00564970386218777*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0183611880081447*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.00672964060654616*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.0186297092705766*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.0270314590447414*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 0.0183262257083589*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.0107428955097569*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.00560242124673912*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.0264704211684697*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 0.00765449789615119*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.00887698983358932*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.00328798073329724*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.0145239894150361*std::sin(0.377439826726913*x_29 - 1.18831992149353) - 0.0173886355004938*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.0055557179727117*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.0165247350367399*std::sin(0.331919848918915*x_3 + 1.97167980670929) + 0.000437381192448373*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.00781915125076106*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.00100360442466396*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00653694990264985*std::sin(0.477279841899872*x_31 - 1.14671981334686) + 0.00666640170436166*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 0.00428096776399323*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.0187200423421472*std::sin(0.3018399477005*x_32 - 1.16751992702484) - 0.00161162751628223*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 0.0027534818113407*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.0325993216012594*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 0.00462907394529226*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.0287460341838268*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 0.00256460291256753*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.0100025577668926*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 0.00388984921229081*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.00360168598304876*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.0142005176548258*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.0219662523545198*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.00737451240594815*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.00116314752300465*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.0274903687975697*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 0.00337098843500511*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.0159600336582983*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.0230316510861851*std::sin(0.212159991264343*x_44 + 1.99047982692719) - 0.00854863649193199*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.0269225374923212*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 0.0203105485253872*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.0361578581241818*std::sin(0.1891999989748*x_47 - 1.16887986660004) - 0.0248387228122189*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.00619885473194855*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.00403723748724768*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.00768945582321103*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.0320921488402262*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.0156224220090104*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.00603033074963855*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.0138417217913925*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.00110131489097548*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.0142862815001581*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.00295418486150088*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.0100371340317537*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.0149768104338909*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.0273706698812527*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.00662191976397904*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.035549069647219*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 0.0050190598184397*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.0188438216566995*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.00620999565078779*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.00971946067743566*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.0142309039376025*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.00600847009615742*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.0208218284634148*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 0.00495975640137519*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.00140047904137126*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.0108944868149967*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.00909453420574745*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.027303820803781*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.0185347782674909*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.0153869622912217*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 0.0110815281847082*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.0112845852805078*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.0159267095080251*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 0.0087342448105639*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.00116423071192569*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.0116545444418916*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.016501648249491*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.0118559673259907*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.00930584581821015*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.0172903161382611*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.00763014393054392*std::sin(0.251599967479706*x_98 + 1.98239982128143) + 0.112415824521127);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00173047404141567*x_1 - 0.0031528528327726*x_10 + 0.00462674700540133*x_100 - 0.000968849027764832*x_101 + 0.000987752233647273*x_102 - 0.00140023782897992*x_103 - 0.00435351528538552*x_104 - 0.00903766944808158*x_105 - 0.00315298717306835*x_106 + 0.00398063765294565*x_107 - 0.00468310747969522*x_108 - 0.00194456943365179*x_109 + 0.00151860990046268*x_11 + 0.00911103818509607*x_110 + 0.00217038519939372*x_111 - 0.00182485071973295*x_112 + 0.00309397834424012*x_113 - 0.00505851995837585*x_114 + 0.00659844703724251*x_115 - 0.00423038047378791*x_116 + 0.00662579996189166*x_117 + 0.000178533387199007*x_118 + 0.00607372816281215*x_119 - 0.00201189984550925*x_12 - 0.0056485573804951*x_120 + 0.00101377724063238*x_13 + 0.00658334805049293*x_14 + 0.000886448661291415*x_15 - 0.000443138756546747*x_16 + 0.000815266706588368*x_17 - 0.00424032776572839*x_18 - 0.000942852867075424*x_19 + 0.00127406466995839*x_2 + 0.00177595772858836*x_20 - 0.00227582143362724*x_21 + 0.00244197905370736*x_22 + 0.000391334656601234*x_23 - 0.00137979676477391*x_24 + 0.000254698628147711*x_25 + 0.00161354684298426*x_26 - 0.0114514810946612*x_27 - 0.00145530855357944*x_28 + 0.00309445595867969*x_29 + 0.00346638500694653*x_3 + 0.00383081122503537*x_30 - 0.00025798971069486*x_31 - 2.16411854875786e-6*x_32 - 0.00147724491854946*x_33 - 0.00250690447753453*x_34 - 0.00681191562387158*x_35 + 0.00537463998974081*x_36 - 0.00723268582915502*x_37 + 0.00379158251199306*x_38 + 0.000462454190453374*x_39 + 0.00476937830638615*x_4 - 0.0027505878114301*x_40 + 0.00512418367850405*x_41 + 0.00442435696152044*x_42 - 0.00669525281505673*x_43 + 0.00141074278603666*x_44 - 0.00138709531006211*x_45 + 0.00429813298378317*x_46 - 0.0027378302317676*x_47 - 0.00472147900165812*x_48 - 0.00199242559090079*x_49 - 0.0043063526859372*x_5 + 0.00386476300269487*x_50 + 0.0020041721340273*x_51 - 0.00734391415053458*x_52 - 0.00285477478105198*x_53 + 0.000537270699572782*x_54 - 0.00777030972853298*x_55 + 0.0024857701458086*x_56 - 0.00512845443995978*x_57 - 0.0131357721026615*x_58 - 0.00536675267933712*x_59 - 0.00270004987949808*x_6 - 0.00475620237487869*x_60 - 0.000931042169694646*x_61 + 0.000408487311730501*x_62 + 0.00206385028327973*x_63 + 0.00167323814713415*x_64 - 0.0042424794963619*x_65 + 0.00133855604713537*x_66 - 0.00179253314731391*x_67 + 0.0034882883012152*x_68 - 0.00283386561715869*x_69 + 0.00833638806690153*x_7 + 0.00233600653997333*x_70 - 0.0019908785195648*x_71 + 0.00040297872985789*x_72 - 0.00194620424157583*x_73 - 0.00412180974705681*x_74 + 0.00484737327176721*x_75 - 0.000451882699716644*x_76 + 0.00099895193953042*x_77 - 0.00149530607249868*x_78 - 0.00303329582134493*x_79 - 0.000334376920456077*x_8 + 0.00384795908886034*x_80 + 0.0017757530015333*x_81 - 0.00390261247408374*x_82 + 0.00165005453432262*x_83 + 0.00220787433893589*x_84 - 7.8929224656526e-5*x_85 - 0.000686176630356434*x_86 - 0.00286603803682901*x_87 + 0.00115458633646285*x_88 - 0.00399287934536027*x_89 - 0.00245734136788522*x_9 + 0.00262586454074766*x_90 - 0.000434478684666865*x_91 - 0.0030534868913509*x_92 - 0.00466371245436877*x_93 + 0.0002690034214226*x_94 - 0.000639137397377178*x_95 - 0.00120188086687871*x_96 + 0.000989103616407064*x_97 + 0.00638204499308753*x_98 - 0.00374279960390825*x_99 - 0.0202255293767174*std::sin(0.205040007829666*x_1 + 5.0) + 0.00455667621765853*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.0178053314948374*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.00665601409898744*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.0362066091607123*std::sin(0.259839981794357*x_107 + 1.96935975551605) - 0.00725986252122092*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.00425498066813135*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0149005355310254*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.019866832181061*std::sin(0.240079984068871*x_109 + 1.97479975223541) - 0.00883188206634302*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.017359450712271*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0480652861708929*std::sin(0.219039991497993*x_111 + 1.98207986354828) - 0.00257808887426579*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.025384727107856*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.0282731981949321*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.00976987616332646*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.0109687348663831*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.0225260122561675*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 0.0212222107351153*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.00725422484171191*std::sin(0.304799944162369*x_13 + 5.14416027069092) + 0.000623510846997117*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.0212293341305078*std::sin(0.318079918622971*x_15 + 1.9463198184967) + 0.0148589157389731*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.0161329079994829*std::sin(0.325119823217392*x_16 - 1.13359987735748) + 0.00367948271994932*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.0221865915932515*std::sin(0.290319949388504*x_17 - 4.35184001922607) + 0.00384683905485952*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.0157414390240475*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.0115191104740094*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.0256118242893053*std::sin(0.215680003166199*x_19 - 7.37871980667114) + 0.00320853712963309*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.0178637553845335*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.00728726835308987*std::sin(0.281359940767288*x_20 + 8.36528015136719) + 0.00436609505020275*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0144184136032366*std::sin(0.262799948453903*x_21 + 1.99535977840424) - 0.00520067091277714*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.0211491190512129*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.0306870889481963*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 0.014390958903758*std::sin(0.297839939594269*x_24 - 1.1561598777771) + 0.00830211707624473*std::sin(0.334879845380783*x_24 + 2.03159976005554) - 0.0043295550122987*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.0300501784808789*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 0.0161968724770966*std::sin(0.361759841442108*x_26 - 7.5729603767395) + 0.00686014387984684*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.00704391397528301*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.0164881575324577*std::sin(0.377439826726913*x_29 - 1.18831992149353) - 0.013654701347801*std::sin(0.28655993938446*x_3 - 7.32575988769531) + 0.00429346268984546*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.0187594762487103*std::sin(0.331919848918915*x_3 + 1.97167980670929) + 0.000937011419444508*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.00614011232332722*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.00215004399537863*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00742098170803484*std::sin(0.477279841899872*x_31 - 1.14671981334686) + 0.0141060667533708*std::sin(0.489679843187332*x_31 + 2.03039979934692) + 0.00330833484734375*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.0212516684177736*std::sin(0.3018399477005*x_32 - 1.16751992702484) - 0.00345262533625216*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 0.00582635129976517*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.0370079276879919*std::sin(0.244719967246056*x_34 - 1.19687986373901) - 0.00357735154488905*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.0326335365933046*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 0.00549420564237012*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.0211653533377562*std::sin(0.231999978423119*x_36 - 7.42991971969604) + 0.0030060781602173*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.00771597168245469*std::sin(0.244319975376129*x_37 + 1.98031985759735) + 0.0109741698601248*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.0249368833086651*std::sin(0.259759962558746*x_4 - 4.17920017242432) + 0.00569902828513932*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.00249183670988001*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.0312080598799143*std::sin(0.251679986715317*x_41 + 5.15888023376465) - 0.00260510219285496*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.0337713372452041*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.0261463624414708*std::sin(0.212159991264343*x_44 + 1.99047982692719) - 0.0180888644809084*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.0305634372665774*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 0.0159491798143855*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.0410477069179468*std::sin(0.1891999989748*x_47 - 1.16887986660004) - 0.0195050003694672*std::sin(0.208880007266998*x_47 - 1.20455992221832) + 0.00479047922196863*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.00864906332022279*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.0162708432449162*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.0364321668456278*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.0177351378992628*std::sin(0.262319952249527*x_5 - 1.16559982299805) + 0.0046602437719429*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.0292890018078602*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.00235937129228555*std::sin(0.213519990444183*x_52 + 5.18127965927124) - 0.0110404482190841*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.00632881568336562*std::sin(0.169600024819374*x_54 + 2.01831984519958) + 0.00775670411816794*std::sin(0.177920013666153*x_54 - 4.17063999176025) + 0.0115740894564188*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.031072173345416*std::sin(0.391919851303101*x_6 - 7.40383958816528) - 0.00511742417117645*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.07522162205374*std::sin(0.118000060319901*x_61 + 8.06375980377197) + 0.00387873289724522*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.0213921871677725*std::sin(0.306159943342209*x_8 - 4.22975969314575) + 0.00479908893174904*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.0205663215633956*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.0111750426404469*std::sin(0.309999912977219*x_9 + 1.95135986804962) + 0.00464334984382094*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.0236376919597019*std::sin(0.345599830150604*x_91 + 5.19392013549805) - 0.00383290317554275*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.00300027728012668*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.00855506826812896*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.0192439808289909*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.0309962838574278*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.0145547281029103*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.0174678355205217*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 0.0234484483886682*std::sin(0.275359958410263*x_94 - 7.40887975692749) - 0.00872073530553809*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.0180805760619839*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 0.0184816105902359*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.0024941572495053*std::sin(0.314479917287827*x_95 - 4.43727970123291) + 0.00900664000119938*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.0129581805649365*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.00931008606288247*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.0196911149567184*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.0196285915754322*std::sin(0.282879948616028*x_97 - 1.22967994213104) - 0.00589658050405885*std::sin(0.251599967479706*x_98 + 1.98239982128143) + 0.0560531197944361);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0018676070152952*x_1 - 0.00448907885518806*x_10 + 0.00218872088176211*x_100 + 0.000352409707152216*x_101 - 0.00346847842359095*x_102 - 0.00212997621631927*x_103 + 0.00167444171783697*x_104 - 0.00666742567137271*x_105 + 0.00156187421059638*x_106 + 7.49248970869227e-5*x_107 - 0.0054602921910207*x_108 - 0.00236146147194274*x_109 + 0.000568062825364925*x_11 + 0.00574257469560417*x_110 + 0.00246180014030053*x_111 + 0.00231166362807836*x_112 + 0.00113469301885516*x_113 - 0.00588991551072806*x_114 - 0.00270817612859672*x_115 + 0.00374459401207396*x_116 + 0.00562410430447606*x_117 - 0.000134607540047731*x_118 + 0.00453780416338455*x_119 - 0.00126263032199093*x_12 + 0.00189444874149599*x_120 + 0.00122335897410181*x_13 + 0.0052493088797898*x_14 - 0.000779765260222772*x_15 + 0.000242180760600559*x_16 - 0.000868174672851308*x_17 + 0.00023895718973314*x_18 + 0.00349172301593367*x_19 + 5.1485354558999e-5*x_2 + 0.00232384445100316*x_20 - 0.00366540664154827*x_21 + 0.00466114610145653*x_22 - 0.000490087560507218*x_23 - 5.51799281479454e-5*x_24 + 0.000940098163621949*x_25 + 0.00255685611667214*x_26 - 0.00415644166782369*x_27 + 0.00383254980510655*x_28 + 0.00072590420466551*x_29 + 3.18004996819012e-5*x_3 + 0.00497959521913294*x_30 + 0.000264556255224686*x_31 - 0.00045686430442713*x_32 - 0.000191754730634537*x_33 + 0.000345559510162883*x_34 + 0.00280493228661356*x_35 - 0.000124210724380053*x_36 + 0.00765223322168711*x_37 + 0.00268638354599451*x_38 + 0.00496017863396925*x_39 + 0.000333696626828347*x_4 - 0.00953813828695713*x_40 - 0.00158060180268048*x_41 + 0.00195415497625509*x_42 - 0.0107200532315962*x_43 - 0.00078442400410035*x_44 + 0.00236087554005619*x_45 - 0.000631019707220854*x_46 - 0.0015695999418222*x_47 - 0.00886176023919743*x_48 + 0.00295597509750911*x_49 + 0.00239049245594992*x_5 - 0.00118387072957369*x_50 + 0.00137778149752464*x_51 - 0.000460407825218968*x_52 + 0.00298930746510161*x_53 + 0.0010792022501475*x_54 - 0.00822470765065104*x_55 + 0.00344619862908198*x_56 - 0.00548938658733671*x_57 - 0.00504138678834301*x_58 - 0.00960746209734346*x_59 + 0.000609437043058644*x_6 - 0.00467166790424389*x_60 + 0.00147881514112479*x_61 - 0.000117120502667978*x_62 + 0.00158046873229266*x_63 + 0.000186611357916426*x_64 - 0.00153798700037249*x_65 + 0.00120371273092091*x_66 - 0.00382573964432006*x_67 - 2.98563680989044e-5*x_68 - 0.00387274620463295*x_69 + 0.000481269439562332*x_7 + 0.00429022180831147*x_70 - 0.00366543706068005*x_71 - 8.45363296447992e-5*x_72 - 0.00135874431669469*x_73 - 0.00292385300218931*x_74 + 0.00275313926464549*x_75 + 0.00197713771937433*x_76 - 0.000132130354933622*x_77 - 0.00135446276576082*x_78 - 1.61350918171488e-5*x_79 + 0.000800382268344863*x_8 + 0.000472182160309093*x_80 + 0.00139440928649102*x_81 + 0.000828339910115189*x_82 - 0.00193974597679346*x_83 + 0.003292670094996*x_84 - 0.00220515086004109*x_85 + 0.00119974484406477*x_86 + 0.00309272574633384*x_87 + 9.91003153878364e-5*x_88 - 0.00275223652053427*x_89 - 0.00427601513450783*x_9 + 0.00446174168283961*x_90 - 0.000480622396473323*x_91 - 0.00245394597635465*x_92 + 0.002061718623618*x_93 - 0.000144501177339048*x_94 + 0.00112400984491575*x_95 - 0.00253298288033626*x_96 - 0.00197375543109936*x_97 + 0.005180530009893*x_98 + 0.000901330787916424*x_99 + 0.0216213455610315*std::sin(0.205040007829666*x_1 + 5.0) - 0.00748479818198355*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.00016334551338153*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.000680876412218508*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.0373782065920459*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.0119250530879736*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.000435262895824861*std::sin(0.237519979476929*x_108 - 4.22295999526978) + 0.0159288600936*std::sin(0.25503996014595*x_108 + 5.14904022216797) - 0.0212378937425595*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.0145072530230435*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.0179211793119745*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0496206145244588*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 0.00423476981847356*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.0262061429146402*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.0291880810615859*std::sin(0.222159996628761*x_118 - 4.2247200012207) + 0.0104441206299862*std::sin(0.265599936246872*x_119 + 8.16975975036621) + 0.0117257156782462*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.0232549238750482*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 0.000194691848821998*std::sin(0.280479967594147*x_13 + 5.16919994354248) + 0.00775485769290297*std::sin(0.304799944162369*x_13 + 5.14416027069092) + 6.37819905680943e-5*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.021916286980078*std::sin(0.318079918622971*x_15 + 1.9463198184967) + 0.000136315194152898*std::sin(0.383039832115173*x_15 + 1.8076798915863) + 0.0172462817790414*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 0.00604391979096294*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.0229045200135938*std::sin(0.290319949388504*x_17 - 4.35184001922607) + 0.000393512083223087*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.000144411433142519*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.000105675932774473*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.000234962016202122*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 0.00527034437549851*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.000163881492184224*std::sin(0.417119860649109*x_2 - 0.990879774093628) - 0.00779018162261307*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.00717174947991309*std::sin(0.32247993350029*x_20 - 1.21759986877441) - 0.0154134656824518*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.00854262412637502*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.0218334762481375*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.0316800820900623*std::sin(0.297039926052094*x_24 - 4.36775970458984) + 0.0153841162630303*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.0136370608379153*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.0071117287990023*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.0310225620521501*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 0.000148589564351197*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.0112684750873978*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.000720556598009025*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.0170216922505724*std::sin(0.377439826726913*x_29 - 1.18831992149353) + 0.0145970476655778*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.00705244353567052*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.0193665078016678*std::sin(0.331919848918915*x_3 + 1.97167980670929) + 9.58515057196473e-5*std::sin(0.532399833202362*x_3 + 4.99351978302002) + 0.0065638573830868*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.000219938572832658*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00766111474751708*std::sin(0.477279841899872*x_31 - 1.14671981334686) + 0.00012940858283327*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 0.00543427214662084*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.0219393439749985*std::sin(0.3018399477005*x_32 - 1.16751992702484) - 0.000353186023455045*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 5.34507512245551e-5*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.0382054547147779*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 0.00587615908186262*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.0336895141767988*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 0.000562029312157968*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.000194170240967415*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 0.0049377851911665*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.000789304685626877*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.0180261758119931*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.0257438074892812*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.00936122614601804*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.000254902230317628*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.0322179109441197*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 0.00427914190641829*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.000309817114132255*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.0269924237486529*std::sin(0.212159991264343*x_44 + 1.99047982692719) - 0.000165946635477111*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.0315524292054608*std::sin(0.208719998598099*x_45 + 1.98703980445862) + 0.0170498740358718*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.0423759557957618*std::sin(0.1891999989748*x_47 - 1.16887986660004) + 0.0208510909801829*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.00786884309059937*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.000884755217603859*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.000149268169691862*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.0376110630218699*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.0183090232337025*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.00765491828817325*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.000268696319308892*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.000241351691371434*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.0181350446709919*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.000647405677331384*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.012741165294312*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.0190116039813848*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.0320776273031687*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.00840588299524654*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.000690080635416546*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 0.00637120821207236*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.0220844097237462*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.00788298540333647*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.00018867474357984*std::sin(0.386799842119217*x_8 - 4.39431953430176) + 0.0119462612863179*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.00762716831506701*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.0244025760464639*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 0.00629592829282987*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.000306913116434672*std::sin(0.282959938049316*x_92 + 1.98607981204987) + 0.00914547569451318*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.000176543634075405*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.0319992821328823*std::sin(0.240719974040985*x_93 + 1.95935988426208) - 0.0155591875989233*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.0180330713076113*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 0.000215115278317502*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.0143246833091845*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.0186656393132049*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 0.000169549675098997*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.000255139609726832*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.0147943104769024*std::sin(0.275039941072464*x_96 + 1.98135983943939) - 0.0138524581788823*std::sin(0.279039949178696*x_96 + 1.97311985492706) + 0.00995259922344714*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.000180645627552203*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.0202637465375662*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.00968572550001767*std::sin(0.251599967479706*x_98 + 1.98239982128143) + 0.328570149686174);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00130156262902895*x_1 - 0.00187312238162219*x_10 - 0.000394078687038163*x_100 - 0.00144277456936183*x_101 - 0.00198084716176659*x_102 - 0.00262852433125238*x_103 - 0.00175991847187941*x_104 - 0.00251372089750307*x_105 - 0.000119064102000225*x_106 - 0.00211808706995095*x_107 - 0.00283381253655469*x_108 - 0.000878271803022899*x_109 + 0.00185369302912528*x_11 + 0.00346923455356132*x_110 + 0.000849559032793942*x_111 - 0.00150111229434316*x_112 + 7.68916597615568e-5*x_113 - 0.00526275198394825*x_114 + 0.000260050191544377*x_115 + 0.00368913437993248*x_116 + 0.000781651891392091*x_117 + 0.00120992578922146*x_118 - 0.000211486868850198*x_119 - 0.00254607176036263*x_12 + 0.00387116529013974*x_120 + 0.000636608070078891*x_13 - 0.00185594005625823*x_14 - 0.00112112577264285*x_15 - 0.000167382468980635*x_16 - 0.000788819167791518*x_17 + 0.00213987784579024*x_18 + 0.00156617905807898*x_19 - 0.00198450393461128*x_2 + 0.0018422697920075*x_20 - 0.00286715065358138*x_21 + 0.00278062325676152*x_22 - 0.00101986151738266*x_23 + 0.00143493279459297*x_24 + 0.00243881376424762*x_25 + 0.00415032781656884*x_26 - 0.00145334534367945*x_27 + 0.00303829092461882*x_28 + 0.0015482653425648*x_29 - 0.000522444300336208*x_3 + 0.00195577140151168*x_30 + 0.000263878891849765*x_31 - 0.000343338941398943*x_32 + 0.00178099901389714*x_33 + 0.00114308436127214*x_34 + 0.00318371819536189*x_35 - 0.00431135268394978*x_36 + 0.00450795094208124*x_37 + 0.00325721428679266*x_38 + 0.00556676133219092*x_39 - 0.000500716262468121*x_4 - 0.0074192560237107*x_40 - 0.00309286891498523*x_41 + 0.000581440063910037*x_42 - 0.00516223228996625*x_43 - 0.00151167114596881*x_44 + 9.27034636266477e-5*x_45 - 0.00193383455839367*x_46 - 0.00198864180116658*x_47 - 0.00566313355472064*x_48 + 0.00398178418127604*x_49 + 0.00475359027085288*x_5 + 0.00159010484439247*x_50 + 5.13422401383461e-5*x_51 + 0.000887309079279074*x_52 + 0.00552803904459833*x_53 + 0.000676305382130795*x_54 - 0.00439248631214637*x_55 + 0.00511771070129353*x_56 - 0.00424721798162162*x_57 - 0.000828170276207962*x_58 - 0.00430778110518236*x_59 + 0.000492105478047666*x_6 - 0.00190486369445925*x_60 + 0.00183060803740406*x_61 + 0.000187482957912979*x_62 + 0.00124608960233286*x_63 - 0.000142116301345607*x_64 - 0.00111632237672602*x_65 + 0.000274051593704542*x_66 - 0.00400812953428034*x_67 + 0.00122863800716387*x_68 - 0.00134741462738128*x_69 - 0.00174398718402977*x_7 + 0.00355388352510285*x_70 - 0.00236602727845394*x_71 + 0.000691696024488929*x_72 - 0.0014853764325092*x_73 - 0.000765510078006641*x_74 - 0.000642528161080225*x_75 + 0.00189769710108211*x_76 - 0.00081037111737639*x_77 - 0.000451863098142788*x_78 + 0.0011522487679734*x_79 - 0.000387788220833394*x_8 - 0.00031881309955077*x_80 + 0.00141449222228034*x_81 - 0.000309261692170809*x_82 - 0.00149023189376567*x_83 + 0.0004591119191714*x_84 - 0.00183788357280147*x_85 + 0.00159066565804521*x_86 + 0.00134562968903982*x_87 - 0.000181768109037693*x_88 - 0.00204136102128808*x_89 - 0.00439329916582101*x_9 + 0.00293444168692339*x_90 + 0.000792487150093591*x_91 - 0.00157791338446077*x_92 - 0.00192605957723657*x_93 - 0.000487859403741755*x_94 - 2.86899720983394e-6*x_95 + 5.2664827060728e-5*x_96 + 0.000379669460924897*x_97 + 0.00153742513403579*x_98 + 0.00266432949518028*x_99 + 0.0194527586478847*std::sin(0.205040007829666*x_1 + 5.0) - 0.000720395256037104*std::sin(0.307839930057526*x_1 + 8.32415962219238) + 0.00268357206035482*std::sin(0.47751984000206*x_1 + 2.21951985359192) + 0.0188880557758821*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.0209944498807445*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.00114775996141691*std::sin(0.267919957637787*x_107 + 8.17055988311768) - 0.0120745405568163*std::sin(0.237519979476929*x_108 - 4.22295999526978) + 0.0143312205090135*std::sin(0.25503996014595*x_108 + 5.14904022216797) - 0.0191077664429929*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.00139629098899242*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.0100659002978797*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0278707193219693*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 0.000407587220585418*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.0147193673573981*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.0163942511113675*std::sin(0.222159996628761*x_118 - 4.2247200012207) + 0.00939659177690984*std::sin(0.265599936246872*x_119 + 8.16975975036621) + 0.010549644859927*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.0130617377956042*std::sin(0.287439942359924*x_120 - 1.23167991638184) - 0.00319855498361435*std::sin(0.280479967594147*x_13 + 5.16919994354248) + 0.00697705767769694*std::sin(0.304799944162369*x_13 + 5.14416027069092) - 0.0017693633877279*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.0123098572811991*std::sin(0.318079918622971*x_15 + 1.9463198184967) - 0.00223949613832444*std::sin(0.383039832115173*x_15 + 1.8076798915863) + 0.0155165068739181*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 0.000581713900550971*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.012864924278369*std::sin(0.290319949388504*x_17 - 4.35184001922607) - 0.0109163396513961*std::sin(0.363919854164124*x_17 - 1.17343986034393) - 0.00237250769338169*std::sin(0.417999863624573*x_17 - 4.41599988937378) + 0.0017361295989999*std::sin(0.3435198366642*x_18 - 7.59256029129028) - 0.00386014582752504*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 0.000507258979264126*std::sin(0.402639865875244*x_2 - 7.39831972122192) - 0.0026923775531417*std::sin(0.417119860649109*x_2 - 0.990879774093628) - 0.00700883867288088*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.00069026501145376*std::sin(0.32247993350029*x_20 - 1.21759986877441) - 0.013867519345724*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.000822208661492298*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.0122633444621041*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.0177939488353949*std::sin(0.297039926052094*x_24 - 4.36775970458984) + 0.0138411136268546*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.00131253691750444*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.000684488153782925*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.0174246354643122*std::sin(0.370959848165512*x_25 - 4.38535976409912) + 0.00244114940838193*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.00108456578231778*std::sin(0.263279944658279*x_28 + 5.00895977020264) - 0.0199888158388819*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.00956067980308468*std::sin(0.377439826726913*x_29 - 1.18831992149353) + 0.0131329867703482*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.000678782078426086*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.0108777069441765*std::sin(0.331919848918915*x_3 + 1.97167980670929) - 0.00265899736537499*std::sin(0.532399833202362*x_3 + 4.99351978302002) + 0.00590551282351514*std::sin(0.309359908103943*x_30 - 7.39224004745483) + 0.00610127176736148*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00430306599117591*std::sin(0.477279841899872*x_31 - 1.14671981334686) - 0.00212602874772772*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 0.000523036664350348*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.0123228078470072*std::sin(0.3018399477005*x_32 - 1.16751992702484) + 0.00979766252813007*std::sin(0.316399842500687*x_32 + 2.01391983032227) + 0.000878132123875103*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.0214590954813532*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 0.000565567303669281*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.0189225990591519*std::sin(0.250799983739853*x_35 - 1.22103989124298) - 0.0155911422472858*std::sin(0.251839965581894*x_35 - 1.2047199010849) - 0.00318998558837329*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 0.000475250893953152*std::sin(0.261919975280762*x_36 + 1.94783973693848) + 0.0218959427272701*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.00173497951764535*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.0144596845421755*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.000900997293756653*std::sin(0.303679943084717*x_4 + 2.03975987434387) + 0.00707119156610025*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.0180960345144689*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 0.000411857935824311*std::sin(0.256479978561401*x_41 + 1.97903978824615) + 0.00508992585160952*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.0151610026060347*std::sin(0.212159991264343*x_44 + 1.99047982692719) + 0.00272630539558251*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.0177222492453865*std::sin(0.208719998598099*x_45 + 1.98703980445862) + 0.0153397985181097*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.0238015667742627*std::sin(0.1891999989748*x_47 - 1.16887986660004) + 0.0187597593885934*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.000757358728337264*std::sin(0.224879994988441*x_48 - 1.18455982208252) - 0.024543816760598*std::sin(0.226239994168282*x_48 - 1.20207989215851) + 0.00245229808516232*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.0211252398006223*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.0102837430067378*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.000736768939665687*std::sin(0.34895983338356*x_5 - 1.15559983253479) + 0.00441436021284103*std::sin(0.203359991312027*x_51 - 1.19439995288849) - 0.0066952887872464*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.00174545790432273*std::sin(0.225999996066093*x_53 + 5.17560005187988) - 0.0179595508430297*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.00122630895466236*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.00182982479752262*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.0180172405289473*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.00080904763032285*std::sin(0.44599986076355*x_6 + 5.16472005844116) + 0.0113372021934282*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 0.000613214686569575*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.0124042878287714*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.000758719894631597*std::sin(0.312239944934845*x_8 - 1.22175979614258) - 0.00309970111748854*std::sin(0.386799842119217*x_8 - 4.39431953430176) + 0.0107480700907971*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.000734098066183886*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.0137063467319367*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 0.000605969160988446*std::sin(0.358959853649139*x_91 + 1.99783980846405) + 0.00851401510984863*std::sin(0.282959938049316*x_92 + 1.98607981204987) + 0.00822819888351913*std::sin(0.284799933433533*x_92 + 2.00287985801697) - 0.00290040144984986*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.0179732359096533*std::sin(0.240719974040985*x_93 + 1.95935988426208) - 0.0139986255834383*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.0101287473713119*std::sin(0.275039941072464*x_94 + 5.18503999710083) + 0.00353408758341552*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.00137871905818517*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.0104840457791392*std::sin(0.255679965019226*x_95 - 7.42280006408691) + 0.00278549904137956*std::sin(0.281039953231812*x_95 + 1.96631979942322) + 0.00707777666060587*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.00142391963347181*std::sin(0.275039941072464*x_96 + 1.98135983943939) - 0.0124630784366807*std::sin(0.279039949178696*x_96 + 1.97311985492706) + 0.00895436919345946*std::sin(0.259119987487793*x_97 - 1.18703985214233) + 0.00296779231267927*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.0113816646079958*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.000932229638240054*std::sin(0.251599967479706*x_98 + 1.98239982128143) + 0.112702042913275);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00132108159197965*x_1 - 0.00224617917218878*x_10 + 0.00317421018591341*x_100 - 0.000343300610126948*x_101 - 0.000252219703033097*x_102 - 0.00181607334566738*x_103 - 0.00143704976673828*x_104 - 0.00802079351172738*x_105 - 0.0037778557237202*x_106 + 0.00171444562060155*x_107 - 0.00338743603480226*x_108 - 0.00156019023373318*x_109 + 0.0019070920960261*x_11 + 0.00326384372040219*x_110 + 0.000326597185332418*x_111 - 0.0018926264410131*x_112 + 0.00333262268966171*x_113 - 0.00674792747434824*x_114 + 0.00114608939377055*x_115 + 0.00240114063951999*x_116 + 0.00231402877085399*x_117 + 0.000641836393763853*x_118 + 0.00348462026238794*x_119 - 0.00240833625715111*x_12 - 0.00152876577112373*x_120 + 0.000740047957855747*x_13 + 0.00336700114392716*x_14 - 0.000515821885351091*x_15 - 0.000118935871219401*x_16 - 0.000639341579340086*x_17 + 5.38918580658128e-5*x_18 + 0.000707184299716255*x_19 + 0.000280701000985815*x_2 + 0.00148256481971392*x_20 - 0.0029592339311414*x_21 + 0.00294537883373434*x_22 - 0.000371356900312156*x_23 - 0.000602272765607416*x_24 + 0.00121831789309113*x_25 + 0.00321001021950741*x_26 - 0.00777188645129063*x_27 + 0.00209650747195586*x_28 + 0.00329571157942558*x_29 + 0.00150150901903432*x_3 + 0.00274503946644385*x_30 + 0.000234190072117873*x_31 - 0.000511295545984548*x_32 - 0.000902049126927418*x_33 + 0.00228872284726122*x_34 + 0.00025263949791802*x_35 + 0.000357884202439711*x_36 - 0.000631897967350192*x_37 + 0.000400799590206219*x_38 + 0.00535404756798609*x_39 + 0.00238982292971709*x_4 - 0.0057486828764138*x_40 + 0.000363981528416664*x_41 + 0.00446689373935152*x_42 - 0.00740798204940559*x_43 - 0.00206033081220952*x_44 - 0.00144948598233071*x_45 + 0.000187685618234199*x_46 - 0.000593679458437372*x_47 - 0.00641504475236174*x_48 + 0.000912033684607888*x_49 + 0.000926878505168085*x_5 + 0.000155379253723037*x_50 + 0.00394615815292643*x_51 - 0.000707268449319965*x_52 + 0.00147664016620157*x_53 + 0.000356671749624852*x_54 - 0.00580665458612081*x_55 + 0.00420909413954669*x_56 - 0.00375593959936784*x_57 - 0.0041904672151182*x_58 - 0.00572176974242872*x_59 - 0.000474421605143096*x_6 - 0.00695789291643061*x_60 + 0.000433753158572863*x_61 - 0.000190531205442924*x_62 + 0.00181481734353664*x_63 + 0.00135736058360209*x_64 - 0.00286880079905149*x_65 + 0.00204579288948023*x_66 - 0.00221436058211919*x_67 + 0.00159298224149299*x_68 - 0.0021422886271647*x_69 + 0.00277088456815121*x_7 + 0.00291913465870383*x_70 - 0.00298572670750055*x_71 - 0.000771743904201687*x_72 - 0.000874484664445162*x_73 - 0.00400973466250059*x_74 + 0.00186283479255859*x_75 + 0.000238845174902116*x_76 + 0.000641285879076387*x_77 - 0.000188500464712377*x_78 - 0.00161103857883239*x_79 + 0.000717192155106112*x_8 + 0.00191899670226778*x_80 + 0.00240680279018171*x_81 - 0.000653807630605476*x_82 + 0.000359730676899288*x_83 + 0.000609718603506076*x_84 - 0.000880324318112339*x_85 - 0.00128014430924137*x_86 + 0.00013048732050076*x_87 + 0.000699655710480005*x_88 - 0.00418645724240451*x_89 - 0.00238512171647899*x_9 + 0.00350915737376585*x_90 - 0.00068367184225438*x_91 - 0.00235651836994579*x_92 - 0.00273175545124584*x_93 - 5.91393110340722e-5*x_94 - 0.000887495303769428*x_95 - 0.00128546702657487*x_96 + 0.00113040044117943*x_97 + 0.00522465408217454*x_98 + 0.00162150162729265*x_99 + 0.0156003550694176*std::sin(0.205040007829666*x_1 + 5.0) + 0.0046713214601989*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.00771260716072172*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.00295013296213127*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.0270845204506915*std::sin(0.259839981794357*x_107 + 1.96935975551605) - 0.00744251949744618*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.00188592730357876*std::sin(0.237519979476929*x_108 - 4.22295999526978) + 0.0114930808820292*std::sin(0.25503996014595*x_108 + 5.14904022216797) - 0.0153236847528876*std::sin(0.240079984068871*x_109 + 1.97479975223541) - 0.00905409080210087*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.0129858169192894*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0359554583110892*std::sin(0.219039991497993*x_111 + 1.98207986354828) - 0.00264295317670084*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.0189891618250181*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.0211498959021002*std::sin(0.222159996628761*x_118 - 4.2247200012207) + 0.00753570076180962*std::sin(0.265599936246872*x_119 + 8.16975975036621) + 0.00846040444186632*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.0168506870366287*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 0.0091926721234847*std::sin(0.280479967594147*x_13 + 5.16919994354248) + 0.00559532861544625*std::sin(0.304799944162369*x_13 + 5.14416027069092) + 0.000276357572958328*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.0158807010029599*std::sin(0.318079918622971*x_15 + 1.9463198184967) + 0.00643632947593214*std::sin(0.383039832115173*x_15 + 1.8076798915863) + 0.0124436343992015*std::sin(0.325119823217392*x_16 - 1.13359987735748) + 0.00377205791482863*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.0165967818491716*std::sin(0.290319949388504*x_17 - 4.35184001922607) + 0.001705027442397*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.00681860572897142*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.0049896500917576*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.011094089400701*std::sin(0.215680003166199*x_19 - 7.37871980667114) + 0.00328926340902091*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.0077379142160921*std::sin(0.417119860649109*x_2 - 0.990879774093628) - 0.00562081573623478*std::sin(0.281359940767288*x_20 + 8.36528015136719) + 0.00447594530114772*std::sin(0.32247993350029*x_20 - 1.21759986877441) - 0.0111212106026328*std::sin(0.262799948453903*x_21 + 1.99535977840424) - 0.00533151895852096*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.0158206957440865*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.0229556179784846*std::sin(0.297039926052094*x_24 - 4.36775970458984) + 0.0111000342441696*std::sin(0.297839939594269*x_24 - 1.1561598777771) + 0.00851099700984985*std::sin(0.334879845380783*x_24 + 2.03159976005554) - 0.00443848592175267*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.0224791741750689*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 0.00701588255654618*std::sin(0.361759841442108*x_26 - 7.5729603767395) + 0.00703274399918798*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.00312206111523423*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.0123340420501639*std::sin(0.377439826726913*x_29 - 1.18831992149353) + 0.0105321440751888*std::sin(0.28655993938446*x_3 - 7.32575988769531) + 0.00440148552225734*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.0140331124587548*std::sin(0.331919848918915*x_3 + 1.97167980670929) + 0.000415309858616011*std::sin(0.532399833202362*x_3 + 4.99351978302002) + 0.0047359913615056*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.000952960069865811*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00555129948632625*std::sin(0.477279841899872*x_31 - 1.14671981334686) + 0.00611022330492478*std::sin(0.489679843187332*x_31 + 2.03039979934692) + 0.00339157202129713*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.015897408269236*std::sin(0.3018399477005*x_32 - 1.16751992702484) - 0.00153030081650767*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 0.00252375861513606*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.027683950459265*std::sin(0.244719967246056*x_34 - 1.19687986373901) - 0.00366735713579028*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.0244116670886383*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 0.00243518672365034*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.00916804361431379*std::sin(0.231999978423119*x_36 - 7.42991971969604) + 0.00308171060441815*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.00341993602428575*std::sin(0.244319975376129*x_37 + 1.98031985759735) + 0.0112502782130548*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.0186541502119709*std::sin(0.259759962558746*x_4 - 4.17920017242432) + 0.00584241492241282*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.00110445222992903*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.0233453326792372*std::sin(0.251679986715317*x_41 + 5.15888023376465) - 0.00267064614605157*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.0146284868405865*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.0195589066381183*std::sin(0.212159991264343*x_44 + 1.99047982692719) - 0.00783542310151484*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.0228631197695332*std::sin(0.208719998598099*x_45 + 1.98703980445862) + 0.012301921177738*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.0307059258860255*std::sin(0.1891999989748*x_47 - 1.16887986660004) + 0.0150445966444313*std::sin(0.208880007266998*x_47 - 1.20455992221832) + 0.00491100691058492*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.00383350852523456*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.00704792394110198*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.0272532499139447*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.0132668514468248*std::sin(0.262319952249527*x_5 - 1.16559982299805) + 0.00477749475753217*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.0126869058932821*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.00104573982503083*std::sin(0.213519990444183*x_52 + 5.18127965927124) - 0.0113182241248915*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.00280510940648256*std::sin(0.169600024819374*x_54 + 2.01831984519958) + 0.00795186154925664*std::sin(0.177920013666153*x_54 - 4.17063999176025) + 0.0118652916901375*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.0232436821323368*std::sin(0.391919851303101*x_6 - 7.40383958816528) - 0.00524617774225812*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.0325832080723121*std::sin(0.118000060319901*x_61 + 8.06375980377197) + 0.00397632119461661*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.0160025239662392*std::sin(0.306159943342209*x_8 - 4.22975969314575) + 0.00491983323928202*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.00890856533648599*std::sin(0.386799842119217*x_8 - 4.39431953430176) + 0.00861953375161291*std::sin(0.309999912977219*x_9 + 1.95135986804962) + 0.0047601757808892*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.0176822841500548*std::sin(0.345599830150604*x_91 + 5.19392013549805) - 0.00392933840446925*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.00132980741446773*std::sin(0.282959938049316*x_92 + 1.98607981204987) + 0.00659869515106755*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.00833577652769347*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.0231869126519283*std::sin(0.240719974040985*x_93 + 1.95935988426208) - 0.0112263527008401*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.0130668946734248*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 0.0101569954483966*std::sin(0.275359958410263*x_94 - 7.40887975692749) - 0.00894014760662704*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.0135252580526779*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 0.00800554610405617*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.00110548075846528*std::sin(0.314479917287827*x_95 - 4.43727970123291) + 0.00923324561855919*std::sin(0.275039941072464*x_96 + 1.98135983943939) - 0.00999490367353957*std::sin(0.279039949178696*x_96 + 1.97311985492706) + 0.00718105546720554*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.00852945839631324*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.0146832581748621*std::sin(0.282879948616028*x_97 - 1.22967994213104) - 0.0060449375234641*std::sin(0.251599967479706*x_98 + 1.98239982128143) + 0.186198858965518);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000551549315772817*x_1 + 0.000481498680098551*x_10 + 0.000474817376285434*x_100 - 0.00153063476027769*x_101 - 0.00128814937999587*x_102 - 0.00204583270284515*x_103 - 0.00218849799377915*x_104 + 0.00179322600630927*x_105 + 0.00246533287952748*x_106 - 0.0039797007903237*x_107 - 0.00107599115549393*x_108 - 0.000828989771753065*x_109 - 0.00154615312535646*x_11 - 0.00191504788237804*x_110 - 0.00338551119258394*x_111 + 0.00227052455589785*x_112 - 0.000987118262158418*x_113 - 0.00214569745218424*x_114 - 0.00301404597552635*x_115 + 0.00246480640213467*x_116 + 0.000803560384144875*x_117 + 2.66689904071234e-5*x_118 - 0.00216779694355423*x_119 - 0.00265015881400675*x_12 + 0.00466061980694382*x_120 + 0.000266124440651765*x_13 - 0.00375944053706429*x_14 - 0.000546038581088151*x_15 + 0.000665241545489325*x_16 - 0.000409924553344616*x_17 + 0.00110255436239589*x_18 + 0.000726911959105539*x_19 - 0.000880106354915311*x_2 + 0.00107621264699459*x_20 - 0.00432177492565913*x_21 + 0.00218523650181289*x_22 - 0.000208130714846171*x_23 + 0.00144778241934651*x_24 - 0.00051497604058463*x_25 + 0.00189487220823859*x_26 + 0.00190224327048241*x_27 + 0.00287511824026452*x_28 - 0.00311301807361513*x_29 - 0.00334731841544396*x_3 + 0.000942303972546977*x_30 + 0.000138149603067739*x_31 + 0.000199647345160311*x_32 + 0.000759634133244688*x_33 + 0.0024613205180983*x_34 + 0.00533794616250783*x_35 - 0.00204675147839819*x_36 + 0.00632178811960612*x_37 + 0.00387856358583922*x_38 + 0.00148183964224983*x_39 - 0.00473093787731734*x_4 - 0.00350223130185874*x_40 - 0.00432878170561333*x_41 + 0.000348709978615999*x_42 + 0.00198817654580146*x_43 - 0.00116812399739662*x_44 - 2.2773397627222e-5*x_45 - 0.000725661806840318*x_46 + 0.00334620202104744*x_47 - 0.00256904165718836*x_48 + 0.000661091203931116*x_49 + 0.00328299625407093*x_5 + 0.00249386691734932*x_50 + 0.000201796489215851*x_51 + 0.0011674063467058*x_52 + 0.0031767727271744*x_53 + 0.00116477493773877*x_54 - 0.00233835535312733*x_55 + 0.00339487134289643*x_56 - 0.00193305224788442*x_57 + 0.00313112860143297*x_58 - 0.000402208846768528*x_59 + 0.00230285528173156*x_6 + 0.000290759069016767*x_60 + 0.000836876443933362*x_61 + 0.00010440683184415*x_62 + 0.000182978956093606*x_63 + 0.000211780118624583*x_64 - 0.00160634349933677*x_65 - 0.000269908166247211*x_66 - 0.00311544840266265*x_67 - 0.00142401115629691*x_68 + 0.000719125376688922*x_69 - 0.00575165442447748*x_7 + 0.00150586913126023*x_70 - 0.000605815903115556*x_71 + 0.000748855417972312*x_72 - 0.00139569886252315*x_73 + 0.00112937468888896*x_74 - 0.000999792391565278*x_75 + 0.00323300227200269*x_76 - 0.000180467273441744*x_77 - 0.00138860859165863*x_78 + 0.00237115352227916*x_79 - 0.000104874307327605*x_8 - 0.00169056616987701*x_80 + 0.000217455926490712*x_81 + 0.000655025312397676*x_82 - 0.000969782292568084*x_83 + 0.00162607673983597*x_84 + 0.00073978825183029*x_85 + 0.00129369961491877*x_86 + 0.00218571747668905*x_87 + 0.000525901319013944*x_88 + 0.00131811734385471*x_89 - 0.00288721368866096*x_9 + 0.000582309304147497*x_90 + 0.000709304119856196*x_91 - 0.000677696127222538*x_92 + 0.00310813237473362*x_93 - 0.000222152501358667*x_94 - 4.59358258618204e-5*x_95 - 0.0016029604038919*x_96 + 0.000214880863777465*x_97 - 0.0020412217218993*x_98 + 0.00409612224371285*x_99 + 0.0101006430902534*std::sin(0.205040007829666*x_1 + 5.0) - 0.000110499893100431*std::sin(0.307839930057526*x_1 + 8.32415962219238) + 0.0171937375353046*std::sin(0.47751984000206*x_1 + 2.21951985359192) + 0.00810921705779179*std::sin(0.265039950609207*x_10 + 1.99079978466034) + 0.00886912260583474*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.000176052454508379*std::sin(0.267919957637787*x_107 + 8.17055988311768) - 0.00518396765713493*std::sin(0.237519979476929*x_108 - 4.22295999526978) + 0.00744133755162826*std::sin(0.25503996014595*x_108 + 5.14904022216797) - 0.00992150946742866*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.000214174099187588*std::sin(0.242559969425201*x_109 - 7.4312801361084) + 0.00425234785322405*std::sin(0.321519911289215*x_11 - 7.46135997772217) + 0.0117740082823541*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 6.25189351628252e-5*std::sin(0.206640005111694*x_116 - 0.982479810714722) - 0.00621820883684217*std::sin(0.264559954404831*x_116 - 7.45655965805054) - 0.00692576485516394*std::sin(0.222159996628761*x_118 - 4.2247200012207) + 0.0048790827831351*std::sin(0.265599936246872*x_119 + 8.16975975036621) + 0.00547779363265971*std::sin(0.317439913749695*x_12 + 8.15423965454102) - 0.00551794186618483*std::sin(0.287439942359924*x_120 - 1.23167991638184) - 0.0204932506538446*std::sin(0.280479967594147*x_13 + 5.16919994354248) + 0.00362276480668682*std::sin(0.304799944162369*x_13 + 5.14416027069092) - 0.000759641539364589*std::sin(0.367359846830368*x_13 - 4.36799955368042) - 0.00520030932496198*std::sin(0.318079918622971*x_15 + 1.9463198184967) - 0.0143485279872035*std::sin(0.383039832115173*x_15 + 1.8076798915863) + 0.00805678519832732*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 8.92278555240883e-5*std::sin(0.358639866113663*x_16 + 5.01695966720581) + 0.00543479783408303*std::sin(0.290319949388504*x_17 - 4.35184001922607) - 0.00468671676747079*std::sin(0.363919854164124*x_17 - 1.17343986034393) - 0.0152007375479614*std::sin(0.417999863624573*x_17 - 4.41599988937378) + 0.0111234414359386*std::sin(0.3435198366642*x_18 - 7.59256029129028) - 0.0247320857103018*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 7.78073738176211e-5*std::sin(0.402639865875244*x_2 - 7.39831972122192) - 0.0172501546273154*std::sin(0.417119860649109*x_2 - 0.990879774093628) - 0.00363926675868327*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.000105878279093887*std::sin(0.32247993350029*x_20 - 1.21759986877441) - 0.00720056553385422*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.000126116834390242*std::sin(0.310959935188293*x_22 - 7.38231992721558) + 0.00518065994631*std::sin(0.294319927692413*x_23 - 7.36359977722168) + 0.00751706830898259*std::sin(0.297039926052094*x_24 - 4.36775970458984) + 0.00718685463831138*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.000201327240649043*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.000104992179206729*std::sin(0.302479922771454*x_25 - 7.40503978729248) + 0.00736105157185863*std::sin(0.370959848165512*x_25 - 4.38535976409912) + 0.0156405273524249*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.000166359234048492*std::sin(0.263279944658279*x_28 + 5.00895977020264) - 0.00858180684603305*std::sin(0.303279936313629*x_28 - 1.16655993461609) + 0.00403891703999624*std::sin(0.377439826726913*x_29 - 1.18831992149353) + 0.00681916711544312*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.000104116936467871*std::sin(0.313919931650162*x_3 + 2.07631993293762) - 0.00459529623811321*std::sin(0.331919848918915*x_3 + 1.97167980670929) - 0.00114158847515978*std::sin(0.532399833202362*x_3 + 4.99351978302002) + 0.003066376259273*std::sin(0.309359908103943*x_30 - 7.39224004745483) + 0.00261946161516989*std::sin(0.394639849662781*x_31 - 7.40343999862671) + 0.00181783376432932*std::sin(0.477279841899872*x_31 - 1.14671981334686) - 0.0136215385533971*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 8.0227479309418e-5*std::sin(0.2483199685812*x_32 - 7.37487983703613) + 0.00520578030213067*std::sin(0.3018399477005*x_32 - 1.16751992702484) + 0.00420643464008879*std::sin(0.316399842500687*x_32 + 2.01391983032227) + 0.00562622240791692*std::sin(0.333439826965332*x_33 - 4.55327987670898) - 0.00906541252166817*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 8.67511634381668e-5*std::sin(0.240719974040985*x_35 + 1.94935977458954) + 0.00799386752355905*std::sin(0.250799983739853*x_35 - 1.22103989124298) - 0.00669375176367212*std::sin(0.251839965581894*x_35 - 1.2047199010849) - 0.0204383462468462*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 7.28977218237025e-5*std::sin(0.261919975280762*x_36 + 1.94783973693848) + 0.00940059444800734*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.000266124810823817*std::sin(0.238239988684654*x_38 + 1.96679985523224) - 0.00610850561813819*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.000138202054788046*std::sin(0.303679943084717*x_4 + 2.03975987434387) + 0.00303587769684334*std::sin(0.426239848136902*x_4 - 4.41856002807617) - 0.00764468465236824*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 6.31740110720645e-5*std::sin(0.256479978561401*x_41 + 1.97903978824615) + 0.0326113281844067*std::sin(0.256719976663589*x_42 - 7.44375991821289) - 0.00640477801057455*std::sin(0.212159991264343*x_44 + 1.99047982692719) + 0.0174675314686845*std::sin(0.199760004878044*x_45 + 2.01159977912903) - 0.0074867787582592*std::sin(0.208719998598099*x_45 + 1.98703980445862) + 0.0079650312180619*std::sin(0.23463998734951*x_45 + 8.18991947174072) + 0.0100549914444537*std::sin(0.1891999989748*x_47 - 1.16887986660004) + 0.00974081041527844*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.000116169641344273*std::sin(0.224879994988441*x_48 - 1.18455982208252) - 0.010537407338266*std::sin(0.226239994168282*x_48 - 1.20207989215851) + 0.0157119573040405*std::sin(0.228159993886948*x_48 + 4.98759984970093) - 0.00892437491497324*std::sin(0.240479975938797*x_49 + 1.96463978290558) + 0.00434437568460922*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.000113011417538518*std::sin(0.34895983338356*x_5 - 1.15559983253479) + 0.0282829561416154*std::sin(0.203359991312027*x_51 - 1.19439995288849) - 0.0028744911961615*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.000267732068225933*std::sin(0.225999996066093*x_53 + 5.17560005187988) - 0.00771058163818735*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.000188100917187762*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.000280672926180893*std::sin(0.188320010900497*x_57 - 4.20039987564087) - 0.00761139806842998*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.000124098091866429*std::sin(0.44599986076355*x_6 + 5.16472005844116) + 0.0726378403539908*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 9.40596939606478e-5*std::sin(0.405279844999313*x_7 + 1.97679972648621) - 0.00524020158738904*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.000116378427741401*std::sin(0.312239944934845*x_8 - 1.22175979614258) - 0.019859890568745*std::sin(0.386799842119217*x_8 - 4.39431953430176) + 0.00558082387497128*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.000112601737947001*std::sin(0.369359821081161*x_9 + 5.02807950973511) + 0.00579025744109272*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 9.29483182325851e-5*std::sin(0.358959853649139*x_91 + 1.99783980846405) + 0.00365532574545021*std::sin(0.282959938049316*x_92 + 1.98607981204987) + 0.00427240689623659*std::sin(0.284799933433533*x_92 + 2.00287985801697) - 0.0185829708143338*std::sin(0.319119840860367*x_92 + 8.22360038757324) + 0.00759280828084525*std::sin(0.240719974040985*x_93 + 1.95935988426208) - 0.00726864108745708*std::sin(0.247999966144562*x_93 - 1.21095979213715) + 0.00427889765104461*std::sin(0.275039941072464*x_94 + 5.18503999710083) + 0.0226430194417775*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.000211478778168331*std::sin(0.286959946155548*x_94 - 7.42695951461792) + 0.00442899375542356*std::sin(0.255679965019226*x_95 - 7.42280006408691) + 0.0178467871721657*std::sin(0.281039953231812*x_95 + 1.96631979942322) + 0.00303870487828148*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.000218411998085307*std::sin(0.275039941072464*x_96 + 1.98135983943939) - 0.00647132416401179*std::sin(0.279039949178696*x_96 + 1.97311985492706) + 0.00464946329508537*std::sin(0.259119987487793*x_97 - 1.18703985214233) + 0.0190147463663618*std::sin(0.268079966306686*x_97 - 1.19311988353729) + 0.00480819356735748*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.000142992717549592*std::sin(0.251599967479706*x_98 + 1.98239982128143) + 0.113884089036073);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00147385684100277*x_1 + 6.95245280580769e-5*x_10 - 0.00243678007570015*x_100 + 0.00273843044235426*x_101 + 0.00139525797299503*x_102 + 0.00412453767218968*x_103 + 0.00487737205227528*x_104 + 0.00215107845605854*x_105 - 0.000137604874025094*x_106 + 0.00472639184965594*x_107 + 0.00303441931951326*x_108 + 0.00185731136694612*x_109 + 0.000608420502725185*x_11 + 0.00140897928667014*x_110 + 0.00516387866452549*x_111 - 0.000920855361681718*x_112 - 0.000871140359480674*x_113 + 0.00745435720033107*x_114 + 0.0027513060611959*x_115 - 0.00502332253563096*x_116 - 0.00140710212930722*x_117 - 0.000756635471776294*x_118 + 0.00173149595074544*x_119 + 0.00566799427276043*x_12 - 0.00559650405193275*x_120 - 0.000701579761520023*x_13 + 0.00453835113905296*x_14 + 0.00115677290088699*x_15 - 0.000772546971932082*x_16 + 0.000986747378724746*x_17 - 0.00195408609128032*x_18 - 0.000889160366758173*x_19 + 0.0013623577096001*x_2 - 0.00230225710124425*x_20 + 0.00786948820543914*x_21 - 0.00452509206547733*x_22 + 0.000614228114216061*x_23 - 0.00183924414588295*x_24 - 0.000325217315483024*x_25 - 0.00511601906931947*x_26 + 0.00227824021592513*x_27 - 0.00518540703254447*x_28 + 0.00186107056552698*x_29 + 0.00373898908875763*x_3 - 0.00235680343981635*x_30 - 0.000354437479151401*x_31 + 4.62371868388112e-5*x_32 - 0.000710669840460091*x_33 - 0.00545182864490685*x_34 - 0.00765248282437862*x_35 + 0.0033451096958209*x_36 - 0.00722540298373334*x_37 - 0.00549772563623354*x_38 - 0.00580308820336163*x_39 + 0.00511362606765294*x_4 + 0.00795900297230915*x_40 + 0.0060097060640368*x_41 - 0.00349433175169123*x_42 + 0.000713510749078549*x_43 + 0.00333682005949766*x_44 + 0.00178612680998909*x_45 + 0.00108910030460514*x_46 - 0.00449814639027365*x_47 + 0.00704445517558537*x_48 - 0.00147975774573467*x_49 - 0.00554613979443916*x_5 - 0.00414645060429557*x_50 - 0.00300626121487881*x_51 - 0.00152063753167274*x_52 - 0.00574756768900123*x_53 - 0.00173347126462051*x_54 + 0.00615445055068059*x_55 - 0.00792417721034473*x_56 + 0.00473596609609718*x_57 - 0.00268765411722742*x_58 + 0.00299061599587382*x_59 - 0.00286915882013572*x_6 + 0.00400159688196062*x_60 - 0.00141862992852631*x_61 - 4.77458716137049e-5*x_62 - 0.00140397227248421*x_63 - 0.00127049003993475*x_64 + 0.00421317895825203*x_65 - 0.000920079861389505*x_66 + 0.00569204834289213*x_67 + 0.000654771042347754*x_68 - 0.000252011636146284*x_69 + 0.00656619791399757*x_7 - 0.00375281520205577*x_70 + 0.00252936463817424*x_71 - 0.000569004752074418*x_72 + 0.00248339948411459*x_73 + 0.000793053411571788*x_74 + 0.00090136962550682*x_75 - 0.00454041901680285*x_76 - 0.000148136976372414*x_77 + 0.00178940810109411*x_78 - 0.0023388528892226*x_79 - 0.000151729066018915*x_8 + 0.00114646610069084*x_80 - 0.0020050939755273*x_81 - 0.000229035609369415*x_82 + 0.000818070704398767*x_83 - 0.00191618964812191*x_84 - 0.000693744387788574*x_85 - 0.000744679659816626*x_86 - 0.00262987129790997*x_87 - 0.00122556115695786*x_88 + 0.000900016891930479*x_89 + 0.00542027391875578*x_9 - 0.00276182520825532*x_90 - 0.000724470194367736*x_91 + 0.00232583892695258*x_92 - 0.00151788521000827*x_93 + 0.000400864970184345*x_94 + 0.00106443555601575*x_95 + 0.00257600708163451*x_96 - 0.0017779674441334*x_97 + 9.79784506182813e-5*x_98 - 0.00734787126910294*x_99 - 0.0241346082891074*std::sin(0.205040007829666*x_1 + 5.0) - 0.00539703331607418*std::sin(0.307839930057526*x_1 + 8.32415962219238) - 0.019205581621054*std::sin(0.47751984000206*x_1 + 2.21951985359192) - 0.0122948643034845*std::sin(0.265039950609207*x_10 + 1.99079978466034) - 0.0261476188366986*std::sin(0.259839981794357*x_107 + 1.96935975551605) + 0.00859875005937579*std::sin(0.267919957637787*x_107 + 8.17055988311768) + 0.00785972041985053*std::sin(0.237519979476929*x_108 - 4.22295999526978) - 0.0177804289638619*std::sin(0.25503996014595*x_108 + 5.14904022216797) + 0.0237065840752377*std::sin(0.240079984068871*x_109 + 1.97479975223541) + 0.0104606865791717*std::sin(0.242559969425201*x_109 - 7.4312801361084) - 0.0125366144734552*std::sin(0.321519911289215*x_11 - 7.46135997772217) - 0.0347116952182613*std::sin(0.219039991497993*x_111 + 1.98207986354828) + 0.00305354843784851*std::sin(0.206640005111694*x_116 - 0.982479810714722) + 0.0183322930281487*std::sin(0.264559954404831*x_116 - 7.45655965805054) + 0.0204182834800699*std::sin(0.222159996628761*x_118 - 4.2247200012207) - 0.0116581440140896*std::sin(0.265599936246872*x_119 + 8.16975975036621) - 0.0130887115237622*std::sin(0.317439913749695*x_12 + 8.15423965454102) + 0.0162677918766332*std::sin(0.287439942359924*x_120 - 1.23167991638184) + 0.0228911717016133*std::sin(0.280479967594147*x_13 + 5.16919994354248) - 0.00865628146165459*std::sin(0.304799944162369*x_13 + 5.14416027069092) + 0.0011517375326393*std::sin(0.367359846830368*x_13 - 4.36799955368042) + 0.0153313593807555*std::sin(0.318079918622971*x_15 + 1.9463198184967) + 0.0160274533000386*std::sin(0.383039832115173*x_15 + 1.8076798915863) - 0.0192509875949126*std::sin(0.325119823217392*x_16 - 1.13359987735748) - 0.00435806493086533*std::sin(0.358639866113663*x_16 + 5.01695966720581) - 0.0160226697200724*std::sin(0.290319949388504*x_17 - 4.35184001922607) + 0.00710580889304866*std::sin(0.363919854164124*x_17 - 1.17343986034393) + 0.0169793801422258*std::sin(0.417999863624573*x_17 - 4.41599988937378) - 0.0124249984604147*std::sin(0.3435198366642*x_18 - 7.59256029129028) + 0.0276259940453774*std::sin(0.215680003166199*x_19 - 7.37871980667114) - 0.00380026601788902*std::sin(0.402639865875244*x_2 - 7.39831972122192) + 0.0192686000929373*std::sin(0.417119860649109*x_2 - 0.990879774093628) + 0.00869571144090258*std::sin(0.281359940767288*x_20 + 8.36528015136719) - 0.00517130454776953*std::sin(0.32247993350029*x_20 - 1.21759986877441) + 0.0172051251654769*std::sin(0.262799948453903*x_21 + 1.99535977840424) + 0.00615979561449268*std::sin(0.310959935188293*x_22 - 7.38231992721558) - 0.015273429810244*std::sin(0.294319927692413*x_23 - 7.36359977722168) - 0.0221615424262369*std::sin(0.297039926052094*x_24 - 4.36775970458984) - 0.0171723641729081*std::sin(0.297839939594269*x_24 - 1.1561598777771) - 0.009833220600753*std::sin(0.334879845380783*x_24 + 2.03159976005554) + 0.00512802567682966*std::sin(0.302479922771454*x_25 - 7.40503978729248) - 0.0217015796592571*std::sin(0.370959848165512*x_25 - 4.38535976409912) - 0.0174706298759378*std::sin(0.361759841442108*x_26 - 7.5729603767395) - 0.0081253140017091*std::sin(0.263279944658279*x_28 + 5.00895977020264) + 0.0130113856737018*std::sin(0.303279936313629*x_28 - 1.16655993461609) - 0.0119073856533895*std::sin(0.377439826726913*x_29 - 1.18831992149353) - 0.0162938068119634*std::sin(0.28655993938446*x_3 - 7.32575988769531) - 0.00508527709048514*std::sin(0.313919931650162*x_3 + 2.07631993293762) + 0.0135476822021665*std::sin(0.331919848918915*x_3 + 1.97167980670929) + 0.00173082990533902*std::sin(0.532399833202362*x_3 + 4.99351978302002) - 0.00732683941243148*std::sin(0.309359908103943*x_30 - 7.39224004745483) - 0.00397152090974736*std::sin(0.394639849662781*x_31 - 7.40343999862671) - 0.00535927018833792*std::sin(0.477279841899872*x_31 - 1.14671981334686) + 0.0152153986272287*std::sin(0.489679843187332*x_31 + 2.03039979934692) - 0.0039184687563819*std::sin(0.2483199685812*x_32 - 7.37487983703613) - 0.0153474887130502*std::sin(0.3018399477005*x_32 - 1.16751992702484) - 0.00637762471183024*std::sin(0.316399842500687*x_32 + 2.01391983032227) - 0.00628454828111563*std::sin(0.333439826965332*x_33 - 4.55327987670898) + 0.0267263134978057*std::sin(0.244719967246056*x_34 - 1.19687986373901) + 0.00423709839120337*std::sin(0.240719974040985*x_35 + 1.94935977458954) - 0.0235672242144423*std::sin(0.250799983739853*x_35 - 1.22103989124298) + 0.0101487935307492*std::sin(0.251839965581894*x_35 - 1.2047199010849) + 0.0228298429144432*std::sin(0.231999978423119*x_36 - 7.42991971969604) - 0.00356046890462462*std::sin(0.261919975280762*x_36 + 1.94783973693848) - 0.0142527980551815*std::sin(0.244319975376129*x_37 + 1.98031985759735) - 0.0129980620790707*std::sin(0.238239988684654*x_38 + 1.96679985523224) + 0.0180088700611527*std::sin(0.259759962558746*x_4 - 4.17920017242432) - 0.00675006167981605*std::sin(0.303679943084717*x_4 + 2.03975987434387) - 0.00460287399617688*std::sin(0.426239848136902*x_4 - 4.41856002807617) + 0.0225377762040839*std::sin(0.251679986715317*x_41 + 5.15888023376465) + 0.00308554364080774*std::sin(0.256479978561401*x_41 + 1.97903978824615) - 0.03642718890704*std::sin(0.256719976663589*x_42 - 7.44375991821289) + 0.0188823293573593*std::sin(0.212159991264343*x_44 + 1.99047982692719) - 0.0195114122599178*std::sin(0.199760004878044*x_45 + 2.01159977912903) + 0.0220722438944375*std::sin(0.208719998598099*x_45 + 1.98703980445862) - 0.0190317494382046*std::sin(0.23463998734951*x_45 + 8.18991947174072) - 0.0296437534331612*std::sin(0.1891999989748*x_47 - 1.16887986660004) - 0.0232748194041281*std::sin(0.208880007266998*x_47 - 1.20455992221832) - 0.0056739550334369*std::sin(0.224879994988441*x_48 - 1.18455982208252) + 0.0159763874133862*std::sin(0.226239994168282*x_48 - 1.20207989215851) - 0.0175504178663689*std::sin(0.228159993886948*x_48 + 4.98759984970093) + 0.026310511648469*std::sin(0.240479975938797*x_49 + 1.96463978290558) - 0.0128079275180899*std::sin(0.262319952249527*x_5 - 1.16559982299805) - 0.00551970113670425*std::sin(0.34895983338356*x_5 - 1.15559983253479) - 0.0315923528288792*std::sin(0.203359991312027*x_51 - 1.19439995288849) + 0.00435818636330722*std::sin(0.213519990444183*x_52 + 5.18127965927124) + 0.0130765637092835*std::sin(0.225999996066093*x_53 + 5.17560005187988) + 0.0116904695319954*std::sin(0.169600024819374*x_54 + 2.01831984519958) - 0.00918722080503533*std::sin(0.177920013666153*x_54 - 4.17063999176025) - 0.0137086208051037*std::sin(0.188320010900497*x_57 - 4.20039987564087) + 0.0224396419299426*std::sin(0.391919851303101*x_6 - 7.40383958816528) + 0.00606119623713679*std::sin(0.44599986076355*x_6 + 5.16472005844116) - 0.0811372145719423*std::sin(0.118000060319901*x_61 + 8.06375980377197) - 0.00459406147609545*std::sin(0.405279844999313*x_7 + 1.97679972648621) + 0.0154489682716046*std::sin(0.306159943342209*x_8 - 4.22975969314575) - 0.00568415257399212*std::sin(0.312239944934845*x_8 - 1.22175979614258) + 0.02218370197405*std::sin(0.386799842119217*x_8 - 4.39431953430176) - 0.0133348933280199*std::sin(0.309999912977219*x_9 + 1.95135986804962) - 0.00549969157522603*std::sin(0.369359821081161*x_9 + 5.02807950973511) - 0.0170706225705401*std::sin(0.345599830150604*x_91 + 5.19392013549805) + 0.00453977968755491*std::sin(0.358959853649139*x_91 + 1.99783980846405) - 0.00554205587358906*std::sin(0.282959938049316*x_92 + 1.98607981204987) - 0.01020854474027*std::sin(0.284799933433533*x_92 + 2.00287985801697) + 0.0207573694784816*std::sin(0.319119840860367*x_92 + 8.22360038757324) - 0.0223848362065782*std::sin(0.240719974040985*x_93 + 1.95935988426208) + 0.0173677857808049*std::sin(0.247999966144562*x_93 - 1.21095979213715) - 0.0126148876042321*std::sin(0.275039941072464*x_94 + 5.18503999710083) - 0.0252924855426711*std::sin(0.275359958410263*x_94 - 7.40887975692749) + 0.0103290417700204*std::sin(0.286959946155548*x_94 - 7.42695951461792) - 0.0130573953809982*std::sin(0.255679965019226*x_95 - 7.42280006408691) - 0.0199350447803923*std::sin(0.281039953231812*x_95 + 1.96631979942322) - 0.00460716045341382*std::sin(0.314479917287827*x_95 - 4.43727970123291) - 0.010667673942683*std::sin(0.275039941072464*x_96 + 1.98135983943939) + 0.0154626663287378*std::sin(0.279039949178696*x_96 + 1.97311985492706) - 0.0111094882156313*std::sin(0.259119987487793*x_97 - 1.18703985214233) - 0.0212396672098167*std::sin(0.268079966306686*x_97 - 1.19311988353729) - 0.0141753382245072*std::sin(0.282879948616028*x_97 - 1.22967994213104) + 0.00698404712364487*std::sin(0.251599967479706*x_98 + 1.98239982128143) - 0.0143616625450779);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
