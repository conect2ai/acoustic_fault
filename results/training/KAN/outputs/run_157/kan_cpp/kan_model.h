
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000153664640353193*x_1 - 0.000346405277474345*x_10 - 0.000340094652304775*x_100 - 0.00108835048440608*x_101 - 0.0010794379964994*x_102 - 0.000664294081264185*x_103 + 0.000294110498894241*x_104 + 0.00190826138214687*x_105 + 0.00183449631976003*x_106 - 0.00106988127942588*x_107 - 0.000188127598326673*x_108 + 0.000505627680153452*x_109 - 0.00127959664024004*x_11 + 0.00035116670525443*x_110 - 0.0034116109287237*x_111 - 0.000328620044478909*x_112 - 0.000460371808836885*x_113 + 0.00156790996304961*x_114 - 0.00344449666004181*x_115 - 0.000544112931375947*x_116 - 0.00112841738820596*x_117 + 1.17454035683871e-6*x_118 - 0.00150675402489904*x_119 - 2.56467368839118e-5*x_12 - 0.000614707806588483*x_120 - 0.00324815486261076*x_13 - 0.000503652399066402*x_14 - 0.000681371159217848*x_15 - 0.000429613465450621*x_16 - 0.00159537036823063*x_17 + 0.000212408812687807*x_18 - 0.00124384848635906*x_19 - 5.78289778340301e-5*x_2 - 7.47757243229226e-5*x_20 + 2.71686594459213e-5*x_21 - 0.000533814974207013*x_22 - 0.000892662127024436*x_23 + 0.000397220795024319*x_24 - 0.00164065374554576*x_25 + 0.000549085979259033*x_26 - 0.00131466321847459*x_27 - 0.00171168420974829*x_28 - 0.000725506719585928*x_29 - 0.00108956650847713*x_3 + 0.00011623394876204*x_30 + 0.000237524923169144*x_31 + 3.64970631095004e-5*x_32 - 0.000595614230076177*x_33 + 0.00338645346040568*x_34 - 0.00221994888532561*x_35 + 0.000306847037745472*x_36 + 0.0011801056926553*x_37 - 0.000396938791419436*x_38 - 0.000337698882539438*x_39 - 4.09503258814888e-5*x_4 - 0.000869117223741327*x_40 - 0.00110404265376162*x_41 + 3.69109618180028e-5*x_42 + 0.00152084492177205*x_43 - 0.000631464937755866*x_44 - 0.00192226992034018*x_45 + 0.00274820234410646*x_46 - 7.20520441602088e-5*x_47 + 0.000551919573140219*x_48 + 0.0030540581492191*x_49 - 0.000299430933630751*x_5 + 0.000576216867311485*x_50 + 0.00207164076844556*x_51 - 0.000569743211850042*x_52 + 9.73312082908876e-5*x_53 + 0.00211219654618828*x_54 - 0.00032013515269016*x_55 - 0.000180963226550791*x_56 + 4.29895063146353e-5*x_57 - 0.00331518236978026*x_58 + 0.00308685980496252*x_59 + 0.000140021401194988*x_6 - 0.000152901802341027*x_60 + 0.000382093636874408*x_61 - 0.000255039497205863*x_62 + 0.0016852331637463*x_63 - 0.000745834030611686*x_64 + 8.46037255926477e-5*x_65 - 0.000629044939595169*x_66 + 0.000289748596121134*x_67 - 0.000144304855662242*x_68 + 0.000361890072848339*x_69 - 0.000629999994106168*x_7 + 0.000154592286976449*x_70 - 0.000288832894240975*x_71 + 0.000283238682393115*x_72 - 0.000778397825521473*x_73 - 2.91038192848731e-5*x_74 + 7.47528147846395e-5*x_75 - 0.000393945356301638*x_76 - 0.000615936605276078*x_77 + 8.230732419726e-5*x_78 - 0.000374031070762872*x_79 - 0.00148656774607812*x_8 - 0.000572175245830822*x_80 - 0.000202632200873744*x_81 - 0.000685482910379547*x_82 + 0.000567554600807999*x_83 + 0.00054822593285167*x_84 + 0.000525163480787149*x_85 - 0.000278230144238843*x_86 + 0.000159675447594799*x_87 - 0.000607794640608534*x_88 + 6.98262285818467e-5*x_89 - 0.00158623997537439*x_9 + 0.00109380737889648*x_90 - 0.000130141714041173*x_91 + 0.00073963918475585*x_92 - 0.00113396429184542*x_93 - 0.000369222424195249*x_94 + 2.59511373296371e-5*x_95 + 0.000544035429812712*x_96 + 0.00142314594741405*x_97 - 0.00089544818715689*x_98 + 0.00110752697791172*x_99 - 5.64076061701625e-7*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) + 0.00371815006090157*std::sin(0.413039863109589*x_1 - 0.994799792766571) - 0.00152992818745363*std::sin(0.453919857740402*x_1 - 0.967119812965393) - 0.00194868088729518*std::sin(0.189440011978149*x_10 - 7.40327978134155) + 0.000439768879728356*std::sin(0.285999923944473*x_10 + 4.99871969223022) + 5.89422539659129e-5*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.00169546782652436*std::sin(0.25655996799469*x_100 + 1.94487977027893) - 0.000676652563948478*std::sin(0.261679977178574*x_100 - 1.21367979049683) - 0.00681855058546193*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.00418271523674076*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.0013482622858758*std::sin(0.236559987068176*x_101 + 1.95871984958649) + 8.34673269328025e-5*std::sin(0.244959965348244*x_101 - 1.20255982875824) - 0.00124191280180362*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.00614959455503894*std::sin(0.23455998301506*x_102 - 1.19255983829498) - 0.0058234103067408*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 0.000974556317734469*std::sin(0.243999972939491*x_103 - 1.20647990703583) + 0.000911008559033398*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.00180394330393771*std::sin(0.235199987888336*x_104 - 1.21823990345001) + 0.00151053071229031*std::sin(0.237759977579117*x_104 - 4.42519998550415) - 0.000997640369894257*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.000641599192946696*std::sin(0.253119975328445*x_107 - 7.42199993133545) - 0.000478597418195481*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 0.00249196152932695*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.000751227449717411*std::sin(0.273199945688248*x_108 - 1.22711992263794) + 9.20475114227652e-5*std::sin(0.274479955434799*x_108 - 1.23687982559204) - 0.0061045098139149*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.000568269143119685*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.00565772978219131*std::sin(0.226879999041557*x_109 + 1.95823979377747) - 0.000128465580482971*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.000683646284066635*std::sin(0.235839992761612*x_109 - 7.43439960479736) + 0.000379518013971059*std::sin(0.237119987607002*x_109 - 1.21911990642548) - 0.00935426741945785*std::sin(0.239999979734421*x_109 - 4.40607976913452) + 0.000414846930765396*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.00758452817202397*std::sin(0.284879922866821*x_11 + 5.14423990249634) - 0.00837855742796126*std::sin(0.293839931488037*x_11 - 7.45207977294922) + 0.000832207734794288*std::sin(0.311919927597046*x_11 + 5.12680006027222) - 0.000877969896987712*std::sin(0.313519924879074*x_11 + 1.93895983695984) - 0.000409733138082307*std::sin(0.256239980459213*x_110 - 7.63824033737183) + 0.00627496544079615*std::sin(0.26759997010231*x_112 + 5.15015983581543) + 0.000699241495399548*std::sin(0.278399974107742*x_112 + 1.96039986610413) + 0.00017073842624407*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.00592657696714677*std::sin(0.264399945735931*x_113 + 5.19080018997192) - 0.0124695729614159*std::sin(0.273839950561523*x_113 - 7.41279983520508) + 0.000165902875646278*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.00145103218848614*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.00172171716815679*std::sin(0.251599967479706*x_116 + 5.15064001083374) + 0.000805506054455587*std::sin(0.272719949483871*x_116 + 1.93367981910706) - 0.00080878197917709*std::sin(0.275199949741364*x_116 - 1.24471986293793) + 0.00295928690365386*std::sin(0.235359981656075*x_118 + 1.94599986076355) + 0.00112749049688745*std::sin(0.240879982709885*x_118 - 7.44632005691528) + 0.000289257683109234*std::sin(0.253039985895157*x_119 - 7.62432050704956) - 0.000563111004350733*std::sin(0.262319952249527*x_119 - 1.23623991012573) + 0.000123986786883561*std::sin(0.317199915647507*x_119 - 4.64807987213135) + 0.00132786273419228*std::sin(0.257279962301254*x_12 + 8.36040019989014) - 0.000166922855104234*std::sin(0.273439943790436*x_12 - 7.43800020217896) + 0.00431029269323461*std::sin(0.263919949531555*x_120 + 5.15799999237061) + 0.000490062450137461*std::sin(0.255679965019226*x_13 - 1.02263987064362) + 0.00156967183298921*std::sin(0.263759940862656*x_13 - 4.21655988693237) + 0.0009382252893976*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.000671049647072933*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.00490232463289446*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.000732887767340922*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.00408529115704666*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.00141174311334797*std::sin(0.344719856977463*x_15 + 1.83199989795685) - 0.000589305219312043*std::sin(0.346479833126068*x_15 + 5.05615997314453) + 0.00483540333365141*std::sin(0.256879955530167*x_16 - 4.20351982116699) - 0.00524923988434916*std::sin(0.328159838914871*x_16 + 8.24831962585449) + 0.000319422415775059*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00129132837477277*std::sin(0.358399868011475*x_16 + 5.03200006484985) + 0.00742319549228175*std::sin(0.363199830055237*x_16 - 7.58160018920898) - 0.000676806366279959*std::sin(0.392959833145142*x_16 + 1.80143988132477) + 0.00927799690659624*std::sin(0.263119965791702*x_17 - 4.18071985244751) - 0.000805968703795182*std::sin(0.349279850721359*x_17 - 1.16287982463837) - 0.00381017493823407*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.00110250144394785*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.000491685861525072*std::sin(0.402239859104156*x_17 - 1.21327984333038) - 0.000664364934943579*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.000577417396363468*std::sin(0.362639844417572*x_18 + 8.20135974884033) + 0.00486265075790538*std::sin(0.389039844274521*x_18 + 5.00959968566895) + 0.000913097399272666*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.000312772476571119*std::sin(0.238639980554581*x_20 - 1.20031988620758) + 0.000820763029162815*std::sin(0.274079948663712*x_20 + 1.98231983184814) + 0.00601584662573472*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 0.000803595138189489*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.00142691969077013*std::sin(0.32551982998848*x_21 + 8.24944019317627) + 0.00602453728718619*std::sin(0.380319833755493*x_21 - 1.37543988227844) - 0.00477788509340999*std::sin(0.369199842214584*x_22 - 1.16735982894897) - 0.00158397289871422*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.00515147239661266*std::sin(0.275199949741364*x_24 + 5.02551984786987) + 0.00852401575118602*std::sin(0.290399938821793*x_24 - 1.37751984596252) - 0.00118075317418017*std::sin(0.298399955034256*x_24 - 1.16463983058929) + 0.00162325877603827*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.00544181486342115*std::sin(0.228399991989136*x_26 - 1.19703996181488) - 0.000381787722839677*std::sin(0.251279979944229*x_26 + 1.98895990848541) - 0.000639233549886198*std::sin(0.271199941635132*x_26 - 1.17551982402802) + 0.000858106712123113*std::sin(0.344799846410751*x_27 + 8.2139196395874) + 0.000624314138672967*std::sin(0.357039839029312*x_27 - 1.14823985099792) - 0.00240733805353511*std::sin(0.242239981889725*x_28 - 1.16359984874725) + 0.000493685928419927*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.00551195005628457*std::sin(0.308959931135178*x_28 - 1.17487978935242) - 0.00100608256888366*std::sin(0.207440003752708*x_29 - 4.39679956436157) - 0.000889748424590095*std::sin(0.225359991192818*x_29 + 1.78623986244202) - 0.000731533053656878*std::sin(0.268239974975586*x_29 + 8.22647953033447) - 0.00504691946030137*std::sin(0.304799944162369*x_29 - 7.40287971496582) + 0.00124100373723105*std::sin(0.329999834299088*x_29 - 4.36855983734131) - 0.00186986406130756*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.000683536602209886*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 0.000117558667952441*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.000895987928310541*std::sin(0.360879838466644*x_3 + 1.97023975849152) + 0.00280954825036634*std::sin(0.396319836378098*x_3 - 1.1827198266983) + 0.000981047518448022*std::sin(0.170480027794838*x_30 - 1.41063988208771) - 0.00972378926450439*std::sin(0.34911984205246*x_30 - 7.36520004272461) - 0.00157330408367949*std::sin(0.272159963846207*x_31 - 1.09007978439331) - 0.00113625123466466*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.00800501384255618*std::sin(0.3572798371315*x_31 - 1.02039980888367) - 0.000471247113692683*std::sin(0.392399847507477*x_31 - 4.40167999267578) + 0.00189664377779624*std::sin(0.413359850645065*x_31 - 7.38687992095947) + 0.000285137657154394*std::sin(0.428559869527817*x_31 - 7.39463949203491) + 4.76217318609928e-6*std::sin(1.1684798002243*x_31 + 4.6057596206665) - 0.00179979344153914*std::sin(0.272559970617294*x_32 + 2.01647973060608) - 0.00157999120139035*std::sin(0.29911994934082*x_32 - 7.36168003082275) - 0.000395544452065925*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.00141726244737563*std::sin(0.303839921951294*x_32 - 1.13263988494873) + 0.000844026523608112*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.00121992170665535*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.00169854283907213*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.000726258131620265*std::sin(0.239439979195595*x_35 + 1.96807980537415) + 0.000219283320013984*std::sin(0.246559977531433*x_35 + 1.94663977622986) + 5.84439275440509e-5*std::sin(0.206800013780594*x_37 - 4.39247989654541) - 0.000681208144088352*std::sin(0.229039996862411*x_37 + 8.19023990631104) + 0.000671440583831912*std::sin(0.225599989295006*x_38 - 7.41167974472046) - 0.0002302422481995*std::sin(0.237679988145828*x_38 - 7.59832000732422) - 0.00523886310703202*std::sin(0.255519956350327*x_4 - 0.956879794597626) - 0.00149346099841287*std::sin(0.324879825115204*x_4 - 7.35623979568481) - 0.000455844218279288*std::sin(0.32551982998848*x_4 - 1.15559983253479) - 0.00047192504405087*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.000671267672074506*std::sin(0.329039841890335*x_4 - 1.40119981765747) + 0.00180941508878953*std::sin(0.345839858055115*x_4 + 2.01703977584839) - 0.00226545656384484*std::sin(0.379119843244553*x_4 - 4.38655996322632) - 0.00110972273540027*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.00686821343070308*std::sin(0.242559969425201*x_41 - 1.21039986610413) + 0.00155017033574273*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.00419443873929123*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.000706296855459357*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.000919114592532595*std::sin(0.259839981794357*x_42 + 8.18391990661621) - 0.0141086446847822*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.00104231405730418*std::sin(0.129440054297447*x_44 + 1.7668799161911) + 0.000928699733169466*std::sin(0.256959974765778*x_44 - 1.23063993453979) - 0.00220692541912076*std::sin(0.282799929380417*x_44 - 1.26543986797333) + 0.00111782896410853*std::sin(0.288799941539764*x_44 - 4.44839954376221) + 0.00199199929252794*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.000954814386442851*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.00765736717768853*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.000924239150557569*std::sin(0.225519984960556*x_47 + 8.19655990600586) - 0.000919891321519064*std::sin(0.231999978423119*x_47 - 4.4127197265625) + 0.00204305946476238*std::sin(0.230159983038902*x_48 + 1.98047983646393) + 0.000885334993908818*std::sin(0.240479975938797*x_48 - 7.42575979232788) - 0.000705995528601711*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.00801715257991169*std::sin(0.256079971790314*x_48 - 1.22367990016937) + 0.00401433663049687*std::sin(0.26639997959137*x_48 - 7.80967998504639) - 0.00502177560951748*std::sin(0.242799982428551*x_49 - 1.21991980075836) + 0.000707511467121002*std::sin(0.260079979896545*x_49 + 1.94671976566315) + 0.000991288695757456*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.00135064477364646*std::sin(0.39183983206749*x_5 + 2.01263976097107) - 0.00769733396235768*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.00106507841348643*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.000468635422092282*std::sin(0.234079986810684*x_52 + 5.17903995513916) - 0.00092788012288339*std::sin(0.25519996881485*x_52 + 1.95015978813171) + 0.00603388013702929*std::sin(0.216879993677139*x_53 - 4.38775968551636) + 0.000128854352741973*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.000970344767065748*std::sin(0.247599974274635*x_53 + 4.9792799949646) + 0.0127322307608842*std::sin(0.267279952764511*x_53 - 1.21335983276367) + 0.012111290710885*std::sin(0.174000009894371*x_55 + 8.2183198928833) - 0.00108518531192023*std::sin(0.220479995012283*x_56 + 8.19176006317139) - 0.000914018520364408*std::sin(0.239279985427856*x_56 - 1.22927987575531) - 0.00010705158215246*std::sin(0.252159982919693*x_56 + 8.16687965393066) - 0.00148704972519395*std::sin(0.247519969940186*x_58 - 1.23071992397308) + 0.00555323198524669*std::sin(0.238879978656769*x_6 + 5.02663946151733) - 0.0016499595929525*std::sin(0.282239943742752*x_6 - 0.996719837188721) - 0.000146207197623454*std::sin(0.387039840221405*x_6 - 1.1794399023056) + 0.000256190086750109*std::sin(0.45159986615181*x_6 - 4.24871969223022) - 0.000961604102923396*std::sin(0.512639820575714*x_6 + 1.91543984413147) + 0.00454876123308823*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.00542324896140313*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.000712380875971715*std::sin(0.348239839076996*x_7 - 7.34895992279053) - 0.00237486438100836*std::sin(0.375999838113785*x_7 + 8.22087955474854) - 0.00022633521440161*std::sin(0.789839863777161*x_7 + 1.21335983276367) + 0.00161781336217904*std::sin(0.285839945077896*x_8 + 1.97279977798462) - 0.00104891980965891*std::sin(0.319279909133911*x_8 - 7.41967964172363) + 0.00302000717792859*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 0.00908608697279868*std::sin(0.345519840717316*x_8 + 5.03679990768433) + 0.00335995717405776*std::sin(0.388639837503433*x_8 + 1.80719995498657) - 0.00347694638978483*std::sin(0.295839935541153*x_9 - 1.21183979511261) - 0.00083194792313467*std::sin(0.341519832611084*x_9 + 5.04423999786377) - 0.00180898667640267*std::sin(0.327279835939407*x_91 + 4.99647998809814) + 0.000195447246501871*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 0.00286871576511947*std::sin(0.367839843034744*x_91 - 1.18095993995667) + 0.000216108374806736*std::sin(0.382879853248596*x_91 - 1.17583978176117) + 0.000190571363288437*std::sin(0.38663986325264*x_91 - 4.39359998703003) + 0.000791896054832818*std::sin(0.291999936103821*x_92 + 1.99447977542877) + 0.00981927698584317*std::sin(0.292239934206009*x_92 - 7.38303995132446) - 0.000419699861346384*std::sin(0.329999834299088*x_92 + 1.7940798997879) - 0.00278885258461617*std::sin(0.230159983038902*x_93 - 7.42727994918823) - 0.000338932681666259*std::sin(0.255759954452515*x_94 + 1.99439978599548) - 0.00100434280923834*std::sin(0.279119968414307*x_94 + 1.99335980415344) - 4.64613615482793e-5*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 0.00304421290067593*std::sin(0.301119923591614*x_94 - 4.40064001083374) - 0.000396011280864698*std::sin(0.336239844560623*x_94 - 7.57615995407104) - 0.000743144842320341*std::sin(0.268159955739975*x_95 - 1.18831992149353) - 0.00468455757131384*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.00654703469389123*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.0010551087112594*std::sin(0.284079939126968*x_95 - 1.20591986179352) - 0.00146280013462337*std::sin(0.292079925537109*x_96 - 1.20975983142853) - 9.95907254186833e-5*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.00322380225301783*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.0012974055218957*std::sin(0.286399960517883*x_97 + 1.94071984291077) - 0.0102602375414808*std::sin(0.265119940042496*x_98 - 1.19839990139008) - 0.00050525419211151*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 0.000965311747028332*std::sin(0.252639979124069*x_99 - 1.21063983440399) + 0.00149924771673568*std::sin(0.263999968767166*x_99 - 1.22975981235504) - 0.000119725930656126*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.411103516817093*std::sin(0.000553393036313852*x_1 + 0.000263045839030821*x_100 - 0.00880401002933414*x_101 - 0.00268053040383773*x_103 - 8.34653048975421e-5*x_104 + 0.0111832962320982*x_105 + 0.0157363481044187*x_106 - 0.000272772129600776*x_107 - 0.00587119135983511*x_108 + 0.00499100276266758*x_109 + 0.00461605472063207*x_11 + 0.013623884255334*x_110 + 0.0110316723313827*x_111 - 0.00713645940024816*x_112 + 0.00643837517022567*x_113 - 0.00618671933471476*x_114 + 0.0222998012484751*x_115 + 0.0273744694964503*x_117 + 0.0179569108528556*x_118 + 0.0282949594559188*x_119 + 0.00618666955094292*x_12 + 0.0139176030343005*x_120 - 0.00373271926772224*x_13 + 0.000244150427738046*x_14 - 0.000159727632625133*x_15 + 0.000455172814611276*x_17 - 0.00149288614231813*x_18 + 0.00253926412080377*x_19 - 0.00069022052089122*x_2 + 0.0139498055528763*x_22 - 0.000633673482745767*x_23 + 0.0118261186993522*x_24 - 0.00433445516423153*x_26 - 8.8162811773973e-5*x_27 + 0.00838798582320475*x_28 - 0.000450876012448027*x_29 + 0.000214115062143755*x_3 - 0.0118279505193444*x_30 + 0.00586968253966387*x_31 - 2.41092204253246e-5*x_32 + 0.0108036289729784*x_33 - 0.00170434785458558*x_35 - 0.000271429758691447*x_36 + 0.0130802791362849*x_37 - 0.00263816662240722*x_38 - 5.47647526650617e-5*x_39 + 0.000178666916071491*x_4 - 0.0102585245453578*x_40 + 0.0158245957847247*x_41 + 0.00386475501727706*x_43 - 0.00233843284158306*x_44 - 0.0152584802298237*x_45 + 0.00551717338631453*x_46 - 0.0128698402113045*x_47 + 0.00072935755205578*x_48 - 0.0222084468466528*x_49 - 0.00620093528539698*x_5 - 0.0227720862668986*x_50 + 0.0164254354723653*x_53 + 0.0261506458057286*x_54 - 0.00364847275010641*x_55 - 0.0126152650837198*x_56 - 0.00800465647457801*x_57 + 0.0183553206429746*x_58 + 0.0125453464263468*x_59 + 0.0122193488096488*x_6 + 0.00023968849177715*x_60 - 0.00104392970333484*x_61 + 6.3101237162239e-5*x_62 - 0.000157876726707276*x_63 - 0.000225445532527241*x_64 - 0.000210036357235149*x_65 + 0.000137271613237476*x_66 + 1.85086662112827e-5*x_67 - 0.000468840829671724*x_68 + 0.00833489953080132*x_69 - 0.00174878049237297*x_7 - 0.000445688044355651*x_70 + 0.000342573603459942*x_71 + 2.65864301207711e-6*x_72 + 0.0040371425047577*x_73 - 0.000510124431184435*x_74 - 7.57084891405061e-5*x_75 - 0.00528489033012565*x_76 + 3.2172604883119e-5*x_77 + 0.00462563749579858*x_78 + 0.000189399588946931*x_79 - 0.000311584448123776*x_80 + 0.000110744499475505*x_81 + 0.0051770873611675*x_82 - 0.000225223917198551*x_83 + 0.000157350155202397*x_84 + 0.0008127496634237*x_85 - 0.000869853792860858*x_86 - 0.00450194173090174*x_87 - 0.000107868126124476*x_88 - 0.00196887648314102*x_89 + 0.000160265933530381*x_9 - 0.00265888772515006*x_90 + 0.0006489820702785*x_92 + 0.00132739704515536*x_93 - 0.00088437724715386*x_94 - 0.000325806666403405*x_95 - 0.00942527577139371*x_96 - 0.00668366390972767*x_98 - 0.0852047724965579*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 0.0798106120313875*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.061800829751514*std::sin(0.317599922418594*x_116 - 1.45887994766235) + 0.0951915707510453*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 0.0775712077446848*std::sin(0.277279943227768*x_20 + 1.99079978466034) + 0.0671387024585752*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.0630186534849311*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 0.117113405389806*std::sin(0.247039973735809*x_34 - 1.20383989810944) - 0.126595874958258*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.0465716330588035*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.141941271142863*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.0571748234016076*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.0432504426491642*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.109632243506911*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.0704063251906901*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 4.57872621232281) - 0.295935760006432);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00405345214126801*x_1 + 0.00504970373616063*x_10 - 0.00331061583304459*x_100 - 0.00578003926184324*x_101 - 0.00361992114816099*x_102 + 0.000292118763276583*x_103 + 0.00519638435300648*x_104 + 0.00691979599757538*x_105 + 0.0104641899836922*x_106 - 0.00211308025281149*x_107 - 0.00250128003219306*x_108 + 0.0015831894540414*x_109 + 0.00323848014838362*x_11 + 0.00505400384721862*x_110 + 0.00033515473839451*x_111 - 0.00147685169393978*x_112 + 0.00366615270773618*x_113 + 0.00163669329560171*x_114 + 0.00806777166651595*x_115 + 0.00107826813023649*x_116 + 0.0122833191084032*x_117 + 0.00203663053471102*x_118 + 0.00517875072160975*x_119 + 0.00435707994781884*x_12 + 0.00402177086490836*x_120 - 0.00337627446175177*x_13 + 0.00166727594491839*x_14 + 0.00184386427440961*x_15 + 0.00314069757506381*x_16 + 0.00275757496426856*x_17 + 0.000561632247025396*x_18 + 0.000946686525352613*x_19 + 0.00104721520556035*x_2 - 0.00100073820947306*x_20 + 0.000387442899325127*x_21 + 0.00652502896486257*x_22 - 0.000741545466545579*x_23 + 0.00265082857236626*x_24 - 0.00577005264805952*x_25 + 0.000591532544542922*x_26 + 0.00247470466328325*x_27 - 0.00354921289471196*x_28 - 0.000719508826131846*x_29 - 0.0028644055839194*x_3 - 0.00442672589213357*x_30 + 0.00244360821504222*x_31 + 0.00117530029134127*x_32 + 0.00288947645253576*x_33 + 0.00338490369044155*x_34 - 0.00323510092313138*x_35 - 0.00265482929736634*x_36 + 0.00281342632600744*x_37 - 0.00208255360254802*x_38 + 0.00839400359977727*x_39 - 0.000270315872711739*x_4 - 0.000366619384502644*x_40 + 0.00385453665026882*x_41 + 0.000389480375102721*x_42 + 0.00453695205329496*x_43 - 0.0019117328791355*x_44 - 0.00834948712009621*x_45 + 0.0117573113133066*x_46 - 0.0101311702390267*x_47 + 0.000578492387880896*x_48 - 0.00256444004217718*x_49 - 0.00256090476641524*x_5 - 0.00411480160355746*x_50 + 0.00597994793337635*x_51 - 0.00097049765483709*x_52 + 0.00576041758424472*x_53 + 0.0056430197549355*x_54 - 0.00353967785709778*x_55 - 0.00368573752775416*x_56 - 0.00562930629640998*x_57 + 0.00476508580190165*x_58 + 0.00636648011101875*x_59 + 0.00440830738202648*x_6 + 0.00292151443150151*x_60 + 0.00021846315193768*x_61 - 0.000645900797151519*x_62 + 0.00137692341204591*x_63 - 0.00175484719555471*x_64 - 0.00119856492566245*x_65 + 0.00174616645532396*x_66 - 2.68789448897822e-5*x_67 + 3.94725284093822e-5*x_68 + 0.00356695318097896*x_69 - 0.00190860987069629*x_7 - 0.00129630909326022*x_70 - 0.000624009240537465*x_71 - 0.000466107977860434*x_72 - 0.0003228477869681*x_73 - 0.000705400925150531*x_74 - 2.00252268601479e-5*x_75 - 0.00299998727411088*x_76 - 0.000116980669336784*x_77 + 0.00190165802450429*x_78 - 0.000769855870897791*x_79 + 0.00246507823539912*x_8 - 0.00097684102821848*x_80 - 0.000492833370483218*x_81 + 0.000737188710909221*x_82 + 0.000121896104411368*x_83 + 0.00143458061263387*x_84 + 0.00133582640092748*x_85 - 0.0001542498110381*x_86 - 0.000983623020425271*x_87 - 0.000777337802214033*x_88 - 0.00131503512421707*x_89 - 0.00338633392923267*x_9 - 2.16825862443663e-5*x_90 + 0.000743894262900421*x_91 + 0.000244496141267747*x_92 - 0.00149556646712255*x_93 - 0.000712527930559909*x_94 - 0.000495865058916341*x_95 - 0.00861983923690557*x_96 + 0.00466883345965268*x_97 - 0.00249564689376854*x_98 - 0.00132939611811918*x_99 - 1.96513689663308e-7*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) + 0.00139919369722067*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.000337747070915014*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.000430190950940936*std::sin(0.189440011978149*x_10 - 7.40327978134155) - 0.0306857437883882*std::sin(0.204960003495216*x_10 - 1.20431983470917) - 0.000438217555507902*std::sin(0.285999923944473*x_10 + 4.99871969223022) + 0.00371140286614863*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.000928936637887113*std::sin(0.25655996799469*x_100 + 1.94487977027893) - 0.00409613395084166*std::sin(0.261679977178574*x_100 - 1.21367979049683) - 0.0025659193004828*std::sin(0.264479964971542*x_100 - 1.2105598449707) + 0.00200016976973892*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.000738704807745562*std::sin(0.236559987068176*x_101 + 1.95871984958649) + 0.00525566729408274*std::sin(0.244959965348244*x_101 - 1.20255982875824) - 0.000338531050303191*std::sin(0.246719971299171*x_101 - 1.207279920578) + 0.00294072927009118*std::sin(0.23455998301506*x_102 - 1.19255983829498) - 0.00219143360651396*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 0.028743084696207*std::sin(0.249999970197678*x_102 - 4.40383958816528) + 0.00589950209718461*std::sin(0.243999972939491*x_103 - 1.20647990703583) + 0.00551481408182201*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.000988369700375903*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.00156369150649034*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.00022023916908098*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.000223521317870867*std::sin(0.253119975328445*x_107 - 7.42199993133545) + 0.000476909122818256*std::sin(0.263919949531555*x_108 + 1.94823980331421) - 0.00119165322911057*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.00454757496762546*std::sin(0.273199945688248*x_108 - 1.22711992263794) + 0.00579593372716737*std::sin(0.274479955434799*x_108 - 1.23687982559204) - 0.0022972154206655*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.000197974481844483*std::sin(0.281999945640564*x_108 + 8.15032005310059) - 0.00270552008329129*std::sin(0.226879999041557*x_109 + 1.95823979377747) + 0.000772665464164664*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.000513486505687873*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 0.00037817923009091*std::sin(0.237119987607002*x_109 - 1.21911990642548) - 0.0244207234118307*std::sin(0.239999979734421*x_109 - 4.40607976913452) + 0.00251128671942782*std::sin(0.261519968509674*x_109 + 4.95928001403809) - 0.00362691292827204*std::sin(0.284879922866821*x_11 + 5.14423990249634) - 0.0218734855829298*std::sin(0.293839931488037*x_11 - 7.45207977294922) + 0.00503779123624731*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.0264200227050969*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.0123297607905533*std::sin(0.256239980459213*x_110 - 7.63824033737183) + 0.00236136034082244*std::sin(0.26759997010231*x_112 + 5.15015983581543) + 0.00423287663676312*std::sin(0.278399974107742*x_112 + 1.96039986610413) - 0.00102691853233097*std::sin(0.241599977016449*x_113 - 4.2131199836731) + 0.00283408250783883*std::sin(0.264399945735931*x_113 + 5.19080018997192) - 0.0325536975478117*std::sin(0.273839950561523*x_113 - 7.41279983520508) + 0.0104463668547861*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.000795011820071791*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.000943318494494071*std::sin(0.251599967479706*x_116 + 5.15064001083374) + 0.00487615191762618*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.0243380078595463*std::sin(0.275199949741364*x_116 - 1.24471986293793) - 0.0222570211984472*std::sin(0.317599922418594*x_116 - 1.45887994766235) + 0.00772566399160866*std::sin(0.235359981656075*x_118 + 1.94599986076355) + 0.00682529314099174*std::sin(0.240879982709885*x_118 - 7.44632005691528) + 0.00175102893191098*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.0169452341947944*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 2.73713331419721e-5*std::sin(0.317199915647507*x_119 - 4.64807987213135) + 0.000361960006702354*std::sin(0.257279962301254*x_12 + 8.36040019989014) + 0.00100396950555873*std::sin(0.273439943790436*x_12 - 7.43800020217896) + 0.00162202554247846*std::sin(0.263919949531555*x_120 + 5.15799999237061) - 0.000488333710830345*std::sin(0.255679965019226*x_13 - 1.02263987064362) + 0.000427874367251426*std::sin(0.263759940862656*x_13 - 4.21655988693237) + 0.00567957126921102*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.000233781312569363*std::sin(0.331999838352203*x_14 - 7.53599977493286) + 0.00234428618186366*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.00055047176805337*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.00153735420696415*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.000773485571803571*std::sin(0.344719856977463*x_15 + 1.83199989795685) - 0.00356737452104896*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.0050055778818436*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.0342824006835862*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 0.00197536496404875*std::sin(0.328159838914871*x_16 + 8.24831962585449) + 0.0019336319281511*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00070751105984046*std::sin(0.358399868011475*x_16 + 5.03200006484985) + 0.019379369417201*std::sin(0.363199830055237*x_16 - 7.58160018920898) - 0.000184489579055704*std::sin(0.392959833145142*x_16 + 1.80143988132477) + 0.0242216077552484*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.00017792571650638*std::sin(0.349279850721359*x_17 - 1.16287982463837) - 0.00143382399084575*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.000604053918679235*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.000369305093606026*std::sin(0.402239859104156*x_17 - 1.21327984333038) + 0.000146665256994384*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.000201161564440201*std::sin(0.362639844417572*x_18 + 8.20135974884033) + 0.0126946818903343*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.00020157545602042*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.000234923307290576*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 0.0246985436976653*std::sin(0.274079948663712*x_20 + 1.98231983184814) - 0.0279365830864157*std::sin(0.277279943227768*x_20 + 1.99079978466034) - 0.00622756505145596*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 0.0241794087533289*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.0048645841361504*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.000781800727411137*std::sin(0.32551982998848*x_21 + 8.24944019317627) + 0.0157279616005634*std::sin(0.380319833755493*x_21 - 1.37543988227844) - 0.0017979873322065*std::sin(0.369199842214584*x_22 - 1.16735982894897) - 0.000431772672183393*std::sin(0.349599838256836*x_23 - 1.15639984607697) - 0.00246342836510621*std::sin(0.275199949741364*x_24 + 5.02551984786987) + 0.0222532264348999*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.000260663166626601*std::sin(0.298399955034256*x_24 - 1.16463983058929) + 0.000442481547470996*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.0226956096245188*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 0.00260226980950592*std::sin(0.228399991989136*x_26 - 1.19703996181488) + 0.000380440932357643*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.0192359270628722*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.00018943570745923*std::sin(0.344799846410751*x_27 + 8.2139196395874) - 0.000622111814476918*std::sin(0.357039839029312*x_27 - 1.14823985099792) - 0.000656212480066652*std::sin(0.242239981889725*x_28 - 1.16359984874725) + 0.00298854064876879*std::sin(0.3018399477005*x_28 + 2.01215982437134) - 0.00263580838065416*std::sin(0.308959931135178*x_28 - 1.17487978935242) - 0.00609034708108804*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.0267744642044641*std::sin(0.225359991192818*x_29 + 1.78623986244202) + 0.000728952505108511*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00522453799171571*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.000273964085818949*std::sin(0.329999834299088*x_29 - 4.36855983734131) - 0.000509703292919861*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.000513404123680288*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 0.0074022886439264*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.000490906403938345*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00290842595945068*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.0295218524018922*std::sin(0.170480027794838*x_30 - 1.41063988208771) - 0.0253854158209593*std::sin(0.34911984205246*x_30 - 7.36520004272461) - 0.00410734717614768*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.00117623984102272*std::sin(0.310239911079407*x_31 - 7.50207996368408) - 0.00382798870780856*std::sin(0.3572798371315*x_31 - 1.02039980888367) - 0.000128456506865091*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.000418703234421769*std::sin(0.413359850645065*x_31 - 7.38687992095947) + 0.00172608824729509*std::sin(0.428559869527817*x_31 - 7.39463949203491) + 0.000299858624717784*std::sin(1.1684798002243*x_31 + 4.6057596206665) + 0.00186313439049818*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.000348798985937542*std::sin(0.29911994934082*x_32 - 7.36168003082275) + 0.000394149133486004*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.000776509581764018*std::sin(0.303839921951294*x_32 - 1.13263988494873) + 0.00510933658270345*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.000668387775301525*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.0421773551724747*std::sin(0.247039973735809*x_34 - 1.20383989810944) + 0.00175832042953962*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.000253014929692535*std::sin(0.239439979195595*x_35 + 1.96807980537415) - 0.00131889528389772*std::sin(0.246559977531433*x_35 + 1.94663977622986) + 0.00368002486503849*std::sin(0.206800013780594*x_37 - 4.39247989654541) + 0.000678805121178348*std::sin(0.229039996862411*x_37 + 8.19023990631104) - 0.000669072016867971*std::sin(0.225599989295006*x_38 - 7.41167974472046) - 0.00139377745687504*std::sin(0.237679988145828*x_38 - 7.59832000732422) - 0.0136768408676398*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.000329696571300702*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.0137173434285692*std::sin(0.32551982998848*x_4 - 1.15559983253479) - 0.0028568105674634*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.000367783525386904*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.00187309465675524*std::sin(0.345839858055115*x_4 + 2.01703977584839) - 0.000852524102991766*std::sin(0.379119843244553*x_4 - 4.38655996322632) - 0.00030249756876231*std::sin(0.379599839448929*x_4 - 1.17863988876343) + 0.00328437201642053*std::sin(0.242559969425201*x_41 - 1.21039986610413) + 0.000422558484899825*std::sin(0.220639988780022*x_42 + 8.20359992980957) + 0.00200577593560719*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.0455923825604119*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.021254007707779*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.000503577364349324*std::sin(0.259839981794357*x_42 + 8.18391990661621) - 0.0368327410488795*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.00036312298127114*std::sin(0.129440054297447*x_44 + 1.7668799161911) + 0.00562190806604656*std::sin(0.256959974765778*x_44 - 1.23063993453979) - 0.000830497985850817*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.000246772012900811*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.000439753925598213*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.000332639710782025*std::sin(0.257039964199066*x_45 - 4.43688011169434) + 0.00366174445969172*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.000321987862876944*std::sin(0.225519984960556*x_47 + 8.19655990600586) - 0.0055685861162949*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.000451025973367528*std::sin(0.230159983038902*x_48 + 1.98047983646393) - 0.000882211895202711*std::sin(0.240479975938797*x_48 - 7.42575979232788) - 0.00427376235297627*std::sin(0.244319975376129*x_48 - 7.42799949645996) - 0.00383379343849833*std::sin(0.256079971790314*x_48 - 1.22367990016937) + 0.0104800301444692*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.0051985092419582*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.0212905580129645*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.00021883697298269*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.000740010158484076*std::sin(0.39183983206749*x_5 + 2.01263976097107) + 0.016772360960262*std::sin(0.220799997448921*x_51 + 1.95815980434418) - 0.0200950491657124*std::sin(0.178240016102791*x_52 - 0.965199828147888) + 0.0511188910159227*std::sin(0.224639996886253*x_52 - 7.41792011260986) - 0.000583550065080526*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.000163263932215918*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.0279219298956561*std::sin(0.25519996881485*x_52 + 1.95015978813171) + 0.00227063645071636*std::sin(0.216879993677139*x_53 - 4.38775968551636) + 0.00811354133757508*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.00587400736532521*std::sin(0.247599974274635*x_53 + 4.9792799949646) + 0.0332394052772521*std::sin(0.267279952764511*x_53 - 1.21335983276367) + 0.0316183477923212*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.0326555849790957*std::sin(0.220479995012283*x_56 + 8.19176006317139) - 0.00553303496127413*std::sin(0.239279985427856*x_56 - 1.22927987575531) - 0.00674069147501814*std::sin(0.252159982919693*x_56 + 8.16687965393066) - 0.000405352537305256*std::sin(0.247519969940186*x_58 - 1.23071992397308) + 0.0144975481534075*std::sin(0.238879978656769*x_6 + 5.02663946151733) - 0.000449759881006814*std::sin(0.282239943742752*x_6 - 0.996719837188721) + 0.000879373695204808*std::sin(0.387039840221405*x_6 - 1.1794399023056) + 0.00155085337456298*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.00099544627336157*std::sin(0.512639820575714*x_6 + 1.91543984413147) + 0.00171176470643993*std::sin(0.292239934206009*x_60 - 7.46751976013184) - 0.00259339161582968*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.000248180349934495*std::sin(0.348239839076996*x_7 - 7.34895992279053) - 0.000893695848535772*std::sin(0.375999838113785*x_7 + 8.22087955474854) - 6.16963588270433e-5*std::sin(0.789839863777161*x_7 + 1.21335983276367) + 0.000440997190702612*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.000231559622368073*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00312629166374687*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 0.0205910060040234*std::sin(0.336479842662811*x_8 - 1.14847981929779) + 0.0237205979804471*std::sin(0.345519840717316*x_8 + 5.03679990768433) + 0.00126440052818445*std::sin(0.388639837503433*x_8 + 1.80719995498657) - 0.00130842526376718*std::sin(0.295839935541153*x_9 - 1.21183979511261) - 0.000226779371150143*std::sin(0.341519832611084*x_9 + 5.04423999786377) - 0.00472263206718083*std::sin(0.327279835939407*x_91 + 4.99647998809814) - 0.00117553150711908*std::sin(0.345599830150604*x_91 + 2.00535988807678) - 0.00137181668523925*std::sin(0.367839843034744*x_91 - 1.18095993995667) + 0.00130821768551591*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.00573470657968613*std::sin(0.38663986325264*x_91 - 4.39359998703003) - 0.0155762636643416*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.0238298736899092*std::sin(0.291999936103821*x_92 + 1.99447977542877) + 0.0256347008934804*std::sin(0.292239934206009*x_92 - 7.38303995132446) - 0.00254066406132078*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.00288700194172539*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 7.482280633098e-5*std::sin(0.255759954452515*x_94 + 1.99439978599548) - 0.0060798154006819*std::sin(0.279119968414307*x_94 + 1.99335980415344) - 0.0029255214860832*std::sin(0.295279920101166*x_94 + 1.96527981758118) + 0.00145573922008753*std::sin(0.301119923591614*x_94 - 4.40064001083374) + 0.000394614315504262*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.000164056715744969*std::sin(0.268159955739975*x_95 - 1.18831992149353) - 0.00176286683449789*std::sin(0.269679963588715*x_95 - 1.18839991092682) - 0.00313078470203415*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.00638712811313236*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.000322927876520418*std::sin(0.292079925537109*x_96 - 1.20975983142853) - 0.00627090548614715*std::sin(0.303679943084717*x_96 + 8.17136001586914) - 0.039483081013275*std::sin(0.274959951639175*x_97 - 1.21607995033264) - 0.00154161864844688*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.000710840692245155*std::sin(0.286399960517883*x_97 + 1.94071984291077) - 0.0267858948119217*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.015204196947106*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 0.0253562141248689*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 0.0290483288339239*std::sin(0.252639979124069*x_99 - 1.21063983440399) + 0.000408677568565272*std::sin(0.263999968767166*x_99 - 1.22975981235504) + 0.000720100212330607*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.0431832082148113);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000184631001866027*x_1 - 0.00184930133828813*x_10 - 0.000691591021562772*x_100 - 0.00028173673961139*x_101 + 6.56460302695501e-5*x_102 - 0.00167534752988262*x_103 - 0.00184207968747235*x_104 - 0.00108807484149726*x_105 + 0.00147947397693083*x_106 - 0.00154826352915976*x_107 + 4.8165165406656e-5*x_108 + 1.88491922663611e-5*x_109 - 0.00198339201658478*x_11 - 0.00223862757828649*x_110 - 0.00270284128368111*x_111 - 0.000286768801650929*x_112 - 0.00109960173271588*x_113 - 0.00135438940259804*x_114 - 0.00226662873246016*x_115 - 0.00120539800327311*x_116 - 0.000397520603196812*x_117 - 8.37092211752179e-5*x_118 + 0.00084906995473412*x_119 - 0.00163767781865869*x_12 - 0.00154199249716033*x_120 - 0.000642277412608427*x_13 + 0.000927909469988606*x_14 - 0.000871317510812387*x_15 - 0.000989038505642959*x_16 - 0.00300791819171932*x_17 - 0.000549573861423487*x_18 - 0.000528372354766787*x_19 + 0.000254846677913209*x_2 + 0.000881882005277133*x_20 + 0.00120984424023762*x_21 + 0.000561707170326948*x_22 + 0.000265491512721209*x_23 + 0.000947675244955265*x_24 + 0.00149617513016303*x_25 + 7.65648356251927e-5*x_26 + 0.000197217212831115*x_27 - 0.000209588525870497*x_28 + 8.68809264724835e-5*x_29 + 0.000201687802729486*x_3 + 0.000654203023169886*x_30 - 0.000146987563348983*x_31 - 0.000536839841994889*x_32 - 0.000650900604451539*x_33 + 0.0018870055318111*x_34 - 0.000736996388165232*x_35 + 0.00156966097525258*x_36 + 0.000901713047165132*x_37 - 5.20890215602583e-5*x_38 - 0.000852062400991671*x_39 + 0.000222784842277869*x_4 + 1.77411920650382e-5*x_40 - 0.000236050801871694*x_41 + 1.74727160284735e-5*x_42 + 0.000156205441244491*x_43 + 0.000118325251476163*x_44 - 0.00048638901854311*x_45 - 0.000397783100047759*x_46 + 0.000119040709619614*x_47 + 0.000514477022837815*x_48 + 0.00159236133881308*x_49 - 0.00138539694442457*x_5 + 0.00170742836898414*x_50 + 0.00229725615504521*x_51 + 0.00198147498455862*x_52 + 0.000724304370535242*x_53 + 7.46129251153349e-5*x_54 - 0.00263218544562234*x_55 + 0.000845999691447359*x_56 + 0.00166744075468375*x_57 - 0.000710365320856854*x_58 + 0.0017841928509173*x_59 + 0.000365562537531395*x_6 + 0.00044884282896967*x_60 + 6.83035500950457e-5*x_61 - 0.000478891346323602*x_62 + 0.000531641663179272*x_63 + 0.000209363781441235*x_64 + 0.000895832180296115*x_65 - 0.00111163969293121*x_66 + 0.000107648745640843*x_67 + 0.000190258515198703*x_68 + 0.000285224996578832*x_69 - 0.0011018407985599*x_7 + 0.000205178190189152*x_70 + 8.29671354855788e-5*x_71 - 0.000102987412600519*x_72 + 0.000383926837289873*x_73 + 0.000201093991745479*x_74 - 0.000266117722739707*x_75 + 0.00017079405850791*x_76 - 0.000518213428017116*x_77 - 0.0002669639208494*x_78 + 7.20459746101831e-5*x_79 - 0.00265817063080585*x_8 - 0.000275795916069294*x_80 - 0.000147145011407987*x_81 - 0.000175353411544679*x_82 + 0.00020452783566869*x_83 - 0.000129600147510984*x_84 + 9.7248120097381e-5*x_85 + 0.000258583568221921*x_86 - 0.000254743618352779*x_87 - 0.000319004445446203*x_88 + 0.000393554427495738*x_89 - 0.00103490890262263*x_9 + 0.000115023607457323*x_90 - 0.000405639354501757*x_91 + 0.00091559548959715*x_92 + 0.000379849656996441*x_93 + 6.85292359922714e-5*x_94 + 0.000190233587583224*x_95 - 0.000634626590272664*x_96 - 9.19892038985601e-5*x_97 - 0.000958586686191083*x_98 + 0.000648171261219191*x_99 - 1.00147473862578e-7*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) - 0.000527050256934165*std::sin(0.413039863109589*x_1 - 0.994799792766571) - 0.0015866286401951*std::sin(0.453919857740402*x_1 - 0.967119812965393) - 0.00202090067477566*std::sin(0.189440011978149*x_10 - 7.40327978134155) - 0.000100240955880955*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 0.00301777405365877*std::sin(0.285999923944473*x_10 + 4.99871969223022) - 0.00334593516130819*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.00229883300977366*std::sin(0.25655996799469*x_100 + 1.94487977027893) + 0.00269775847222576*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.000966534104090172*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.0076879965288882*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.00182806762836538*std::sin(0.236559987068176*x_101 + 1.95871984958649) - 0.00473813343083857*std::sin(0.244959965348244*x_101 - 1.20255982875824) + 1.27284844920879e-6*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.011303198739881*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.000825472304271815*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 9.38948817660834e-5*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.00388547639203137*std::sin(0.243999972939491*x_103 - 1.20647990703583) - 0.00363211667160648*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.00244591159441419*std::sin(0.235199987888336*x_104 - 1.21823990345001) + 3.05555298558592e-5*std::sin(0.237759977579117*x_104 - 4.42519998550415) - 0.0010346137789144*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.00011391112434739*std::sin(0.253119975328445*x_107 - 7.42199993133545) - 0.0032842225481497*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 0.00458032414430318*std::sin(0.268879950046539*x_108 + 1.95047986507416) - 0.00299508244706513*std::sin(0.273199945688248*x_108 - 1.22711992263794) - 0.00522519897454988*std::sin(0.274479955434799*x_108 - 1.23687982559204) + 0.00086531834734525*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.000100891924017849*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.0103991317756471*std::sin(0.226879999041557*x_109 + 1.95823979377747) - 0.000525977772790351*std::sin(0.232559978961945*x_109 + 4.97751951217651) - 0.000658210370106116*std::sin(0.235839992761612*x_109 - 7.43439960479736) + 0.00260432165224019*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.000172470862595612*std::sin(0.239999979734421*x_109 - 4.40607976913452) - 0.00165396080910205*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.0139406636501535*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.000154481047217175*std::sin(0.293839931488037*x_11 - 7.45207977294922) - 0.00331794422545637*std::sin(0.311919927597046*x_11 + 5.12680006027222) - 0.000211585483832026*std::sin(0.313519924879074*x_11 + 1.93895983695984) - 9.8743230901882e-5*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.000889480546415249*std::sin(0.26759997010231*x_112 + 5.15015983581543) - 0.00278781869581385*std::sin(0.278399974107742*x_112 + 1.96039986610413) + 0.000699055862496101*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.0108932835664703*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.000229909827078577*std::sin(0.273839950561523*x_113 - 7.41279983520508) - 0.00941769660366304*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.001967410198502*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.00233442368987118*std::sin(0.251599967479706*x_116 + 5.15064001083374) - 0.00321148680817261*std::sin(0.272719949483871*x_116 + 1.93367981910706) - 0.000194911610256727*std::sin(0.275199949741364*x_116 - 1.24471986293793) - 7.27068926658797e-5*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 5.45623448694028e-5*std::sin(0.235359981656075*x_118 + 1.94599986076355) - 0.00449521246558635*std::sin(0.240879982709885*x_118 - 7.44632005691528) - 0.0011532467426278*std::sin(0.253039985895157*x_119 - 7.62432050704956) - 0.000135706377536946*std::sin(0.262319952249527*x_119 - 1.23623991012573) + 0.000128581843702508*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 1.36093936669641e-6*std::sin(0.257279962301254*x_12 + 8.36040019989014) - 0.000683433735522409*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.000610986870949451*std::sin(0.263919949531555*x_120 + 5.15799999237061) + 0.00336289768300746*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 1.60877185216661e-6*std::sin(0.263759940862656*x_13 - 4.21655988693237) - 0.00374062755124884*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.000119139831582282*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.00901066714513983*std::sin(0.297199934720993*x_15 + 5.15664005279541) - 0.000705619762486259*std::sin(0.33231982588768*x_15 - 4.33368015289307) - 0.000579092752768086*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.00191413934225919*std::sin(0.344719856977463*x_15 + 1.83199989795685) + 0.00234951174772609*std::sin(0.346479833126068*x_15 + 5.05615997314453) + 9.78121859584617e-5*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.000111990135814045*std::sin(0.288159936666489*x_16 - 7.40983963012695) + 0.0007440832630312*std::sin(0.328159838914871*x_16 + 8.24831962585449) - 0.00127351106651774*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00175087267829223*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.000136866402504868*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 6.93665394609809e-7*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.000171064612319242*std::sin(0.263119965791702*x_17 - 4.18071985244751) - 0.000835838596235496*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.000540094844820075*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.00149484801363999*std::sin(0.38239985704422*x_17 - 1.19231986999512) + 0.000473392074868379*std::sin(0.402239859104156*x_17 - 1.21327984333038) - 0.000688986870081303*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.00010251612776416*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 8.96559327534975e-5*std::sin(0.389039844274521*x_18 + 5.00959968566895) + 0.000946937573184352*std::sin(0.435919851064682*x_2 - 4.1898398399353) - 0.000301135385887385*std::sin(0.238639980554581*x_20 - 1.20031988620758) + 0.000197798971505379*std::sin(0.274079948663712*x_20 + 1.98231983184814) - 9.1260287250711e-5*std::sin(0.277279943227768*x_20 + 1.99079978466034) + 0.000121690595024181*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 7.89867458577686e-5*std::sin(0.318079918622971*x_21 - 4.38975954055786) - 0.00320386814119158*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.00193471679976539*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.000111078409037044*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.000677268406287252*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 1.62342915282707e-6*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.00946861061827436*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.00015716295926366*std::sin(0.290399938821793*x_24 - 1.37751984596252) - 0.00122451290100982*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 1.66369362868649e-6*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 7.4139627142545e-5*std::sin(0.374799847602844*x_25 + 8.20135974884033) + 0.0100022715898379*std::sin(0.228399991989136*x_26 - 1.19703996181488) - 0.00261989680739283*std::sin(0.251279979944229*x_26 + 1.98895990848541) - 0.000154051454837326*std::sin(0.271199941635132*x_26 - 1.17551982402802) + 0.00088990888393541*std::sin(0.344799846410751*x_27 + 8.2139196395874) + 0.00428415719225828*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 2.46730406813859e-6*std::sin(0.242239981889725*x_28 - 1.16359984874725) - 0.00196828544953967*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.0101311828565076*std::sin(0.308959931135178*x_28 - 1.17487978935242) + 0.00401116897884277*std::sin(0.207440003752708*x_29 - 4.39679956436157) - 0.000214424038399932*std::sin(0.225359991192818*x_29 + 1.78623986244202) - 0.00501991289170604*std::sin(0.268239974975586*x_29 + 8.22647953033447) - 0.000102090806227658*std::sin(0.304799944162369*x_29 - 7.40287971496582) + 0.0012869964016789*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 1.91644177208741e-6*std::sin(0.330399841070175*x_29 - 1.12807989120483) - 0.000658104769099853*std::sin(0.339599847793579*x_29 - 4.35775995254517) + 0.00667337358435768*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.00121484264917096*std::sin(0.360879838466644*x_3 + 1.97023975849152) + 5.68324991653973e-5*std::sin(0.396319836378098*x_3 - 1.1827198266983) + 0.000236426572898704*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.000179283983121814*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 2.9008055924611e-5*std::sin(0.272159963846207*x_31 - 1.09007978439331) - 2.29844770729033e-5*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.0147135329928003*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 4.82985727328623e-7*std::sin(0.392399847507477*x_31 - 4.40167999267578) + 0.001966935025302*std::sin(0.413359850645065*x_31 - 7.38687992095947) - 0.00113682053585988*std::sin(0.428559869527817*x_31 - 7.39463949203491) - 0.000270331072117184*std::sin(1.1684798002243*x_31 + 4.6057596206665) - 3.64068348891403e-5*std::sin(0.272559970617294*x_32 + 2.01647973060608) - 0.00163854703242938*std::sin(0.29911994934082*x_32 - 7.36168003082275) - 0.00271429798591148*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.0019216228385876*std::sin(0.303839921951294*x_32 - 1.13263988494873) - 0.00336506477055249*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.0016540545592939*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.000137780541614875*std::sin(0.247039973735809*x_34 - 1.20383989810944) - 3.43587032083792e-5*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.000128941683918503*std::sin(0.239439979195595*x_35 + 1.96807980537415) + 0.000897813654345476*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.00331764700154963*std::sin(0.206800013780594*x_37 - 4.39247989654541) - 0.00467457420734431*std::sin(0.229039996862411*x_37 + 8.19023990631104) + 0.00460754743198985*std::sin(0.225599989295006*x_38 - 7.41167974472046) + 0.000917957026749407*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 9.65924105623342e-5*std::sin(0.255519956350327*x_4 - 0.956879794597626) - 0.00154880994580541*std::sin(0.324879825115204*x_4 - 7.35623979568481) - 0.000109855724903065*std::sin(0.32551982998848*x_4 - 1.15559983253479) + 0.00188152658199444*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.000910151321551263*std::sin(0.329039841890335*x_4 - 1.40119981765747) + 3.66014648476243e-5*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.000321129982515577*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 1.13736557087953e-6*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.0126240487401799*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 1.58878457891249e-6*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.00770954479163454*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.000148936393403483*std::sin(0.253199964761734*x_42 - 1.22143983840942) - 0.000170213309595395*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.00124619938640177*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.000260130484807159*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.000185055042923774*std::sin(0.129440054297447*x_44 + 1.7668799161911) - 0.0037026499370547*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.000312833153619436*std::sin(0.282799929380417*x_44 - 1.26543986797333) + 0.00115925666566489*std::sin(0.288799941539764*x_44 - 4.44839954376221) + 0.00206582449731419*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.000169520132659838*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.014074544632009*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.000164091728860133*std::sin(0.225519984960556*x_47 + 8.19655990600586) + 0.00366753151968248*std::sin(0.231999978423119*x_47 - 4.4127197265625) + 0.0021187770033892*std::sin(0.230159983038902*x_48 + 1.98047983646393) + 0.00607532978473716*std::sin(0.240479975938797*x_48 - 7.42575979232788) + 0.00281474647420947*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.0147358444735903*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 7.40149998246559e-5*std::sin(0.26639997959137*x_48 - 7.80967998504639) - 0.000101582187847993*std::sin(0.242799982428551*x_49 - 1.21991980075836) + 0.000170506023727142*std::sin(0.260079979896545*x_49 + 1.94671976566315) + 0.00102802670627839*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.00183129797072097*std::sin(0.39183983206749*x_5 + 2.01263976097107) + 5.47901822628556e-5*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.000141920876178166*std::sin(0.178240016102791*x_52 - 0.965199828147888) + 0.00016698980915527*std::sin(0.224639996886253*x_52 - 7.41792011260986) - 0.00144410727034506*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 8.32027041592317e-5*std::sin(0.234079986810684*x_52 + 5.17903995513916) - 0.00022361354917975*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.000855306543426632*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.00731458810136963*std::sin(0.246479973196983*x_53 - 1.2053599357605) - 0.00386868528370917*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.000234752623976549*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.000223303938447124*std::sin(0.174000009894371*x_55 + 8.2183198928833) - 0.000261523157067039*std::sin(0.220479995012283*x_56 + 8.19176006317139) + 0.00364411714144054*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.00607692493410128*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 1.52409165430986e-6*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.000102388639082177*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 1.69105955433967e-6*std::sin(0.282239943742752*x_6 - 0.996719837188721) - 0.000598617434201349*std::sin(0.387039840221405*x_6 - 1.1794399023056) - 0.00102140893843267*std::sin(0.45159986615181*x_6 - 4.24871969223022) - 1.94516553932507e-5*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.000644789945903905*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.00996814672543962*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.000126477881265444*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.000336638613744048*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 2.31973151604555e-7*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 1.65811257132405e-6*std::sin(0.285839945077896*x_8 + 1.97279977798462) - 0.00108779367876263*std::sin(0.319279909133911*x_8 - 7.41967964172363) + 6.10897340512805e-5*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 6.72645296991255e-5*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.000167526240970794*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.000476276175751105*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.000492859475294568*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 8.52671477616256e-7*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 3.33534929581071e-5*std::sin(0.327279835939407*x_91 + 4.99647998809814) + 0.000800221405816075*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 0.00527281337512011*std::sin(0.367839843034744*x_91 - 1.18095993995667) - 0.000861606428640095*std::sin(0.382879853248596*x_91 - 1.17583978176117) + 4.59265565303056e-5*std::sin(0.38663986325264*x_91 - 4.39359998703003) - 5.08828975935801e-5*std::sin(0.445439845323563*x_91 - 1.38639986515045) + 0.000190842203680725*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.000181044553878252*std::sin(0.292239934206009*x_92 - 7.38303995132446) + 0.00167330904671692*std::sin(0.329999834299088*x_92 + 1.7940798997879) - 5.64138601880027e-5*std::sin(0.230159983038902*x_93 - 7.42727994918823) - 0.000351493817971189*std::sin(0.255759954452515*x_94 + 1.99439978599548) + 0.00400423269932081*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.00263744076255622*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 0.00559538407205314*std::sin(0.301119923591614*x_94 - 4.40064001083374) - 0.00271750145005225*std::sin(0.336239844560623*x_94 - 7.57615995407104) - 0.000770686428492555*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.000664039167635201*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.012033709481109*std::sin(0.276159942150116*x_95 + 1.96335983276367) - 0.00420663220177495*std::sin(0.284079939126968*x_95 - 1.20591986179352) - 0.00151701276406808*std::sin(0.292079925537109*x_96 - 1.20975983142853) + 0.0056533995138915*std::sin(0.303679943084717*x_96 + 8.17136001586914) - 0.000128979170561724*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.00592547642577159*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.00175911249634886*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.000189174837522192*std::sin(0.265119940042496*x_98 - 1.19839990139008) - 0.000121763232501318*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 8.28310097003693e-5*std::sin(0.246479973196983*x_99 - 7.43895959854126) + 0.000232634346285094*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 1.53659349388733e-6*std::sin(0.263999968767166*x_99 - 1.22975981235504) - 0.000490194946498598*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.0361662505239819);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00187853216873701*x_1 - 0.00141302676679339*x_10 + 0.00287875983422208*x_100 - 0.00244888683418736*x_101 - 0.00348804850344941*x_102 - 0.000533174525110655*x_103 + 0.00328270720400909*x_104 + 0.00582936467920078*x_105 + 0.00375615209868781*x_106 - 0.000304154591524334*x_107 - 0.00054940716232313*x_108 + 0.000559475797906884*x_109 - 0.001201482975145*x_11 - 0.00239179449565517*x_110 - 0.00641566389880083*x_111 - 0.00229214447510004*x_112 - 0.00247527006246786*x_113 + 0.00369638328679742*x_114 - 0.0038875487130096*x_115 - 0.00107415024562321*x_116 - 0.00570242300734461*x_117 + 0.00252733342556719*x_118 - 0.00329323865079927*x_119 + 0.00485669157821996*x_12 - 0.00320265925059365*x_120 - 0.0028622985235729*x_13 - 0.00127316811376537*x_14 - 0.000546448748145122*x_15 - 0.00186995965094693*x_16 - 0.00193542938227561*x_17 - 0.000358560866187699*x_18 - 0.0021176353576044*x_19 + 0.00154883152326264*x_2 - 0.000184115090343292*x_20 - 0.000590118481455092*x_21 - 0.00325758190871193*x_22 - 0.00173695519903567*x_23 + 0.00270524354037097*x_24 - 0.00300013484652538*x_25 + 0.00166690171686048*x_26 - 0.0026106237936158*x_27 - 0.00259491458008772*x_28 - 0.000572417373649522*x_29 - 0.000536416099544427*x_3 + 0.000593274151950449*x_30 + 0.00028689871112399*x_31 - 0.000724756034488346*x_32 + 0.000752420673330617*x_33 + 0.00757536145784447*x_34 - 0.00793018600287506*x_35 + 0.00130381466932604*x_36 + 0.00335513868039245*x_37 - 0.00551152928579382*x_38 - 0.00254254485800251*x_39 - 0.000300311200242643*x_4 - 0.00348681404689251*x_40 + 0.00142791951583923*x_41 + 0.000146612507945192*x_42 + 0.00118628220199124*x_43 - 0.000715137417316275*x_44 - 0.00319801218547109*x_45 + 0.00130432782789185*x_46 + 0.0039936491954249*x_47 - 0.000797941995762467*x_48 + 0.00684864414132003*x_49 + 0.000882619172860684*x_5 - 0.00142044830801857*x_50 - 0.00153991903007377*x_51 + 0.00164996339334129*x_52 - 7.6643364919332e-5*x_53 + 0.009253366434791*x_54 + 0.0017823115208845*x_55 - 0.00147427484389146*x_56 - 0.00134946715900756*x_57 - 0.00910550147452488*x_58 + 0.00552256568613181*x_59 + 0.000137496931861386*x_6 - 0.000778020279094637*x_60 + 3.29838264235012e-5*x_61 - 0.00157404974387912*x_62 + 0.00252265422387467*x_63 - 0.00145266301195513*x_64 - 9.54380150028206e-5*x_65 - 0.00132065583980946*x_66 + 0.00205942872083876*x_67 + 0.000309920324888439*x_68 + 0.0011416919969188*x_69 - 0.00282652748305744*x_7 - 0.000310917752352024*x_70 + 0.000866959572130436*x_71 + 0.000563700923231615*x_72 - 0.0012065505332473*x_73 - 0.00016288726094227*x_74 + 0.000639971463393555*x_75 - 0.00028027881842856*x_76 - 0.000594908884993444*x_77 + 0.000316278755623661*x_78 - 0.000512528556627315*x_79 - 0.00268661050397858*x_8 - 0.000676825370899921*x_80 - 0.000408920988496186*x_81 - 0.000587380076689569*x_82 - 0.000854049452536893*x_83 - 0.00122148739472816*x_84 + 0.00140992229721285*x_85 - 0.000785878354871446*x_86 + 0.000315242695274409*x_87 - 0.00117001745350623*x_88 + 0.00130743594069294*x_89 - 0.00283537561967586*x_9 + 0.00188752261782839*x_90 - 0.000337742357456504*x_91 + 0.00122189982892887*x_92 - 0.000364244215162266*x_93 + 0.000140087933028938*x_94 - 0.000895747689953901*x_95 + 0.000897804334131584*x_96 + 0.00263100565190997*x_97 + 0.000549286660239292*x_98 - 3.56746343232951e-6*x_99 + 3.49846027016867e-6*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) + 0.000504159659612924*std::pow(0.0652663041966141*x_1 - 0.120981603126184*x_10 - 0.00143057046343149*x_100 - 0.13258273210453*x_101 - 0.164287437679324*x_102 - 0.00568111959800418*x_103 - 0.00397505178950051*x_104 - 0.0996071054138478*x_105 + 0.00373535531579205*x_106 + 0.00829997276140405*x_107 + 0.00196773701374069*x_108 - 0.0566627027792004*x_11 + 0.0857141872757043*x_110 + 0.00660750809284773*x_111 - 0.149981467920471*x_112 - 0.0372904809642234*x_113 - 0.0159322776924943*x_114 + 0.00303143318450063*x_115 - 0.365920258105495*x_116 - 0.00237206754090733*x_117 + 0.0585211237440873*x_118 - 0.0402654079249664*x_119 + 0.0110886616406751*x_12 - 0.239521404695464*x_120 + 0.146358569365718*x_13 + 0.187266546596261*x_14 + 0.0613868268590639*x_16 + 0.00989995280098705*x_18 + 0.0247231525517341*x_19 + 0.116402833792314*x_2 + 0.0256694001326639*x_21 + 0.0836850588556905*x_22 - 0.00155628001278668*x_23 + 0.036407861268259*x_24 + 0.152548077045516*x_25 + 0.156687630304719*x_26 + 0.182970042492925*x_27 - 0.0775803937355603*x_28 + 0.00464821377116233*x_3 + 0.175803211816131*x_30 - 0.127676884061738*x_31 + 0.00209330378911154*x_32 - 6.08121390078231e-5*x_33 + 0.0098035825530895*x_34 + 0.000120677842362524*x_35 + 0.0860477553342543*x_36 + 0.00207857104894407*x_37 + 0.273308468854535*x_38 - 0.101180204220592*x_39 + 0.0177100687785855*x_4 + 0.00181968522359996*x_40 + 0.00797959732967259*x_41 - 0.131939593128859*x_42 + 0.0101449427909307*x_43 - 0.209882560839585*x_44 - 0.00129846652025618*x_45 + 0.0983152242967812*x_46 + 0.00196329990505584*x_47 + 0.0849178371958555*x_48 + 0.0185035942514285*x_49 - 0.00209622260122617*x_5 + 0.278767324633506*x_50 + 0.390637035186122*x_51 + 0.00625029912210373*x_52 + 0.00780780106600223*x_53 - 0.00722710042165952*x_54 - 0.0590296067733396*x_55 - 0.00521394724121557*x_56 + 0.0170879945238943*x_57 - 0.109294330298579*x_58 - 0.000507332264224066*x_59 - 0.00347141383299876*x_6 - 0.114870943418155*x_60 - 0.00484915413303362*x_61 + 0.0407775796937726*x_62 + 0.00234173538308221*x_63 + 0.00110057758241708*x_64 + 0.000451047993101341*x_65 - 0.0152195902135685*x_66 - 0.004357461811439*x_67 - 0.000217007942723289*x_68 + 0.0855282139132423*x_69 - 0.0332083652253224*x_7 - 0.00127862833616694*x_70 - 0.0576828935657507*x_71 - 0.00867075800804125*x_72 - 0.00986748701022481*x_73 - 0.0107361886030509*x_74 - 4.5845930663782e-5*x_75 + 0.000677802510383626*x_76 - 0.0249208479465449*x_77 + 0.00045470786744534*x_78 + 0.00110521783086043*x_79 + 0.00834681434067131*x_8 - 0.00552811546533619*x_80 - 0.00387866596529647*x_81 - 0.00501000327625585*x_82 + 0.0895926128094543*x_83 - 0.00498892338266295*x_84 + 0.0768615493434677*x_85 - 0.0903497137419636*x_86 - 0.000464681090089082*x_87 - 0.0741037695684566*x_88 - 0.0107329123856153*x_89 + 0.0695239615802724*x_9 + 0.000772128390728496*x_90 - 0.0580391198791993*x_91 + 0.0775456424138672*x_92 - 0.0015458297917965*x_93 + 0.003963125623475*x_94 - 0.00115824938273254*x_95 + 0.0774793491904494*x_96 + 0.0225741848098766*x_97 - 0.00391338174068525*x_98 + 0.0881267567436783*x_99 - 1.30788260669405*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 1.40208640916214*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.940643431016355*std::sin(0.402239859104156*x_17 - 1.21327984333038) - 0.598364521966914*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 1.30767277451028*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 9.13685603459738, 2) - 0.000513862753830511*std::sin(0.413039863109589*x_1 - 0.994799792766571) - 0.00106666051371021*std::sin(0.453919857740402*x_1 - 0.967119812965393) - 0.0013586134129335*std::sin(0.189440011978149*x_10 - 7.40327978134155) - 0.00147988430236372*std::sin(0.285999923944473*x_10 + 4.99871969223022) - 0.000243554091535606*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.0110114660125068*std::sin(0.25655996799469*x_100 + 1.94487977027893) + 0.000752200313092066*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.000942350126699438*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.00576741986611653*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.00875648838898968*std::sin(0.236559987068176*x_101 + 1.95871984958649) - 0.000344893647870686*std::sin(0.244959965348244*x_101 - 1.20255982875824) + 0.000469398986954544*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.00847949042615923*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.000804817881982207*std::sin(0.235199987888336*x_102 - 1.20855987071991) - 0.00108336479662188*std::sin(0.243999972939491*x_103 - 1.20647990703583) - 0.00101272197852287*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.011715976009123*std::sin(0.235199987888336*x_104 - 1.21823990345001) + 0.000176323852243402*std::sin(0.237759977579117*x_104 - 4.42519998550415) - 0.000695551332524032*std::sin(0.241519972681999*x_107 - 7.42303991317749) - 0.00397926704977531*std::sin(0.253119975328445*x_107 - 7.42199993133545) + 0.00161054781042441*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 0.00343609058144666*std::sin(0.268879950046539*x_108 + 1.95047986507416) - 0.000835101428690983*std::sin(0.273199945688248*x_108 - 1.22711992263794) - 0.00038034765408954*std::sin(0.274479955434799*x_108 - 1.23687982559204) + 0.000843666923707505*std::sin(0.275599956512451*x_108 + 1.92775976657867) - 0.00352446621111644*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.00780127292824159*std::sin(0.226879999041557*x_109 + 1.95823979377747) - 0.000495259208970842*std::sin(0.232559978961945*x_109 + 4.97751951217651) - 0.00127713164170905*std::sin(0.237119987607002*x_109 - 1.21911990642548) - 0.0226972079469099*std::sin(0.239999979734421*x_109 - 4.40607976913452) - 0.000461164278143153*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.0104580771050857*std::sin(0.284879922866821*x_11 + 5.14423990249634) - 0.0203297438174571*std::sin(0.293839931488037*x_11 - 7.45207977294922) - 0.000925123101606346*std::sin(0.311919927597046*x_11 + 5.12680006027222) - 0.0198701177190745*std::sin(0.313519924879074*x_11 + 1.93895983695984) - 0.00927303511775781*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.000867224552205657*std::sin(0.26759997010231*x_112 + 5.15015983581543) - 0.000777311281726781*std::sin(0.278399974107742*x_112 + 1.96039986610413) + 0.000658229057189164*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.00817197820165864*std::sin(0.264399945735931*x_113 + 5.19080018997192) - 0.0302561898033513*std::sin(0.273839950561523*x_113 - 7.41279983520508) - 0.000685523905898499*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.00942394268803244*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.0111819462355546*std::sin(0.251599967479706*x_116 + 5.15064001083374) - 0.000895440198768215*std::sin(0.272719949483871*x_116 + 1.93367981910706) - 0.0183042644063909*std::sin(0.275199949741364*x_116 - 1.24471986293793) + 0.00718041800762327*std::sin(0.235359981656075*x_118 + 1.94599986076355) - 0.00125337396169483*std::sin(0.240879982709885*x_118 - 7.44632005691528) - 0.000321553085573793*std::sin(0.253039985895157*x_119 - 7.62432050704956) - 0.012744266043454*std::sin(0.262319952249527*x_119 - 1.23623991012573) + 8.64431486883142e-5*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 0.000501885012650916*std::sin(0.257279962301254*x_12 + 8.36040019989014) - 0.000643519305850457*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.000595699161379196*std::sin(0.263919949531555*x_120 + 5.15799999237061) - 0.00164912925986102*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 0.000593280274739226*std::sin(0.263759940862656*x_13 - 4.21655988693237) - 0.00104297743633394*std::sin(0.281439960002899*x_13 + 5.15664005279541) + 0.00416192192682904*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.00675966755507347*std::sin(0.297199934720993*x_15 + 5.15664005279541) - 0.000564603076738223*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.00916877399135853*std::sin(0.344719856977463*x_15 + 1.83199989795685) + 0.000655100703212675*std::sin(0.346479833126068*x_15 + 5.05615997314453) + 0.000564435357720912*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.000725465303526389*std::sin(0.328159838914871*x_16 + 8.24831962585449) - 0.000355085687923172*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00838672270115869*std::sin(0.358399868011475*x_16 + 5.03200006484985) + 0.0180116522399622*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 0.000255808799325376*std::sin(0.392959833145142*x_16 + 1.80143988132477) + 0.0225121450645899*std::sin(0.263119965791702*x_17 - 4.18071985244751) - 0.000561918525767783*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.00052658094866193*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.00716035833228299*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.000463192879645826*std::sin(0.331679850816727*x_18 + 5.02007961273193) - 0.00358120465950631*std::sin(0.362639844417572*x_18 + 8.20135974884033) + 0.011798742806497*std::sin(0.389039844274521*x_18 + 5.00959968566895) + 0.000636608272834476*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.0185754182061183*std::sin(0.274079948663712*x_20 + 1.98231983184814) + 0.000702228192332943*std::sin(0.298959940671921*x_21 - 4.21544027328491) - 0.000893315930140214*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.00926734051315024*std::sin(0.32551982998848*x_21 + 8.24944019317627) + 0.0146179459555266*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.000660322243957546*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 0.000598685570307435*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.00710320989078995*std::sin(0.275199949741364*x_24 + 5.02551984786987) + 0.0206826841025481*std::sin(0.290399938821793*x_24 - 1.37751984596252) - 0.000823216931137268*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 0.000613534238419036*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.00750355435993755*std::sin(0.228399991989136*x_26 - 1.19703996181488) + 0.00128476953215659*std::sin(0.251279979944229*x_26 + 1.98895990848541) - 0.0144670630847363*std::sin(0.271199941635132*x_26 - 1.17551982402802) + 0.000598268960515612*std::sin(0.344799846410751*x_27 + 8.2139196395874) - 0.00210090512574821*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 0.00090988839308638*std::sin(0.242239981889725*x_28 - 1.16359984874725) - 0.000548805590508177*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.00760026166171161*std::sin(0.308959931135178*x_28 - 1.17487978935242) + 0.00111841092996787*std::sin(0.207440003752708*x_29 - 4.39679956436157) - 0.0201366880545948*std::sin(0.225359991192818*x_29 + 1.78623986244202) + 0.0024617118961117*std::sin(0.268239974975586*x_29 + 8.22647953033447) - 0.000589125579481433*std::sin(0.304799944162369*x_29 - 7.40287971496582) + 0.000865223410305513*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 0.000706742288867447*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.000485761786304453*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.00581912582819875*std::sin(0.360879838466644*x_3 + 1.97023975849152) + 0.000327957827363323*std::sin(0.396319836378098*x_3 - 1.1827198266983) + 0.022202959060954*std::sin(0.170480027794838*x_30 - 1.41063988208771) - 0.0235938162842449*std::sin(0.34911984205246*x_30 - 7.36520004272461) - 0.00381746729591205*std::sin(0.272159963846207*x_31 - 1.09007978439331) - 0.000132634307387647*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.0110378721120091*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 0.000178114693279066*std::sin(0.392399847507477*x_31 - 4.40167999267578) + 0.00132233332449189*std::sin(0.413359850645065*x_31 - 7.38687992095947) - 0.000316973061824095*std::sin(0.428559869527817*x_31 - 7.39463949203491) - 1.9677679186588e-5*std::sin(1.1684798002243*x_31 + 4.6057596206665) - 0.000210089414450515*std::sin(0.272559970617294*x_32 + 2.01647973060608) - 0.00110156426971754*std::sin(0.29911994934082*x_32 - 7.36168003082275) + 0.00133106286616051*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.00920462012073145*std::sin(0.303839921951294*x_32 - 1.13263988494873) - 0.000938261449289906*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.00792296155704235*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.000198270458289154*std::sin(0.286079943180084*x_34 - 4.60623979568481) + 0.00450433087285382*std::sin(0.239439979195595*x_35 + 1.96807980537415) + 0.000845378841572445*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.000241494967040045*std::sin(0.206800013780594*x_37 - 4.39247989654541) + 0.00229236147792309*std::sin(0.229039996862411*x_37 + 8.19023990631104) - 0.00225949226010844*std::sin(0.225599989295006*x_38 - 7.41167974472046) + 0.000255948621803895*std::sin(0.237679988145828*x_38 - 7.59832000732422) - 0.0127115849925736*std::sin(0.255519956350327*x_4 - 0.956879794597626) - 0.00104123571866769*std::sin(0.324879825115204*x_4 - 7.35623979568481) - 0.0103166159908735*std::sin(0.32551982998848*x_4 - 1.15559983253479) + 0.000524615119788537*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.00435964696038824*std::sin(0.329039841890335*x_4 - 1.40119981765747) + 0.000211212546800167*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.00031309488038749*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 0.000419435830793281*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.00947037231629269*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.000585909400521407*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.0057835850501377*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.0159848324079681*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.00596932536196746*std::sin(0.259839981794357*x_42 + 8.18391990661621) - 0.0342332357949766*std::sin(0.263039946556091*x_42 + 1.95919990539551) + 0.00646454364242433*std::sin(0.129440054297447*x_44 + 1.7668799161911) - 0.00103238835892711*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.000305005649259074*std::sin(0.282799929380417*x_44 - 1.26543986797333) + 0.000779346394735468*std::sin(0.288799941539764*x_44 - 4.44839954376221) + 0.00138881485163997*std::sin(0.215279996395111*x_45 + 8.193039894104) - 0.00592186129345572*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.0105585126127693*std::sin(0.199520006775856*x_47 - 1.18703985214233) - 0.00573223039922309*std::sin(0.225519984960556*x_47 + 8.19655990600586) + 0.00102259649475*std::sin(0.231999978423119*x_47 - 4.4127197265625) + 0.00142441382288081*std::sin(0.230159983038902*x_48 + 1.98047983646393) - 0.00297927711626216*std::sin(0.240479975938797*x_48 - 7.42575979232788) + 0.000784819397649162*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.0110546098507771*std::sin(0.256079971790314*x_48 - 1.22367990016937) + 0.00974039218525634*std::sin(0.26639997959137*x_48 - 7.80967998504639) - 0.000586190544401128*std::sin(0.242799982428551*x_49 - 1.21991980075836) + 0.016012321364916*std::sin(0.260079979896545*x_49 + 1.94671976566315) + 0.000691122967811727*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.00877196180741813*std::sin(0.39183983206749*x_5 + 2.01263976097107) - 0.0186768222188125*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.00691730893814871*std::sin(0.22639998793602*x_52 + 8.20399951934814) - 0.00290652718081628*std::sin(0.234079986810684*x_52 + 5.17903995513916) - 0.0209996804379505*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.000833905628527879*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.000532436456207271*std::sin(0.246479973196983*x_53 - 1.2053599357605) - 0.00107868302949293*std::sin(0.247599974274635*x_53 + 4.9792799949646) + 0.0308935030664946*std::sin(0.267279952764511*x_53 - 1.21335983276367) + 0.0293868532343464*std::sin(0.174000009894371*x_55 + 8.2183198928833) - 0.0245597940986892*std::sin(0.220479995012283*x_56 + 8.19176006317139) + 0.00101606799976953*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.000442345670283831*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 0.000562052048697253*std::sin(0.247519969940186*x_58 - 1.23071992397308) + 0.0134743700917074*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 0.000623626200102817*std::sin(0.282239943742752*x_6 - 0.996719837188721) - 0.000563656512262706*std::sin(0.387039840221405*x_6 - 1.1794399023056) - 0.000284793516986051*std::sin(0.45159986615181*x_6 - 4.24871969223022) - 0.000112247793693272*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.000628656438138868*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.0074779543976952*std::sin(0.301359921693802*x_60 - 7.47583961486816) + 0.00441826264404267*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.000328215464897896*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 8.55466826640014e-5*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 0.000611476065135567*std::sin(0.285839945077896*x_8 + 1.97279977798462) - 0.00073130317631036*std::sin(0.319279909133911*x_8 - 7.41967964172363) + 0.000352524642552751*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 0.0220464945246641*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.000464359108140798*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.000480527471326066*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 0.000314446804760534*std::sin(0.341519832611084*x_9 + 5.04423999786377) - 0.00438932787853531*std::sin(0.327279835939407*x_91 + 4.99647998809814) + 0.000753486251602446*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 0.00395558563218947*std::sin(0.367839843034744*x_91 - 1.18095993995667) - 0.000240236712091763*std::sin(0.382879853248596*x_91 - 1.17583978176117) + 0.00431299004147833*std::sin(0.38663986325264*x_91 - 4.39359998703003) + 0.0179221040320236*std::sin(0.291999936103821*x_92 + 1.99447977542877) + 0.0238255078289077*std::sin(0.292239934206009*x_92 - 7.38303995132446) + 0.000466559034768521*std::sin(0.329999834299088*x_92 + 1.7940798997879) - 0.000325542027750564*std::sin(0.230159983038902*x_93 - 7.42727994918823) - 0.000236302665251906*std::sin(0.255759954452515*x_94 + 1.99439978599548) + 0.00111647692746845*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.000191982049243359*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 0.00419757333844402*std::sin(0.301119923591614*x_94 - 4.40064001083374) + 0.00133263381090681*std::sin(0.336239844560623*x_94 - 7.57615995407104) - 0.000518117952052263*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.000647424018569387*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.0090275086446299*std::sin(0.276159942150116*x_95 + 1.96335983276367) - 0.00117291080421579*std::sin(0.284079939126968*x_95 - 1.20591986179352) - 0.00101985907302595*std::sin(0.292079925537109*x_96 - 1.20975983142853) + 0.000411516815572523*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.00444520367898013*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.00842619162999955*std::sin(0.286399960517883*x_97 + 1.94071984291077) - 0.0248954551565705*std::sin(0.265119940042496*x_98 - 1.19839990139008) - 0.0114348570603123*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 0.0218468288205181*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 0.000566662456822729*std::sin(0.263999968767166*x_99 - 1.22975981235504) - 0.000461566199188357*std::sin(0.268559962511063*x_99 + 4.97799968719482) - 0.225208878517151*std::sin(0.000791134085311213*x_1 + 0.000376051947893584*x_100 - 0.0125862668385256*x_101 - 0.00383210273716987*x_103 - 0.00011932251277533*x_104 + 0.0159877090146966*x_105 + 0.0224967799498428*x_106 - 0.00038995671266039*x_107 - 0.00839349124645641*x_108 + 0.00713516821919199*x_109 + 0.00659914019424452*x_11 + 0.0194767886501135*x_110 + 0.0157709465545059*x_111 - 0.0102023262120955*x_112 + 0.0092043407071319*x_113 - 0.00884457197826189*x_114 + 0.0318799328969666*x_115 + 0.0391347098080783*x_117 + 0.0256713101003531*x_118 + 0.0404506479105397*x_119 + 0.00884450080707574*x_12 + 0.0198966908214242*x_120 - 0.00533631840267351*x_13 + 0.000349038951797242*x_14 - 0.000228347605126246*x_15 + 0.00065071785280253*x_17 - 0.0021342392028345*x_18 + 0.00363014759086405*x_19 - 0.000986743498067101*x_2 + 0.0199427277398645*x_22 - 0.000905903504853146*x_23 + 0.0169066919640233*x_24 - 0.00619656373798671*x_26 - 0.000126038097472028*x_27 + 0.0119915160769767*x_28 - 0.000644575118026125*x_29 + 0.000306100208576501*x_3 - 0.0169093107451407*x_30 + 0.00839133422786791*x_31 - 3.44666896710608e-5*x_32 + 0.0154449343680059*x_33 - 0.00243654616612301*x_35 - 0.000388037650959552*x_36 + 0.0186996474314708*x_37 - 0.00377153921491163*x_38 - 7.82920269390529e-5*x_39 + 0.000255423321122945*x_4 - 0.0146656497286161*x_40 + 0.0226229393758898*x_41 + 0.00552507752159597*x_43 - 0.0033430379599831*x_44 - 0.0218136170998265*x_45 + 0.00788738497607303*x_46 - 0.0183988026511727*x_47 + 0.00104269403831678*x_48 - 0.0317493320827492*x_49 - 0.00886489518871412*x_5 - 0.0325551144614935*x_50 + 0.0234819034854971*x_53 + 0.0373851239394332*x_54 - 0.00521587906339557*x_55 - 0.018034860484415*x_56 - 0.0114435060846233*x_57 + 0.0262408791845332*x_58 + 0.0179349043421849*x_59 + 0.0174688561461*x_6 + 0.000342660140728976*x_60 - 0.00149240831882933*x_61 + 9.02099164038654e-5*x_62 - 0.000225701538652272*x_63 - 0.000322298318662405*x_64 - 0.00030026926697554*x_65 + 0.000196244341817546*x_66 + 2.64601029512939e-5*x_67 - 0.000670257731122817*x_68 + 0.0119156235871418*x_69 - 0.00250006733814216*x_7 - 0.000637158366961231*x_70 + 0.000489745328619097*x_71 + 3.80081238741099e-6*x_72 + 0.00577152373301839*x_73 - 0.000729277021532876*x_74 - 0.000108233321303485*x_75 - 0.00755531169156741*x_76 + 4.59941536413733e-5*x_77 + 0.00661283978850865*x_78 + 0.000270766816217884*x_79 - 0.000445443041722338*x_80 + 0.000158321016974476*x_81 + 0.00740119590469622*x_82 - 0.000321981496026686*x_83 + 0.000224948748793118*x_84 + 0.00116191191317239*x_85 - 0.00124354832752029*x_86 - 0.0064360035629024*x_87 - 0.000154208935956547*x_88 - 0.00281471791903272*x_89 + 0.000229117163408245*x_9 - 0.00380116223072384*x_90 + 0.000927788755661121*x_92 + 0.00189765497260108*x_93 - 0.0012643111470241*x_94 - 0.000465775212370343*x_95 - 0.0134744321610482*x_96 - 0.00955500699642181*x_98 - 0.121809266343901*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 0.11409774139581*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.0883508459784972*std::sin(0.317599922418594*x_116 - 1.45887994766235) + 0.136086454497333*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 0.110896275266414*std::sin(0.277279943227768*x_20 + 1.99079978466034) + 0.0959819016017081*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.0900918542713098*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 0.167426044006449*std::sin(0.247039973735809*x_34 - 1.20383989810944) - 0.180982240771227*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.0665790928032748*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.202920113454107*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.0817374788738894*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.0618310985849591*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.156730929006967*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.100653315139062*std::sin(0.246479973196983*x_99 - 7.43895959854126) + 4.6658216420706) - 0.0936553684525233);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000312938543663762*x_1 + 0.000215536048013733*x_10 - 0.000635075358843837*x_100 - 0.000879553615817146*x_101 - 0.000247887251786081*x_102 - 0.000133072114411824*x_103 + 0.00194603061368122*x_104 + 0.0020670548470298*x_105 - 0.00238684997371696*x_106 + 0.000337818161985768*x_107 + 6.09280492985156e-5*x_108 + 0.00081740758543535*x_109 - 1.31779855873583e-5*x_11 - 0.00386840850262982*x_110 - 0.000570296807606207*x_111 - 0.000218949002512652*x_112 - 0.000995262859821167*x_113 - 0.00101247499335998*x_114 + 0.00156416730562735*x_115 - 0.00109594588018529*x_116 - 0.00233843964122685*x_117 - 0.00103451333061873*x_118 - 0.00250677449222434*x_119 + 0.000450295658456537*x_12 - 0.00045357048198213*x_120 + 0.00131180932191548*x_13 - 6.23033682532204e-5*x_14 - 0.000793070139009875*x_15 + 0.000219404352272825*x_16 + 0.000842024772727388*x_17 - 0.000420192324192746*x_18 - 0.000880493063538981*x_19 + 0.00132503167673285*x_2 - 0.000471035421292892*x_20 + 0.00019060722400102*x_21 - 0.00143712737358574*x_22 - 0.000932060635702594*x_23 - 0.00267163691542232*x_24 - 0.00143110292358546*x_25 + 0.000968651562274033*x_26 - 0.0005151597757015*x_27 - 0.00154995510144281*x_28 + 0.00149533339942813*x_29 + 0.00109591585037581*x_3 - 7.84832754106483e-5*x_30 - 0.000742116206030693*x_31 + 0.000152240933568653*x_32 + 0.00145697205740364*x_33 + 0.000432480205445639*x_34 - 0.00112271149368891*x_35 - 0.000278601063619676*x_36 + 0.00163464646107076*x_37 - 0.00442143326232335*x_38 - 0.000322285109565075*x_39 + 1.22153824777272e-5*x_4 - 0.00019656759982428*x_40 - 0.000698601831064335*x_41 - 2.02052212492645e-5*x_42 - 0.00401569483417715*x_43 - 0.000287171485012829*x_44 + 0.00322157724497206*x_45 - 0.00132839462472879*x_46 - 0.00136789549369372*x_47 - 0.00384331934725733*x_48 + 0.00164620667226775*x_49 + 0.000601397228650273*x_5 + 0.000715543690999881*x_50 + 0.000565912516070347*x_51 + 0.00158699751113718*x_52 - 0.00185969274772369*x_53 + 0.00425545116470641*x_54 + 0.00272919363626618*x_55 - 0.00120694283700784*x_56 - 0.0022835951768015*x_57 - 0.00213883933476284*x_58 + 0.000889632452094923*x_59 - 0.00104174688878987*x_6 - 0.000451054093212048*x_60 - 0.000766011241534268*x_61 - 0.00123366390035402*x_62 - 0.000526326501353105*x_63 - 0.0004835640776613*x_64 - 0.000422671928002747*x_65 + 0.00152754672396327*x_66 + 0.000491410243209667*x_67 + 0.000589894374000587*x_68 - 3.53409134203365e-5*x_69 - 0.000587416038145622*x_7 + 0.00024060592499479*x_70 + 0.00148291251355576*x_71 + 0.000184200531823053*x_72 + 9.00710959378141e-5*x_73 + 0.00115071222187625*x_74 - 0.000175750489590679*x_75 + 0.000908321351184309*x_76 + 0.00102101445807293*x_77 - 0.000764445037462374*x_78 + 3.52563628093434e-5*x_79 + 0.00101739550868092*x_8 - 0.000830615534567545*x_80 - 0.000317948232796992*x_81 - 0.000601868889979218*x_82 - 0.00108493423281457*x_83 - 0.00132027313957478*x_84 + 0.000393529286296259*x_85 - 5.0202200164058e-5*x_86 + 0.000320772244009796*x_87 + 0.000686780208085133*x_88 - 1.30690466031015e-5*x_89 - 0.000894622063479521*x_9 - 0.000674324167678116*x_90 - 0.00048599731654182*x_91 - 0.000793052314174162*x_92 + 0.00275152981426528*x_93 + 0.00140287568623609*x_94 + 0.000716671672080143*x_95 - 0.00178133300483418*x_96 + 0.00130525367045766*x_97 - 8.33379565482416e-5*x_98 - 0.00367786030674539*x_99 - 4.80902222706544e-9*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) - 0.0109771869689153*std::sin(0.413039863109589*x_1 - 0.994799792766571) - 0.000643611044666949*std::sin(0.453919857740402*x_1 - 0.967119812965393) - 0.000819772164392902*std::sin(0.189440011978149*x_10 - 7.40327978134155) + 0.00336435368105068*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 0.00242042324024677*std::sin(0.285999923944473*x_10 + 4.99871969223022) + 2.57955958392478e-5*std::sin(0.235359981656075*x_100 - 1.21407985687256) + 0.000916066593212743*std::sin(0.25655996799469*x_100 + 1.94487977027893) + 0.000101544308807045*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.0201305766060107*std::sin(0.264479964971542*x_100 - 1.2105598449707) + 0.00273704819232859*std::sin(0.234399989247322*x_101 + 1.9826397895813) + 0.000728470348807134*std::sin(0.236559987068176*x_101 + 1.95871984958649) + 3.65287936322574e-5*std::sin(0.244959965348244*x_101 - 1.20255982875824) - 0.0050758090985184*std::sin(0.246719971299171*x_101 - 1.207279920578) + 0.00402411727974544*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.0171925991922719*std::sin(0.235199987888336*x_102 - 1.20855987071991) - 0.0031513625176988*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.00014625031064749*std::sin(0.243999972939491*x_103 - 1.20647990703583) - 0.000136713786916785*std::sin(0.22495998442173*x_104 - 1.19919991493225) - 0.000974676234449568*std::sin(0.235199987888336*x_104 - 1.21823990345001) + 0.00178883860622632*std::sin(0.237759977579117*x_104 - 4.42519998550415) - 0.000419687908187538*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 5.46994455045674e-6*std::sin(0.253119975328445*x_107 - 7.42199993133545) - 0.0026341298057243*std::sin(0.263919949531555*x_108 + 1.94823980331421) - 0.00163066773929163*std::sin(0.268879950046539*x_108 + 1.95047986507416) - 0.000112735658154163*std::sin(0.273199945688248*x_108 - 1.22711992263794) + 4.02838412667991e-5*std::sin(0.274479955434799*x_108 - 1.23687982559204) + 0.0180224962638204*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 4.84477028146525e-6*std::sin(0.281999945640564*x_108 + 8.15032005310059) - 0.00370225516119449*std::sin(0.226879999041557*x_109 + 1.95823979377747) - 0.000483641735681307*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.000518792454548898*std::sin(0.235839992761612*x_109 - 7.43439960479736) + 0.00208881133579817*std::sin(0.237119987607002*x_109 - 1.21911990642548) - 0.00708511865200472*std::sin(0.239999979734421*x_109 - 4.40607976913452) - 6.22555017001363e-5*std::sin(0.261519968509674*x_109 + 4.95928001403809) - 0.00496309644523622*std::sin(0.284879922866821*x_11 + 5.14423990249634) - 0.00634609540734955*std::sin(0.293839931488037*x_11 - 7.45207977294922) - 0.000124888256863233*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.0014418929554569*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.000672906129748999*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.0185257366536731*std::sin(0.26759997010231*x_112 + 5.15015983581543) - 0.000104934198320658*std::sin(0.278399974107742*x_112 + 1.96039986610413) + 0.000642788741589215*std::sin(0.241599977016449*x_113 - 4.2131199836731) + 0.00387818100360694*std::sin(0.264399945735931*x_113 + 5.19080018997192) - 0.00944471651384347*std::sin(0.273839950561523*x_113 - 7.41279983520508) + 7.26060379573423e-5*std::sin(0.223999992012978*x_114 + 5.16527986526489) + 0.000783997250053056*std::sin(0.258879989385605*x_114 - 4.44127988815308) + 0.000930249194962607*std::sin(0.251599967479706*x_116 + 5.15064001083374) - 0.000120881172846351*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.00132826540212489*std::sin(0.275199949741364*x_116 - 1.24471986293793) + 0.00244023712492034*std::sin(0.317599922418594*x_116 - 1.45887994766235) + 0.00224142606764672*std::sin(0.235359981656075*x_118 + 1.94599986076355) - 0.000169200930127068*std::sin(0.240879982709885*x_118 - 7.44632005691528) - 4.34084980437478e-5*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.000924799122497642*std::sin(0.262319952249527*x_119 - 1.23623991012573) + 5.21588307774386e-5*std::sin(0.317199915647507*x_119 - 4.64807987213135) + 0.00542709418729579*std::sin(0.257279962301254*x_12 + 8.36040019989014) - 0.000628424042175193*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.0127253844006804*std::sin(0.263919949531555*x_120 + 5.15799999237061) + 0.00269723165544973*std::sin(0.255679965019226*x_13 - 1.02263987064362) + 0.00641538967953605*std::sin(0.263759940862656*x_13 - 4.21655988693237) - 0.000140798163774375*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 5.72102396705705e-6*std::sin(0.331999838352203*x_14 - 7.53599977493286) + 0.00320793982263233*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.000556159892314427*std::sin(0.33231982588768*x_15 - 4.33368015289307) - 0.0120611067651432*std::sin(0.339999854564667*x_15 - 4.34223985671997) - 0.000762769239323958*std::sin(0.344719856977463*x_15 + 1.83199989795685) + 8.84362143287198e-5*std::sin(0.346479833126068*x_15 + 5.05615997314453) + 0.00572630274216412*std::sin(0.256879955530167*x_16 - 4.20351982116699) - 0.00375868747814816*std::sin(0.288159936666489*x_16 - 7.40983963012695) + 0.015497461563242*std::sin(0.328159838914871*x_16 + 8.24831962585449) - 4.79352775050219e-5*std::sin(0.348159849643707*x_16 - 7.56640005111694) + 0.00069770877777258*std::sin(0.358399868011475*x_16 + 5.03200006484985) + 0.00562248420762927*std::sin(0.363199830055237*x_16 - 7.58160018920898) - 0.00276616837100791*std::sin(0.392959833145142*x_16 + 1.80143988132477) + 0.00702734976332085*std::sin(0.263119965791702*x_17 - 4.18071985244751) - 0.00033905536460626*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.0112488743047474*std::sin(0.354559868574142*x_17 + 8.22639942169189) + 0.000595684993822517*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.000373121189879412*std::sin(0.402239859104156*x_17 - 1.21327984333038) - 0.00027948541201192*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 4.92276358090693e-6*std::sin(0.362639844417572*x_18 + 8.20135974884033) + 0.00368307383551549*std::sin(0.389039844274521*x_18 + 5.00959968566895) + 0.000384122324072395*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.000237350812280364*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 0.00134794192136851*std::sin(0.274079948663712*x_20 + 1.98231983184814) + 0.00306293850300369*std::sin(0.277279943227768*x_20 + 1.99079978466034) + 0.00712423693586073*std::sin(0.298959940671921*x_21 - 4.21544027328491) - 0.00265100573757883*std::sin(0.318079918622971*x_21 - 4.38975954055786) - 0.000120594404301062*std::sin(0.322879940271378*x_21 - 1.21151983737946) - 0.00077096919178442*std::sin(0.32551982998848*x_21 + 8.24944019317627) + 0.00456311110096687*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.0141058690820126*std::sin(0.369199842214584*x_22 - 1.16735982894897) - 0.00647383941885761*std::sin(0.349599838256836*x_23 - 1.15639984607697) - 0.00337097493205541*std::sin(0.275199949741364*x_24 + 5.02551984786987) + 0.00645626859705603*std::sin(0.290399938821793*x_24 - 1.37751984596252) - 0.00049671990499943*std::sin(0.298399955034256*x_24 - 1.16463983058929) + 0.00663440432589061*std::sin(0.295839935541153*x_25 + 2.01895976066589) - 0.00248832351304559*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 0.00356096666683906*std::sin(0.228399991989136*x_26 - 1.19703996181488) - 0.0021013034796206*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.00104981543858732*std::sin(0.271199941635132*x_26 - 1.17551982402802) + 0.000360988811079094*std::sin(0.344799846410751*x_27 + 8.2139196395874) + 0.00343613320567863*std::sin(0.357039839029312*x_27 - 1.14823985099792) - 0.00983900671415675*std::sin(0.242239981889725*x_28 - 1.16359984874725) - 7.40867603850279e-5*std::sin(0.3018399477005*x_28 + 2.01215982437134) - 0.00360686111386219*std::sin(0.308959931135178*x_28 - 1.17487978935242) + 0.000150981411293206*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.00146123687149981*std::sin(0.225359991192818*x_29 + 1.78623986244202) - 0.00402625034580324*std::sin(0.268239974975586*x_29 + 8.22647953033447) - 0.00597678968037223*std::sin(0.304799944162369*x_29 - 7.40287971496582) + 0.000522066145525589*std::sin(0.329999834299088*x_29 - 4.36855983734131) - 0.00764230226276243*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.00051870922127314*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 5.14485904739107e-5*std::sin(0.346159845590591*x_3 - 7.3919997215271) + 0.00048410509253352*std::sin(0.360879838466644*x_3 + 1.97023975849152) + 0.00332719377065206*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.00161117768464728*std::sin(0.170480027794838*x_30 - 1.41063988208771) - 0.00736500226012313*std::sin(0.34911984205246*x_30 - 7.36520004272461) - 0.00119165356395154*std::sin(0.272159963846207*x_31 - 1.09007978439331) - 0.00134559996589452*std::sin(0.310239911079407*x_31 - 7.50207996368408) - 0.00523825013830165*std::sin(0.3572798371315*x_31 - 1.02039980888367) - 0.00192602925411351*std::sin(0.392399847507477*x_31 - 4.40167999267578) + 0.000797881164095821*std::sin(0.413359850645065*x_31 - 7.38687992095947) - 4.27902114811282e-5*std::sin(0.428559869527817*x_31 - 7.39463949203491) + 2.08412618384363e-6*std::sin(1.1684798002243*x_31 + 4.6057596206665) - 0.00213139657821097*std::sin(0.272559970617294*x_32 + 2.01647973060608) - 0.000664671581339995*std::sin(0.29911994934082*x_32 - 7.36168003082275) - 0.00217701849417452*std::sin(0.301039934158325*x_32 - 1.13639986515045) - 0.000765751352838835*std::sin(0.303839921951294*x_32 - 1.13263988494873) - 0.000126661886056379*std::sin(0.272879958152771*x_33 + 8.16928005218506) + 0.000659127530655023*std::sin(0.24695996940136*x_34 + 8.19207954406738) + 0.00462428224357375*std::sin(0.247039973735809*x_34 - 1.20383989810944) - 0.00201149104757662*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 6.19170309587844e-6*std::sin(0.239439979195595*x_35 + 1.96807980537415) + 0.000825548486207799*std::sin(0.246559977531433*x_35 + 1.94663977622986) + 2.55775073524755e-5*std::sin(0.206800013780594*x_37 - 4.39247989654541) - 0.00374926944447567*std::sin(0.229039996862411*x_37 + 8.19023990631104) + 0.00369551022927198*std::sin(0.225599989295006*x_38 - 7.41167974472046) + 3.45521338383319e-5*std::sin(0.237679988145828*x_38 - 7.59832000732422) - 0.00396802497197404*std::sin(0.255519956350327*x_4 - 0.956879794597626) - 0.00062827000720711*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.000748634513982501*std::sin(0.32551982998848*x_4 - 1.15559983253479) + 7.08211347449037e-5*std::sin(0.325999826192856*x_4 + 5.23935985565186) - 0.000362688032100093*std::sin(0.329039841890335*x_4 - 1.40119981765747) + 0.00214279096689632*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.00668836380026338*std::sin(0.379119843244553*x_4 - 4.38655996322632) - 0.00453553643137991*std::sin(0.379599839448929*x_4 - 1.17863988876343) + 0.00449436074201432*std::sin(0.242559969425201*x_41 - 1.21039986610413) + 0.00633568530978107*std::sin(0.220639988780022*x_42 + 8.20359992980957) + 0.00274471971421027*std::sin(0.246079966425896*x_42 + 8.18551921844482) + 0.00499870236657051*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.0011599537339974*std::sin(0.256239980459213*x_42 + 8.18048000335693) + 0.000496600501868242*std::sin(0.259839981794357*x_42 + 8.18391990661621) - 0.0106861838696986*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 8.8862332750614e-6*std::sin(0.129440054297447*x_44 + 1.7668799161911) - 0.000139368676804661*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.00651556084486435*std::sin(0.282799929380417*x_44 - 1.26543986797333) + 0.000470248913150816*std::sin(0.288799941539764*x_44 - 4.44839954376221) + 0.000837995375308157*std::sin(0.215279996395111*x_45 + 8.193039894104) + 8.14025610885499e-6*std::sin(0.257039964199066*x_45 - 4.43688011169434) + 0.00501076018935966*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 7.87958738179267e-6*std::sin(0.225519984960556*x_47 + 8.19655990600586) + 0.000138046810723922*std::sin(0.231999978423119*x_47 - 4.4127197265625) + 0.000859475397090995*std::sin(0.230159983038902*x_48 + 1.98047983646393) + 0.00487275360635862*std::sin(0.240479975938797*x_48 - 7.42575979232788) + 0.000105947766686041*std::sin(0.244319975376129*x_48 - 7.42799949645996) - 0.0052461933778615*std::sin(0.256079971790314*x_48 - 1.22367990016937) + 0.00304054289457202*std::sin(0.26639997959137*x_48 - 7.80967998504639) - 0.0059470131980899*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.00116194849487081*std::sin(0.260079979896545*x_49 + 1.94671976566315) + 0.000417015882362996*std::sin(0.36959981918335*x_5 + 2.01391983032227) - 0.000729757614434527*std::sin(0.39183983206749*x_5 + 2.01263976097107) - 0.00183890456511995*std::sin(0.220799997448921*x_51 + 1.95815980434418) - 0.0058301224437916*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.00560462312227633*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.000575465212894698*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 3.99534444775656e-6*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.00152386068962541*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.0178139745107905*std::sin(0.216879993677139*x_53 - 4.38775968551636) + 5.63920546265848e-5*std::sin(0.246479973196983*x_53 - 1.2053599357605) - 0.000145618289098402*std::sin(0.247599974274635*x_53 + 4.9792799949646) + 0.00964365904890892*std::sin(0.267279952764511*x_53 - 1.21335983276367) + 0.00917334601072546*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.0017822035379477*std::sin(0.220479995012283*x_56 + 8.19176006317139) + 0.000137165487625801*std::sin(0.239279985427856*x_56 - 1.22927987575531) - 4.68502502254812e-5*std::sin(0.252159982919693*x_56 + 8.16687965393066) - 0.00607770570858665*std::sin(0.247519969940186*x_58 - 1.23071992397308) + 0.00420613456439552*std::sin(0.238879978656769*x_6 + 5.02663946151733) - 0.00674353296135866*std::sin(0.282239943742752*x_6 - 0.996719837188721) - 0.000550434618843921*std::sin(0.387039840221405*x_6 - 1.1794399023056) - 3.84460898669372e-5*std::sin(0.45159986615181*x_6 - 4.24871969223022) - 0.00113877495453691*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.0134294210063312*std::sin(0.292239934206009*x_60 - 7.46751976013184) - 0.00354881767612819*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 6.07339275549061e-6*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.007011371222017*std::sin(0.375999838113785*x_7 + 8.22087955474854) - 0.000925052337737689*std::sin(0.789839863777161*x_7 + 1.21335983276367) + 0.00661214843065245*std::sin(0.285839945077896*x_8 + 1.97279977798462) - 0.000441260171557493*std::sin(0.319279909133911*x_8 - 7.41967964172363) + 0.00357642872601256*std::sin(0.327199846506119*x_8 + 8.25103950500488) - 0.00225757691662626*std::sin(0.336479842662811*x_8 - 1.14847981929779) + 0.00688199314794061*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.00991968519372697*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.0102650753671595*std::sin(0.295839935541153*x_9 - 1.21183979511261) - 0.00340024583981072*std::sin(0.341519832611084*x_9 + 5.04423999786377) - 0.00137016451075026*std::sin(0.327279835939407*x_91 + 4.99647998809814) + 0.000735811453752219*std::sin(0.345599830150604*x_91 + 2.00535988807678) - 0.0018772048429821*std::sin(0.367839843034744*x_91 - 1.18095993995667) - 3.24310831235314e-5*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.000312975999724124*std::sin(0.38663986325264*x_91 - 4.39359998703003) + 0.00170776567638468*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.00130053359099797*std::sin(0.291999936103821*x_92 + 1.99447977542877) + 0.00743732666621052*std::sin(0.292239934206009*x_92 - 7.38303995132446) + 6.29837742402705e-5*std::sin(0.329999834299088*x_92 + 1.7940798997879) - 0.00330268502973455*std::sin(0.230159983038902*x_93 - 7.42727994918823) - 0.000142582389884626*std::sin(0.255759954452515*x_94 + 1.99439978599548) + 0.000150720327983858*std::sin(0.279119968414307*x_94 + 1.99335980415344) - 2.03334352523011e-5*std::sin(0.295279920101166*x_94 + 1.96527981758118) + 0.00199204510593243*std::sin(0.301119923591614*x_94 - 4.40064001083374) - 0.00217958785122967*std::sin(0.336239844560623*x_94 - 7.57615995407104) - 0.000312626587461411*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.0138303359156222*std::sin(0.269679963588715*x_95 - 1.18839991092682) - 0.00428419064167293*std::sin(0.276159942150116*x_95 + 1.96335983276367) - 0.000158338696266708*std::sin(0.284079939126968*x_95 - 1.20591986179352) - 0.000615371577897958*std::sin(0.292079925537109*x_96 - 1.20975983142853) - 4.35850672375635e-5*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.00432888477014854*std::sin(0.274959951639175*x_97 - 1.21607995033264) - 0.00210956319749916*std::sin(0.282879948616028*x_97 - 4.42759990692139) + 0.000700992279455275*std::sin(0.286399960517883*x_97 + 1.94071984291077) - 0.00777131945446968*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.000829780682481475*std::sin(0.271519958972931*x_98 - 4.40455961227417) - 0.00278002947938296*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 0.00158533477359011*std::sin(0.252639979124069*x_99 - 1.21063983440399) + 0.00612755999494334*std::sin(0.263999968767166*x_99 - 1.22975981235504) - 0.0004507390749405*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.00891726317904796);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00299775718538632*x_1 - 0.00183952645744856*x_10 + 0.00348176245220804*x_100 + 0.00209111308579543*x_101 + 0.00349574633284817*x_102 + 0.00289532668774625*x_103 - 0.00353379875586809*x_104 - 0.00126684073363902*x_105 - 0.00211770255826463*x_106 + 0.00508457760557687*x_107 + 0.000263390611467998*x_108 - 0.00164809847599016*x_109 - 0.00106574382472724*x_11 + 0.00699615447581533*x_110 + 0.00763693340122226*x_111 - 0.00107536366624713*x_112 + 0.000382049401248603*x_113 + 0.00444652259683511*x_114 - 0.00127736859421154*x_115 + 0.00189867858134887*x_116 - 0.00208250981354802*x_117 + 0.00480645065961622*x_118 + 0.000533982838139391*x_119 - 0.000333158637181989*x_12 + 0.00420792163235287*x_120 + 0.00147748571271625*x_13 - 0.00220106191918639*x_14 + 0.000712689849739774*x_15 - 0.00249902265071043*x_16 + 0.00167781363324267*x_17 + 0.00117541570047944*x_18 + 0.00237573810978592*x_19 - 0.00241112871513684*x_2 - 0.000396789784061483*x_20 - 0.00267419338031723*x_21 - 0.00305336446410699*x_22 + 0.00162301947558193*x_23 + 0.00370831248426456*x_24 + 0.00193871890817223*x_25 - 0.00192119094988675*x_26 - 0.00131592192347731*x_27 + 0.00489312720112855*x_28 - 0.00291553658645553*x_29 - 0.000362659074163989*x_3 - 0.00070968853845454*x_30 + 0.000550427970444553*x_31 - 0.000410273514087222*x_32 - 2.45881455755194e-6*x_33 - 0.00503960067773692*x_34 + 0.00293240524747052*x_35 - 0.00130700830851722*x_36 - 0.00181267180115165*x_37 + 0.00353030910954125*x_38 - 0.00600112287085349*x_39 + 0.000642451977018488*x_4 - 0.00519039010546767*x_40 + 0.00196455119826379*x_41 - 0.000231001361939044*x_42 - 0.00112595858226268*x_43 + 0.00131088741479962*x_44 - 0.000401238269600231*x_45 - 0.00420028700808599*x_46 + 0.00561776653453175*x_47 + 0.00383565355326795*x_48 - 0.00509054617426106*x_49 + 0.000952804344979646*x_5 - 0.0040620119663414*x_50 - 0.00846302465998813*x_51 - 0.00715036334065908*x_52 - 0.00202801776016295*x_53 - 0.00233467105968329*x_54 + 0.000409965173790566*x_55 + 0.000219929031006675*x_56 + 0.00395416222669985*x_57 + 0.00215378498272765*x_58 - 0.00121612417737908*x_59 - 0.000197513579603625*x_6 - 0.00348009903333535*x_60 + 0.000858320998359192*x_61 + 0.00215494452638992*x_62 + 0.000646007596265623*x_63 + 0.00099404894753996*x_64 - 0.000887192410810537*x_65 - 0.00145463321936174*x_66 - 0.000561612526547195*x_67 - 0.00135694643603749*x_68 - 0.000616951383507429*x_69 - 0.000108101167868275*x_7 + 0.000609157855730226*x_70 - 0.000745065532488346*x_71 + 0.000482990649441847*x_72 - 0.00033825771973868*x_73 - 0.00152983518334849*x_74 + 0.000391014412268674*x_75 - 0.000189421638985571*x_76 - 0.000132896885480587*x_77 + 0.00190487998138595*x_78 - 0.000165790741543583*x_79 + 0.00291800783433411*x_8 + 0.00108869425564228*x_80 + 0.000606467462172133*x_81 + 0.000989495612989638*x_82 + 0.00149080718675589*x_83 + 0.000593598077935488*x_84 - 0.00122721429217668*x_85 - 0.000545453490202678*x_86 - 0.000450641711076592*x_87 - 0.000552984426181475*x_88 - 0.000112699576786825*x_89 + 0.00459579020324173*x_9 + 0.00103123739178404*x_90 + 0.00101492601399418*x_91 - 0.00106164473201271*x_92 - 0.00308930074817533*x_93 - 0.0013080447285921*x_94 - 6.17644780439338e-5*x_95 + 0.00898304353728614*x_96 - 0.00303778760013183*x_97 + 0.00195932089941667*x_98 + 0.00268208299393979*x_99 - 5.29237542695461e-6*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) + 0.0166442671975395*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.000984795305768618*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.00125434108998498*std::sin(0.189440011978149*x_10 - 7.40327978134155) + 0.000214099118151892*std::sin(0.204960003495216*x_10 - 1.20431983470917) - 0.00266648252805411*std::sin(0.285999923944473*x_10 + 4.99871969223022) - 0.000636247962531109*std::sin(0.235359981656075*x_100 - 1.21407985687256) + 0.0035409027097598*std::sin(0.25655996799469*x_100 + 1.94487977027893) - 0.00198462879150466*std::sin(0.261679977178574*x_100 - 1.21367979049683) - 0.0305231838375155*std::sin(0.264479964971542*x_100 - 1.2105598449707) + 0.0136896793805018*std::sin(0.234399989247322*x_101 + 1.9826397895813) + 0.0028157806988949*std::sin(0.236559987068176*x_101 + 1.95871984958649) - 0.000900982115981267*std::sin(0.244959965348244*x_101 - 1.20255982875824) - 0.000623996409122266*std::sin(0.246719971299171*x_101 - 1.207279920578) + 0.0201271119389332*std::sin(0.23455998301506*x_102 - 1.19255983829498) - 0.0260684468240093*std::sin(0.235199987888336*x_102 - 1.20855987071991) - 0.000200544889146592*std::sin(0.249999970197678*x_102 - 4.40383958816528) + 0.00285838350457482*std::sin(0.243999972939491*x_103 - 1.20647990703583) + 0.00267199728766936*std::sin(0.22495998442173*x_104 - 1.19919991493225) - 0.00376744850786132*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.0015075426222263*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.000642168411023482*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.00601972682985639*std::sin(0.253119975328445*x_107 - 7.42199993133545) + 0.0029019144200889*std::sin(0.263919949531555*x_108 + 1.94823980331421) - 0.00815598300007943*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.0022033576832664*std::sin(0.273199945688248*x_108 - 1.22711992263794) - 0.000993600306372101*std::sin(0.274479955434799*x_108 - 1.23687982559204) - 0.0273267863826252*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.00533171650622895*std::sin(0.281999945640564*x_108 + 8.15032005310059) - 0.0185172794120375*std::sin(0.226879999041557*x_109 + 1.95823979377747) + 0.00115766589109258*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.000902659307518873*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 0.00230115908601973*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.0155932353111762*std::sin(0.239999979734421*x_109 - 4.40607976913452) + 0.00121675023007381*std::sin(0.261519968509674*x_109 + 4.95928001403809) - 0.0248235304223812*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.0139667610176121*std::sin(0.293839931488037*x_11 - 7.45207977294922) + 0.00244087367577222*std::sin(0.311919927597046*x_11 + 5.12680006027222) - 0.0274308888594063*std::sin(0.313519924879074*x_11 + 1.93895983695984) - 0.0128015142789216*std::sin(0.256239980459213*x_110 - 7.63824033737183) + 0.0280898295499705*std::sin(0.26759997010231*x_112 + 5.15015983581543) + 0.00205088235517331*std::sin(0.278399974107742*x_112 + 1.96039986610413) - 0.0015386070854036*std::sin(0.241599977016449*x_113 - 4.2131199836731) + 0.0193971939068284*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.0207863402550136*std::sin(0.273839950561523*x_113 - 7.41279983520508) - 0.0017908267754579*std::sin(0.223999992012978*x_114 + 5.16527986526489) + 0.00303041067944763*std::sin(0.258879989385605*x_114 - 4.44127988815308) + 0.00359572319261511*std::sin(0.251599967479706*x_116 + 5.15064001083374) + 0.00236255737815485*std::sin(0.272719949483871*x_116 + 1.93367981910706) - 0.0252692132821587*std::sin(0.275199949741364*x_116 - 1.24471986293793) + 0.000155290634117812*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 0.00493302735241143*std::sin(0.235359981656075*x_118 + 1.94599986076355) + 0.00330694099378468*std::sin(0.240879982709885*x_118 - 7.44632005691528) + 0.000848395700612801*std::sin(0.253039985895157*x_119 - 7.62432050704956) - 0.0175935819996227*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 7.98087169721919e-5*std::sin(0.317199915647507*x_119 - 4.64807987213135) + 0.000667181767302753*std::sin(0.257279962301254*x_12 + 8.36040019989014) + 0.00150422311619552*std::sin(0.273439943790436*x_12 - 7.43800020217896) + 0.0192949886665961*std::sin(0.263919949531555*x_120 + 5.15799999237061) - 0.00297143117938245*std::sin(0.255679965019226*x_13 - 1.02263987064362) + 0.000788678227539931*std::sin(0.263759940862656*x_13 - 4.21655988693237) + 0.00275182423220382*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.00629604215382204*std::sin(0.331999838352203*x_14 - 7.53599977493286) + 0.0160449011335889*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.000967675799569661*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.0182877711990845*std::sin(0.339999854564667*x_15 - 4.34223985671997) - 0.00294835734263741*std::sin(0.344719856977463*x_15 + 1.83199989795685) - 0.00172843814912331*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.00482583807255531*std::sin(0.256879955530167*x_16 - 4.20351982116699) - 0.000239193542287969*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 0.0234981778002537*std::sin(0.328159838914871*x_16 + 8.24831962585449) + 0.000936869165617207*std::sin(0.348159849643707*x_16 - 7.56640005111694) + 0.00269687697394766*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.0123742062185689*std::sin(0.363199830055237*x_16 - 7.58160018920898) - 0.000340059899226777*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.0154660950444909*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.000518791798597391*std::sin(0.349279850721359*x_17 - 1.16287982463837) - 0.0170562157800482*std::sin(0.354559868574142*x_17 + 8.22639942169189) + 0.00230252104423107*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.000649202415964251*std::sin(0.402239859104156*x_17 - 1.21327984333038) + 0.000427643254510298*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.0054175488858568*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.00810586806042824*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.000587749176652457*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.000412972312865129*std::sin(0.238639980554581*x_20 - 1.20031988620758) + 0.0256435437138797*std::sin(0.274079948663712*x_20 + 1.98231983184814) + 0.000194917804314132*std::sin(0.277279943227768*x_20 + 1.99079978466034) - 0.00600394624437691*std::sin(0.298959940671921*x_21 - 4.21544027328491) - 0.000168703425513212*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.00235695264148213*std::sin(0.322879940271378*x_21 - 1.21151983737946) - 0.00298005289195913*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.0100426921048505*std::sin(0.380319833755493*x_21 - 1.37543988227844) - 0.0213881620782606*std::sin(0.369199842214584*x_22 - 1.16735982894897) - 0.000795863767173687*std::sin(0.349599838256836*x_23 - 1.15639984607697) - 0.016860341059719*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.0142092349346283*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.000760035793012849*std::sin(0.298399955034256*x_24 - 1.16463983058929) + 0.000815602871516458*std::sin(0.295839935541153*x_25 + 2.01895976066589) - 0.000158350732510769*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 0.0178106078257275*std::sin(0.228399991989136*x_26 - 1.19703996181488) + 0.00231492117633789*std::sin(0.251279979944229*x_26 + 1.98895990848541) - 0.0199719199055608*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.000552352371096502*std::sin(0.344799846410751*x_27 + 8.2139196395874) - 0.00378544917461397*std::sin(0.357039839029312*x_27 - 1.14823985099792) - 0.00120956181365366*std::sin(0.242239981889725*x_28 - 1.16359984874725) + 0.00144798580498322*std::sin(0.3018399477005*x_28 + 2.01215982437134) - 0.0180401544836392*std::sin(0.308959931135178*x_28 - 1.17487978935242) - 0.00295085031701663*std::sin(0.207440003752708*x_29 - 4.39679956436157) - 0.0277988917746508*std::sin(0.225359991192818*x_29 + 1.78623986244202) + 0.00443555739431819*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00503693578385544*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.000798818313754022*std::sin(0.329999834299088*x_29 - 4.36855983734131) - 0.000939509165303854*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.00090251448796647*std::sin(0.339599847793579*x_29 - 4.35775995254517) + 0.00126897866861127*std::sin(0.346159845590591*x_3 - 7.3919997215271) + 0.00187122753592475*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00280399047974774*std::sin(0.396319836378098*x_3 - 1.1827198266983) + 0.0306513987970144*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.0162092152510318*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.00262264266059122*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.0011340035339083*std::sin(0.310239911079407*x_31 - 7.50207996368408) - 0.0261997450790994*std::sin(0.3572798371315*x_31 - 1.02039980888367) - 0.000236777096046043*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.00122084546477814*std::sin(0.413359850645065*x_31 - 7.38687992095947) + 0.000836311622952606*std::sin(0.428559869527817*x_31 - 7.39463949203491) - 5.14049392924164e-5*std::sin(1.1684798002243*x_31 + 4.6057596206665) + 0.00179623313994701*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.00101702023078263*std::sin(0.29911994934082*x_32 - 7.36168003082275) + 0.0023983333499042*std::sin(0.301039934158325*x_32 - 1.13639986515045) - 0.00295988420531734*std::sin(0.303839921951294*x_32 - 1.13263988494873) + 0.00247553830251028*std::sin(0.272879958152771*x_33 + 8.16928005218506) + 0.00254774759462454*std::sin(0.24695996940136*x_34 + 8.19207954406738) + 0.000294277844808933*std::sin(0.247039973735809*x_34 - 1.20383989810944) + 0.00169518282862055*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.0068140290829186*std::sin(0.239439979195595*x_35 + 1.96807980537415) - 0.00197606875796104*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.000630868813461436*std::sin(0.206800013780594*x_37 - 4.39247989654541) + 0.0041304187219927*std::sin(0.229039996862411*x_37 + 8.19023990631104) - 0.0040711943658227*std::sin(0.225599989295006*x_38 - 7.41167974472046) - 0.00067530283507842*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.00873300083564691*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.000961321840231855*std::sin(0.324879825115204*x_4 - 7.35623979568481) - 0.0142421877238886*std::sin(0.32551982998848*x_4 - 1.15559983253479) - 0.00138416091175378*std::sin(0.325999826192856*x_4 + 5.23935985565186) - 0.00140191012877862*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.001805835753921*std::sin(0.345839858055115*x_4 + 2.01703977584839) - 0.0101412970846879*std::sin(0.379119843244553*x_4 - 4.38655996322632) - 0.000557577795321418*std::sin(0.379599839448929*x_4 - 1.17863988876343) + 0.0224790918007716*std::sin(0.242559969425201*x_41 - 1.21039986610413) + 0.000778879742302773*std::sin(0.220639988780022*x_42 + 8.20359992980957) + 0.0137280494301104*std::sin(0.246079966425896*x_42 + 8.18551921844482) + 0.000318105012149702*std::sin(0.253199964761734*x_42 - 1.22143983840942) - 0.0220672150723238*std::sin(0.256239980459213*x_42 + 8.18048000335693) + 0.00191952645775062*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.0235186152615183*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.00977938558038639*std::sin(0.129440054297447*x_44 + 1.7668799161911) + 0.00272388567975803*std::sin(0.256959974765778*x_44 - 1.23063993453979) - 0.00987928291199225*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.000719532279706852*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.00128222459620209*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.00895843050114376*std::sin(0.257039964199066*x_45 - 4.43688011169434) + 0.0250619264349004*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.00867156204836016*std::sin(0.225519984960556*x_47 + 8.19655990600586) - 0.00269805051958838*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.0013150913793234*std::sin(0.230159983038902*x_48 + 1.98047983646393) - 0.0053681158480131*std::sin(0.240479975938797*x_48 - 7.42575979232788) - 0.00207069200264376*std::sin(0.244319975376129*x_48 - 7.42799949645996) - 0.0262394741577183*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 0.00669175819876656*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.00501184167194152*std::sin(0.242799982428551*x_49 - 1.21991980075836) + 0.0221051638421076*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.000638079919207338*std::sin(0.36959981918335*x_5 + 2.01391983032227) - 0.00282075640959321*std::sin(0.39183983206749*x_5 + 2.01263976097107) - 0.000117023322480981*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.0128311854217557*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.000356664305186346*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.00222436485164798*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.00439691516885116*std::sin(0.234079986810684*x_52 + 5.17903995513916) - 0.0289902610704462*std::sin(0.25519996881485*x_52 + 1.95015978813171) + 0.0270106132333696*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.00139090913358618*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.00284603098400614*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.0212241815834435*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.0201890963245349*std::sin(0.174000009894371*x_55 + 8.2183198928833) - 0.0339050322628096*std::sin(0.220479995012283*x_56 + 8.19176006317139) - 0.00268082553459712*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.00115556067926455*std::sin(0.252159982919693*x_56 + 8.16687965393066) - 0.00074716492765005*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.00925704271650175*std::sin(0.238879978656769*x_6 + 5.02663946151733) - 0.000829018639395584*std::sin(0.282239943742752*x_6 - 0.996719837188721) + 0.00131754424091316*std::sin(0.387039840221405*x_6 - 1.1794399023056) + 0.000751408107131707*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.000959701884291181*std::sin(0.512639820575714*x_6 + 1.91543984413147) + 0.0203624910617437*std::sin(0.292239934206009*x_60 - 7.46751976013184) - 0.0177498431712744*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.00668382741017538*std::sin(0.348239839076996*x_7 - 7.34895992279053) - 0.0106310602498485*std::sin(0.375999838113785*x_7 + 8.22087955474854) - 0.00011372164039167*std::sin(0.789839863777161*x_7 + 1.21335983276367) + 0.000812866835065745*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.000675176333863789*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00301403308328214*std::sin(0.327199846506119*x_8 + 8.25103950500488) - 0.000143666591812904*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.0151461879238079*std::sin(0.345519840717316*x_8 + 5.03679990768433) + 0.0150408197790024*std::sin(0.388639837503433*x_8 + 1.80719995498657) - 0.0155645210105013*std::sin(0.295839935541153*x_9 - 1.21183979511261) - 0.00041801043991078*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.00301551726661715*std::sin(0.327279835939407*x_91 + 4.99647998809814) - 0.00176127029459983*std::sin(0.345599830150604*x_91 + 2.00535988807678) - 0.00938906830503664*std::sin(0.367839843034744*x_91 - 1.18095993995667) + 0.000633848041931582*std::sin(0.382879853248596*x_91 - 1.17583978176117) + 0.00595412428613577*std::sin(0.38663986325264*x_91 - 4.39359998703003) + 0.000108677969080184*std::sin(0.445439845323563*x_91 - 1.38639986515045) + 0.0247416372051596*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.0163683899294322*std::sin(0.292239934206009*x_92 - 7.38303995132446) - 0.00123098392439103*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.00278333575359097*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 0.000218166654234952*std::sin(0.255759954452515*x_94 + 1.99439978599548) - 0.00294574758443811*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.000501523858225872*std::sin(0.295279920101166*x_94 + 1.96527981758118) + 0.00996345584566119*std::sin(0.301119923591614*x_94 - 4.40064001083374) + 0.00240116390680101*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.000478352878406206*std::sin(0.268159955739975*x_95 - 1.18831992149353) - 0.0209703822175209*std::sin(0.269679963588715*x_95 - 1.18839991092682) - 0.0214279004855782*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.00309464448684513*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.000941585832373236*std::sin(0.292079925537109*x_96 - 1.20975983142853) + 0.00107502499261865*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.000275479482757745*std::sin(0.274959951639175*x_97 - 1.21607995033264) - 0.0105512368717557*std::sin(0.282879948616028*x_97 - 4.42759990692139) + 0.00270956880234955*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.0171034556912578*std::sin(0.265119940042496*x_98 - 1.19839990139008) - 0.0157859302888536*std::sin(0.271519958972931*x_98 - 4.40455961227417) - 0.00017691417621297*std::sin(0.246479973196983*x_99 - 7.43895959854126) + 0.0301597575705766*std::sin(0.252639979124069*x_99 - 1.21063983440399) + 0.000753293782195626*std::sin(0.263999968767166*x_99 - 1.22975981235504) + 0.0010789086514756*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.0731979267849643);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00087391183740168*x_1 - 0.000399906561650846*x_10 - 0.00216123257696915*x_100 + 0.00193033197117242*x_101 + 0.00314380467275554*x_102 - 0.00132505761749274*x_103 - 0.0046478571740568*x_104 - 0.00752956510994437*x_105 - 0.00387089892122831*x_106 - 0.000669694156970416*x_107 + 0.00032346535629619*x_108 - 0.000173724570425802*x_109 - 0.00215755710779355*x_11 + 0.00025389155847607*x_110 + 0.00390185984330402*x_111 - 1.78854163391322e-5*x_112 - 0.00218403581564058*x_113 - 0.00673224286967956*x_114 + 0.00684196378817579*x_115 - 0.00019767893977235*x_116 + 0.00586330745369888*x_117 - 0.00322696020277071*x_118 + 0.00565035446288559*x_119 - 0.00444816375170214*x_12 - 0.00254858992335462*x_120 + 0.00372369400590439*x_13 - 0.000524638077226993*x_14 - 7.01736325384725e-5*x_15 + 0.000955749921967923*x_16 + 0.000586546593983472*x_17 - 0.000134150206739555*x_18 + 0.00254438693994481*x_19 + 0.000921927277290757*x_2 + 0.00116833080730578*x_20 + 0.00163112463995477*x_21 + 0.00147419716669556*x_22 - 2.52436676633396e-5*x_23 + 0.000450072782348468*x_24 + 0.00400530502699008*x_25 - 0.00353068052121984*x_26 + 0.00189181882665275*x_27 + 0.00346122277929408*x_28 - 0.000507382118436808*x_29 + 0.00175352443399887*x_3 + 0.000344090492472839*x_30 - 1.8780469366156e-5*x_31 - 4.50412932470688e-6*x_32 - 0.000569122401616418*x_33 - 0.00605796014508287*x_34 + 0.00354912383416233*x_35 - 0.00079206244635347*x_36 - 0.00504228917580433*x_37 + 0.00310299206219898*x_38 - 0.00158643651338818*x_39 + 0.000262512415019385*x_4 + 0.00260506970006254*x_40 + 0.00141339698195033*x_41 + 0.000109582080583096*x_42 - 0.00140479837629914*x_43 + 0.00260570411446084*x_44 + 0.00592041475579689*x_45 - 0.00311924249691811*x_46 - 0.00302622582555873*x_47 - 0.00111853272122523*x_48 - 0.00273140497679476*x_49 - 0.00193932337431549*x_5 + 0.00301659727572087*x_50 - 9.19881763743343e-5*x_51 + 0.00115150011319861*x_52 + 4.98096302333414e-5*x_53 - 0.00848101919003171*x_54 - 0.00347010176904079*x_55 - 0.00273110740465627*x_56 + 0.00487608996913277*x_57 + 0.00673329698343877*x_58 - 0.00385922840438766*x_59 + 0.000443837648615128*x_6 + 0.00200896659657239*x_60 + 0.000108573102831082*x_61 + 0.000178797120206527*x_62 - 0.00307545448687977*x_63 + 0.00226314349459977*x_64 + 0.000568333025408948*x_65 + 0.000783790172751339*x_66 - 0.00138180235798724*x_67 + 0.000715187156522812*x_68 - 0.00010677505140713*x_69 - 0.000230723864334463*x_7 + 0.00023437230314489*x_70 - 0.000147563284143158*x_71 - 0.000612104886144304*x_72 + 0.0019390042615034*x_73 + 0.000139662812846249*x_74 - 0.00060359706320384*x_75 + 0.000599069030359731*x_76 + 0.00042330892479753*x_77 + 0.000394602094263104*x_78 + 0.000810949534124894*x_79 + 0.00142231328411647*x_8 + 0.000931308148241543*x_80 + 0.000290933627217866*x_81 + 0.000956104939039693*x_82 - 0.000976309058969164*x_83 + 0.000465377708022231*x_84 - 0.00132164683156977*x_85 + 0.000903048335415701*x_86 - 0.000612790465129873*x_87 + 0.000508902083598764*x_88 - 9.98492744119028e-6*x_89 + 0.00228204630985916*x_9 - 0.00319406450948356*x_90 - 0.000790270704759248*x_91 + 0.00013858002278639*x_92 + 3.25470285819571e-5*x_93 + 0.000243354489720492*x_94 + 0.000407009029204531*x_95 - 0.00297133135833177*x_96 - 0.00349688968503571*x_97 + 0.000729818139521021*x_98 - 0.000640945562187298*x_99 - 3.00047601826454e-7*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) - 0.00448503497794151*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.00287265369734065*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.00365892033477894*std::sin(0.189440011978149*x_10 - 7.40327978134155) - 0.00127377658849438*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 0.00490655362786174*std::sin(0.285999923944473*x_10 + 4.99871969223022) - 0.00247634689076859*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.010550160727058*std::sin(0.25655996799469*x_100 + 1.94487977027893) - 0.00113968851362869*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.00822490684177632*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.000119533525466165*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.00838965127836115*std::sin(0.236559987068176*x_101 + 1.95871984958649) - 0.00350672126740088*std::sin(0.244959965348244*x_101 - 1.20255982875824) + 0.000369369073066044*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.000175742950630348*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.00702451447328205*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 0.00119313609015383*std::sin(0.249999970197678*x_102 - 4.40383958816528) + 0.00164144895088407*std::sin(0.243999972939491*x_103 - 1.20647990703583) + 0.00153441521670912*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.011225156562279*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.000693163790252235*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.00187320903078655*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.000341284291690568*std::sin(0.253119975328445*x_107 - 7.42199993133545) - 0.00533976824368023*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 7.12152107104984e-5*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.00126529528029793*std::sin(0.273199945688248*x_108 - 1.22711992263794) - 0.00386720142813969*std::sin(0.274479955434799*x_108 - 1.23687982559204) + 0.00736359199874703*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.000302278017384166*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.000161686452154275*std::sin(0.226879999041557*x_109 + 1.95823979377747) - 0.00152530966318267*std::sin(0.232559978961945*x_109 + 4.97751951217651) - 0.00124430718355036*std::sin(0.235839992761612*x_109 - 7.43439960479736) + 0.00423432756187481*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.0250389748278706*std::sin(0.239999979734421*x_109 - 4.40607976913452) + 0.000698728279618899*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.000216750445604304*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.0224272494173306*std::sin(0.293839931488037*x_11 - 7.45207977294922) + 0.00140169068563556*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.013520131531201*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.00630960803846568*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.00756920485358807*std::sin(0.26759997010231*x_112 + 5.15015983581543) + 0.00117773513767413*std::sin(0.278399974107742*x_112 + 1.96039986610413) + 0.00202722760795219*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.000169369559899*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.0333778487929186*std::sin(0.273839950561523*x_113 - 7.41279983520508) - 0.0069700943318832*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.00902914379687494*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.0107134989920897*std::sin(0.251599967479706*x_116 + 5.15064001083374) + 0.00135671694283463*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.0124546852643313*std::sin(0.275199949741364*x_116 - 1.24471986293793) - 0.000923897192380695*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 0.00792125208382493*std::sin(0.235359981656075*x_118 + 1.94599986076355) + 0.00189903657651103*std::sin(0.240879982709885*x_118 - 7.44632005691528) + 0.000487197827190296*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.00867152150843639*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 0.000232802496668324*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 0.000394932258186915*std::sin(0.257279962301254*x_12 + 8.36040019989014) - 0.00198192420833127*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.00519930965068028*std::sin(0.263919949531555*x_120 + 5.15799999237061) + 0.00546768496689907*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 0.000466850997209367*std::sin(0.263759940862656*x_13 - 4.21655988693237) + 0.00158025646024717*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.000356949799825448*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.000140098503766685*std::sin(0.297199934720993*x_15 + 5.15664005279541) - 0.00133393179322775*std::sin(0.33231982588768*x_15 - 4.33368015289307) - 0.00492790055116458*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.00878466492736147*std::sin(0.344719856977463*x_15 + 1.83199989795685) - 0.000992569045408228*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.00221890655706704*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.00142307514816247*std::sin(0.288159936666489*x_16 - 7.40983963012695) + 0.00633191885838061*std::sin(0.328159838914871*x_16 + 8.24831962585449) + 0.00053800440233325*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00803537624962862*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.019869990533623*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 0.000201295404794092*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.0248348182257536*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.00151331872690806*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.00459604039378452*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.00686038817929537*std::sin(0.38239985704422*x_17 - 1.19231986999512) + 0.000894919293507285*std::sin(0.402239859104156*x_17 - 1.21327984333038) + 0.00124743788786949*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.000307144225388841*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.0130160689730394*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.00171446780415127*std::sin(0.435919851064682*x_2 - 4.1898398399353) - 0.000569278365852049*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 0.0126391851796982*std::sin(0.274079948663712*x_20 + 1.98231983184814) - 0.00115965790966*std::sin(0.277279943227768*x_20 + 1.99079978466034) - 0.00276059732830442*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 0.0010036962117008*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.00135349837922457*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.00887910218449221*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.0161261412272267*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.00576334505426958*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 0.000471104412894456*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.000147218641972042*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.0228166040434505*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.00221702887708786*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 0.00048278879852177*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.000942103160369192*std::sin(0.374799847602844*x_25 + 8.20135974884033) + 0.000155516041313338*std::sin(0.228399991989136*x_26 - 1.19703996181488) - 0.00425965097332308*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.00984375626461703*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.00161121511421791*std::sin(0.344799846410751*x_27 + 8.2139196395874) + 0.00696554700260595*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 0.000715989257941058*std::sin(0.242239981889725*x_28 - 1.16359984874725) + 0.000831517106322746*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.000157520363000977*std::sin(0.308959931135178*x_28 - 1.17487978935242) - 0.00169454873684046*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.0137015127413934*std::sin(0.225359991192818*x_29 + 1.78623986244202) - 0.00816180117278431*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00231596868156093*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.00233015771812388*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 0.000556134016882364*std::sin(0.330399841070175*x_29 - 1.12807989120483) - 0.00124410755118865*std::sin(0.339599847793579*x_29 - 4.35775995254517) + 0.0049390042334533*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.0055753441647771*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00128926681084667*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.0151074558857697*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.0260280900371731*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.00421133153258943*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.000521411584743446*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.000228767073981301*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 0.000140158076571014*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.00356121339910254*std::sin(0.413359850645065*x_31 - 7.38687992095947) + 0.000480258451642549*std::sin(0.428559869527817*x_31 - 7.39463949203491) - 0.000200073664802816*std::sin(1.1684798002243*x_31 + 4.6057596206665) + 0.000825902865435163*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.0029666539930831*std::sin(0.29911994934082*x_32 - 7.36168003082275) - 0.00441313643535544*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.00881900934852189*std::sin(0.303839921951294*x_32 - 1.13263988494873) + 0.00142159711705069*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.00759104353281921*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.00175079763273135*std::sin(0.247039973735809*x_34 - 1.20383989810944) + 0.000779440221014687*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.000386316714171943*std::sin(0.239439979195595*x_35 + 1.96807980537415) + 0.00260361542550649*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.00245541065229221*std::sin(0.206800013780594*x_37 - 4.39247989654541) - 0.00760032017902279*std::sin(0.229039996862411*x_37 + 8.19023990631104) + 0.007491342349029*std::sin(0.225599989295006*x_38 - 7.41167974472046) - 0.00038779790339344*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.0140230929458758*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.00280418146035029*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.00701968690500529*std::sin(0.32551982998848*x_4 - 1.15559983253479) - 0.000794865165159474*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.0041770075022785*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.000830318119903202*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.00273271701341381*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 0.000330053170834395*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.000196279621862502*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.000461050871829493*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.000119868559412143*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.00189255668429026*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.0108764849667936*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.00571925136301839*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.0377652234297688*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.000554435570799938*std::sin(0.129440054297447*x_44 + 1.7668799161911) + 0.00156421252928831*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.00266211356086708*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.00209887989062112*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.0037402566863641*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.000507892084584006*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.000218832036782698*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.000491628274035155*std::sin(0.225519984960556*x_47 + 8.19655990600586) - 0.00154937648769749*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.00383612928597954*std::sin(0.230159983038902*x_48 + 1.98047983646393) + 0.00987778768911413*std::sin(0.240479975938797*x_48 - 7.42575979232788) - 0.00118911098175023*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.000229113974496562*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 0.0107453496179218*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.00230443048060341*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.0108951891495693*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.00186128287611928*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.00840447646614557*std::sin(0.39183983206749*x_5 + 2.01263976097107) + 0.000696226914761746*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.020603788910747*std::sin(0.178240016102791*x_52 - 0.965199828147888) + 0.00212196409690803*std::sin(0.224639996886253*x_52 - 7.41792011260986) - 0.00662752089624529*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.000249280095499065*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.0142887146240573*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.00727839463819836*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.0054135709835446*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.00163435541990903*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.0340809163592306*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.0324188190955577*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.01671110615891*std::sin(0.220479995012283*x_56 + 8.19176006317139) - 0.00153948490614531*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.00449756897264924*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 0.000442277571984362*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.0148645778078447*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 0.000490730141890961*std::sin(0.282239943742752*x_6 - 0.996719837188721) - 0.00173596110743044*std::sin(0.387039840221405*x_6 - 1.1794399023056) + 0.000431501947573893*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.000441268184275342*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.00548696338301048*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.000154985465456254*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.000378935019468006*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.0028646906774137*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 6.73165042057006e-5*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 0.000481169226304846*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.00196949333579218*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00138584379980459*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 0.00085474028468547*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.0243211245514013*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.00405296322181805*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.0041940819814118*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 0.000247437527627696*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.00484219338867533*std::sin(0.327279835939407*x_91 + 4.99647998809814) + 0.00232060270627328*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 8.19820833015388e-5*std::sin(0.367839843034744*x_91 - 1.18095993995667) + 0.000363992166125825*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.00293466769940522*std::sin(0.38663986325264*x_91 - 4.39359998703003) - 0.000646576473057891*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.0121946536630842*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.0262836861778179*std::sin(0.292239934206009*x_92 - 7.38303995132446) - 0.000706902089244795*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.0012797698267758*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 0.000636393413182782*std::sin(0.255759954452515*x_94 + 1.99439978599548) - 0.00169161845298448*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.00195198589245491*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 8.69974358022324e-5*std::sin(0.301119923591614*x_94 - 4.40064001083374) - 0.00441834489971431*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.00139535815893703*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.00565076831741126*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.000187100984412202*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.00177712365683649*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.00274661140938263*std::sin(0.292079925537109*x_96 - 1.20975983142853) + 0.00418411524239587*std::sin(0.303679943084717*x_96 + 8.17136001586914) - 0.00163895731461357*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 9.21297355660432e-5*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.00807319169968069*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.0274640244937535*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.00778056646073589*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 0.00105254583847925*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 0.0148651358471567*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 0.000445905492416854*std::sin(0.263999968767166*x_99 - 1.22975981235504) - 0.00142154122743824*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.112322412064367);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00291716385098317*x_1 + 0.00362934140752303*x_10 - 0.00321726721276316*x_100 + 2.42743641108489e-5*x_101 - 7.7675590903608e-5*x_102 + 0.00308292082301922*x_103 + 0.00399731266618916*x_104 - 0.00364116889739877*x_105 - 0.00238801635740123*x_106 + 0.00200746140811985*x_107 + 7.64009575828389e-5*x_108 - 0.000214219142804555*x_109 + 0.00276224289410786*x_11 - 0.00361668498930739*x_110 + 0.00590182812698524*x_111 + 0.00195929284494354*x_112 + 0.00209207944037789*x_113 - 0.00191705994307086*x_114 + 0.00705366054907909*x_115 + 0.000490520918210394*x_116 + 0.00388960916716191*x_117 - 0.00405602566112641*x_118 - 0.00146302946895047*x_119 - 0.00140979525776454*x_12 + 0.00184484256269178*x_120 + 0.00647823907069961*x_13 + 0.00235985763104633*x_14 + 0.000905342136268826*x_15 + 0.00362203616408804*x_16 + 0.00734956035409456*x_17 - 0.000552557043131969*x_18 + 0.00418004017630051*x_19 + 0.00140230883636438*x_2 + 0.00064274294811266*x_20 + 0.000908064943167008*x_21 + 0.00443375310369239*x_22 + 0.000899388942557939*x_23 - 0.00351933961644921*x_24 - 0.000540351507501171*x_25 + 0.000841453578973785*x_26 + 0.00491285428607735*x_27 - 0.00163210470131403*x_28 + 0.00215558958162386*x_29 + 0.000546907253323505*x_3 - 0.00155843542096919*x_30 - 0.000629963623842502*x_31 + 0.000148207116386335*x_32 + 0.000919378249262224*x_33 - 0.0075965920791235*x_34 + 0.00438048709040048*x_35 - 0.00292327701001017*x_36 - 0.0024221115826703*x_37 - 0.0023822217448091*x_38 + 0.00862978314694478*x_39 + 0.000170018589298544*x_4 + 0.00544470850089134*x_40 - 0.00127905702116924*x_41 - 0.000135699422861355*x_42 - 0.00726003302537701*x_43 - 0.000441903462152908*x_44 + 0.00282986826159774*x_45 + 0.00144702928233546*x_46 - 0.00557169174536893*x_47 - 0.00162287092570661*x_48 - 0.00460431222678304*x_49 - 0.000246172547998638*x_5 + 0.000869609605179618*x_50 + 0.000903008773087526*x_51 - 0.000914669620468219*x_52 - 0.00120691845829114*x_53 - 0.00770088204710383*x_54 - 0.00151539457227661*x_55 - 0.00183968916737249*x_56 - 0.00305566903064185*x_57 + 0.00995998388393603*x_58 - 0.00672923453695855*x_59 - 0.000407287023099952*x_6 + 0.00319467254744638*x_60 - 0.000876263610188448*x_61 - 0.000570997273609523*x_62 - 0.00347197344901966*x_63 + 0.000127952417290092*x_64 - 0.00125957858182883*x_65 + 0.00380259947709186*x_66 - 0.000844221768810674*x_67 + 0.000546144426419966*x_68 - 0.000444770980409443*x_69 - 0.00070910507358108*x_7 - 0.000541769297105276*x_70 + 0.00102378536083278*x_71 - 0.000947302009509682*x_72 + 0.000906186471826548*x_73 + 0.000796327607119036*x_74 - 0.000566943632489973*x_75 + 0.000377765458215269*x_76 + 0.00214130608249787*x_77 + 7.06526561209962e-6*x_78 + 0.000272517429843568*x_79 + 0.00736196744590628*x_8 - 0.000426623842391026*x_80 - 0.000146935120998854*x_81 + 0.000277069794176223*x_82 - 0.00142519222542463*x_83 - 0.000550318622163171*x_84 - 0.000176123334925487*x_85 + 0.000947894751838651*x_86 - 0.000214476487472952*x_87 + 0.00113538824198211*x_88 - 0.00093376497906124*x_89 + 0.000242003525895922*x_9 - 0.00239918902068621*x_90 - 6.11698407799378e-5*x_91 - 0.00302931925690077*x_92 + 0.00300081962859151*x_93 + 0.000999979225710513*x_94 + 0.000421349448394116*x_95 - 0.00626609159405462*x_96 + 0.000542737748934688*x_97 + 0.00237051804691816*x_98 - 0.0060055306465563*x_99 + 9.72034674695261e-7*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) - 0.00137539161369205*std::pow(0.0514800505951133*x_1 - 0.0954265623996676*x_10 - 0.00112838992101453*x_100 - 0.104577175631367*x_101 - 0.129584870906661*x_102 - 0.00448109216451262*x_103 - 0.00313539842282502*x_104 - 0.078567016923316*x_105 + 0.00294633322684259*x_106 + 0.00654676288101064*x_107 + 0.00155209035155545*x_108 - 0.0446937947817862*x_11 + 0.0676087109878238*x_110 + 0.0052117988771466*x_111 - 0.118300762574446*x_112 - 0.0294135828646158*x_113 - 0.0125668899411582*x_114 + 0.00239110112997472*x_115 - 0.288626629513136*x_116 - 0.00187101381829539*x_117 + 0.0461596600008613*x_118 - 0.0317601136256414*x_119 + 0.00874639477937009*x_12 - 0.188927106936979*x_120 + 0.115443131777124*x_13 + 0.147710084280332*x_14 + 0.0484200383563623*x_16 + 0.00780877785800052*x_18 + 0.0195008612775105*x_19 + 0.091814970171909*x_2 + 0.0202472322256038*x_21 + 0.0660081969858112*x_22 - 0.0012275457417823*x_23 + 0.0287173996324902*x_24 + 0.120325224802569*x_25 + 0.123590376918168*x_26 + 0.144321134172854*x_27 - 0.0611930251583427*x_28 + 0.00366636786105552*x_3 + 0.138668158868223*x_30 - 0.100707593791801*x_31 + 0.00165113355660171*x_32 - 4.79667422792756e-5*x_33 + 0.00773276397459317*x_34 + 9.51869652649054e-5*x_35 + 0.0678718191987519*x_36 + 0.00163951282491539*x_37 + 0.215577302528405*x_38 - 0.0798078288117653*x_39 + 0.0139691567951815*x_4 + 0.00143531165938098*x_40 + 0.00629406060779349*x_41 - 0.104069887415575*x_42 + 0.00800201841655276*x_43 - 0.165548899758511*x_44 - 0.00102419039934418*x_45 + 0.077548020887182*x_46 + 0.00154859049688459*x_47 + 0.0669805745718481*x_48 + 0.0145950652481469*x_49 - 0.00165343582570042*x_5 + 0.21988307983803*x_50 + 0.308122462015397*x_51 + 0.00493004344280283*x_52 + 0.00615855300621153*x_53 - 0.00570051422311573*x_54 - 0.0465607357534244*x_55 - 0.00411260099804998*x_56 + 0.0134784837825203*x_57 - 0.0862080015528407*x_58 - 0.000400168064551497*x_59 - 0.00273814431442287*x_6 - 0.090606662225893*x_60 - 0.00382486342968113*x_61 + 0.0321640989423541*x_62 + 0.00184708874641156*x_63 + 0.000868101700013493*x_64 + 0.000355772765004915*x_65 - 0.0120047440080427*x_66 - 0.00343703167017677*x_67 - 0.000171169181531745*x_68 + 0.0674620209273594*x_69 - 0.0261937356959962*x_7 - 0.00100854265073637*x_70 - 0.0454984898530754*x_71 - 0.00683922686363945*x_72 - 0.00778316984217024*x_73 - 0.00846837490320786*x_74 - 3.6161858085937e-5*x_75 + 0.000534629744361318*x_76 - 0.0196567973160615*x_77 + 0.000358659561165967*x_78 + 0.000871761785069303*x_79 + 0.00658371007604975*x_8 - 0.00436040721708123*x_80 - 0.00305937225330686*x_81 - 0.00395173627981703*x_82 + 0.0706678935961319*x_83 - 0.00393510910899649*x_84 + 0.0606260228417497*x_85 - 0.0712650714935316*x_86 - 0.000366526132019275*x_87 - 0.0584507710928524*x_88 - 0.00846579072379981*x_89 + 0.0548383596065611*x_9 + 0.000609031093608154*x_90 - 0.0457794701976097*x_91 + 0.0611656143861069*x_92 - 0.00121930292932453*x_93 + 0.00312599143038143*x_94 - 0.00091359143985241*x_95 + 0.0611133243332584*x_96 + 0.0178058217093925*x_97 - 0.00308675498771264*x_98 + 0.0695116714787591*x_99 - 1.03161751831769*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 1.10592257629523*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.741950567245311*std::sin(0.402239859104156*x_17 - 1.21327984333038) - 0.471971505731062*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 1.03145200915381*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 6.68658500517171, 2) - 0.00245307940138981*std::exp(0.0418664746783332*x_1 - 0.120720416273472*x_10 - 0.00536867001092114*x_102 - 0.00647685584560812*x_103 - 0.0383609103419679*x_104 - 0.107350288200251*x_105 + 0.0658430411564752*x_106 - 0.00593544674483622*x_107 + 0.000182931863654649*x_109 - 0.111314086755329*x_11 - 0.0783199794625049*x_110 - 0.00331786748549689*x_111 + 0.049200742892024*x_112 - 0.0035371545877018*x_113 - 0.0819277753517023*x_115 - 0.082305393211911*x_116 - 0.0563848704976507*x_117 - 0.00765648881157375*x_118 - 0.00772661927551993*x_119 - 0.161793006688941*x_12 - 0.00619626099933645*x_120 + 0.0653187419069622*x_13 - 0.0373539899056566*x_14 - 0.0853567175727442*x_15 - 0.049196333288573*x_16 - 0.0610681298676987*x_17 - 0.0387332931935592*x_18 + 0.0716035446975358*x_19 - 0.0107641295346112*x_2 + 0.0466185967573786*x_20 + 0.0474572435860758*x_21 + 0.0681603628949172*x_22 + 0.0320272302598221*x_23 + 0.0242586291378097*x_24 + 0.0380044199003146*x_25 - 0.00822724227516772*x_26 + 0.0147924810648815*x_27 - 0.0165271201795581*x_28 + 0.0105747061738624*x_29 + 0.0777311956923357*x_30 - 0.0367562111202112*x_32 - 0.0420743778544668*x_33 - 0.00371992651186914*x_34 - 0.00276247132174946*x_35 + 0.0246584091485019*x_36 - 0.0806468595573566*x_38 + 0.0103309094100628*x_39 + 0.0311816938619187*x_4 - 0.00559621018426356*x_40 - 0.0368530512745137*x_41 + 0.00583609638541305*x_42 - 0.191580784141146*x_43 - 0.0034882004579132*x_44 - 0.00294978262562803*x_45 + 0.00274644686365276*x_46 - 0.00173163333648468*x_47 + 0.0777018694991587*x_48 + 0.0639414289512121*x_49 - 0.0809684598124801*x_5 + 0.00151134194154545*x_50 - 0.00514347470215941*x_51 - 0.00167431679432218*x_52 - 0.0740787194382508*x_54 - 0.0781520403452225*x_55 + 0.0642424307013919*x_57 + 0.0851516429093332*x_58 - 0.00791564031299732*x_59 + 0.0318773559879855*x_6 - 0.0044107777791254*x_60 + 0.00268736086893568*x_61 - 0.0294196495658784*x_62 - 2.70868685614522e-5*x_63 + 0.000255234922061948*x_64 - 0.00133429395217942*x_65 - 0.0174136735630835*x_66 - 0.0128962824071547*x_67 + 0.0237348079368949*x_68 + 0.0117869090252557*x_69 - 0.16819322243999*x_7 + 0.000771621223505109*x_70 - 8.15344657665273e-5*x_71 + 0.000119760941239579*x_72 + 0.0285644309435065*x_73 + 0.0121531763583195*x_74 - 0.0135703460067085*x_75 + 0.00942137793462118*x_76 - 0.000422054882370384*x_77 + 0.0228362450422573*x_78 - 0.00287605020539913*x_79 + 0.0068601632004381*x_8 - 0.00481324010771175*x_80 + 0.00114291837532354*x_81 - 0.00534447492787893*x_82 + 0.023429807841691*x_83 + 0.000616119778558858*x_84 + 0.00345146456706461*x_85 - 0.000126164455627038*x_86 - 0.0316034469575656*x_87 - 0.0234315467808621*x_88 - 0.0023078673339176*x_89 - 0.00426733720026955*x_9 - 0.00923640069140449*x_90 - 0.0292309224871945*x_91 - 0.00828744786208641*x_92 + 0.0291250348516033*x_93 + 0.000896254352294598*x_95 - 0.00668259782603894*x_97 - 0.00694560793980126*x_98 - 0.000551869669310176*x_99 - 0.308842385359199*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.437347515831185*std::sin(0.244959965348244*x_101 - 1.20255982875824) - 0.482305495317931*std::sin(0.274479955434799*x_108 - 1.23687982559204) - 0.869288776811601*std::sin(0.223999992012978*x_114 + 5.16527986526489) + 0.615977452288789*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.0249525735330562*std::sin(1.1684798002243*x_31 + 4.6057596206665) - 0.306231281940853*std::sin(0.206800013780594*x_37 - 4.39247989654541) - 0.675163961116262*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.560923001138743*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 0.243445690690843*std::sin(0.295279920101166*x_94 + 1.96527981758118) + 0.521830013757988*std::sin(0.303679943084717*x_96 + 8.17136001586914)) - 0.0119556666169262*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.00196249215388932*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.00249964082177993*std::sin(0.189440011978149*x_10 - 7.40327978134155) - 0.000878955206741985*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 0.00255617465652771*std::sin(0.285999923944473*x_10 + 4.99871969223022) + 0.00822070492550017*std::sin(0.25655996799469*x_100 + 1.94487977027893) + 0.00147672889229144*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.021924967060276*std::sin(0.264479964971542*x_100 - 1.2105598449707) + 0.0166971344786411*std::sin(0.234399989247322*x_101 + 1.9826397895813) + 0.00653723193148785*std::sin(0.236559987068176*x_101 + 1.95871984958649) + 0.00168633011707617*std::sin(0.246719971299171*x_101 - 1.207279920578) + 0.024548792222971*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.018725105512305*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 0.000823310137951327*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.00212687507332526*std::sin(0.243999972939491*x_103 - 1.20647990703583) - 0.00198818822528225*std::sin(0.22495998442173*x_104 - 1.19919991493225) - 0.00874666293987072*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.00146745793829591*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.00127970803752517*std::sin(0.241519972681999*x_107 - 7.42303991317749) - 0.00110562511892337*std::sin(0.253119975328445*x_107 - 7.42199993133545) - 0.00278186712944891*std::sin(0.263919949531555*x_108 + 1.94823980331421) - 0.00994775269549408*std::sin(0.268879950046539*x_108 + 1.95047986507416) - 0.00163948138052808*std::sin(0.273199945688248*x_108 - 1.22711992263794) + 0.0196289775827994*std::sin(0.275599956512451*x_108 + 1.92775976657867) - 0.000979260332383834*std::sin(0.281999945640564*x_108 + 8.15032005310059) - 0.0225852991825166*std::sin(0.226879999041557*x_109 + 1.95823979377747) - 0.00165842585100478*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.00220596402730404*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.00186218614066183*std::sin(0.239999979734421*x_109 - 4.40607976913452) - 0.000905363374321494*std::sin(0.261519968509674*x_109 + 4.95928001403809) - 0.0302769563973486*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.00166794820176233*std::sin(0.293839931488037*x_11 - 7.45207977294922) - 0.00181621303433457*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.0282569490706798*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.0131870220779604*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.0201770755924524*std::sin(0.26759997010231*x_112 + 5.15015983581543) - 0.00152602705429814*std::sin(0.278399974107742*x_112 + 1.96039986610413) + 0.00220414696900523*std::sin(0.241599977016449*x_113 - 4.2131199836731) + 0.0236585201280819*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.00248236071382979*std::sin(0.273839950561523*x_113 - 7.41279983520508) + 0.00703552569522966*std::sin(0.258879989385605*x_114 - 4.44127988815308) + 0.00834797840640795*std::sin(0.251599967479706*x_116 + 5.15064001083374) - 0.00175793919495266*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.0260301762888466*std::sin(0.275199949741364*x_116 - 1.24471986293793) - 0.000637524865092065*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 0.000589115407024108*std::sin(0.235359981656075*x_118 + 1.94599986076355) - 0.00246063915404672*std::sin(0.240879982709885*x_118 - 7.44632005691528) - 0.000631276966530805*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.0181233992482782*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 0.000159042168410477*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 0.00180303715104598*std::sin(0.257279962301254*x_12 + 8.36040019989014) - 0.00215488987001528*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.0138596940999177*std::sin(0.263919949531555*x_120 + 5.15799999237061) + 0.00284850809800601*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 0.00213137740592709*std::sin(0.263759940862656*x_13 - 4.21655988693237) - 0.00204758611161847*std::sin(0.281439960002899*x_13 + 5.15664005279541) + 0.00115637512329311*std::sin(0.331999838352203*x_14 - 7.53599977493286) + 0.0195697696401575*std::sin(0.297199934720993*x_15 + 5.15664005279541) - 0.0131362043776371*std::sin(0.339999854564667*x_15 - 4.34223985671997) - 0.00684502730389847*std::sin(0.344719856977463*x_15 + 1.83199989795685) + 0.00128610174571436*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.0046975218372558*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.000981976998447586*std::sin(0.288159936666489*x_16 - 7.40983963012695) + 0.0168788674533307*std::sin(0.328159838914871*x_16 + 8.24831962585449) - 0.000697108583270623*std::sin(0.348159849643707*x_16 - 7.56640005111694) + 0.00626118016800961*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.0014777610202159*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 0.000919000880922757*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.00184700270772975*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.00103384411794579*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.0122515714986093*std::sin(0.354559868574142*x_17 + 8.22639942169189) + 0.00534562727103624*std::sin(0.38239985704422*x_17 - 1.19231986999512) + 0.000852204033390606*std::sin(0.331679850816727*x_18 + 5.02007961273193) - 0.000995024907358041*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.000968024586234775*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.00117126182555785*std::sin(0.435919851064682*x_2 - 4.1898398399353) - 0.0264157793948545*std::sin(0.274079948663712*x_20 + 1.98231983184814) - 0.000800208896082779*std::sin(0.277279943227768*x_20 + 1.99079978466034) - 0.00584430479610694*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 0.000692589280750084*std::sin(0.318079918622971*x_21 - 4.38975954055786) - 0.00175376880469443*std::sin(0.322879940271378*x_21 - 1.21151983737946) - 0.00691861299087804*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.00119932532789925*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.0153632318155928*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 0.00215079609442386*std::sin(0.349599838256836*x_23 - 1.15639984607697) - 0.0205643517430254*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.00169690508971591*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.00151459320706105*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 0.00220414038559397*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.000650087688511659*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 0.0217233804931967*std::sin(0.228399991989136*x_26 - 1.19703996181488) - 0.00221915680322588*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.0205733589789092*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.0011007233565284*std::sin(0.344799846410751*x_27 + 8.2139196395874) + 0.00362885154577904*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 0.00326880168701384*std::sin(0.242239981889725*x_28 - 1.16359984874725) - 0.00107742187506281*std::sin(0.3018399477005*x_28 + 2.01215982437134) - 0.0220033557438758*std::sin(0.308959931135178*x_28 - 1.17487978935242) + 0.002195678072705*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.0286360341118982*std::sin(0.225359991192818*x_29 + 1.78623986244202) - 0.00425206588816627*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00490300658285191*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.00159187870204338*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 0.00253899313771619*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.0043443185769856*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00272943399924271*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.0315744421987746*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.00193574812340845*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.00031320304715475*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.00110385103767868*std::sin(0.310239911079407*x_31 - 7.50207996368408) - 0.0319555085793252*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 0.000639882445249844*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.00243289100963828*std::sin(0.413359850645065*x_31 - 7.38687992095947) - 0.000622285407658995*std::sin(0.428559869527817*x_31 - 7.39463949203491) + 0.00174847234259473*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.00202670972492081*std::sin(0.29911994934082*x_32 - 7.36168003082275) - 0.00229911835627296*std::sin(0.301039934158325*x_32 - 1.13639986515045) - 0.00687178854095458*std::sin(0.303839921951294*x_32 - 1.13263988494873) - 0.00184200639985649*std::sin(0.272879958152771*x_33 + 8.16928005218506) + 0.005914955285931*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.0012081182125193*std::sin(0.247039973735809*x_34 - 1.20383989810944) + 0.00165010890043593*std::sin(0.286079943180084*x_34 - 4.60623979568481) + 0.00125151222440585*std::sin(0.239439979195595*x_35 + 1.96807980537415) + 0.002830837063423*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.00395955028653803*std::sin(0.229039996862411*x_37 + 8.19023990631104) + 0.00390277594179804*std::sin(0.225599989295006*x_38 - 7.41167974472046) + 0.000502481477581789*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.0010429184706059*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.00191571442082068*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.0146710803004468*std::sin(0.32551982998848*x_4 - 1.15559983253479) + 0.00102993084586744*std::sin(0.325999826192856*x_4 + 5.23935985565186) - 0.00325473204022055*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.0017578196286328*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.00728454822124329*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 0.00150683596110118*std::sin(0.379599839448929*x_4 - 1.17863988876343) + 0.0274174732893885*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.00210489731643365*std::sin(0.220639988780022*x_42 + 8.20359992980957) + 0.0167439339587793*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.00130593745146275*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.0227317523550306*std::sin(0.256239980459213*x_42 + 8.18048000335693) + 0.00445645133439118*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.00280865635088358*std::sin(0.263039946556091*x_42 + 1.95919990539551) + 0.00179615033221866*std::sin(0.129440054297447*x_44 + 1.7668799161911) - 0.00202679750481094*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.00709634203226056*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.00143387813195625*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.00255520684839833*std::sin(0.215279996395111*x_45 + 8.193039894104) - 0.00164536798232588*std::sin(0.257039964199066*x_45 - 4.43688011169434) + 0.0305677250975912*std::sin(0.199520006775856*x_47 - 1.18703985214233) - 0.00159267971653097*std::sin(0.225519984960556*x_47 + 8.19655990600586) + 0.00200757399680641*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.00262070350909657*std::sin(0.230159983038902*x_48 + 1.98047983646393) + 0.00514604597616076*std::sin(0.240479975938797*x_48 - 7.42575979232788) + 0.00154076707968271*std::sin(0.244319975376129*x_48 - 7.42799949645996) - 0.0320039656505228*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 0.000799147779516403*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.00487857970881887*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.0227708439229551*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.00127156052396227*std::sin(0.36959981918335*x_5 + 2.01391983032227) - 0.0065487837454738*std::sin(0.39183983206749*x_5 + 2.01263976097107) + 0.000480423550983205*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.00153233470693088*std::sin(0.178240016102791*x_52 - 0.965199828147888) + 0.00146423745603728*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.00516417664954496*std::sin(0.22639998793602*x_52 + 8.20399951934814) - 0.000807568182719843*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.0298632805816793*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.0194018687097646*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.00211768377060181*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.0025346489040187*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.00241103623576367*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.0349260563447415*std::sin(0.220479995012283*x_56 + 8.19176006317139) + 0.00199475717528555*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.0020191890554172*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.00110550096283282*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 0.00224039606445292*std::sin(0.282239943742752*x_6 - 0.996719837188721) - 0.00188746118010841*std::sin(0.387039840221405*x_6 - 1.1794399023056) - 0.000559110130042073*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.00093418396782763*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.014626486809845*std::sin(0.292239934206009*x_60 - 7.46751976013184) - 0.021649266587476*std::sin(0.301359921693802*x_60 - 7.47583961486816) + 0.00122759847483224*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.00763634773602013*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 0.000307329055668015*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 0.00219674633556291*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.0013454859603187*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00293389169177661*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 0.000589803918852394*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.00180879853813013*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.0108039017151566*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.0111800791254544*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 0.00112965969638406*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.000360121190295648*std::sin(0.327279835939407*x_91 + 4.99647998809814) + 0.00252312537636782*std::sin(0.345599830150604*x_91 + 2.00535988807678) - 0.0114517317579863*std::sin(0.367839843034744*x_91 - 1.18095993995667) - 0.000471635663479955*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.0061334281793112*std::sin(0.38663986325264*x_91 - 4.39359998703003) - 0.000446162822181284*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.0254867126623094*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.00195475719202996*std::sin(0.292239934206009*x_92 - 7.38303995132446) + 0.000915954426780398*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.00270932847027444*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 0.000434760751466226*std::sin(0.255759954452515*x_94 + 1.99439978599548) + 0.00219188121524702*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.012152305214975*std::sin(0.301119923591614*x_94 - 4.40064001083374) - 0.00230183181781916*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.000953257763479953*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.0150631382954042*std::sin(0.269679963588715*x_95 - 1.18839991092682) - 0.0261353481011564*std::sin(0.276159942150116*x_95 + 1.96335983276367) - 0.00230267289513112*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.00187638466331193*std::sin(0.292079925537109*x_96 - 1.20975983142853) - 0.00113094405904431*std::sin(0.274959951639175*x_97 - 1.21607995033264) - 0.0128692145423528*std::sin(0.282879948616028*x_97 - 4.42759990692139) + 0.00629064603725516*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.00204254072423676*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.016261311490549*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 0.000726297416220746*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 0.0310679955733041*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 0.00203575208663388*std::sin(0.263999968767166*x_99 - 1.22975981235504) - 0.00154560137967885*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.18164545652086);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000403099075965523*x_1 + 0.000240754047020233*x_10 + 0.000470267115822277*x_100 + 0.000791464702664765*x_101 + 0.00397216756447509*x_102 - 0.00165639183689481*x_103 - 0.00352577998066141*x_104 + 0.00120307459595229*x_105 + 0.00439223698969811*x_106 + 0.000126775782316722*x_107 - 0.00156517225070556*x_108 + 0.00180730371552814*x_109 + 0.00344300632856871*x_11 + 0.00618504799621364*x_110 + 0.00785920710092115*x_111 + 0.00139081036717994*x_112 + 0.00579681040257634*x_113 - 0.00416130919414367*x_114 + 0.00841456857213914*x_115 + 0.0029664630574504*x_116 + 0.0104358911302751*x_117 + 0.00624352388571264*x_118 + 0.0134049873787522*x_119 - 0.00116040417051821*x_12 + 0.00951430292297633*x_120 - 0.000395089303882975*x_13 - 0.000216136968781457*x_14 - 0.00017828949325162*x_15 - 0.000224143663384178*x_16 + 5.70104652819069e-5*x_17 - 0.00092662331211578*x_18 + 0.000628190936576002*x_19 - 0.00454599354006369*x_2 - 0.000193601448299657*x_20 - 0.000207330067150114*x_21 + 0.00596880872075031*x_22 + 0.00215200013540071*x_23 + 0.00350109398223262*x_24 + 0.00279398170932358*x_25 - 0.00328050043613521*x_26 + 0.00051444879503128*x_27 + 0.00653400726359827*x_28 + 0.00116303448827729*x_29 + 0.000616439632602571*x_3 - 0.00506394896577457*x_30 + 0.00283719357359866*x_31 + 3.78733001675107e-5*x_32 + 0.00250744044002835*x_33 - 0.00429778850354823*x_34 + 0.00615537262291617*x_35 + 0.000269180972209907*x_36 + 0.00508884282037527*x_37 + 0.00112901525676793*x_38 + 0.0013095009674308*x_39 + 8.74490950460233e-5*x_4 - 0.0010050257263306*x_40 + 0.0045245757796836*x_41 + 0.000608259102719053*x_42 + 0.000832948378062351*x_43 + 0.0013103605368319*x_44 - 0.00434962841850392*x_45 - 0.00091950924567735*x_46 - 0.00583890962791432*x_47 + 0.00242135728448206*x_48 - 0.0144655820120501*x_49 - 0.00240768531979734*x_5 - 0.0119358077081719*x_50 - 0.0035415363252438*x_51 + 0.000758422035879513*x_52 + 0.00645280956044837*x_53 + 0.00520031616452165*x_54 - 0.00136689860195123*x_55 - 0.000470468999557579*x_56 - 0.00282682488147663*x_57 + 0.0142479498981909*x_58 - 0.00106978181873048*x_59 + 0.00463489280848526*x_6 - 0.000638028367076576*x_60 - 0.000411845172998002*x_61 + 0.00118046144134779*x_62 - 0.00143420925582334*x_63 + 0.000873306480610766*x_64 + 0.000637105144701758*x_65 - 0.000322066575993329*x_66 - 0.00131578890650733*x_67 - 0.000555387833282543*x_68 + 0.00129303273049167*x_69 + 0.0020655053379236*x_7 - 0.000217204532580151*x_70 - 0.00033327455060138*x_71 - 0.000292038184827047*x_72 + 0.00250994351648657*x_73 - 8.59215094763301e-5*x_74 - 0.000608066326955*x_75 - 0.00171534486016616*x_76 + 0.000161214998457188*x_77 + 0.00102427820980235*x_78 + 0.000599336873379387*x_79 - 0.000470833834684978*x_8 + 0.000869122322602848*x_80 + 0.000655614505047856*x_81 + 0.00264296457084173*x_82 + 0.000553149472490368*x_83 + 0.000547069173317553*x_84 - 0.00140006204964204*x_85 + 0.000799329813344321*x_86 - 0.00194844117931888*x_87 + 0.00143475261359237*x_88 - 0.0012146436020893*x_89 + 0.00174765875733134*x_9 - 0.00177195877312139*x_90 + 0.000848604951734755*x_91 - 0.000894989077654461*x_92 + 0.0013400989788341*x_93 - 0.000791993591996249*x_94 + 0.000481386447332262*x_95 - 0.00252615611017577*x_96 - 0.00254841319375191*x_97 - 0.00341220116996428*x_98 + 0.00146143809852915*x_99 + 4.3459596812282e-7*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) + 0.00255742076574897*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.000369102681063421*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.000470128824304375*std::sin(0.189440011978149*x_10 - 7.40327978134155) - 0.0294036315407167*std::sin(0.204960003495216*x_10 - 1.20431983470917) - 0.00374743513411949*std::sin(0.285999923944473*x_10 + 4.99871969223022) - 0.00167206612044923*std::sin(0.235359981656075*x_100 - 1.21407985687256) + 0.0132238865628638*std::sin(0.25655996799469*x_100 + 1.94487977027893) + 0.0029152966018107*std::sin(0.261679977178574*x_100 - 1.21367979049683) - 0.00468994058172625*std::sin(0.264479964971542*x_100 - 1.2105598449707) + 0.0105158394907194*std::sin(0.236559987068176*x_101 + 1.95871984958649) - 0.00236779016984165*std::sin(0.244959965348244*x_101 - 1.20255982875824) - 0.00214030601140223*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.00400546244825964*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 0.0275421406624237*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.00419878808229976*std::sin(0.243999972939491*x_103 - 1.20647990703583) - 0.00392499828992409*std::sin(0.22495998442173*x_104 - 1.19919991493225) - 0.0140699465032092*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.000943793513326871*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.000240685633668825*std::sin(0.241519972681999*x_107 - 7.42303991317749) - 0.000494324154732493*std::sin(0.253119975328445*x_107 - 7.42199993133545) + 0.00407830763548452*std::sin(0.263919949531555*x_108 + 1.94823980331421) - 0.003236595777556*std::sin(0.273199945688248*x_108 - 1.22711992263794) - 0.00261119171673816*std::sin(0.274479955434799*x_108 - 1.23687982559204) - 0.00419880852227865*std::sin(0.275599956512451*x_108 + 1.92775976657867) - 0.000437826554212225*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.000124692009934223*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.00969397752436714*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 0.0032340149681917*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.0187550027016104*std::sin(0.239999979734421*x_109 - 4.40607976913452) - 0.0017873306213084*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.0167987358229832*std::sin(0.293839931488037*x_11 - 7.45207977294922) - 0.00358549203905935*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.00462984702077629*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.00216066832720831*std::sin(0.256239980459213*x_110 - 7.63824033737183) + 0.00431605143950485*std::sin(0.26759997010231*x_112 + 5.15015983581543) - 0.00301261897758589*std::sin(0.278399974107742*x_112 + 1.96039986610413) - 0.000165723125691252*std::sin(0.241599977016449*x_113 - 4.2131199836731) + 0.0250010892454085*std::sin(0.273839950561523*x_113 - 7.41279983520508) - 0.00470631099064633*std::sin(0.223999992012978*x_114 + 5.16527986526489) + 0.0113173985135064*std::sin(0.258879989385605*x_114 - 4.44127988815308) + 0.0134286196227702*std::sin(0.251599967479706*x_116 + 5.15064001083374) - 0.00347045025528215*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.00426499456256757*std::sin(0.275199949741364*x_116 - 1.24471986293793) - 0.0213270779755617*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 0.00593327423560924*std::sin(0.235359981656075*x_118 + 1.94599986076355) - 0.00485769121300503*std::sin(0.240879982709885*x_118 - 7.44632005691528) - 0.00124624066403478*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.00296948427822472*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 2.99124206158523e-5*std::sin(0.317199915647507*x_119 - 4.64807987213135) + 0.00228843167425383*std::sin(0.257279962301254*x_12 + 8.36040019989014) + 0.000162019633808956*std::sin(0.273439943790436*x_12 - 7.43800020217896) + 0.00296470875558513*std::sin(0.263919949531555*x_120 + 5.15799999237061) - 0.00417600546153286*std::sin(0.255679965019226*x_13 - 1.02263987064362) + 0.00270516420733924*std::sin(0.263759940862656*x_13 - 4.21655988693237) - 0.00404225912032744*std::sin(0.281439960002899*x_13 + 5.15664005279541) + 0.000517014443315274*std::sin(0.331999838352203*x_14 - 7.53599977493286) + 0.0103922126252558*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.0028099480300772*std::sin(0.339999854564667*x_15 - 4.34223985671997) - 0.0110109613964707*std::sin(0.344719856977463*x_15 + 1.83199989795685) + 0.00253896843790061*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.00302120457630408*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.0328500128588323*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 0.0036105361173554*std::sin(0.328159838914871*x_16 + 8.24831962585449) - 0.00137620269672413*std::sin(0.348159849643707*x_16 - 7.56640005111694) + 0.010071780588375*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.0148832661361305*std::sin(0.363199830055237*x_16 - 7.58160018920898) - 0.00116640454321796*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.0186020827977174*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.000194443903879658*std::sin(0.349279850721359*x_17 - 1.16287982463837) - 0.00262071738595009*std::sin(0.354559868574142*x_17 + 8.22639942169189) + 0.00859901544699145*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.00697201433220773*std::sin(0.402239859104156*x_17 - 1.21327984333038) + 0.000160281299934957*std::sin(0.331679850816727*x_18 + 5.02007961273193) - 0.000444874883763954*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.00974945701379025*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.000220289227237859*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.00443505571343901*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 0.0043281748934337*std::sin(0.274079948663712*x_20 + 1.98231983184814) - 0.0267693363160526*std::sin(0.277279943227768*x_20 + 1.99079978466034) - 0.00375875642669262*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 0.0231691443022573*std::sin(0.318079918622971*x_21 - 4.38975954055786) - 0.00346221724473329*std::sin(0.322879940271378*x_21 - 1.21151983737946) - 0.0111293318751689*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.0120790018106707*std::sin(0.380319833755493*x_21 - 1.37543988227844) - 0.00328632851125066*std::sin(0.369199842214584*x_22 - 1.16735982894897) - 0.00272981058903066*std::sin(0.349599838256836*x_23 - 1.15639984607697) - 0.0170903750420392*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.000284862496055721*std::sin(0.298399955034256*x_24 - 1.16463983058929) + 0.00279751566403895*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.0217473412928586*std::sin(0.374799847602844*x_25 + 8.20135974884033) + 0.00325335600652014*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.00337090549080897*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.000207022454178267*std::sin(0.344799846410751*x_27 + 8.2139196395874) - 0.00532001432078544*std::sin(0.357039839029312*x_27 - 1.14823985099792) - 0.00414879378002681*std::sin(0.242239981889725*x_28 - 1.16359984874725) - 0.00212700133889386*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.00433461609469471*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.00469195937920239*std::sin(0.225359991192818*x_29 + 1.78623986244202) + 0.00623366680411047*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00315336180202084*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.000299398239981503*std::sin(0.329999834299088*x_29 - 4.36855983734131) - 0.00322251391974489*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.00969242225597917*std::sin(0.339599847793579*x_29 - 4.35775995254517) + 0.00333488885515123*std::sin(0.346159845590591*x_3 - 7.3919997215271) + 0.00698830289806372*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00175543164564601*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.00517341192005598*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.0194958820127722*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.00315442364609816*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.000709940245544674*std::sin(0.310239911079407*x_31 - 7.50207996368408) - 0.000812144805035907*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.00045757461634327*std::sin(0.413359850645065*x_31 - 7.38687992095947) - 0.00122848990344439*std::sin(0.428559869527817*x_31 - 7.39463949203491) - 0.000135092703594153*std::sin(1.1684798002243*x_31 + 4.6057596206665) + 0.0011245275330267*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.000381180628785213*std::sin(0.29911994934082*x_32 - 7.36168003082275) + 0.00337058224241217*std::sin(0.301039934158325*x_32 - 1.13639986515045) - 0.0110540097197373*std::sin(0.303839921951294*x_32 - 1.13263988494873) - 0.00363641222572857*std::sin(0.272879958152771*x_33 + 8.16928005218506) + 0.00951484068999159*std::sin(0.24695996940136*x_34 + 8.19207954406738) - 0.0404151002304426*std::sin(0.247039973735809*x_34 - 1.20383989810944) + 0.0010612652232628*std::sin(0.286079943180084*x_34 - 4.60623979568481) + 0.000559550169291771*std::sin(0.239439979195595*x_35 + 1.96807980537415) - 0.000212842053216095*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.00165792966195203*std::sin(0.206800013780594*x_37 - 4.39247989654541) + 0.00580482942399624*std::sin(0.229039996862411*x_37 + 8.19023990631104) - 0.00572159638917526*std::sin(0.225599989295006*x_38 - 7.41167974472046) + 0.000991977980327828*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.0105037505685771*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.000360304792799009*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.00240382842644091*std::sin(0.32551982998848*x_4 - 1.15559983253479) + 0.00203324652936011*std::sin(0.325999826192856*x_4 + 5.23935985565186) - 0.00523558596038237*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.00113053922692246*std::sin(0.345839858055115*x_4 + 2.01703977584839) - 0.00155822803420534*std::sin(0.379119843244553*x_4 - 4.38655996322632) - 0.00191249034402216*std::sin(0.379599839448929*x_4 - 1.17863988876343) + 0.00267155542922909*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.0436874408883333*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.00372455411427157*std::sin(0.256239980459213*x_42 + 8.18048000335693) + 0.00716868047849638*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.0282873748754221*std::sin(0.263039946556091*x_42 + 1.95919990539551) + 0.000803057455506325*std::sin(0.129440054297447*x_44 + 1.7668799161911) - 0.00400121911962133*std::sin(0.256959974765778*x_44 - 1.23063993453979) - 0.00151796909830749*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.000269681721669248*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.000480579602087229*std::sin(0.215279996395111*x_45 + 8.193039894104) - 0.000735642780872387*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.000712085897071888*std::sin(0.225519984960556*x_47 + 8.19655990600586) + 0.00396326887170988*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.000492898119140411*std::sin(0.230159983038902*x_48 + 1.98047983646393) - 0.00754427067165081*std::sin(0.240479975938797*x_48 - 7.42575979232788) + 0.00304171812106343*std::sin(0.244319975376129*x_48 - 7.42799949645996) - 0.00804861470963867*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.00313765169227146*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.00373095919285383*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.000239153261121956*std::sin(0.36959981918335*x_5 + 2.01391983032227) - 0.0105344218238806*std::sin(0.39183983206749*x_5 + 2.01263976097107) + 0.0160715779009426*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.015432904874937*std::sin(0.178240016102791*x_52 - 0.965199828147888) + 0.0489830406773789*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.00830713263923869*std::sin(0.22639998793602*x_52 + 8.20399951934814) - 0.000361063123910006*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.00489304136429785*std::sin(0.25519996881485*x_52 + 1.95015978813171) + 0.00415022796490824*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.00365532335795753*std::sin(0.246479973196983*x_53 - 1.2053599357605) - 0.00418064299572648*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.0255277096121065*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.0242827449566117*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.0057225674828056*std::sin(0.220479995012283*x_56 + 8.19176006317139) + 0.00393796643710537*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.00303682522492491*std::sin(0.252159982919693*x_56 + 8.16687965393066) - 0.00256277369994444*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.0111340499705328*std::sin(0.238879978656769*x_6 + 5.02663946151733) - 0.00284353171191919*std::sin(0.282239943742752*x_6 - 0.996719837188721) + 0.000141912481693376*std::sin(0.387039840221405*x_6 - 1.1794399023056) - 0.00110377190468615*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.000600819107710525*std::sin(0.512639820575714*x_6 + 1.91543984413147) + 0.00312873236566278*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.000548858349938054*std::sin(0.348239839076996*x_7 - 7.34895992279053) - 0.00163348100112873*std::sin(0.375999838113785*x_7 + 8.22087955474854) - 0.000390064921846565*std::sin(0.789839863777161*x_7 + 1.21335983276367) + 0.00278813106634372*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.000253057050089401*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00188692832362736*std::sin(0.327199846506119*x_8 + 8.25103950500488) + 0.019730672255176*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.0182173096064622*std::sin(0.345519840717316*x_8 + 5.03679990768433) + 0.00231104826545893*std::sin(0.388639837503433*x_8 + 1.80719995498657) - 0.00239151587563293*std::sin(0.295839935541153*x_9 - 1.21183979511261) - 0.00143377468890952*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.00362695959841135*std::sin(0.327279835939407*x_91 + 4.99647998809814) - 0.000189706144718338*std::sin(0.345599830150604*x_91 + 2.00535988807678) - 0.000931083460351568*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.00100495046765663*std::sin(0.38663986325264*x_91 - 4.39359998703003) - 0.0149254559617573*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.00417594908756141*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.0196873317962106*std::sin(0.292239934206009*x_92 - 7.38303995132446) + 0.00180823903544198*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.0017425008029097*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 8.17691722585006e-5*std::sin(0.255759954452515*x_94 + 1.99439978599548) + 0.00432712049702436*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.00131800980328556*std::sin(0.295279920101166*x_94 + 1.96527981758118) + 0.00337456026523911*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.000179287339084473*std::sin(0.268159955739975*x_95 - 1.18831992149353) - 0.00322213590495044*std::sin(0.269679963588715*x_95 - 1.18839991092682) - 0.00454584081160683*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.000352907708987344*std::sin(0.292079925537109*x_96 - 1.20975983142853) + 0.00282517662083035*std::sin(0.303679943084717*x_96 + 8.17136001586914) - 0.0378333982781255*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.0101191796029256*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.020571443404468*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.00266438476319986*std::sin(0.271519958972931*x_98 - 4.40455961227417) + 0.0242967803725615*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 0.00509043160982321*std::sin(0.252639979124069*x_99 - 1.21063983440399) + 0.00258379565461459*std::sin(0.263999968767166*x_99 - 1.22975981235504) + 0.000116209080118053*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.206426352262497*std::sin(0.000383823987303082*x_1 - 0.00732756568254515*x_10 - 0.00329481220891008*x_100 - 0.0267993721788787*x_103 - 0.0183351583622484*x_104 + 0.0105339633663895*x_105 + 0.0177173923721371*x_106 - 0.0287236399087668*x_107 - 0.00242794123614082*x_110 - 0.0367255913020116*x_111 + 0.000784828409176541*x_112 - 0.0193109498022899*x_114 - 0.0198909381984306*x_115 - 0.00129449446768587*x_116 + 0.00118364649116959*x_117 + 0.00072148073377447*x_118 + 0.0177728568715425*x_119 + 0.000658241051701339*x_12 - 0.0156198147739681*x_120 - 0.0248286770298326*x_13 + 0.00763593494406135*x_14 - 0.00659527411159733*x_16 - 0.0410601165504241*x_17 + 0.000258828958388413*x_18 - 0.0246423364917367*x_19 - 0.00371411229165707*x_2 + 0.00108165357039527*x_20 + 0.00770750634800133*x_21 + 0.00113324847040626*x_22 + 0.00340690792927791*x_23 + 0.00776589052229284*x_25 - 0.00853943797383618*x_27 + 0.00344325739774763*x_29 + 0.0016268446790673*x_3 + 0.00987574629182161*x_30 + 0.000886507072267367*x_32 - 0.00474372798635485*x_33 + 0.0384669862391787*x_34 - 0.00600130032968725*x_35 + 0.0211577244687254*x_36 + 0.0106712945302257*x_37 + 0.016217407831733*x_38 - 0.0111519796719406*x_39 - 0.001955144900779*x_4 - 0.000772135911853244*x_40 + 0.0431008242716978*x_43 + 0.00038290939051196*x_44 - 0.00690240385688092*x_45 - 0.00261935514155425*x_46 + 0.019834254628012*x_49 - 0.00559556801040556*x_5 + 0.0126997187167539*x_50 + 0.0293196182751476*x_51 + 0.0349114050968514*x_52 + 0.0206647382694228*x_53 + 0.020232300931455*x_54 + 0.000296877185819211*x_55 + 0.0274992819172151*x_56 + 0.00362702116332489*x_57 - 0.0341920825278387*x_58 + 0.0243783666485543*x_59 + 0.00335979484946074*x_6 + 0.000220418624078166*x_61 + 0.000377632054543491*x_62 + 0.00851046659529342*x_63 + 9.59739796267024e-5*x_64 + 0.0109921790988122*x_65 - 0.0129139782145611*x_66 + 0.000742815675011338*x_67 + 0.00047643177903179*x_68 + 0.000420509595812131*x_69 + 0.0102900074713538*x_7 + 0.000197769929348929*x_70 - 0.00479785207921049*x_71 + 0.000632319099426251*x_72 + 0.000909522909646529*x_73 + 0.000910001627089454*x_74 + 0.000119034618424962*x_75 + 0.000148894530339039*x_76 - 0.00976537184225494*x_77 - 0.00950468825250478*x_78 + 0.000776036406421398*x_79 - 0.046920764044507*x_8 + 0.00172103754524755*x_80 - 0.000276280083533275*x_81 - 0.00169679095798359*x_82 + 0.0053758689891054*x_83 + 0.00277855003915548*x_84 + 0.000123020116353859*x_85 + 0.000770092457411775*x_86 + 0.00125923386458177*x_87 + 0.000704523762315407*x_88 + 0.000633136055733951*x_89 - 0.0102527637430103*x_9 + 0.00489148244194011*x_90 + 0.0145849892677827*x_92 + 0.000806719956157891*x_93 - 0.00342297727350896*x_96 - 0.0245036693493624*x_98 + 0.0213326289977551*x_99 - 0.130054572582022*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.191211413194727*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.0774833985208123*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.175917696271579*std::sin(0.226879999041557*x_109 + 1.95823979377747) + 0.235828287085951*std::sin(0.284879922866821*x_11 + 5.14423990249634) - 0.184277052276055*std::sin(0.264399945735931*x_113 + 5.19080018997192) - 0.152429629726888*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.160176464996837*std::sin(0.275199949741364*x_24 + 5.02551984786987) + 0.169204181034377*std::sin(0.228399991989136*x_26 - 1.19703996181488) + 0.171384918190636*std::sin(0.308959931135178*x_28 - 1.17487978935242) + 0.248902589557602*std::sin(0.3572798371315*x_31 - 1.02039980888367) - 0.213555671752644*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.130419095392462*std::sin(0.246079966425896*x_42 + 8.18551921844482) - 0.238093094803626*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.249280023403585*std::sin(0.256079971790314*x_48 - 1.22367990016937) + 0.168626905194429*std::sin(0.301359921693802*x_60 - 7.47583961486816) + 0.0891979447739404*std::sin(0.367839843034744*x_91 - 1.18095993995667) - 0.0946547362747525*std::sin(0.301119923591614*x_94 - 4.40064001083374) + 0.203569153193698*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.100238768449342*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 2.38015073653912) - 0.120147303940749);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00208864597219058*x_1 - 0.00482380701145726*x_10 + 0.00182904690240593*x_100 + 0.00387668782574404*x_101 + 0.00202249945944979*x_102 - 0.00340498038814141*x_103 - 0.00464297172383083*x_104 - 0.00420511548836753*x_105 - 0.00627834972633185*x_106 - 0.0026397032735032*x_107 + 0.00205216424923333*x_108 - 0.00317930193110967*x_109 - 0.000411467385768645*x_11 - 0.00677876113826702*x_110 - 0.00334503511178642*x_111 + 0.00103071632749519*x_112 - 0.00272455958124683*x_113 - 0.00607206621855124*x_114 - 0.00420507345280171*x_115 - 0.00161645104000838*x_116 - 0.00830834119913123*x_117 - 0.00154185219696816*x_118 - 0.00045170044769141*x_119 - 0.00198298401740331*x_12 - 0.00628715010804056*x_120 + 0.00399290192049365*x_13 + 0.000813842310513547*x_14 + 1.64605486258162e-5*x_15 - 0.00331017020534516*x_16 - 0.00825586257340284*x_17 - 0.000624270813394078*x_18 - 0.00280624353859683*x_19 + 0.00124648024262094*x_2 + 0.00093879411633097*x_20 + 0.00131901565833077*x_21 - 0.00390806932838867*x_22 + 0.0024010806124633*x_23 - 0.00407512716203155*x_24 + 0.0060011592076436*x_25 - 7.72986037327252e-5*x_26 - 0.00145158818591116*x_27 + 0.00246190186277894*x_28 + 0.00206806479060664*x_29 + 0.00423416845433889*x_3 + 0.00695076157270717*x_30 - 0.00283879514877099*x_31 - 0.000808976759824762*x_32 - 0.000574700059651126*x_33 + 0.00211319596388948*x_34 + 0.000562629388482056*x_35 + 0.00463605154299125*x_36 - 0.00309694419147406*x_37 + 0.00307107599538628*x_38 - 0.00754291805650122*x_39 + 0.000313242524319584*x_4 - 0.00083223408546809*x_40 - 0.000500310745843862*x_41 - 0.00114607248040082*x_42 + 0.00150099831728865*x_43 + 0.00106627121945326*x_44 + 0.00815336840720511*x_45 - 0.0137002635544247*x_46 + 0.00843902994798762*x_47 - 0.00362212556797018*x_48 + 0.0053723898251995*x_49 + 0.00149339705937741*x_5 + 0.00753337852589294*x_50 + 0.000614048490883586*x_51 + 0.00848920704670202*x_52 - 0.0010704005084029*x_53 - 0.00255647616928809*x_54 + 0.00493827011530603*x_55 + 0.00804151187771542*x_56 + 0.00359192812679307*x_57 - 0.0107778251372459*x_58 - 0.00161014143013212*x_59 - 0.00327934166666297*x_6 - 0.00232344198978038*x_60 - 0.00103692230637467*x_61 - 0.000126139514292904*x_62 - 0.00149216406312471*x_63 + 0.00197638486399462*x_64 + 0.00214823449812243*x_65 - 0.00205623039450061*x_66 + 0.000340501896989254*x_67 + 0.00110775676011515*x_68 - 0.00238374422476075*x_69 + 0.00141836668306376*x_7 + 0.000577531966879204*x_70 + 0.000200534921003128*x_71 + 0.000206475768855029*x_72 + 0.00128340167272124*x_73 + 0.000949153115736724*x_74 + 0.000320651211866906*x_75 + 0.00344492175212786*x_76 - 0.000549198453712685*x_77 - 0.00345117243283703*x_78 + 0.000877045190415361*x_79 - 0.00816141964292145*x_8 + 0.00165122104406154*x_80 + 0.000364586837667015*x_81 - 0.000415367690427994*x_82 - 0.000113437069866302*x_83 - 0.00211643958667371*x_84 - 0.000920716339627099*x_85 - 0.000106126444288732*x_86 + 0.000867763721450487*x_87 + 0.00107626217740282*x_88 + 0.000850424215906232*x_89 + 0.00215480026481048*x_9 - 0.000259614856252409*x_90 - 0.000146152432163871*x_91 + 0.00163653767241412*x_92 + 0.00343778916161859*x_93 + 0.0021279343791774*x_94 - 0.000265691717200879*x_95 + 0.00399327540186937*x_96 - 0.00393631466263969*x_97 - 0.00150571147897203*x_98 + 0.00175290559464518*x_99 - 2.77820855661817e-6*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) - 0.0119838053728178*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.000449757152018768*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.000572859022567589*std::sin(0.189440011978149*x_10 - 7.40327978134155) + 0.0239915070467268*std::sin(0.204960003495216*x_10 - 1.20431983470917) - 0.00131715591451606*std::sin(0.285999923944473*x_10 + 4.99871969223022) - 0.00358462510524322*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 9.99730742202485e-5*std::sin(0.25655996799469*x_100 + 1.94487977027893) - 0.000344188416694475*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.0219765694774232*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.0193496704717131*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 7.95001376407935e-5*std::sin(0.236559987068176*x_101 + 1.95871984958649) - 0.00507613902522116*std::sin(0.244959965348244*x_101 - 1.20255982875824) + 0.00366640554213671*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.0284486563009165*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.0187691767623605*std::sin(0.235199987888336*x_102 - 1.20855987071991) - 0.022472648008443*std::sin(0.249999970197678*x_102 - 4.40383958816528) + 0.000495721163048997*std::sin(0.243999972939491*x_103 - 1.20647990703583) + 0.000463396741895292*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.000106369318834782*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.00182914018351265*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.000293279053998861*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.00316002838763736*std::sin(0.253119975328445*x_107 - 7.42199993133545) + 0.00143345163586311*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 0.0115280700911964*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.000382121934167905*std::sin(0.273199945688248*x_108 - 1.22711992263794) - 0.00559795050443819*std::sin(0.274479955434799*x_108 - 1.23687982559204) + 0.0196751761785198*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.00279886047834501*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.026173239321141*std::sin(0.226879999041557*x_109 + 1.95823979377747) + 0.000146071031769395*std::sin(0.232559978961945*x_109 + 4.97751951217651) - 0.00674938110813487*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 0.00113669797889325*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.0201491429053116*std::sin(0.239999979734421*x_109 - 4.40607976913452) + 0.00021101746432099*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.0350868066568272*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.0180474582761219*std::sin(0.293839931488037*x_11 - 7.45207977294922) + 0.000423313644048428*std::sin(0.311919927597046*x_11 + 5.12680006027222) - 0.0193671621836971*std::sin(0.313519924879074*x_11 + 1.93895983695984) - 0.0090383145988276*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.0202245641870153*std::sin(0.26759997010231*x_112 + 5.15015983581543) + 0.000355678580133146*std::sin(0.278399974107742*x_112 + 1.96039986610413) - 0.000194137122102212*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.0274169540236005*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.026859527988814*std::sin(0.273839950561523*x_113 - 7.41279983520508) - 0.0100895295489992*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 8.5559953663568e-5*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.000101520863767297*std::sin(0.251599967479706*x_116 + 5.15064001083374) + 0.000409731475638054*std::sin(0.272719949483871*x_116 + 1.93367981910706) - 0.0178409439955929*std::sin(0.275199949741364*x_116 - 1.24471986293793) + 0.0174015492211649*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 0.00637432008791069*std::sin(0.235359981656075*x_118 + 1.94599986076355) + 0.00057351318776841*std::sin(0.240879982709885*x_118 - 7.44632005691528) + 0.000147134806354861*std::sin(0.253039985895157*x_119 - 7.62432050704956) - 0.012421681183037*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 3.64487330934928e-5*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 0.00392014904812068*std::sin(0.257279962301254*x_12 + 8.36040019989014) + 0.000189798649407113*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.013892314158799*std::sin(0.263919949531555*x_120 + 5.15799999237061) - 0.00146779066103884*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 0.0046340238215191*std::sin(0.263759940862656*x_13 - 4.21655988693237) + 0.000477240897420237*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.00330507886789171*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.0226786574803464*std::sin(0.297199934720993*x_15 + 5.15664005279541) - 0.00723552364221118*std::sin(0.33231982588768*x_15 - 4.33368015289307) - 0.0131671216372235*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 8.32432776621809e-5*std::sin(0.344719856977463*x_15 + 1.83199989795685) - 0.000299758016434926*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.00585531328102713*std::sin(0.256879955530167*x_16 - 4.20351982116699) - 0.0268035366276573*std::sin(0.288159936666489*x_16 - 7.40983963012695) + 0.0169185934130963*std::sin(0.328159838914871*x_16 + 8.24831962585449) + 0.000162478502853517*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 7.61430358242286e-5*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.0159896034698481*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 0.00199808441355823*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.019984855805724*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.00023693281279986*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.0122804066937292*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 6.50088765822689e-5*std::sin(0.38239985704422*x_17 - 1.19231986999512) + 0.00485422848373279*std::sin(0.402239859104156*x_17 - 1.21327984333038) + 0.000195305167583505*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.00284391779803222*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.0104741761835729*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.000268425726893843*std::sin(0.435919851064682*x_2 - 4.1898398399353) - 0.00308788432514599*std::sin(0.238639980554581*x_20 - 1.20031988620758) + 0.0181052343078241*std::sin(0.274079948663712*x_20 + 1.98231983184814) + 0.0218420884499739*std::sin(0.277279943227768*x_20 + 1.99079978466034) - 0.00728474218461672*std::sin(0.298959940671921*x_21 - 4.21544027328491) - 0.0189045590516432*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.00040875946240836*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 8.4138162883415e-5*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.0129768860878823*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.0153993905881327*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 0.00467624377976133*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.0238312406359876*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.0183607762955882*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.000347109223303*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 0.00479222451378663*std::sin(0.295839935541153*x_25 + 2.01895976066589) - 0.0177444575562952*std::sin(0.374799847602844*x_25 + 8.20135974884033) + 0.025174394721004*std::sin(0.228399991989136*x_26 - 1.19703996181488) + 0.00114349600530743*std::sin(0.251279979944229*x_26 + 1.98895990848541) - 0.0141008705154725*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.000252259964969355*std::sin(0.344799846410751*x_27 + 8.2139196395874) - 0.00186988915808923*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 0.00710700265627293*std::sin(0.242239981889725*x_28 - 1.16359984874725) + 0.000251119979588424*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.0254988473297918*std::sin(0.308959931135178*x_28 - 1.17487978935242) - 0.000511757414214637*std::sin(0.207440003752708*x_29 - 4.39679956436157) - 0.0196269850490859*std::sin(0.225359991192818*x_29 + 1.78623986244202) + 0.00219102154041308*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00611144355601491*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.000364821245257699*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 0.00552025870694288*std::sin(0.330399841070175*x_29 - 1.12807989120483) - 0.00674829826066081*std::sin(0.339599847793579*x_29 - 4.35775995254517) + 0.00714943396506305*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 5.28318298089212e-5*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00340215366721723*std::sin(0.396319836378098*x_3 - 1.1827198266983) + 0.0216409542797369*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.0209450949696058*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.00338890555444541*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.00137591561361881*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.0370320165748744*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 0.00139122732839981*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.000557561531901387*std::sin(0.413359850645065*x_31 - 7.38687992095947) + 0.000145039099805163*std::sin(0.428559869527817*x_31 - 7.39463949203491) - 0.000289615757963374*std::sin(1.1684798002243*x_31 + 4.6057596206665) + 0.00217941580343654*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.000464474312441268*std::sin(0.29911994934082*x_32 - 7.36168003082275) + 0.00118469891460821*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 8.35687245870714e-5*std::sin(0.303839921951294*x_32 - 1.13263988494873) + 0.000429325429750294*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 7.19325494794903e-5*std::sin(0.24695996940136*x_34 + 8.19207954406738) + 0.03297617032883*std::sin(0.247039973735809*x_34 - 1.20383989810944) + 0.00205680886531182*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.00357699376480229*std::sin(0.239439979195595*x_35 + 1.96807980537415) - 0.000249334807688095*std::sin(0.246559977531433*x_35 + 1.94663977622986) - 0.00355431894485366*std::sin(0.206800013780594*x_37 - 4.39247989654541) + 0.0020402929296787*std::sin(0.229039996862411*x_37 + 8.19023990631104) - 0.00201103801793935*std::sin(0.225599989295006*x_38 - 7.41167974472046) - 0.000117115812584132*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.0112845396300495*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.000439036793233563*std::sin(0.324879825115204*x_4 - 7.35623979568481) - 0.0100554801892475*std::sin(0.32551982998848*x_4 - 1.15559983253479) - 0.000240051013421871*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 3.95812245753599e-5*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.00219106690160626*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.00730169307236247*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 0.00327615077435206*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.0317730610599861*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.00457645102133489*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.0194039045991366*std::sin(0.246079966425896*x_42 + 8.18551921844482) + 0.0356461937184363*std::sin(0.253199964761734*x_42 - 1.22143983840942) - 0.0155802218236055*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 5.41954910253524e-5*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.0303900973968968*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.0051336442534901*std::sin(0.129440054297447*x_44 + 1.7668799161911) + 0.000472395595280001*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.00711304392288421*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.000328611222058933*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.000585593452018103*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.00470268759570375*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.035423767381458*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.00455209729818099*std::sin(0.225519984960556*x_47 + 8.19655990600586) - 0.000467915078363234*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.00060060374977853*std::sin(0.230159983038902*x_48 + 1.98047983646393) - 0.00265167518055247*std::sin(0.240479975938797*x_48 - 7.42575979232788) - 0.000359114109854026*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.0370881716211727*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 0.00864690293861585*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.00608099622550858*std::sin(0.242799982428551*x_49 - 1.21991980075836) + 0.0156070149757648*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.000291411835070714*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 7.96406207705812e-5*std::sin(0.39183983206749*x_5 + 2.01263976097107) - 0.0131133929470089*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.0165800992256048*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.0399670688280158*std::sin(0.224639996886253*x_52 - 7.41792011260986) - 6.28022317003454e-5*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.00230814074198354*std::sin(0.234079986810684*x_52 + 5.17903995513916) - 0.0204681332339153*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.0194475327839611*std::sin(0.216879993677139*x_53 - 4.38775968551636) - 0.0078363909874546*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.000493578901224055*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.0274252943176312*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.0260877860722458*std::sin(0.174000009894371*x_55 + 8.2183198928833) - 0.0239381327394408*std::sin(0.220479995012283*x_56 + 8.19176006317139) - 0.000464927799161649*std::sin(0.239279985427856*x_56 - 1.22927987575531) + 0.00651043628500592*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 0.00439010480121137*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.0119616919037758*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 0.00487105132269926*std::sin(0.282239943742752*x_6 - 0.996719837188721) + 0.000166244033060674*std::sin(0.387039840221405*x_6 - 1.1794399023056) + 0.000130314529242003*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.00116443094534696*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.0146609115855669*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.0250885069505665*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.00350864498526203*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.00765432057950362*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 0.000668192391009736*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 0.00477614842895708*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.000308353810431747*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00365700375285329*std::sin(0.327199846506119*x_8 + 8.25103950500488) - 0.0160989829365538*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.0195714807644041*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.0108293296869109*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.0112063924651819*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 0.00245609713638526*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.0038965671411984*std::sin(0.327279835939407*x_91 + 4.99647998809814) - 0.000222232140668995*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 0.0132709738986016*std::sin(0.367839843034744*x_91 - 1.18095993995667) + 0.000109926428010713*std::sin(0.382879853248596*x_91 - 1.17583978176117) + 0.0042038189612634*std::sin(0.38663986325264*x_91 - 4.39359998703003) + 0.0121782298008412*std::sin(0.445439845323563*x_91 - 1.38639986515045) + 0.017468456924545*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.0211507760407879*std::sin(0.292239934206009*x_92 - 7.38303995132446) - 0.000213485972654501*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.00337709275747194*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 9.96369626250325e-5*std::sin(0.255759954452515*x_94 + 1.99439978599548) - 0.000510872462099393*std::sin(0.279119968414307*x_94 + 1.99335980415344) + 0.00282558863673689*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 0.0140828416805435*std::sin(0.301119923591614*x_94 - 4.40064001083374) + 0.00118609711794117*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.00021846431130583*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.0150985907703716*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.0302872552214149*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.000536695220143395*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.000430023335680794*std::sin(0.292079925537109*x_96 - 1.20975983142853) + 0.00605669770945053*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.0308696645220288*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.0149136404778223*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 7.65013741370309e-5*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.0221006074762958*std::sin(0.265119940042496*x_98 - 1.19839990139008) - 0.0111454161653944*std::sin(0.271519958972931*x_98 - 4.40455961227417) - 0.0198246388958414*std::sin(0.246479973196983*x_99 - 7.43895959854126) + 0.0212938384637888*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 0.0044261160120843*std::sin(0.263999968767166*x_99 - 1.22975981235504) + 0.000136133664400556*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.256900612880453);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000793943495505996*x_1 + 0.00132234982403555*x_10 - 0.00116272661531059*x_100 + 0.00168737330288626*x_101 + 0.00231523880177393*x_102 - 0.00122760851271626*x_103 - 0.00136895532210631*x_104 + 0.000270134888592874*x_105 - 0.001815583033032*x_106 - 0.0021252295755224*x_107 + 0.000350486865795368*x_108 - 0.000682039907985072*x_109 + 0.000902740405207507*x_11 - 0.00290355430337243*x_110 - 0.000879982188214597*x_111 + 0.00136392323865724*x_112 - 0.000815750673034192*x_113 - 0.00299460828597941*x_114 + 0.00277455874399544*x_115 + 0.00429799471418386*x_116 + 0.00297989741969651*x_117 - 0.00108146860571308*x_118 + 0.00362687202865742*x_119 - 0.000264593890966078*x_12 + 0.00231720683795303*x_120 - 0.000856212095852407*x_13 - 0.00164823196910884*x_14 + 0.000650677662425596*x_15 - 0.00106700770473179*x_16 - 0.003107866604536*x_17 - 0.000205585822450683*x_18 - 0.00112838266837215*x_19 + 6.51364813832118e-5*x_2 - 0.000436657865677159*x_20 + 0.000467761645196955*x_21 - 0.00143945760345272*x_22 + 5.88243176136972e-5*x_23 - 0.00198284599841209*x_24 - 0.000401506423543191*x_25 - 0.00289849928877941*x_26 - 0.00210196326069073*x_27 + 0.00181769522447563*x_28 + 0.000418155175888205*x_29 + 0.00139254908438742*x_3 - 0.00121320459866022*x_30 + 0.00112372269077937*x_31 + 0.00052397292128458*x_32 + 0.00106817698741217*x_33 + 0.000232197739875485*x_34 - 0.00114583295740189*x_35 - 0.00081263939912661*x_36 - 0.00138527145821889*x_37 - 0.00196835063440709*x_38 - 0.00054110396143272*x_39 - 0.000205012638312596*x_4 - 0.000667338309229463*x_40 + 0.00164619309427681*x_41 + 0.00166202233683826*x_42 + 0.00226210826142657*x_43 + 0.0032577523616324*x_44 + 0.00261550769555174*x_45 - 0.00519105024435922*x_46 - 5.16178273176706e-5*x_47 - 0.00421436579814665*x_48 + 6.62616148949216e-6*x_49 - 0.000284632223445123*x_5 + 0.000224841572049796*x_50 - 0.00204398360327562*x_51 + 0.00244090864588479*x_52 - 3.0022355413748e-5*x_53 + 0.000182833601889328*x_54 + 0.000663307528529424*x_55 + 0.000916192842464002*x_56 + 0.000613902703069917*x_57 - 0.00106379471455121*x_58 + 0.00190279208345403*x_59 - 0.0003339015279797*x_6 + 0.00118047544577709*x_60 - 0.000308357473036606*x_61 - 0.000855649505531446*x_62 - 0.000892736810461306*x_63 + 0.00118371021357582*x_64 + 0.000839493256942898*x_65 + 0.000219603910284462*x_66 + 3.0958096413631e-5*x_67 + 0.000629950443336241*x_68 - 0.000911991792721477*x_69 + 0.00168619651923473*x_7 + 0.000144246071298387*x_70 + 0.000829206530315227*x_71 - 4.23585493943424e-5*x_72 + 0.00100839615463148*x_73 + 0.000430133450437916*x_74 - 2.39742147826239e-5*x_75 + 0.000807663747001602*x_76 + 0.000408708240189947*x_77 - 0.00103560672819449*x_78 + 0.000357735851083069*x_79 - 0.00251116991549027*x_8 + 0.000466565708607716*x_80 + 5.96826519338021e-5*x_81 + 0.000308994339291122*x_82 - 0.00163211367426893*x_83 - 0.000702848643829354*x_84 - 0.00120731238812297*x_85 + 0.001179298219145*x_86 + 0.000141931106749759*x_87 + 0.00138225633724903*x_88 + 0.000418223646517807*x_89 - 0.000270024566711518*x_9 - 0.000998257001321897*x_90 + 0.00117151456698014*x_91 + 0.000338954647068907*x_92 + 0.000891183602407996*x_93 + 0.000921696106839534*x_94 + 2.1482058903726e-5*x_95 - 0.00272816024576489*x_96 - 0.00145528592383631*x_97 - 0.00119058470418779*x_98 - 0.00148410753662729*x_99 - 2.35634367975671e-6*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) - 0.00682957277218567*std::sin(0.413039863109589*x_1 - 0.994799792766571) - 0.00504845821122521*std::sin(0.453919857740402*x_1 - 0.967119812965393) - 0.00643025869266245*std::sin(0.189440011978149*x_10 - 7.40327978134155) + 0.00197081991452455*std::sin(0.285999923944473*x_10 + 4.99871969223022) + 0.000674397831033146*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.00469448158941924*std::sin(0.25655996799469*x_100 + 1.94487977027893) - 0.00117778136860225*std::sin(0.261679977178574*x_100 - 1.21367979049683) + 0.0125244507783394*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.00777114458603068*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.00373312449799018*std::sin(0.236559987068176*x_101 + 1.95871984958649) + 0.000955005627680438*std::sin(0.244959965348244*x_101 - 1.20255982875824) + 0.000391679039439232*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.0114254463256057*std::sin(0.23455998301506*x_102 - 1.19255983829498) + 0.0106965571105914*std::sin(0.235199987888336*x_102 - 1.20855987071991) + 0.00169631260536932*std::sin(0.243999972939491*x_103 - 1.20647990703583) + 0.00158570138448248*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.00499483298721859*std::sin(0.235199987888336*x_104 - 1.21823990345001) - 0.000735376646258989*std::sin(0.237759977579117*x_104 - 4.42519998550415) - 0.00329201446090428*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.00268018500674587*std::sin(0.253119975328445*x_107 - 7.42199993133545) - 0.00214482962824091*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 0.00462986176470279*std::sin(0.268879950046539*x_108 + 1.95047986507416) + 0.00130758640549114*std::sin(0.273199945688248*x_108 - 1.22711992263794) + 0.00105317726891495*std::sin(0.274479955434799*x_108 - 1.23687982559204) + 0.0112128863358851*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.00237385965245788*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.0105116015979037*std::sin(0.226879999041557*x_109 + 1.95823979377747) + 0.00217167316412947*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.0131568405562744*std::sin(0.235839992761612*x_109 - 7.43439960479736) + 0.00170080625149507*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.00762895404296734*std::sin(0.239999979734421*x_109 - 4.40607976913452) + 0.000722082516064352*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.0140914362335478*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.00683320528460835*std::sin(0.293839931488037*x_11 - 7.45207977294922) + 0.0014485406796183*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.0023438924177671*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.00109385344412609*std::sin(0.256239980459213*x_110 - 7.63824033737183) - 0.011525982657751*std::sin(0.26759997010231*x_112 + 5.15015983581543) + 0.00121709965987489*std::sin(0.278399974107742*x_112 + 1.96039986610413) - 0.00288628329055888*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.0110110977929792*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.010169668536543*std::sin(0.273839950561523*x_113 - 7.41279983520508) + 0.00189820598925036*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.00401767806379841*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.0047671618544765*std::sin(0.251599967479706*x_116 + 5.15064001083374) + 0.00140206373814367*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.00215918331041181*std::sin(0.275199949741364*x_116 - 1.24471986293793) - 0.00241347213796448*std::sin(0.235359981656075*x_118 + 1.94599986076355) + 0.00196250981857101*std::sin(0.240879982709885*x_118 - 7.44632005691528) + 0.000503481887223073*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.00150332217310336*std::sin(0.262319952249527*x_119 - 1.23623991012573) + 0.000409131694846113*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 0.000418786246087689*std::sin(0.257279962301254*x_12 + 8.36040019989014) + 0.00282178217345766*std::sin(0.273439943790436*x_12 - 7.43800020217896) - 0.0079172322621987*std::sin(0.263919949531555*x_120 + 5.15799999237061) + 0.00219621005626454*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 0.000495048891425509*std::sin(0.263759940862656*x_13 - 4.21655988693237) + 0.00163307482196741*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.00280320988966144*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.00910812029354601*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.0141044977867657*std::sin(0.33231982588768*x_15 - 4.33368015289307) - 0.00750394491766464*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.00390889284415816*std::sin(0.344719856977463*x_15 + 1.83199989795685) - 0.00102574459139807*std::sin(0.346479833126068*x_15 + 5.05615997314453) - 0.00235403534524541*std::sin(0.256879955530167*x_16 - 4.20351982116699) + 0.00964190933706674*std::sin(0.328159838914871*x_16 + 8.24831962585449) + 0.000555986617147338*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00357548352521236*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.00605405155990955*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 0.000213453687767693*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.00756675096373482*std::sin(0.263119965791702*x_17 - 4.18071985244751) - 0.00265953614949568*std::sin(0.349279850721359*x_17 - 1.16287982463837) + 0.00699860591670631*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.0030526516929143*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.00946254318151062*std::sin(0.402239859104156*x_17 - 1.21327984333038) - 0.0021922719239838*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.00241207511695885*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.00396577706148265*std::sin(0.389039844274521*x_18 + 5.00959968566895) + 0.00301303950133686*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.00601933733941894*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 0.00219116879455515*std::sin(0.274079948663712*x_20 + 1.98231983184814) - 0.0029287144445634*std::sin(0.298959940671921*x_21 - 4.21544027328491) + 0.0013987375975287*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.00395091438074182*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.00491336371231842*std::sin(0.380319833755493*x_21 - 1.37543988227844) + 0.00877611538214045*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 0.000499559214274259*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.00957101656679292*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.00695183508353206*std::sin(0.290399938821793*x_24 - 1.37751984596252) - 0.00389625023351026*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 0.000511949339145719*std::sin(0.295839935541153*x_25 + 2.01895976066589) + 0.0101104492466021*std::sin(0.228399991989136*x_26 - 1.19703996181488) - 0.00171097792949377*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.00170654446798371*std::sin(0.271199941635132*x_26 - 1.17551982402802) + 0.00283158118952999*std::sin(0.344799846410751*x_27 + 8.2139196395874) + 0.00279785767964288*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 0.000759235153260976*std::sin(0.242239981889725*x_28 - 1.16359984874725) + 0.000859309665570658*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.0102407547284391*std::sin(0.308959931135178*x_28 - 1.17487978935242) - 0.0017511871941963*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.00237533723339735*std::sin(0.225359991192818*x_29 + 1.78623986244202) - 0.00327835819390058*std::sin(0.268239974975586*x_29 + 8.22647953033447) + 0.00245700843846356*std::sin(0.304799944162369*x_29 - 7.40287971496582) + 0.00409506508786719*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 0.000589724623460878*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.0131547297180606*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 0.00134506750848248*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.0024808485115393*std::sin(0.360879838466644*x_3 + 1.97023975849152) - 0.00136778163664383*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.00261907594764804*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.00793032079327732*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.00128312181080443*std::sin(0.272159963846207*x_31 - 1.09007978439331) + 0.000553164934321934*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.0148726643968607*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 0.000148623652612003*std::sin(0.392399847507477*x_31 - 4.40167999267578) + 0.00625854659866176*std::sin(0.413359850645065*x_31 - 7.38687992095947) + 0.000496310570558796*std::sin(0.428559869527817*x_31 - 7.39463949203491) + 5.448721505572e-5*std::sin(1.1684798002243*x_31 + 4.6057596206665) + 0.000876199374318718*std::sin(0.272559970617294*x_32 + 2.01647973060608) - 0.00521365618316938*std::sin(0.29911994934082*x_32 - 7.36168003082275) - 0.00177262857638483*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.00392417500497144*std::sin(0.303839921951294*x_32 - 1.13263988494873) + 0.00146911246195685*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.00337776978296683*std::sin(0.24695996940136*x_34 + 8.19207954406738) + 0.000826907209738366*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.0030338351057708*std::sin(0.239439979195595*x_35 + 1.96807980537415) - 0.00370692055899525*std::sin(0.246559977531433*x_35 + 1.94663977622986) + 0.000668696144459629*std::sin(0.206800013780594*x_37 - 4.39247989654541) - 0.00305282760602551*std::sin(0.229039996862411*x_37 + 8.19023990631104) + 0.00300905438068587*std::sin(0.225599989295006*x_38 - 7.41167974472046) - 0.000400759628563403*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.00427260031050735*std::sin(0.255519956350327*x_4 - 0.956879794597626) - 0.00492812375274351*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.0012169549440973*std::sin(0.32551982998848*x_4 - 1.15559983253479) - 0.000821432672945925*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.00185863375218746*std::sin(0.329039841890335*x_4 - 1.40119981765747) - 0.000880883512568215*std::sin(0.345839858055115*x_4 + 2.01703977584839) + 0.00416123615550158*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 0.000349988448797862*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.0127605817266445*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.000488898437305031*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.00779292589989449*std::sin(0.246079966425896*x_42 + 8.18551921844482) + 0.00188558155568186*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.0025448825779584*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.0115064277171368*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.00435411163140165*std::sin(0.129440054297447*x_44 + 1.7668799161911) + 0.00161649463998213*std::sin(0.256959974765778*x_44 - 1.23063993453979) + 0.00405372497230971*std::sin(0.282799929380417*x_44 - 1.26543986797333) + 0.00368861287665513*std::sin(0.288799941539764*x_44 - 4.44839954376221) + 0.00657320079961093*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.00398859479703553*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.0142267651795755*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.00386087130595523*std::sin(0.225519984960556*x_47 + 8.19655990600586) - 0.00160116271975961*std::sin(0.231999978423119*x_47 - 4.4127197265625) + 0.00674168919527385*std::sin(0.230159983038902*x_48 + 1.98047983646393) + 0.00396762007829829*std::sin(0.240479975938797*x_48 - 7.42575979232788) - 0.00122885572922607*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.014895217183207*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 0.00327392710661205*std::sin(0.26639997959137*x_48 - 7.80967998504639) + 0.00244476757469756*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.00188882417148683*std::sin(0.260079979896545*x_49 + 1.94671976566315) + 0.00327105520169596*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.00373972122887554*std::sin(0.39183983206749*x_5 + 2.01263976097107) + 0.00627762757028406*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.0029490332551162*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.00195765463194108*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.00247713639395272*std::sin(0.25519996881485*x_52 + 1.95015978813171) - 0.0110831523256205*std::sin(0.216879993677139*x_53 - 4.38775968551636) + 0.00147430900858697*std::sin(0.246479973196983*x_53 - 1.2053599357605) + 0.00168898198079945*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.010383881386285*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.00987746833516484*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.00289708978999043*std::sin(0.220479995012283*x_56 + 8.19176006317139) - 0.00159094052280066*std::sin(0.239279985427856*x_56 - 1.22927987575531) - 0.00122484889794063*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 0.000468991226369884*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.00452898657967154*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 0.000520370341253131*std::sin(0.282239943742752*x_6 - 0.996719837188721) + 0.00247159002658707*std::sin(0.387039840221405*x_6 - 1.1794399023056) + 0.000445924433115498*std::sin(0.45159986615181*x_6 - 4.24871969223022) + 0.000468140895437012*std::sin(0.512639820575714*x_6 + 1.91543984413147) - 0.00835525606977258*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.0100759553112548*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.00297586493851856*std::sin(0.348239839076996*x_7 - 7.34895992279053) + 0.00436219863332666*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 7.13824346116317e-5*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 0.000510231944440846*std::sin(0.285839945077896*x_8 + 1.97279977798462) - 0.00346122639573228*std::sin(0.319279909133911*x_8 - 7.41967964172363) - 0.00147024005014496*std::sin(0.327199846506119*x_8 + 8.25103950500488) - 0.00741023715034041*std::sin(0.345519840717316*x_8 + 5.03679990768433) - 0.00617163687742357*std::sin(0.388639837503433*x_8 + 1.80719995498657) + 0.00638652502052751*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 0.000262382804109606*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.00147533479638495*std::sin(0.327279835939407*x_91 + 4.99647998809814) - 0.00330397868935311*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 0.00532984048044836*std::sin(0.367839843034744*x_91 - 1.18095993995667) + 0.000376158210294857*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.000508763199043439*std::sin(0.38663986325264*x_91 - 4.39359998703003) - 0.00211410341624537*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.00800819663379969*std::sin(0.292239934206009*x_92 - 7.38303995132446) - 0.000730529526429694*std::sin(0.329999834299088*x_92 + 1.7940798997879) + 0.00135770629746163*std::sin(0.230159983038902*x_93 - 7.42727994918823) - 0.00111841032398945*std::sin(0.255759954452515*x_94 + 1.99439978599548) - 0.00174815896877416*std::sin(0.279119968414307*x_94 + 1.99335980415344) - 0.000531595576123147*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 0.00565589987910495*std::sin(0.301119923591614*x_94 - 4.40064001083374) - 0.00177472066506074*std::sin(0.336239844560623*x_94 - 7.57615995407104) - 0.00245222992301755*std::sin(0.268159955739975*x_95 - 1.18831992149353) + 0.00860468951353285*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.0121638577661416*std::sin(0.276159942150116*x_95 + 1.96335983276367) + 0.00183652209151442*std::sin(0.284079939126968*x_95 - 1.20591986179352) - 0.00482694901079764*std::sin(0.292079925537109*x_96 - 1.20975983142853) - 0.00113948423574401*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.00598956228358841*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.00359231018204326*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.00836782584503255*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.00134886341091918*std::sin(0.271519958972931*x_98 - 4.40455961227417) - 0.00257706658554477*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 0.000472838273926857*std::sin(0.263999968767166*x_99 - 1.22975981235504) + 0.00202393193319826*std::sin(0.268559962511063*x_99 + 4.97799968719482) - 0.0250179376453161*std::sin(0.00779194233893056*x_1 + 0.0037037654537115*x_100 - 0.123963140116262*x_101 - 0.0377426837236315*x_103 - 0.00117521688996112*x_104 + 0.157464213825538*x_105 + 0.221572569600295*x_106 - 0.00384071458447324*x_107 - 0.0826681608453*x_108 + 0.0702748375714887*x_109 + 0.0649954550496264*x_11 + 0.191828435820108*x_110 + 0.155329303167016*x_111 - 0.100483519852815*x_112 + 0.0906542814795171*x_113 - 0.087110890741141*x_114 + 0.313987987010346*x_115 + 0.385440860072881*x_117 + 0.252838768775928*x_118 + 0.398401638790875*x_119 + 0.0871101897704851*x_12 + 0.195964085601342*x_120 - 0.0525578230894315*x_13 + 0.00343771231317256*x_14 - 0.00224901366963183*x_15 + 0.00640897173069652*x_17 - 0.0210202911424677*x_18 + 0.0357536114737028*x_19 - 0.00971851495594322*x_2 + 0.196417506861542*x_22 - 0.00892231545260001*x_23 + 0.166515349763888*x_24 - 0.061030447609784*x_26 - 0.00124135921614883*x_27 + 0.118105392705214*x_28 - 0.00634847144879771*x_29 + 0.00301480522637887*x_3 - 0.166541142346768*x_30 + 0.0826469161981818*x_31 - 0.000339465159594372*x_32 + 0.152118383291156*x_33 - 0.023997736395221*x_35 - 0.00382181359361036*x_36 + 0.184174310334554*x_37 - 0.0371461887905468*x_38 - 0.000771104381461608*x_39 + 0.00251568454344274*x_4 - 0.144443147084703*x_40 + 0.222815123791199*x_41 + 0.0544169266192871*x_43 - 0.0329258459528986*x_44 - 0.214844044519325*x_45 + 0.0776834800567745*x_46 - 0.181211266238017*x_47 + 0.0102695762634408*x_48 - 0.312701689235173*x_49 - 0.0873110556524069*x_5 - 0.320637903777657*x_50 + 0.23127512941798*x_53 + 0.368209050119796*x_54 - 0.0513716064866878*x_55 - 0.177626770978954*x_56 - 0.112707998836265*x_57 + 0.258448499849798*x_58 + 0.176642295008142*x_59 + 0.172052149369773*x_6 + 0.00337488689715562*x_60 - 0.0146988478721454*x_61 + 0.00088848461982542*x_62 - 0.00222295235111074*x_63 - 0.00317434169703841*x_64 - 0.00295737582018853*x_65 + 0.00193282608368742*x_66 + 0.000260607652111897*x_67 - 0.00660142154168084*x_68 + 0.117357921554962*x_69 - 0.0246233614553267*x_7 - 0.00627542327945088*x_70 + 0.00482354057575392*x_71 + 3.74345025876989e-5*x_72 + 0.0568441948974526*x_73 - 0.00718270721284349*x_74 - 0.00106599856384136*x_75 - 0.0744128639460438*x_76 + 0.000453000066304202*x_77 + 0.0651303834398384*x_78 + 0.00266680384328987*x_79 - 0.0043872038391734*x_80 + 0.00155931625019124*x_81 + 0.0728949653405921*x_82 - 0.00317122128577687*x_83 + 0.00221553806409573*x_84 + 0.0114437625662334*x_85 - 0.0122478060844767*x_86 - 0.0633887094316758*x_87 - 0.00151881603817964*x_88 - 0.0277223799766256*x_89 + 0.00225659311017309*x_9 - 0.0374379482222279*x_90 + 0.00913786502319106*x_92 + 0.0186901542990349*x_93 - 0.0124523007401503*x_94 - 0.00458745700011796*x_95 - 0.132710750804547*x_96 - 0.0941080215686941*x_98 - 1.19970912304423*std::sin(0.204960003495216*x_10 - 1.20431983470917) + 1.1237577023478*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.87017448779163*std::sin(0.317599922418594*x_116 - 1.45887994766235) + 1.34032628127201*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 1.09222620858024*std::sin(0.277279943227768*x_20 + 1.99079978466034) + 0.945333359726519*std::sin(0.318079918622971*x_21 - 4.38975954055786) + 0.887321816520185*std::sin(0.374799847602844*x_25 + 8.20135974884033) - 1.64899238340908*std::sin(0.247039973735809*x_34 - 1.20383989810944) - 1.78250844027926*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.655742764385316*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 1.99857628788888*std::sin(0.224639996886253*x_52 - 7.41792011260986) + 0.805038910773717*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.608979392838584*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 1.54365534771378*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.991342482074018*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 14.2971510293271) + 0.106837768975829);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00167441015641466*x_1 + 0.00095505591211823*x_10 - 0.00185846333474622*x_100 + 0.00350491898393124*x_101 + 0.00103556784192859*x_102 - 0.000280820053958143*x_103 - 0.00106785719222898*x_104 - 0.0064746497662432*x_105 - 0.00134602993785344*x_106 - 0.00224327718266567*x_107 + 0.00125836654871883*x_108 - 0.00149838475703716*x_109 - 0.00143625129420046*x_11 - 0.000772875197706141*x_110 - 0.00423393353806672*x_111 + 0.00371635611558202*x_112 - 0.000483097986512423*x_113 + 0.000653326779959458*x_114 - 0.00620648827473354*x_115 + 0.0007249626269123*x_116 - 0.00275546374071903*x_117 - 0.00782609098545499*x_118 - 0.00442570338909966*x_119 - 0.0051746885707951*x_12 - 0.00378519748632184*x_120 - 0.00175207000645364*x_13 - 0.00076576569805465*x_14 + 1.92166737225298e-6*x_15 + 0.00134332129942219*x_16 - 0.0017541125288398*x_17 - 0.000104466752262314*x_18 + 0.000148972775913907*x_19 - 0.0010755855949693*x_2 + 4.12366199757575e-5*x_20 + 0.000718455359559023*x_21 - 0.000897348248578766*x_22 - 0.000367228788612083*x_23 - 0.00277809936485345*x_24 + 0.000677949878329892*x_25 + 0.000243602383516528*x_26 + 0.00121720317493724*x_27 - 0.00255954472269589*x_28 - 0.00135593213946925*x_29 - 0.00121012424979016*x_3 + 0.00255287382578969*x_30 - 0.00053328913023313*x_31 + 0.000347109059504556*x_32 - 0.00448383689442063*x_33 - 0.000245885691218275*x_34 + 0.00227357781858848*x_35 - 0.00121019730452912*x_36 - 0.00595743701245879*x_37 + 0.00491738681289079*x_38 + 0.0023381010647*x_39 - 4.47593301565451e-5*x_4 + 0.00608790303447167*x_40 - 0.00507780136858819*x_41 - 0.000463202284112039*x_42 + 0.0030421603971705*x_43 + 0.000861399372132741*x_44 + 0.00114024905922385*x_45 + 0.00279047721382855*x_46 + 0.000159563243400528*x_47 + 0.00122275733512537*x_48 + 0.00496078576988179*x_49 + 0.000944822773445041*x_5 + 0.00645662000741938*x_50 + 0.00308727149018257*x_51 + 0.00121728822815628*x_52 - 0.00170802725762632*x_53 - 0.0143386272450245*x_54 - 0.00234511341935343*x_55 + 0.0028959197381893*x_56 + 0.00338224149457162*x_57 - 0.00106668943955991*x_58 - 0.00649756804713153*x_59 - 0.00187699999380744*x_6 + 0.00197105577529908*x_60 + 0.00102244628681365*x_61 + 0.000638536054121655*x_62 - 1.13790388364938e-5*x_63 + 0.000222342272135658*x_64 + 0.000742605078028827*x_65 - 0.000598974871793955*x_66 - 0.000731343972754443*x_67 + 0.000553314916752159*x_68 - 0.00203591705872038*x_69 + 0.00216222712608926*x_7 - 0.000210655443539657*x_70 - 0.0018573019182807*x_71 - 0.000509074202331883*x_72 - 0.000970345165657235*x_73 - 0.000383015666734211*x_74 - 0.000341069638354766*x_75 + 0.000534376418641601*x_76 - 0.000976835818044287*x_77 - 0.000689343228743372*x_78 - 7.4203085914556e-5*x_79 - 0.000802575476753944*x_8 + 0.000596757287849482*x_80 + 0.000261024683401204*x_81 - 0.00148678085418479*x_82 + 0.000310429976638644*x_83 + 0.00190319849961206*x_84 - 0.000513490364105142*x_85 + 0.000606953978431743*x_86 + 0.000954658188230875*x_87 - 0.000422361993794398*x_88 + 0.000266854312029591*x_89 - 0.000868334312680284*x_9 + 0.000566303641249196*x_90 - 0.000149583164808432*x_91 + 0.000791606884618119*x_92 - 0.00346449804439895*x_93 - 0.000714959165083694*x_94 - 0.00064624136700973*x_95 + 0.000128327876578327*x_96 + 7.83531933435463e-5*x_97 + 0.00204816260630372*x_98 + 0.00350073161842551*x_99 - 1.52735064282304e-6*std::pow(-4.68487977981567*x_10 - 8.4019193649292, 2) + 0.00613436449702183*std::sin(0.413039863109589*x_1 - 0.994799792766571) + 0.0044251046458247*std::sin(0.453919857740402*x_1 - 0.967119812965393) + 0.00563628862995969*std::sin(0.189440011978149*x_10 - 7.40327978134155) + 0.0193279334665146*std::sin(0.204960003495216*x_10 - 1.20431983470917) - 0.00421900631782335*std::sin(0.285999923944473*x_10 + 4.99871969223022) + 0.000337477717244832*std::sin(0.235359981656075*x_100 - 1.21407985687256) - 0.00526184088339674*std::sin(0.25655996799469*x_100 + 1.94487977027893) + 0.00199211974595714*std::sin(0.261679977178574*x_100 - 1.21367979049683) - 0.0112495391384131*std::sin(0.264479964971542*x_100 - 1.2105598449707) - 0.00578173390413877*std::sin(0.234399989247322*x_101 + 1.9826397895813) - 0.00418429739944187*std::sin(0.236559987068176*x_101 + 1.95871984958649) + 0.000477897621188704*std::sin(0.244959965348244*x_101 - 1.20255982875824) + 0.00343372071288955*std::sin(0.246719971299171*x_101 - 1.207279920578) - 0.00850053549504389*std::sin(0.23455998301506*x_102 - 1.19255983829498) - 0.00960771374262387*std::sin(0.235199987888336*x_102 - 1.20855987071991) - 0.0181043168600302*std::sin(0.249999970197678*x_102 - 4.40383958816528) - 0.0028691724343395*std::sin(0.243999972939491*x_103 - 1.20647990703583) - 0.00268208270518662*std::sin(0.22495998442173*x_104 - 1.19919991493225) + 0.00559849174339543*std::sin(0.235199987888336*x_104 - 1.21823990345001) + 0.000607894807098732*std::sin(0.237759977579117*x_104 - 4.42519998550415) + 0.0028855361133185*std::sin(0.241519972681999*x_107 - 7.42303991317749) + 0.00173726028512132*std::sin(0.253119975328445*x_107 - 7.42199993133545) + 0.00459151528027162*std::sin(0.263919949531555*x_108 + 1.94823980331421) + 0.00344461854236721*std::sin(0.268879950046539*x_108 + 1.95047986507416) - 0.00221167422695384*std::sin(0.273199945688248*x_108 - 1.22711992263794) + 0.000527024026787084*std::sin(0.274479955434799*x_108 - 1.23687982559204) - 0.0100714838456845*std::sin(0.275599956512451*x_108 + 1.92775976657867) + 0.00153870426343222*std::sin(0.281999945640564*x_108 + 8.15032005310059) + 0.00782063474338751*std::sin(0.226879999041557*x_109 + 1.95823979377747) + 0.00066345713033842*std::sin(0.232559978961945*x_109 + 4.97751951217651) + 0.000873694883105547*std::sin(0.235839992761612*x_109 - 7.43439960479736) - 0.00364097818758963*std::sin(0.237119987607002*x_109 - 1.21911990642548) + 0.00421186216207875*std::sin(0.239999979734421*x_109 - 4.40607976913452) - 0.00122134283731228*std::sin(0.261519968509674*x_109 + 4.95928001403809) + 0.0104840327866203*std::sin(0.284879922866821*x_11 + 5.14423990249634) + 0.00377253796809661*std::sin(0.293839931488037*x_11 - 7.45207977294922) - 0.00245008672035151*std::sin(0.311919927597046*x_11 + 5.12680006027222) + 0.0172690113579848*std::sin(0.313519924879074*x_11 + 1.93895983695984) + 0.00805914444169734*std::sin(0.256239980459213*x_110 - 7.63824033737183) + 0.0103527088981248*std::sin(0.26759997010231*x_112 + 5.15015983581543) - 0.00205862338280315*std::sin(0.278399974107742*x_112 + 1.96039986610413) - 0.000881774136609335*std::sin(0.241599977016449*x_113 - 4.2131199836731) - 0.00819226006242321*std::sin(0.264399945735931*x_113 + 5.19080018997192) + 0.00561456287044142*std::sin(0.273839950561523*x_113 - 7.41279983520508) + 0.000949887728925979*std::sin(0.223999992012978*x_114 + 5.16527986526489) - 0.00450324115447986*std::sin(0.258879989385605*x_114 - 4.44127988815308) - 0.00534330504143207*std::sin(0.251599967479706*x_116 + 5.15064001083374) - 0.00237147481893114*std::sin(0.272719949483871*x_116 + 1.93367981910706) + 0.0159081367510007*std::sin(0.275199949741364*x_116 - 1.24471986293793) + 0.0140189603306659*std::sin(0.317599922418594*x_116 - 1.45887994766235) - 0.00133245159426469*std::sin(0.235359981656075*x_118 + 1.94599986076355) - 0.0033194229977078*std::sin(0.240879982709885*x_118 - 7.44632005691528) - 0.000851597958676465*std::sin(0.253039985895157*x_119 - 7.62432050704956) + 0.0110759723804917*std::sin(0.262319952249527*x_119 - 1.23623991012573) - 0.000358614548812575*std::sin(0.317199915647507*x_119 - 4.64807987213135) - 0.0036713606363091*std::sin(0.257279962301254*x_12 + 8.36040019989014) + 0.000862068719255359*std::sin(0.273439943790436*x_12 - 7.43800020217896) + 0.00711130697687325*std::sin(0.263919949531555*x_120 + 5.15799999237061) - 0.00470150724292969*std::sin(0.255679965019226*x_13 - 1.02263987064362) - 0.00433993004786386*std::sin(0.263759940862656*x_13 - 4.21655988693237) - 0.00276221095544039*std::sin(0.281439960002899*x_13 + 5.15664005279541) - 0.00181700337846488*std::sin(0.331999838352203*x_14 - 7.53599977493286) - 0.00677644423175855*std::sin(0.297199934720993*x_15 + 5.15664005279541) + 0.000936625133698525*std::sin(0.33231982588768*x_15 - 4.33368015289307) + 0.00674008972830635*std::sin(0.339999854564667*x_15 - 4.34223985671997) + 0.00438130851818994*std::sin(0.344719856977463*x_15 + 1.83199989795685) + 0.00173496211547129*std::sin(0.346479833126068*x_15 + 5.05615997314453) + 0.00194594956119613*std::sin(0.256879955530167*x_16 - 4.20351982116699) - 0.0215933484961016*std::sin(0.288159936666489*x_16 - 7.40983963012695) - 0.00866042259066179*std::sin(0.328159838914871*x_16 + 8.24831962585449) - 0.000940405365574408*std::sin(0.348159849643707*x_16 - 7.56640005111694) - 0.00400760446761095*std::sin(0.358399868011475*x_16 + 5.03200006484985) - 0.0033423757108568*std::sin(0.363199830055237*x_16 - 7.58160018920898) + 0.0018712779473212*std::sin(0.392959833145142*x_16 + 1.80143988132477) - 0.00417752052175575*std::sin(0.263119965791702*x_17 - 4.18071985244751) + 0.00233115245852772*std::sin(0.349279850721359*x_17 - 1.16287982463837) - 0.00628619111270566*std::sin(0.354559868574142*x_17 + 8.22639942169189) - 0.00342158493426616*std::sin(0.38239985704422*x_17 - 1.19231986999512) - 0.000628370886117369*std::sin(0.402239859104156*x_17 - 1.21327984333038) + 0.00192158323786094*std::sin(0.331679850816727*x_18 + 5.02007961273193) + 0.00156347501940164*std::sin(0.362639844417572*x_18 + 8.20135974884033) - 0.0021894621797986*std::sin(0.389039844274521*x_18 + 5.00959968566895) - 0.00264100732096251*std::sin(0.435919851064682*x_2 - 4.1898398399353) + 0.000399720906447289*std::sin(0.238639980554581*x_20 - 1.20031988620758) - 0.0161437950452019*std::sin(0.274079948663712*x_20 + 1.98231983184814) + 0.017596328213505*std::sin(0.277279943227768*x_20 + 1.99079978466034) + 0.00242100468023038*std::sin(0.298959940671921*x_21 - 4.21544027328491) - 0.0152298085673533*std::sin(0.318079918622971*x_21 - 4.38975954055786) - 0.00236584892725587*std::sin(0.322879940271378*x_21 - 1.21151983737946) + 0.00442840863669448*std::sin(0.32551982998848*x_21 + 8.24944019317627) - 0.00271261441501559*std::sin(0.380319833755493*x_21 - 1.37543988227844) - 0.00788276110640818*std::sin(0.369199842214584*x_22 - 1.16735982894897) + 0.00437947055789407*std::sin(0.349599838256836*x_23 - 1.15639984607697) + 0.0071208391979701*std::sin(0.275199949741364*x_24 + 5.02551984786987) - 0.00383803218376073*std::sin(0.290399938821793*x_24 - 1.37751984596252) + 0.00341516444986429*std::sin(0.298399955034256*x_24 - 1.16463983058929) - 0.00448809068846663*std::sin(0.295839935541153*x_25 + 2.01895976066589) - 0.0142952126508558*std::sin(0.374799847602844*x_25 + 8.20135974884033) + 0.00752217727363264*std::sin(0.228399991989136*x_26 - 1.19703996181488) + 0.00366275307093797*std::sin(0.251279979944229*x_26 + 1.98895990848541) + 0.0125732459293467*std::sin(0.271199941635132*x_26 - 1.17551982402802) - 0.00248195440123849*std::sin(0.344799846410751*x_27 + 8.2139196395874) - 0.00598947632900876*std::sin(0.357039839029312*x_27 - 1.14823985099792) + 0.00665596370803639*std::sin(0.242239981889725*x_28 - 1.16359984874725) - 0.00145345120776252*std::sin(0.3018399477005*x_28 + 2.01215982437134) + 0.00761912459122429*std::sin(0.308959931135178*x_28 - 1.17487978935242) + 0.00296198826151058*std::sin(0.207440003752708*x_29 - 4.39679956436157) + 0.0175006861883448*std::sin(0.225359991192818*x_29 + 1.78623986244202) + 0.00701810136492924*std::sin(0.268239974975586*x_29 + 8.22647953033447) - 0.00203107166693153*std::sin(0.304799944162369*x_29 - 7.40287971496582) - 0.00358943082959141*std::sin(0.329999834299088*x_29 - 4.36855983734131) + 0.00516992090610141*std::sin(0.330399841070175*x_29 - 1.12807989120483) + 0.000873554710505703*std::sin(0.339599847793579*x_29 - 4.35775995254517) - 0.000673089816447748*std::sin(0.346159845590591*x_3 - 7.3919997215271) - 0.00278067553890361*std::sin(0.360879838466644*x_3 + 1.97023975849152) + 0.00113066869663408*std::sin(0.396319836378098*x_3 - 1.1827198266983) - 0.0192964710942006*std::sin(0.170480027794838*x_30 - 1.41063988208771) + 0.00437824345175362*std::sin(0.34911984205246*x_30 - 7.36520004272461) + 0.000708397530490707*std::sin(0.272159963846207*x_31 - 1.09007978439331) - 0.000457270560268767*std::sin(0.310239911079407*x_31 - 7.50207996368408) + 0.0110652667745729*std::sin(0.3572798371315*x_31 - 1.02039980888367) + 0.00130293445145744*std::sin(0.392399847507477*x_31 - 4.40167999267578) - 0.0054857785230884*std::sin(0.413359850645065*x_31 - 7.38687992095947) - 0.000839468269829059*std::sin(0.428559869527817*x_31 - 7.39463949203491) + 2.72661330002541e-5*std::sin(1.1684798002243*x_31 + 4.6057596206665) - 0.000724305092283173*std::sin(0.272559970617294*x_32 + 2.01647973060608) + 0.00456990495565108*std::sin(0.29911994934082*x_32 - 7.36168003082275) + 0.00379473086698843*std::sin(0.301039934158325*x_32 - 1.13639986515045) + 0.00439843762968442*std::sin(0.303839921951294*x_32 - 1.13263988494873) - 0.00248488218825298*std::sin(0.272879958152771*x_33 + 8.16928005218506) - 0.00378599570584657*std::sin(0.24695996940136*x_34 + 8.19207954406738) + 0.0265661187875664*std::sin(0.247039973735809*x_34 - 1.20383989810944) - 0.000683558012495574*std::sin(0.286079943180084*x_34 - 4.60623979568481) - 0.00196649157711008*std::sin(0.239439979195595*x_35 + 1.96807980537415) - 0.00113248297077398*std::sin(0.246559977531433*x_35 + 1.94663977622986) + 0.00033462451683295*std::sin(0.206800013780594*x_37 - 4.39247989654541) + 0.00653529978164156*std::sin(0.229039996862411*x_37 + 8.19023990631104) - 0.00644159283617262*std::sin(0.225599989295006*x_38 - 7.41167974472046) + 0.000677851756469091*std::sin(0.237679988145828*x_38 - 7.59832000732422) + 0.00235885594278823*std::sin(0.255519956350327*x_4 - 0.956879794597626) + 0.00431962836990027*std::sin(0.324879825115204*x_4 - 7.35623979568481) + 0.00896611490888836*std::sin(0.32551982998848*x_4 - 1.15559983253479) + 0.00138938540833936*std::sin(0.325999826192856*x_4 + 5.23935985565186) + 0.00208326199139081*std::sin(0.329039841890335*x_4 - 1.40119981765747) + 0.000728177207793078*std::sin(0.345839858055115*x_4 + 2.01703977584839) - 0.00373764804732628*std::sin(0.379119843244553*x_4 - 4.38655996322632) + 0.00306823308091714*std::sin(0.379599839448929*x_4 - 1.17863988876343) - 0.00949387663409284*std::sin(0.242559969425201*x_41 - 1.21039986610413) - 0.00428601104893709*std::sin(0.220639988780022*x_42 + 8.20359992980957) - 0.00579793920819004*std::sin(0.246079966425896*x_42 + 8.18551921844482) + 0.0287171314074838*std::sin(0.253199964761734*x_42 - 1.22143983840942) + 0.0138923310023319*std::sin(0.256239980459213*x_42 + 8.18048000335693) - 0.00285244854774309*std::sin(0.259839981794357*x_42 + 8.18391990661621) + 0.0063525730066729*std::sin(0.263039946556091*x_42 + 1.95919990539551) - 0.00282227726637534*std::sin(0.129440054297447*x_44 + 1.7668799161911) - 0.00273416694930737*std::sin(0.256959974765778*x_44 - 1.23063993453979) - 0.00364108083775046*std::sin(0.282799929380417*x_44 - 1.26543986797333) - 0.00323316491772527*std::sin(0.288799941539764*x_44 - 4.44839954376221) - 0.00576158109650626*std::sin(0.215279996395111*x_45 + 8.193039894104) + 0.0025853541143208*std::sin(0.257039964199066*x_45 - 4.43688011169434) - 0.0105847175630773*std::sin(0.199520006775856*x_47 - 1.18703985214233) + 0.00250256544563847*std::sin(0.225519984960556*x_47 + 8.19655990600586) + 0.00270823427467612*std::sin(0.231999978423119*x_47 - 4.4127197265625) - 0.00590926554811918*std::sin(0.230159983038902*x_48 + 1.98047983646393) - 0.0084936295060229*std::sin(0.240479975938797*x_48 - 7.42575979232788) + 0.00207850780151926*std::sin(0.244319975376129*x_48 - 7.42799949645996) + 0.0110820460543826*std::sin(0.256079971790314*x_48 - 1.22367990016937) - 0.00180749937987302*std::sin(0.26639997959137*x_48 - 7.80967998504639) - 0.00202095282843481*std::sin(0.242799982428551*x_49 - 1.21991980075836) - 0.0139162215054716*std::sin(0.260079979896545*x_49 + 1.94671976566315) - 0.00286716477866239*std::sin(0.36959981918335*x_5 + 2.01391983032227) + 0.00419169138908869*std::sin(0.39183983206749*x_5 + 2.01263976097107) - 0.0105643545403968*std::sin(0.220799997448921*x_51 + 1.95815980434418) + 0.00346580958306802*std::sin(0.178240016102791*x_52 - 0.965199828147888) - 0.0321980960035143*std::sin(0.224639996886253*x_52 - 7.41792011260986) - 0.00330544351973625*std::sin(0.22639998793602*x_52 + 8.20399951934814) + 0.00126892570307461*std::sin(0.234079986810684*x_52 + 5.17903995513916) + 0.0182507081801984*std::sin(0.25519996881485*x_52 + 1.95015978813171) + 0.00995495595540934*std::sin(0.216879993677139*x_53 - 4.38775968551636) + 0.000737763996021759*std::sin(0.246479973196983*x_53 - 1.2053599357605) - 0.00285677328934949*std::sin(0.247599974274635*x_53 + 4.9792799949646) - 0.00573282744398291*std::sin(0.267279952764511*x_53 - 1.21335983276367) - 0.00545324233226474*std::sin(0.174000009894371*x_55 + 8.2183198928833) + 0.0213447836211302*std::sin(0.220479995012283*x_56 + 8.19176006317139) + 0.00269094427421266*std::sin(0.239279985427856*x_56 - 1.22927987575531) - 0.000612930811793398*std::sin(0.252159982919693*x_56 + 8.16687965393066) + 0.0041114911087796*std::sin(0.247519969940186*x_58 - 1.23071992397308) - 0.00250040400034465*std::sin(0.238879978656769*x_6 + 5.02663946151733) + 0.00456191483131814*std::sin(0.282239943742752*x_6 - 0.996719837188721) + 0.000755083248021733*std::sin(0.387039840221405*x_6 - 1.1794399023056) - 0.000754244286839392*std::sin(0.45159986615181*x_6 - 4.24871969223022) - 0.00038698593540389*std::sin(0.512639820575714*x_6 + 1.91543984413147) + 0.00750474266950906*std::sin(0.292239934206009*x_60 - 7.46751976013184) + 0.0074965137753826*std::sin(0.301359921693802*x_60 - 7.47583961486816) - 0.00192891608547958*std::sin(0.348239839076996*x_7 - 7.34895992279053) - 0.00391815378763032*std::sin(0.375999838113785*x_7 + 8.22087955474854) + 0.000625786216728278*std::sin(0.789839863777161*x_7 + 1.21335983276367) - 0.00447303485658251*std::sin(0.285839945077896*x_8 + 1.97279977798462) + 0.00303385476578777*std::sin(0.319279909133911*x_8 - 7.41967964172363) + 0.00121536534538919*std::sin(0.327199846506119*x_8 + 8.25103950500488) - 0.0129695925508238*std::sin(0.336479842662811*x_8 - 1.14847981929779) - 0.00409111095567817*std::sin(0.345519840717316*x_8 + 5.03679990768433) + 0.00554340240777049*std::sin(0.388639837503433*x_8 + 1.80719995498657) - 0.00573641626674221*std::sin(0.295839935541153*x_9 - 1.21183979511261) + 0.00230022334222195*std::sin(0.341519832611084*x_9 + 5.04423999786377) + 0.000814516219431174*std::sin(0.327279835939407*x_91 + 4.99647998809814) - 0.0010093821925622*std::sin(0.345599830150604*x_91 + 2.00535988807678) + 0.00396540291694656*std::sin(0.367839843034744*x_91 - 1.18095993995667) - 0.000636240492767845*std::sin(0.382879853248596*x_91 - 1.17583978176117) - 0.00374839621315709*std::sin(0.38663986325264*x_91 - 4.39359998703003) + 0.00981097247755838*std::sin(0.445439845323563*x_91 - 1.38639986515045) - 0.0155760032458637*std::sin(0.291999936103821*x_92 + 1.99447977542877) - 0.00442123785232136*std::sin(0.292239934206009*x_92 - 7.38303995132446) + 0.00123563025651562*std::sin(0.329999834299088*x_92 + 1.7940798997879) - 0.00112233997637926*std::sin(0.230159983038902*x_93 - 7.42727994918823) + 0.000980315675312473*std::sin(0.255759954452515*x_94 + 1.99439978599548) + 0.00295686626873716*std::sin(0.279119968414307*x_94 + 1.99335980415344) - 0.000266017554138121*std::sin(0.295279920101166*x_94 + 1.96527981758118) - 0.00420799120739797*std::sin(0.301119923591614*x_94 - 4.40064001083374) + 0.00379920947778185*std::sin(0.336239844560623*x_94 - 7.57615995407104) + 0.00214944317075803*std::sin(0.268159955739975*x_95 - 1.18831992149353) - 0.00772878533115321*std::sin(0.269679963588715*x_95 - 1.18839991092682) + 0.00904991382840097*std::sin(0.276159942150116*x_95 + 1.96335983276367) - 0.00310632518048256*std::sin(0.284079939126968*x_95 - 1.20591986179352) + 0.00423094608277559*std::sin(0.292079925537109*x_96 - 1.20975983142853) - 0.000570213190226676*std::sin(0.303679943084717*x_96 + 8.17136001586914) + 0.0248690847495885*std::sin(0.274959951639175*x_97 - 1.21607995033264) + 0.00445623613646624*std::sin(0.282879948616028*x_97 - 4.42759990692139) - 0.00402646473772965*std::sin(0.286399960517883*x_97 + 1.94071984291077) + 0.0046197852100114*std::sin(0.265119940042496*x_98 - 1.19839990139008) + 0.00993797214708513*std::sin(0.271519958972931*x_98 - 4.40455961227417) - 0.0159710392861201*std::sin(0.246479973196983*x_99 - 7.43895959854126) - 0.0189869602370452*std::sin(0.252639979124069*x_99 - 1.21063983440399) - 0.00414521690349857*std::sin(0.263999968767166*x_99 - 1.22975981235504) + 0.000618321437396529*std::sin(0.268559962511063*x_99 + 4.97799968719482) + 0.162606397428162);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
