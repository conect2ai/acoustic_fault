
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000318556186995011*x_1 + 0.00262472656316348*x_10 - 0.000319297757947153*x_100 + 0.000887791622076231*x_101 + 0.000453770149146674*x_102 + 0.000638187633881889*x_103 - 0.000105610627211185*x_104 - 5.34487290852421e-5*x_105 - 0.000152991922739056*x_106 - 0.000421457532098344*x_107 + 0.000369810141877221*x_108 - 0.000363489261671884*x_109 - 0.000379514509537721*x_11 + 0.000661602920047707*x_110 + 0.000253456135292112*x_111 - 0.00142107290270411*x_112 - 0.00563191565571794*x_113 - 0.0011781494275357*x_114 - 7.86462133077595e-5*x_115 - 0.00310142384818535*x_116 - 0.00293175932653442*x_117 - 0.0012819146781164*x_118 - 0.000919495477357865*x_119 + 0.00222392007383416*x_12 - 0.00399659853130012*x_120 - 0.000469403260388243*x_13 + 0.00102215449119702*x_14 - 9.73296715892668e-5*x_15 - 0.000758753976347118*x_16 - 0.000736123106134105*x_17 - 0.000633910469167217*x_18 - 0.0012661597380369*x_19 - 0.000508047396302159*x_2 + 0.00135907689948898*x_20 - 0.000196175726929711*x_21 + 0.00077899869882834*x_22 - 0.00240496894880738*x_23 - 0.00105138005763995*x_24 - 0.000549759718339583*x_25 + 7.46507772675423e-5*x_26 + 0.000306514289003789*x_27 + 0.000612098756405028*x_28 - 0.00150065960121208*x_29 + 0.000678657358206045*x_3 - 0.000671268147164062*x_30 - 0.000242041131810518*x_31 + 0.000406630833372919*x_32 + 0.00219957969089577*x_33 + 0.000750914209081368*x_34 + 1.76525580474233e-5*x_35 - 0.00103183089943081*x_36 + 0.000240751714547817*x_37 + 0.00214251140928268*x_38 + 0.00137416880612893*x_39 + 0.00039818764786747*x_4 - 0.000319761486514831*x_40 + 0.00108605474857728*x_41 - 0.000563725956348332*x_42 + 0.00541120175528961*x_43 - 0.000123919541103576*x_44 + 0.000427351790077696*x_45 + 9.62400552834186e-6*x_46 - 0.000563286129364411*x_47 - 0.00108640582467674*x_48 - 0.000745094861279252*x_49 + 0.000406333702895616*x_5 + 0.00328556500782869*x_50 + 0.0027003922231479*x_51 + 0.00232200086861469*x_52 + 0.000152910292124626*x_53 + 0.00517968527184637*x_54 + 0.00159349872099336*x_55 + 0.00114519686648653*x_56 + 0.000343706166576969*x_57 + 0.000609326439581663*x_58 + 0.00215384762413227*x_59 + 3.82938346701015e-5*x_6 - 0.00100268972637879*x_60 - 0.000205312205638496*x_61 - 0.000330073977843064*x_62 + 0.000672175411853605*x_63 + 0.000202144324874103*x_64 - 0.000147625332030421*x_65 - 0.000721689236835637*x_66 + 0.000139299286908198*x_67 + 0.000609207155074344*x_68 + 0.00090537577501527*x_69 + 0.000902293069251318*x_7 + 0.000377483691765082*x_70 + 0.000218026302493554*x_71 - 0.000186658435826671*x_72 - 0.000216363144225733*x_73 + 0.000464917222561406*x_74 + 5.36101673090466e-5*x_75 - 0.000320249135718798*x_76 - 0.000211547593109552*x_77 - 0.000314902085280549*x_78 + 0.000138945951775868*x_79 + 0.000573682693691859*x_8 - 0.000402314287365598*x_80 - 0.000748973656974315*x_81 - 0.000423452140095609*x_82 - 0.000494732662660025*x_83 + 0.000269407864679703*x_84 + 3.84367131190337e-5*x_85 + 0.000160109552107503*x_86 - 4.19090446530098e-6*x_87 - 0.000591602965225808*x_88 + 0.000214507228653985*x_89 + 0.000865531394223803*x_9 + 0.000424219651954246*x_90 - 9.57193479498674e-5*x_91 + 0.000169288100436268*x_92 - 0.000731343268092061*x_93 + 0.000355955269259512*x_94 + 9.50574313769959e-5*x_95 + 0.000505159854350756*x_96 + 0.00021690332216759*x_97 + 0.00052431931376518*x_98 + 0.000181756602723778*x_99 - 1.39085386038626e-6*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) - 0.00256336956252485*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.0319876030569092*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.00387307880362588*std::sin(0.362479835748672*x_1 - 4.21680021286011) + 0.0176847552326024*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.0303850000843348*std::sin(0.373199850320816*x_1 - 4.20703983306885) + 0.000597030902422677*std::sin(0.387519836425781*x_1 + 8.3884801864624) - 0.000584595797013316*std::sin(0.224879994988441*x_101 + 1.97831988334656) + 0.00048688166569594*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.0163437261261051*std::sin(0.278799951076508*x_11 + 5.15200042724609) + 0.0225343111512475*std::sin(0.307279914617538*x_11 - 7.46184015274048) + 0.00124754087687985*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.000826536329905939*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.00231723904113262*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00980111586652947*std::sin(0.260159969329834*x_113 + 5.17639970779419) - 0.000312487734785833*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.00269092122135052*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.00205691869138709*std::sin(0.284079939126968*x_113 + 5.1561598777771) + 0.000741886597201603*std::sin(0.260399967432022*x_116 - 7.44079971313477) - 0.00860030886328883*std::sin(0.213119998574257*x_118 + 5.19831991195679) - 0.000867576750608529*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 0.00862033850650409*std::sin(0.284399926662445*x_12 - 7.44591999053955) - 0.000562112504365203*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.00137460014894011*std::sin(0.299919933080673*x_12 - 7.45160007476807) + 0.000152797445203101*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.00315275017524838*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.0159516991022753*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.021314398202652*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.00199804018908529*std::sin(0.376319825649261*x_13 - 4.56640005111694) + 0.0010734190882479*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.00399888375003144*std::sin(0.304639935493469*x_15 + 5.14416027069092) + 0.00185554291096971*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.0029283236604695*std::sin(0.314319908618927*x_15 - 7.44855976104736) + 0.00153228168537782*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.00311397802992356*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.00140001740820251*std::sin(0.352239847183228*x_16 + 8.24815940856934) + 0.0174546127344409*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.00138232058377375*std::sin(0.357919842004776*x_17 + 1.99319982528687) - 0.00292838880068684*std::sin(0.359039843082428*x_17 + 1.99607980251312) + 0.00165395574635441*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.0211457048891395*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.00373681304719549*std::sin(0.326719850301743*x_18 - 1.16375982761383) + 0.0260110006259881*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.00436636202625309*std::sin(0.345119833946228*x_2 + 5.16480016708374) - 0.00329111134631011*std::sin(0.368799835443497*x_2 + 5.17743968963623) + 0.00137944774032434*std::sin(0.378879845142365*x_2 - 7.41175985336304) + 0.00330431308775776*std::sin(0.311599940061569*x_21 + 1.98407983779907) - 0.033698284966857*std::sin(0.326479852199554*x_21 - 1.15463984012604) + 0.000816382360774961*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.00369517668313762*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.00860501981293848*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.00127410656035783*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.0181307337446612*std::sin(0.291679948568344*x_23 - 1.16535985469818) - 0.00100255558827094*std::sin(0.306639939546585*x_23 - 1.1671998500824) + 0.00057504028563792*std::sin(0.308479934930801*x_23 - 4.34592008590698) + 0.000990768841375317*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.0103772381948683*std::sin(0.283759921789169*x_24 - 1.16415989398956) + 0.000567169450336753*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.000987716161102734*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.00900622594915425*std::sin(0.292479932308197*x_25 - 7.39152002334595) - 0.0190041491425054*std::sin(0.299039930105209*x_25 - 7.3854398727417) - 0.00115649288846083*std::sin(0.33231982588768*x_25 - 1.16279983520508) - 0.000801087611248573*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.00371756845444015*std::sin(0.268079966306686*x_26 + 1.99735975265503) + 0.0189242108999683*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.00165413707792345*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 0.000324910695664369*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.00222178967919447*std::sin(0.256639957427979*x_28 - 1.167839884758) - 0.000165771825452594*std::sin(0.352239847183228*x_28 + 1.79639983177185) - 0.00115309719498521*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.00285131185329166*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.00338888231417601*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.000490746662682441*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.00222744582382871*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.0128042953468425*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.0012969461507165*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.00427170961199921*std::sin(0.363599836826324*x_3 + 2.00703978538513) - 0.000208129601907886*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.00619828102404824*std::sin(0.39711982011795*x_3 + 1.98215973377228) + 0.000678312846150025*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.0178700008073224*std::sin(0.288559943437576*x_30 - 1.17079985141754) - 0.0799727382700495*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.0172729103068697*std::sin(0.344319850206375*x_30 - 1.14927983283997) + 0.00097838038687053*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.000778559513039735*std::sin(0.350719839334488*x_31 + 5.17671966552734) - 0.00244627029034592*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.00740664595305315*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0387513827958859*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 0.000166857254696951*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 0.000180832058092251*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00297717294990599*std::sin(0.441199868917465*x_31 + 8.22439956665039) + 0.0259027583856924*std::sin(0.296959936618805*x_32 - 1.13887989521027) - 0.00120801291485555*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.0130160178744965*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.00409021949572332*std::sin(0.307359933853149*x_32 - 1.14471983909607) + 0.00058890835726955*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.00216345889542252*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.00704866147402336*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.00235232798421002*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.00238977207257334*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.0018008866296876*std::sin(0.349999845027924*x_5 + 2.03919982910156) + 0.00169670608591012*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.00225291816774616*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.00262822282698216*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.00110621603404821*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.00222366977952208*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.00932886832423124*std::sin(0.283759921789169*x_6 - 1.15247988700867) - 0.00106184257249123*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.00260174419425403*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.00223206460966649*std::sin(0.381839841604233*x_6 + 2.00863981246948) - 0.0026323304753934*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.002886910353295*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.00522064001539711*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.00786054389226368*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.00775871670818917*std::sin(0.343439847230911*x_7 + 2.00559997558594) - 0.00145007415440051*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.00196508285235545*std::sin(0.365919858217239*x_7 + 2.01863980293274) + 0.00331504991847677*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.00378635397043012*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.000653031111297385*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.011693277048042*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.00256100066300429*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00546374066767832*std::sin(0.380799859762192*x_91 + 2.00823974609375) - 0.000335370298090662*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.000842680689795672*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.0138528362235193*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.000418446383252116*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.000962551420304885*std::sin(0.271759957075119*x_94 - 7.41368007659912) - 0.174930474072507);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00036709590013818*x_1 + 0.00107646581776255*x_10 - 0.000374722206234832*x_100 + 0.00426582561972673*x_101 - 0.00275315648201806*x_102 - 0.00169490799752834*x_103 - 0.00166779958602668*x_104 - 0.00307696789509528*x_105 - 0.0041492740370012*x_106 - 0.00108382078256339*x_107 + 0.00257934977006242*x_108 + 0.00579411809745227*x_109 + 0.00336072207830518*x_11 - 0.0021732782380794*x_110 + 0.000467257970320068*x_111 + 0.000546782706767036*x_112 + 0.00261107380422248*x_113 - 0.00183709507707356*x_114 + 0.00445263558094143*x_115 + 0.00532981792545207*x_116 - 4.01706062762544e-5*x_117 + 0.00231028208928251*x_118 + 0.00371621580276124*x_119 + 0.00240199142110818*x_12 - 0.00222620269212329*x_120 + 0.00404670377090494*x_13 + 0.00357324364674156*x_14 + 0.00494120863578811*x_15 - 9.41736906134847e-5*x_16 - 0.000850926390152072*x_17 + 0.00181399006204313*x_18 + 0.00342436955885762*x_19 - 0.00213376500008619*x_2 + 0.000403321454510447*x_20 - 0.00104055101643393*x_21 - 0.00116790714716474*x_22 + 0.00148620730245938*x_23 + 0.00221357859627888*x_24 + 0.00256691527948178*x_25 + 0.00341851875509883*x_26 - 0.00110805875141228*x_27 + 0.000287093065270834*x_28 - 0.00169264326041386*x_29 - 0.000982015977141788*x_3 - 0.00658574073134952*x_30 + 0.000776565017496547*x_31 + 0.000429230726785751*x_32 + 0.00288066236268736*x_33 + 0.00580419722188137*x_34 + 0.000360225560496584*x_35 - 0.0053080846235759*x_36 - 0.000973810156966262*x_37 + 0.000106386329420428*x_38 - 0.00293525939481624*x_39 + 0.000670652322210168*x_4 - 0.000722755007395057*x_40 - 0.00121097434752862*x_41 - 0.00130944889974053*x_42 - 7.88246250240169e-5*x_43 + 3.68232289836707e-5*x_44 - 0.00161613210378716*x_45 + 0.000537743607507656*x_46 - 0.00197206128645341*x_47 + 0.0025130867096018*x_48 + 0.000534126249011577*x_49 + 0.000786887237084755*x_5 - 0.00534835153865543*x_50 + 0.00039989765716515*x_51 - 0.00241676265880372*x_52 + 0.000151340711921359*x_53 - 0.000877403968413052*x_54 + 0.00664739294605965*x_55 - 0.0029303554182133*x_56 + 0.000853361779188906*x_57 + 0.00257107418042571*x_58 + 0.00443601792263878*x_59 + 0.00231927502677472*x_6 + 0.00116711735500721*x_60 - 0.00305646534334456*x_61 - 0.00091065075876939*x_62 + 0.00134393345687617*x_63 + 0.0025786949191461*x_64 - 0.000455584048964142*x_65 - 0.00183407703091864*x_66 + 0.00288120484775025*x_67 - 4.78211088851207e-5*x_68 - 0.000996616292582207*x_69 - 0.00160035838652752*x_7 - 0.00438002698561933*x_70 + 0.000633376209890138*x_71 - 0.000964546404201422*x_72 - 0.000472902376643087*x_73 + 0.000114023401446167*x_74 - 0.00164009851118225*x_75 - 0.00134172612601147*x_76 - 0.0014159844551607*x_77 + 0.000228494156869124*x_78 - 0.000394589112269795*x_79 + 0.00124603246106385*x_8 - 0.00167814539854934*x_80 - 0.00363703731827389*x_81 - 0.000140814969955606*x_82 - 0.00014997407339144*x_83 + 0.00231754184631534*x_84 + 0.00278986470285101*x_85 + 0.000889123934989939*x_86 + 0.000209090721451468*x_87 + 0.00233766588071777*x_88 + 0.00198146547633917*x_89 + 0.00250937298862286*x_9 + 0.00212078561941741*x_90 - 0.00220082651150579*x_91 + 0.00391941005138122*x_92 + 0.0011964145738665*x_93 + 0.00340411359504067*x_94 + 0.00171563133336566*x_95 - 0.000149377108005028*x_96 + 0.00264436809258959*x_97 - 0.00182058425456769*x_98 - 0.000663143081179697*x_99 - 1.49863573662817e-6*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) - 0.452076970454661*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.0274659167766671*std::sin(0.339599847793579*x_1 - 4.24663972854614) - 0.0278238557865456*std::sin(0.362479835748672*x_1 - 4.21680021286011) - 0.00967435533704515*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.123501169992398*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.00154429060062113*std::sin(0.387519836425781*x_1 + 8.3884801864624) + 0.000537375181717696*std::sin(0.224879994988441*x_101 + 1.97831988334656) + 0.0858666622306848*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.0664297940762538*std::sin(0.278799951076508*x_11 + 5.15200042724609) - 0.0123272802187733*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.00322691110667543*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.0162656348067353*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.0456015817323626*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00437785735689175*std::sin(0.260159969329834*x_113 + 5.17639970779419) - 0.0551104727587829*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.0091829344945304*std::sin(0.283439934253693*x_113 - 7.42184019088745) + 0.0071988415276664*std::sin(0.284079939126968*x_113 + 5.1561598777771) + 0.130839442812712*std::sin(0.260399967432022*x_116 - 7.44079971313477) + 0.00470475518928353*std::sin(0.213119998574257*x_118 + 5.19831991195679) + 0.000797498402133888*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 0.035037745214049*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.0014539700599421*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.0270511328043961*std::sin(0.299919933080673*x_12 - 7.45160007476807) + 0.0269474238636866*std::sin(0.207120001316071*x_120 - 0.981359839439392) + 0.0226490785896209*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.013696807454127*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.00952048687617867*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.0081211222760893*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.00277652463512678*std::sin(0.27975994348526*x_15 + 5.17375993728638) + 0.0139953662361947*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.00633215453058614*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.000774625228485258*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.00396342667461728*std::sin(0.343999862670898*x_16 - 1.16511988639832) + 0.0108983570677446*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.000370344582927124*std::sin(0.352239847183228*x_16 + 8.24815940856934) - 0.00954845705481931*std::sin(0.342879861593246*x_17 + 2.01807975769043) + 0.00993046889148952*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.00757462181859263*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.00564422590862844*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.00944513675547038*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.0151884410758792*std::sin(0.326719850301743*x_18 - 1.16375982761383) - 0.0142291855000632*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.0115358561669681*std::sin(0.345119833946228*x_2 + 5.16480016708374) - 0.00354615047438056*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.00356810371253241*std::sin(0.378879845142365*x_2 - 7.41175985336304) - 0.00303740782102397*std::sin(0.311599940061569*x_21 + 1.98407983779907) + 0.018434475271525*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.00211166892893109*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.00976259560519986*std::sin(0.277439951896667*x_22 + 8.23896026611328) - 0.0010937954963445*std::sin(0.357919842004776*x_22 + 1.98535978794098) + 0.00445914136313813*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.0736931651825383*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.00259322786355688*std::sin(0.306639939546585*x_23 - 1.1671998500824) + 0.000619602063597485*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.00338105972682661*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00463519350187102*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.00193550070080732*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.00260952974118107*std::sin(0.269519954919815*x_25 - 7.3997597694397) + 0.00114479334114187*std::sin(0.292479932308197*x_25 - 7.39152002334595) + 0.0103961230599257*std::sin(0.299039930105209*x_25 - 7.3854398727417) - 0.00124611335609509*std::sin(0.33231982588768*x_25 - 1.16279983520508) + 0.000736379910471186*std::sin(0.375679850578308*x_25 - 1.19015979766846) - 0.000472545063371615*std::sin(0.268079966306686*x_26 + 1.99735975265503) - 0.0103523932512203*std::sin(0.279839962720871*x_26 + 2.01703977584839) - 0.00152052446729248*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 0.000350089102531675*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.00586993153988098*std::sin(0.256639957427979*x_28 - 1.167839884758) + 0.000565706569962647*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.0029826214230994*std::sin(0.175040021538734*x_29 - 1.19559991359711) + 0.000362434036365002*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.00895337095459855*std::sin(0.344559848308563*x_29 - 1.16015994548798) - 0.00352548064795939*std::sin(0.321119844913483*x_3 + 5.1866397857666) + 0.00028313359683285*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.00571928536988495*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.000343079292051606*std::sin(0.352559864521027*x_3 - 7.38783979415894) + 0.00392666307339363*std::sin(0.363599836826324*x_3 + 2.00703978538513) - 0.0367058270754277*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.025193185989369*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.00231478438817618*std::sin(0.411679863929749*x_3 - 1.17503976821899) + 0.00227147953492591*std::sin(0.288559943437576*x_30 - 1.17079985141754) + 0.0437486794204908*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.0702065040694856*std::sin(0.344319850206375*x_30 - 1.14927983283997) - 0.000899351895565552*std::sin(0.353439837694168*x_30 + 2.03903985023499) - 0.000715671515148164*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.00632756562621845*std::sin(0.359519839286804*x_31 + 5.17639970779419) + 0.000941468603510543*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0332735858000674*std::sin(0.379279851913452*x_31 + 5.17120027542114) + 0.000583970061303105*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 0.00355864359720719*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00132981169480861*std::sin(0.441199868917465*x_31 + 8.22439956665039) - 0.0141699721334475*std::sin(0.296959936618805*x_32 - 1.13887989521027) - 0.00130162584012106*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.0111761066644634*std::sin(0.304719924926758*x_32 - 1.13631987571716) - 0.00375983278704536*std::sin(0.307359933853149*x_32 - 1.14471983909607) + 0.103860133912029*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.0425753001278605*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.00605228060033115*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.00201980887817044*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.0470289791233212*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.000476385939105564*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.00579011407683054*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.00915708503674577*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.000695239988442673*std::sin(0.210720002651215*x_6 + 2.01455974578857) - 0.00794695821094758*std::sin(0.225599989295006*x_6 - 1.17279982566833) + 0.00778244002530085*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.0379175958384009*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.00362360321414272*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.00687376507667054*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.0439254107680965*std::sin(0.381839841604233*x_6 + 2.00863981246948) + 0.00144000298836713*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.00247882404205876*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.0137928444675532*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.0319495265682643*std::sin(0.333679854869843*x_7 + 2.04503989219666) - 0.0271540981538002*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.00375078723355421*std::sin(0.3504798412323*x_7 + 2.00343990325928) + 0.0141169815190347*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.00857476624563253*std::sin(0.325679838657379*x_8 - 1.13759982585907) - 0.0132515506397561*std::sin(0.326079845428467*x_8 + 8.27583980560303) + 0.00060028264639191*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.00522302762747265*std::sin(0.352719843387604*x_91 + 1.98895990848541) - 0.0183980023979811*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00469140017152146*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.000867474693466123*std::sin(0.381119847297668*x_91 + 2.00167965888977) - 0.0060537435915405*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.0563054624508544*std::sin(0.301919937133789*x_92 + 1.9864798784256) + 0.00300608183110263*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.0189423130223028*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.881951082948584);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00112983612700816*x_1 + 0.00185541052140694*x_10 + 0.000372981764312383*x_100 + 0.000982838823268694*x_101 + 0.000931388039740516*x_102 - 0.00149287723421626*x_103 + 3.72843332326528e-5*x_104 + 8.53341233312854e-5*x_105 - 0.000729033406227858*x_106 - 0.00167895856104356*x_107 - 0.000563863653678723*x_108 - 0.00132908293584902*x_109 + 0.000409260306576503*x_11 + 0.000542450484679239*x_110 - 0.000591584951835629*x_111 - 0.00523349366168646*x_112 - 0.00164463887172868*x_113 - 0.00344109770104341*x_114 + 0.000331994142970553*x_115 - 0.0114554902858851*x_116 - 0.00771114406857942*x_117 - 0.00672701795373287*x_118 - 0.0011997607808644*x_119 + 0.000523311214381809*x_12 - 0.0067277357199666*x_120 + 0.00110893477692853*x_13 + 0.0018810581422871*x_14 + 0.000521563690048697*x_15 + 0.000350157320732673*x_16 - 0.00106261310230947*x_17 - 0.000400742771688586*x_18 + 0.000158709203536331*x_19 - 1.6675293046869e-5*x_2 + 0.000336535650813007*x_20 + 0.00027641739040369*x_21 + 0.00201504248918336*x_22 + 0.00473609112455055*x_23 - 0.000672758539409901*x_24 + 6.14791600301546e-5*x_25 + 0.000609682859200406*x_26 + 0.0021779767821206*x_27 - 4.08326040517779e-5*x_28 - 0.000332800393747905*x_29 - 0.000200498693315888*x_3 + 0.00147189807268378*x_30 + 0.000239063307090525*x_31 - 0.000905702130302041*x_32 + 0.00037394876118076*x_33 + 0.000636355689618285*x_34 + 0.00112655275495253*x_35 + 0.000176263957701741*x_36 + 0.000574278419361371*x_37 + 0.00228156054932826*x_38 + 0.00136782402507755*x_39 - 0.000339606407518425*x_4 + 0.000616496948768642*x_40 + 0.00210847876400024*x_41 + 0.00154080955110639*x_42 + 0.000338658746628623*x_43 + 0.000457986071832011*x_44 + 0.000563484180744602*x_45 + 0.000528630649627562*x_46 + 0.00128816500636716*x_47 + 0.00720919283526327*x_48 + 0.00285242656148859*x_49 - 8.27277662012018e-5*x_5 + 0.00333069982778521*x_50 + 0.00115787705239883*x_51 + 0.0025225102925267*x_52 + 0.000424513979141662*x_53 + 0.000807108117636038*x_54 + 0.00194053770297534*x_55 + 0.00110341069217523*x_56 + 0.00076246251686309*x_57 + 0.000827802592777573*x_58 + 0.00169382735267768*x_59 + 0.000171615229050217*x_6 - 0.00048786050673735*x_60 - 0.000112504148924346*x_61 + 0.00042935884252639*x_62 + 0.000884446503642347*x_63 - 0.000663684682694065*x_64 - 0.000512234887201739*x_65 + 0.000127892400423154*x_66 - 0.00062480842466548*x_67 - 0.000194591478374097*x_68 - 0.000129724904836964*x_69 + 0.000418462745724118*x_7 - 0.000127354276580914*x_70 - 0.000216448338467073*x_71 - 0.000752413005231607*x_72 - 0.000743515144654264*x_73 - 0.000412781646024226*x_74 - 0.000195119089069637*x_75 - 0.000462542536078044*x_76 + 8.88620265109344e-7*x_77 - 0.00025980531241551*x_78 - 2.65805644291494e-6*x_79 + 2.02283552981266e-5*x_8 - 0.000395131832536756*x_80 - 0.000539602500477061*x_81 - 0.000623951946602769*x_82 - 0.000836210069206946*x_83 - 8.94567651618542e-5*x_84 - 0.000329376779431998*x_85 + 0.000674176205975416*x_86 - 1.18124041582296e-5*x_87 - 0.000839579802008218*x_88 - 7.3138805356055e-5*x_89 - 0.000394414982242141*x_9 - 7.45765142082689e-5*x_90 + 0.000142328096035485*x_91 + 0.00134588580160071*x_92 - 0.000937549518629402*x_93 - 0.000254310832059592*x_94 + 0.000775292715618743*x_95 + 0.00112753868575783*x_96 + 0.000311859943061952*x_97 + 0.00083992583242292*x_98 + 0.000621424843395597*x_99 - 4.49071711413106e-6*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.00436039230772079*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.0737357073562309*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.0219424365531062*std::sin(0.362479835748672*x_1 - 4.21680021286011) + 0.00270183397886545*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.0300120030494413*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.00234068140829613*std::sin(0.387519836425781*x_1 + 8.3884801864624) - 0.0013887630336438*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.000828204836675899*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.0161430955068118*std::sin(0.278799951076508*x_11 + 5.15200042724609) + 0.00344273736096307*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.00489102946723985*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.000966680278109905*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.00271014013501879*std::sin(0.277519941329956*x_112 + 1.97351980209351) - 0.0111826592060714*std::sin(0.260159969329834*x_113 + 5.17639970779419) + 0.000531553910500189*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.0445363219635829*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.00436783083538327*std::sin(0.284079939126968*x_113 + 5.1561598777771) - 0.00126197824103549*std::sin(0.260399967432022*x_116 - 7.44079971313477) - 0.0013139343129123*std::sin(0.213119998574257*x_118 + 5.19831991195679) - 0.00206101125983034*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 0.00851451784848931*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.00220378255631217*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.00160767144309138*std::sin(0.299919933080673*x_12 - 7.45160007476807) - 0.000259914455739556*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.0178615061029531*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.0367708019493498*std::sin(0.270399957895279*x_120 + 5.14656019210815) - 0.0243188280322981*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.00197351285441166*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.00420837865004392*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.008491559643868*std::sin(0.304639935493469*x_15 + 5.14416027069092) + 0.0307103217457685*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.000896143052039147*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.00600736618269274*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.0066124778372421*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.00042844166784944*std::sin(0.352239847183228*x_16 + 8.24815940856934) + 0.00266667336661297*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.00783136188117644*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.0114808550013339*std::sin(0.359039843082428*x_17 + 1.99607980251312) + 0.0273739361259297*std::sin(0.289999932050705*x_18 - 1.16223990917206) + 0.0241263560871603*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.00369094106487901*std::sin(0.326719850301743*x_18 - 1.16375982761383) + 0.00397389754007038*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.0155751105485006*std::sin(0.345119833946228*x_2 + 5.16480016708374) - 0.0106261703463808*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.00540817513195888*std::sin(0.378879845142365*x_2 - 7.41175985336304) + 0.0078497106741239*std::sin(0.311599940061569*x_21 + 1.98407983779907) - 0.005148342182599*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.0032006567937651*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.0131809467446972*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.00311960975248854*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.00270554297804655*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.0179081663624519*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.00393055571617267*std::sin(0.306639939546585*x_23 - 1.1671998500824) + 0.00185666037646246*std::sin(0.308479934930801*x_23 - 4.34592008590698) + 0.0163978044993943*std::sin(0.321359902620316*x_23 - 1.14807987213135) + 0.0118399904473868*std::sin(0.283759921789169*x_24 - 1.16415989398956) + 0.00938698652628285*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.00352325077655482*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.00326506050129623*std::sin(0.292479932308197*x_25 - 7.39152002334595) - 0.00290340777790297*std::sin(0.299039930105209*x_25 - 7.3854398727417) - 0.00373402451148938*std::sin(0.33231982588768*x_25 - 1.16279983520508) - 0.00190305997219938*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.00134774388184179*std::sin(0.268079966306686*x_26 + 1.99735975265503) + 0.00289119500723938*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.00392956028444957*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 0.00104905487423316*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.00792527501405255*std::sin(0.256639957427979*x_28 - 1.167839884758) - 0.00274362078394189*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.00452075957091661*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.00103369666291068*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.0120883738823745*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.00278026295242874*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.000807524197063181*std::sin(0.326239854097366*x_3 - 7.39215993881226) + 0.0146091601392656*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.000396899187587468*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.0101478533200441*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.000354036627584143*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.00612219280825132*std::sin(0.39711982011795*x_3 + 1.98215973377228) + 0.0112264748103663*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.00647847768016516*std::sin(0.288559943437576*x_30 - 1.17079985141754) - 0.0122180408379414*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.0170608733047121*std::sin(0.344319850206375*x_30 - 1.14927983283997) + 0.00232423585846781*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.00184954232775074*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.0095906918135137*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.00268515883178241*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0893271251491768*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 0.000354318459560145*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 0.000211493164768325*std::sin(0.432479858398438*x_31 + 2.00671982765198) + 0.00339682858051161*std::sin(0.441199868917465*x_31 + 8.22439956665039) + 0.00395736055333051*std::sin(0.296959936618805*x_32 - 1.13887989521027) - 0.00390036971197434*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.0300036637077765*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.00971670625100365*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.00100175624636088*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.00253028568864528*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.016248108330501*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.00542243091928445*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.00279497155557261*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.000551118055183145*std::sin(0.349999845027924*x_5 + 2.03919982910156) + 0.0280814792793298*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.00222526202839798*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.000804304407127291*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.00626712658632397*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.0047219238521075*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.00921434996931298*std::sin(0.283759921789169*x_6 - 1.15247988700867) - 0.0175741163687335*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.0092805986312591*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.00261052389297543*std::sin(0.381839841604233*x_6 + 2.00863981246948) - 0.000402161060669335*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.00665471484673355*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.0186223782830743*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.00776405024222826*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.0164754991157084*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.00568506856191682*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.0111329275740633*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.0129967740032638*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.008040256377158*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.00155133764529697*std::sin(0.380799859762192*x_9 - 1.16319990158081) + 0.0133415351895776*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.0145090243213814*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.0125946536921042*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.0013148314743008*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.00477410053032203*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.0136827830123331*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.00237065489263751*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.0011257575027359*std::sin(0.271759957075119*x_94 - 7.41368007659912) - 0.119553842488829);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000588478242523198*x_1 + 0.00290062119937825*x_10 - 6.5513529384148e-5*x_100 + 0.0014152542221311*x_101 + 0.000975536261373827*x_102 - 0.00138618517698438*x_103 - 7.26721356289414e-5*x_104 + 0.000760109816232488*x_105 + 0.000315408581615022*x_106 - 0.00108750494909781*x_107 + 0.00156812708865814*x_108 - 0.00119135261696554*x_109 - 0.0012696995327865*x_11 + 0.00132163023202555*x_110 - 0.000822352061047275*x_111 - 0.000781819066090401*x_112 - 0.00837448793656943*x_113 + 0.000605022140245097*x_114 - 0.00091387143228675*x_115 - 0.000390414055160315*x_116 + 0.000947221691055663*x_117 + 0.000543844586425797*x_118 - 0.000982164039075041*x_119 + 0.000815618990645483*x_12 - 0.0059539026100044*x_120 - 0.00114984928482146*x_13 + 0.000902199346398708*x_14 - 0.000671922518487616*x_15 + 0.000896861362371941*x_16 - 0.00127339853533646*x_17 - 0.00185663977840965*x_18 - 0.00309055242891555*x_19 + 0.0010803586714851*x_2 + 0.000750232484801802*x_20 + 0.000433946853517467*x_21 - 0.00145077189478246*x_22 - 0.0041602412160167*x_23 - 0.00354657314266289*x_24 - 0.000949578242349296*x_25 - 0.0001561009889029*x_26 + 0.000149353574665172*x_27 + 0.00109616464847956*x_28 + 0.000681912735049731*x_29 + 0.000747287883307017*x_3 + 0.00250222031011327*x_30 - 0.000197041375297336*x_31 - 5.37556296098272e-5*x_32 + 0.000911140417900974*x_33 - 0.00209753001387272*x_34 + 0.000231417470333918*x_35 - 0.000516384938180972*x_36 + 5.23955531411248e-5*x_37 - 0.00117420553200312*x_38 + 0.00207964178147696*x_39 - 0.000219157103729588*x_4 - 0.000446713430193993*x_40 + 0.00171282311515772*x_41 - 0.000427308911249985*x_42 + 0.000431351491687927*x_43 + 0.000364549828096534*x_44 + 0.000553664489849964*x_45 - 0.000570060204618312*x_46 - 0.00047249484129501*x_47 - 0.00251380230520561*x_48 - 0.00147817211206126*x_49 - 8.35727017815159e-5*x_5 + 0.00587691134338876*x_50 + 0.00220774697786481*x_51 + 0.0022249290115048*x_52 + 0.000926952381484635*x_53 + 0.00551705972707316*x_54 + 0.00039670362127112*x_55 + 0.00138989340855217*x_56 - 0.000261802763895854*x_57 + 0.000710966106556002*x_58 + 0.0017783379755247*x_59 - 0.00027923006805103*x_6 - 0.00369812634417409*x_60 + 0.000356171598937896*x_61 + 0.000425319535447048*x_62 + 0.000489339178344289*x_63 - 0.00057197207848304*x_64 - 0.000226945187144427*x_65 - 0.000158095834187158*x_66 + 6.2075043777775e-5*x_67 + 0.000967738626610658*x_68 + 0.00107463292981263*x_69 + 0.00133216185176831*x_7 + 0.00113389102359854*x_70 + 0.000448537063550397*x_71 - 0.000546719002937639*x_72 - 0.000650237076970037*x_73 + 0.000331345420583404*x_74 + 0.000318680317614089*x_75 - 0.000866524264629726*x_76 - 0.000970612208853145*x_77 - 0.000801774739131374*x_78 + 0.000279972488738076*x_79 + 0.000105362785629423*x_8 + 0.000240746625297555*x_80 + 0.000902460877290361*x_81 - 0.000354688452403237*x_82 - 0.000631738702156617*x_83 + 0.000388160953046033*x_84 - 0.000280519993751643*x_85 - 0.000347785421173784*x_86 + 7.49381548806927e-5*x_87 - 0.00162296618369347*x_88 - 0.000482541619913293*x_89 + 9.3539907753115e-5*x_9 + 0.000255952347213874*x_90 + 0.000612772092199638*x_91 - 0.00180273485149148*x_92 - 0.00104043139341149*x_93 - 0.00238353397301706*x_94 + 0.000299410326612417*x_95 - 0.000741657272683178*x_96 - 0.00170518062100544*x_97 - 0.00117901645728919*x_98 - 0.000334276111076959*x_99 - 9.66583287117086e-7*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.129183143787108*std::sin(0.333279848098755*x_1 - 4.25399971008301) + 0.0188592593257486*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.10581247513833*std::sin(0.362479835748672*x_1 - 4.21680021286011) + 0.0152159373223753*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.0975004425324514*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.000470463372639369*std::sin(0.387519836425781*x_1 + 8.3884801864624) - 0.00364117254491493*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.024536807000608*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.0524443154682099*std::sin(0.278799951076508*x_11 + 5.15200042724609) + 0.0193884880831245*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.000983068524695644*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.000153288204895196*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.000429751724245088*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00306463111091154*std::sin(0.260159969329834*x_113 + 5.17639970779419) + 0.0157480796232848*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00712379185336665*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.000543168670037738*std::sin(0.284079939126968*x_113 + 5.1561598777771) - 0.0373879928829395*std::sin(0.260399967432022*x_116 - 7.44079971313477) - 0.00739969306307525*std::sin(0.213119998574257*x_118 + 5.19831991195679) - 0.00540372794512296*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 0.0276612412977086*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.000442947498250588*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.000254931309920372*std::sin(0.299919933080673*x_12 - 7.45160007476807) - 0.0077003544953279*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.086133104036904*std::sin(0.269119948148727*x_120 + 5.15200042724609) + 0.00940480690350263*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.0066646256132195*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.00641138068430924*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.000845859674035866*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.00105598163759957*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.00491225880856673*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.00118752019821315*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.00120744572284472*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.000822305379460431*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.000567747675072209*std::sin(0.352239847183228*x_16 + 8.24815940856934) + 0.0150179230563489*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.0377649848660013*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.00230758519530556*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.00437858840988111*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.00661187827466813*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.0119908153612426*std::sin(0.326719850301743*x_18 - 1.16375982761383) + 0.0223798265801081*std::sin(0.365919858217239*x_18 + 1.99887979030609) + 0.00448851316657287*std::sin(0.345119833946228*x_2 + 5.16480016708374) - 0.00228718006541774*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.00108701180066102*std::sin(0.378879845142365*x_2 - 7.41175985336304) + 0.0205810136788797*std::sin(0.311599940061569*x_21 + 1.98407983779907) - 0.0289939546905329*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.000643313431942865*std::sin(0.249279975891113*x_22 - 4.37048006057739) - 0.00379855108104929*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.0173758574636689*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.000336452174202972*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.0581785275180532*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.000790018877418963*std::sin(0.306639939546585*x_23 - 1.1671998500824) + 0.000399628131572563*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.00262290510207382*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00324477411045994*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.00150149215730649*std::sin(0.329999834299088*x_24 - 1.14263987541199) + 0.00101534800992002*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.0181860009366627*std::sin(0.292479932308197*x_25 - 7.39152002334595) - 0.0163511418967421*std::sin(0.299039930105209*x_25 - 7.3854398727417) - 0.000803712546295527*std::sin(0.33231982588768*x_25 - 1.16279983520508) - 0.00498959833623872*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.00750677406676713*std::sin(0.268079966306686*x_26 + 1.99735975265503) + 0.0162823631507483*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.0103028426554416*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 0.000225798883103037*std::sin(0.252399981021881*x_27 - 1.16151988506317) + 0.00228394534591027*std::sin(0.256639957427979*x_28 - 1.167839884758) + 0.000438854906010302*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.000908646425390011*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.00575756818976422*std::sin(0.343199849128723*x_29 - 1.14407992362976) + 0.00348368797541004*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.0134071940379037*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.00449781429726604*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.004003670848055*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.000525949289950996*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.0266064720932409*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.0104888646111321*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.0198892592103947*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.00179572686450194*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.0360843546736296*std::sin(0.288559943437576*x_30 - 1.17079985141754) - 0.0688084260715398*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.0554259139071518*std::sin(0.344319850206375*x_30 - 1.14927983283997) + 0.00609387173386585*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.00484928139741321*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.00192767336918994*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.0149560172041212*std::sin(0.368639826774597*x_31 + 5.17511987686157) + 0.0228470503425579*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 4.4061845273414e-5*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 3.353684595524e-5*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.000930907966918764*std::sin(0.441199868917465*x_31 + 8.22439956665039) + 0.0222866951161828*std::sin(0.296959936618805*x_32 - 1.13887989521027) - 0.000839516736716461*std::sin(0.301519930362701*x_32 - 1.13487982749939) - 0.00767398720207291*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.0254760554328178*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.0296785270866867*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.000401231885937308*std::sin(0.227999985218048*x_34 + 1.99599981307983) + 0.00415575166421565*std::sin(0.347839832305908*x_4 + 1.99647974967957) + 0.00138688614443869*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.000443203592944459*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.000730311774041789*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.00449176322831847*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.00722924198568285*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.00106582060397851*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.0302218112605319*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.000587202480002559*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.0299347963605388*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.00281106165704639*std::sin(0.321599900722504*x_6 - 1.17895984649658) - 0.00267452927671803*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.000413955400199782*std::sin(0.381839841604233*x_6 + 2.00863981246948) - 0.00226485325912369*std::sin(0.812399864196777*x_6 + 1.78415989875793) + 0.00170206535657316*std::sin(0.231199979782104*x_61 - 1.15639984607697) + 0.00536669000558242*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.025223185977103*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.00204883734745235*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.00114266577238822*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.0536860443595832*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.00261227611298803*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.000999859089725974*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.00406742396298337*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.00365627558310118*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.0699665131341242*std::sin(0.363119840621948*x_91 + 2.00071978569031) - 0.00322131364319677*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.000264273492180311*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.0230220282259892*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.0444514615229194*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.0114319511090603*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.000178513362328124*std::sin(0.271759957075119*x_94 - 7.41368007659912) - 0.468772322401274);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00206993605125004*x_1 + 0.00191854564690893*x_10 - 5.84215083949363e-5*x_100 + 0.000332657572936871*x_101 + 0.000242393223805828*x_102 + 0.000451170574332987*x_103 - 0.000180837272704112*x_104 - 0.000110227081872462*x_105 - 0.000183686170326215*x_106 - 0.000523146829289648*x_107 + 0.000122417254042583*x_108 - 0.000580118527270737*x_109 - 6.96787772712648e-5*x_11 + 0.000818409554887019*x_110 - 0.000260482451244765*x_111 - 0.00379696513538209*x_112 - 0.00525448192729665*x_113 - 0.00112644768408183*x_114 - 0.000558592883134509*x_115 - 0.00227365640519007*x_116 - 0.000285173023837836*x_117 - 7.3375265427575e-5*x_118 - 0.00145606332014844*x_119 + 0.00144585547814735*x_12 - 0.00258101795308249*x_120 + 0.00149309946884697*x_13 + 0.00314007897857941*x_14 - 4.6971558208121e-5*x_15 - 0.00041524305100605*x_16 + 0.000162182345136693*x_17 + 1.49206128795949e-5*x_18 - 0.000286087618186032*x_19 + 0.00168709257474212*x_2 + 0.00094874015569468*x_20 + 0.000286178814023875*x_21 + 9.48353637533193e-5*x_22 - 0.0014349750385391*x_23 - 0.000171922985031045*x_24 + 0.000203478411990752*x_25 + 0.000220690248646205*x_26 + 0.000594972616039578*x_27 + 0.00114512777435651*x_28 - 0.000557269687672442*x_29 + 0.000361653508205003*x_3 + 0.00269209078525852*x_30 + 0.000354199893423666*x_31 + 0.000110409093030368*x_32 + 0.000757178134917178*x_33 + 0.000708103124698077*x_34 + 0.000189424308582901*x_35 - 2.46950761722615e-5*x_36 + 0.000264717008377042*x_37 + 0.00124870405247417*x_38 + 0.00100823882565482*x_39 + 0.000248883183371961*x_4 - 3.34849598444179e-5*x_40 + 0.000699863923344865*x_41 - 0.000207389493664418*x_42 + 0.00254932984299373*x_43 + 0.000393220512326398*x_44 + 0.000262877621481368*x_45 - 5.55388684744089e-5*x_46 - 0.000356489226294077*x_47 - 9.0264995989939e-5*x_48 - 0.000470327421134781*x_49 + 0.000147112303758893*x_5 + 0.00237754926222633*x_50 + 0.00117835684220197*x_51 + 0.000916080045525181*x_52 - 0.000166211110775944*x_53 + 0.0026192753196684*x_54 + 0.000344706706285402*x_55 + 0.000131914114522628*x_56 + 0.000181554506957499*x_57 + 0.000386267128752389*x_58 + 0.00126591969705777*x_59 - 0.000394628188815957*x_6 - 0.000360708896255112*x_60 - 0.0001365761093053*x_61 - 0.000129349928668525*x_62 + 0.000333236316556345*x_63 + 0.000146785543897143*x_64 - 9.0091868890442e-5*x_65 - 0.000221525269540638*x_66 + 0.000407805473319909*x_67 + 0.00019573017864775*x_68 + 0.000553898185263697*x_69 + 0.000813941149517201*x_7 + 0.000393822683625067*x_70 + 4.92597288131241e-5*x_71 - 5.58224171293002e-5*x_72 - 8.36319002563678e-5*x_73 + 0.000465994592368991*x_74 + 2.43555384206017e-5*x_75 + 4.23021341138985e-5*x_76 + 0.00013895514097137*x_77 - 0.000200852176768068*x_78 + 7.89309671295285e-6*x_79 + 0.000503485825538902*x_8 + 0.000303571621427395*x_80 - 0.000132515951470712*x_81 - 0.00025093461609749*x_82 - 0.000261230135895108*x_83 + 6.00118535728633e-5*x_84 - 1.99204844330441e-5*x_85 + 0.000183454080803413*x_86 + 0.00014380171237095*x_87 - 0.000530111070908384*x_88 - 1.19319630724465e-5*x_89 + 0.000560716648844278*x_9 + 0.000170583958498125*x_90 + 0.000192262157343003*x_91 - 0.000603159451757754*x_92 - 0.000279983693669351*x_93 + 0.00029456623958019*x_94 - 0.000300437082127902*x_95 + 0.000515016839995965*x_96 + 0.000520457381188089*x_97 + 0.000182249132301478*x_98 + 0.000607235539533018*x_99 - 3.47015139044618e-8*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.0104699942480844*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.000675603258473287*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.00119933204395634*std::sin(0.362479835748672*x_1 - 4.21680021286011) + 0.0100846710224244*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.00688140037273401*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.00278759678196855*std::sin(0.387519836425781*x_1 + 8.3884801864624) - 0.000760242164408388*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.00198865131031406*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.00370142250267842*std::sin(0.278799951076508*x_11 + 5.15200042724609) + 0.0128501136537269*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.00582489268085229*std::sin(0.316479921340942*x_11 - 4.28007984161377) + 0.000657417711680394*std::sin(0.327039837837219*x_11 + 8.27447986602783) - 0.0018431059019647*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00366023582029678*std::sin(0.260159969329834*x_113 + 5.17639970779419) + 0.00127634533609036*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.000543384111092903*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.00293495201279586*std::sin(0.284079939126968*x_113 + 5.1561598777771) - 0.00303021012615162*std::sin(0.260399967432022*x_116 - 7.44079971313477) - 0.00490429663496937*std::sin(0.213119998574257*x_118 + 5.19831991195679) - 0.00112824695292498*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 0.00195227909978955*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.00262455930156088*std::sin(0.297759920358658*x_12 - 7.4475998878479) - 0.00109334151651213*std::sin(0.299919933080673*x_12 - 7.45160007476807) - 0.000624095875907454*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.00097627611093905*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.000336912392982656*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.00795988179834069*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.00045250335572642*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.00501190069720219*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.00570588033461685*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.000374694185497553*std::sin(0.31143993139267*x_15 + 5.14224004745483) + 0.0184515804598897*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.00715437589226254*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.00444323644147697*std::sin(0.347039848566055*x_16 - 1.15951991081238) - 0.00882161155934284*std::sin(0.352239847183228*x_16 + 8.24815940856934) + 0.00995343305210982*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.000428047415298712*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.0136729391460681*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.000333987210732514*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.00789688312378451*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.00084628950549405*std::sin(0.326719850301743*x_18 - 1.16375982761383) + 0.0148326839035683*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.00641773649667549*std::sin(0.345119833946228*x_2 + 5.16480016708374) - 8.21125420850436e-5*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.0064407789717718*std::sin(0.378879845142365*x_2 - 7.41175985336304) + 0.00429711973051135*std::sin(0.311599940061569*x_21 + 1.98407983779907) - 0.0192163314357987*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.00381177060101492*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.00543121942671044*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.00145896003369237*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.00181798222238766*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.00410613255231737*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.00468103195373645*std::sin(0.306639939546585*x_23 - 1.1671998500824) + 1.43471352641953e-5*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.000200068304451914*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.0038753892387213*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.000114529873697162*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.00145175824115181*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.00152698355144544*std::sin(0.292479932308197*x_25 - 7.39152002334595) - 0.0108370508747524*std::sin(0.299039930105209*x_25 - 7.3854398727417) - 2.88542565055609e-5*std::sin(0.33231982588768*x_25 - 1.16279983520508) - 0.00104178063299092*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.000630304626305278*std::sin(0.268079966306686*x_26 + 1.99735975265503) + 0.0107914663660898*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.00215113546620323*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 8.10645413183398e-6*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.00326561577495653*std::sin(0.256639957427979*x_28 - 1.167839884758) + 3.34746982940651e-5*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.00538392571807291*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.00048343294123402*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.00498102392331606*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.000151963909814765*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.000377657983924075*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.00478177598555087*std::sin(0.350879848003387*x_3 - 7.39895963668823) - 0.00817215206609126*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.00555517808670873*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.000850098154666893*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.00140374702092516*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.000136973323493708*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.00302981486930833*std::sin(0.288559943437576*x_30 - 1.17079985141754) - 0.0456041797360642*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.0039118581896985*std::sin(0.344319850206375*x_30 - 1.14927983283997) + 0.0012723424060338*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.00101248379194315*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.0114218797746013*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.0012557786808307*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.000818459590131472*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 0.0002380833221911*std::sin(0.406399875879288*x_31 - 7.58871984481812) + 0.000143831787579129*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00111182800232757*std::sin(0.441199868917465*x_31 + 8.22439956665039) + 0.0147709591372509*std::sin(0.296959936618805*x_32 - 1.13887989521027) - 3.01396704251785e-5*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.000274908503544688*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.00531915784927077*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.00240537580043191*std::sin(0.307519912719727*x_32 - 1.13815987110138) + 0.00172079090159912*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.000148873257281987*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 4.96830115186425e-5*std::sin(0.223999992012978*x_44 + 1.78319990634918) - 0.00190079786035257*std::sin(0.335439831018448*x_5 + 2.00743985176086) + 0.0113475176925944*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.000342619888298132*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.000510226489262392*std::sin(0.362559854984283*x_5 + 8.22663974761963) + 0.0165606232716792*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.000342549275251066*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.00317288384928846*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.00211274239872877*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.000214420391721527*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.0038240779326322*std::sin(0.347519844770432*x_6 + 2.03223991394043) - 0.00177535911600731*std::sin(0.381839841604233*x_6 + 2.00863981246948) - 0.00150107742614983*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 6.09738103269694e-5*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.00767336555268869*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.00178020567780096*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.0110706666796132*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.00677054073753934*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.000608504746056973*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.0154782984386772*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.00540262833587143*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.000849239402703798*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.00436686517032807*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.000793035803159753*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00011539848709418*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.00156587734392265*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.000260943297396642*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.00313730169779054*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.000129575508673377*std::sin(0.222079992294312*x_93 - 7.41519975662231) - 0.000765602586620195*std::sin(0.271759957075119*x_94 - 7.41368007659912) - 0.126309541269292);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000153938529450973*x_1 - 0.00399762001460239*x_10 + 0.000369221068586232*x_100 - 0.00316420962086975*x_101 + 0.000937954238544319*x_102 + 0.00457771780214236*x_103 + 0.0014215905743176*x_104 + 0.000749376034243478*x_105 + 0.00244017277666004*x_106 + 0.00358401176176481*x_107 - 0.00262152329027467*x_108 - 0.000756489664601719*x_109 - 0.00069530824223314*x_11 - 0.000330727119466725*x_110 + 0.00249409412659291*x_111 + 0.00368132205068566*x_112 + 0.00781979562326579*x_113 - 0.000223272277864079*x_114 - 0.00125678171535802*x_115 + 0.000521973101129779*x_116 - 0.00284496711928629*x_117 - 0.00214713731485068*x_118 - 0.00045200214642881*x_119 - 0.00159207814771088*x_12 + 0.0102070232076757*x_120 - 0.000283648510098996*x_13 - 0.00322786584857491*x_14 - 0.00195723382302511*x_15 - 0.00222536934503915*x_16 + 0.00113472772123717*x_17 - 0.00118396570678278*x_18 + 0.000666128402230238*x_19 - 0.00236995081553155*x_2 - 0.00116127519847124*x_20 - 0.000577921149128032*x_21 + 0.00321296781163993*x_22 + 0.00186179193042702*x_23 + 0.0025350560304215*x_24 - 0.000911569861840386*x_25 - 0.00179802416623924*x_26 - 0.00185889909898374*x_27 - 0.00328234532135332*x_28 - 0.000714608290350484*x_29 - 0.000418554629782074*x_3 - 0.00488054477070566*x_30 - 0.000379498235857279*x_31 + 0.00086367714877416*x_32 - 0.000810843124585173*x_33 + 0.00046482569562368*x_34 - 0.000497899008213737*x_35 + 0.00285792571139764*x_36 + 0.000413389186789277*x_37 + 0.00246005097970842*x_38 - 0.000763854178741668*x_39 + 2.25037006365689e-5*x_4 + 0.000777175447890638*x_40 - 0.00168689413488257*x_41 + 0.000573645624756773*x_42 + 0.00654560187214091*x_43 - 0.000963709280709056*x_44 + 0.000286268617266696*x_45 + 0.000488358749560974*x_46 + 0.00151766731629609*x_47 - 0.00215940791051359*x_48 + 0.000809185788780822*x_49 - 0.000191336319111194*x_5 - 0.00370835197220886*x_50 - 0.000508151318815674*x_51 - 0.000703864124316298*x_52 - 0.00135601772288684*x_53 - 0.00408966761342626*x_54 - 0.00285443930025631*x_55 + 0.000451320144979354*x_56 + 0.000275780304648972*x_57 - 0.00320728277929723*x_58 - 0.00364554200183394*x_59 - 0.000235484993678992*x_6 + 0.00367557976255504*x_60 + 0.000941113080632967*x_61 - 0.000595775793811821*x_62 - 0.000443169152774416*x_63 + 0.000109612581455425*x_64 + 0.000740552342606882*x_65 + 0.000767715583104565*x_66 - 0.00190812018280513*x_67 - 0.000452841199368591*x_68 - 0.000237740884109349*x_69 - 0.00165023917855885*x_7 + 0.00114569123168684*x_70 - 0.000404684096705757*x_71 + 0.00142140291746331*x_72 + 0.00111792951627814*x_73 + 9.17605277198061e-5*x_74 + 0.00070966069088943*x_75 + 0.00156807671569457*x_76 + 0.00143221285745254*x_77 + 0.000679647014051066*x_78 - 0.000130934408086914*x_79 - 0.000999320103808045*x_8 - 0.000552914357755891*x_80 - 2.71269769200095e-5*x_81 + 0.000903272750745187*x_82 + 0.000827229998855614*x_83 - 0.00146532972056336*x_84 - 0.000778817633624002*x_85 - 0.000413036817616716*x_86 - 0.000109512932850529*x_87 + 0.00103377379755856*x_88 - 2.0250028277193e-5*x_89 - 0.000812171002491468*x_9 - 0.000994381001039324*x_90 + 0.0017741868415262*x_91 + 0.00173663542262943*x_92 + 0.00108428195460349*x_93 + 0.00214304282185108*x_94 - 0.000686261448825544*x_95 + 0.00181635735773673*x_96 + 0.00132725839800005*x_97 + 0.00315501200589364*x_98 + 0.000376167728679552*x_99 + 7.62228988117896e-7*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.0477296189689047*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.042891071641199*std::sin(0.339599847793579*x_1 - 4.24663972854614) - 0.137453739700565*std::sin(0.362479835748672*x_1 - 4.21680021286011) - 0.00739272659799798*std::sin(0.367519825696945*x_1 + 8.36279964447021) - 0.16596872558906*std::sin(0.373199850320816*x_1 - 4.20703983306885) + 0.00585966719875063*std::sin(0.387519836425781*x_1 + 8.3884801864624) + 0.0053964413165028*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.00906567540098409*std::sin(0.247599974274635*x_108 - 7.41831970214844) - 0.0892725815039498*std::sin(0.278799951076508*x_11 + 5.15200042724609) - 0.00941997778449749*std::sin(0.307279914617538*x_11 - 7.46184015274048) + 0.0122442143709642*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.000284713916908835*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.000798210774219717*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00865664202115034*std::sin(0.260159969329834*x_113 + 5.17639970779419) + 0.00581848233350059*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.000840596918318771*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.000835454585515054*std::sin(0.284079939126968*x_113 + 5.1561598777771) - 0.0138138351645605*std::sin(0.260399967432022*x_116 - 7.44079971313477) + 0.00359517173115419*std::sin(0.213119998574257*x_118 + 5.19831991195679) + 0.00800865665839617*std::sin(0.280639946460724*x_12 + 5.1448802947998) - 0.0470859500444234*std::sin(0.284399926662445*x_12 - 7.44591999053955) - 0.00551695429913351*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.000473503436482634*std::sin(0.299919933080673*x_12 - 7.45160007476807) - 0.00284506921888498*std::sin(0.207120001316071*x_120 - 0.981359839439392) + 0.111889616478705*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.0213890821321405*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.0188255212619931*std::sin(0.270559966564178*x_120 + 5.14432001113892) + 0.010913680531111*std::sin(0.376319825649261*x_13 - 4.56640005111694) + 0.0105352647516159*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.00162421868199975*std::sin(0.304639935493469*x_15 + 5.14416027069092) + 0.000579639285012797*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.0034985886237435*std::sin(0.314319908618927*x_15 - 7.44855976104736) + 0.0150388542613464*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.00126479828064491*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.00167265833469885*std::sin(0.352239847183228*x_16 + 8.24815940856934) - 0.00729652054113657*std::sin(0.342879861593246*x_17 + 2.01807975769043) + 0.0490579054386633*std::sin(0.357919842004776*x_17 + 1.99319982528687) - 0.0287411987067047*std::sin(0.359039843082428*x_17 + 1.99607980251312) + 0.000516666966089542*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.018676526224456*std::sin(0.326159834861755*x_18 - 1.14807987213135) + 0.0204111929401427*std::sin(0.326719850301743*x_18 - 1.16375982761383) - 0.010873332067033*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.00250708630061661*std::sin(0.345119833946228*x_2 + 5.16480016708374) + 0.00180362620598012*std::sin(0.368799835443497*x_2 + 5.17743968963623) + 0.0135388380125199*std::sin(0.378879845142365*x_2 - 7.41175985336304) - 0.0305023261551618*std::sin(0.311599940061569*x_21 + 1.98407983779907) + 0.0140868337901638*std::sin(0.326479852199554*x_21 - 1.15463984012604) + 0.00801253154846736*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.00212170378565748*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.0219139484633299*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.000517501334760072*std::sin(0.363519847393036*x_22 + 2.02551984786987) + 0.0990335614692784*std::sin(0.291679948568344*x_23 - 1.16535985469818) - 0.00983976218262204*std::sin(0.306639939546585*x_23 - 1.1671998500824) - 0.000315139057763475*std::sin(0.308479934930801*x_23 - 4.34592008590698) + 0.000309498928552195*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00916549068947927*std::sin(0.283759921789169*x_24 - 1.16415989398956) + 0.000177173857166412*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.000567128800019194*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.0229356788931639*std::sin(0.292479932308197*x_25 - 7.39152002334595) + 0.00794427047421715*std::sin(0.299039930105209*x_25 - 7.3854398727417) + 0.000633792254703333*std::sin(0.33231982588768*x_25 - 1.16279983520508) + 0.00739489114626984*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.00946733479881238*std::sin(0.268079966306686*x_26 + 1.99735975265503) - 0.00791085403367113*std::sin(0.279839962720871*x_26 + 2.01703977584839) - 0.0152694455144398*std::sin(0.304159939289093*x_26 + 1.99455988407135) + 0.000178060656003181*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.00127571154981388*std::sin(0.256639957427979*x_28 - 1.167839884758) - 5.17842308105892e-5*std::sin(0.352239847183228*x_28 + 1.79639983177185) - 0.0113172798644226*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.00726128496670806*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.00194583508494907*std::sin(0.344559848308563*x_29 - 1.16015994548798) - 0.0174163675596075*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.00567251837292089*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.0113091409855912*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.00154951486741639*std::sin(0.352559864521027*x_3 - 7.38783979415894) + 0.0394324255495282*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.0038753470199703*std::sin(0.394879847764969*x_3 + 1.97239983081818) - 0.0338562053496425*std::sin(0.39711982011795*x_3 + 1.98215973377228) + 0.000211893118091201*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.045508585133356*std::sin(0.288559943437576*x_30 - 1.17079985141754) + 0.0334308607355674*std::sin(0.308159917593002*x_30 - 1.16127991676331) + 0.0943479645512094*std::sin(0.344319850206375*x_30 - 1.14927983283997) - 0.0090314921351442*std::sin(0.353439837694168*x_30 + 2.03903985023499) - 0.00718693282604668*std::sin(0.350719839334488*x_31 + 5.17671966552734) - 0.0240093598529845*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.0188621131885473*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0519603901779336*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 6.77720802220992e-5*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 6.22905511824144e-5*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00262952921007699*std::sin(0.441199868917465*x_31 + 8.22439956665039) - 0.01082808375693*std::sin(0.296959936618805*x_32 - 1.13887989521027) + 0.00066202675058038*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.0174527286131736*std::sin(0.304719924926758*x_32 - 1.13631987571716) - 0.0377570786397285*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.0109653995705533*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.000745238695384517*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.0094513066114716*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.00315415531182028*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.000823195959673221*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.0021515932683024*std::sin(0.349999845027924*x_5 + 2.03919982910156) + 0.000530021427529173*std::sin(0.352959841489792*x_5 + 2.00391983985901) + 0.0123058731650307*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.00314004582460277*std::sin(0.210720002651215*x_6 + 2.01455974578857) - 0.0392590852151794*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.000903183544275235*std::sin(0.283119946718216*x_6 - 1.15295994281769) - 0.0509560764411204*std::sin(0.283759921789169*x_6 - 1.15247988700867) - 0.000331701124170344*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.00149387457748676*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.000768871052388052*std::sin(0.381839841604233*x_6 + 2.00863981246948) + 0.00110038840030345*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.00387095833859766*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.00299759730969552*std::sin(0.321439921855927*x_7 - 7.40119981765747) + 0.0429358054505477*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.00315134257795952*std::sin(0.343439847230911*x_7 + 2.00559997558594) - 0.0142320136592882*std::sin(0.3504798412323*x_7 + 2.00343990325928) + 0.0697398634452884*std::sin(0.365919858217239*x_7 + 2.01863980293274) + 0.032536153808278*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.00153789588291688*std::sin(0.326079845428467*x_8 + 8.27583980560303) + 0.0060281720942422*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.0103278560153249*std::sin(0.352719843387604*x_91 + 1.98895990848541) - 0.090888705434037*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00732614106750663*std::sin(0.380799859762192*x_91 + 2.00823974609375) - 0.00329155212432506*std::sin(0.381119847297668*x_91 + 2.00167965888977) - 0.029906340164685*std::sin(0.279999971389771*x_92 - 1.17543983459473) + 0.0756668608665503*std::sin(0.301919937133789*x_92 + 1.9864798784256) + 0.0148504647486989*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.000331566532752836*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.147506606661633);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00200512151952423*x_1 + 0.00131622140601081*x_10 - 0.000307704186189827*x_100 - 0.000707127485841422*x_101 + 0.00136601508058685*x_102 + 0.000379075629992198*x_103 + 0.000112950239664212*x_104 - 0.000728275073016746*x_105 - 0.00048145135311014*x_106 - 0.00250433343435722*x_107 - 0.00463026324618918*x_108 - 0.00293724093709074*x_109 + 0.000968070441900576*x_11 - 6.75096171625084e-5*x_110 - 0.00167313685248924*x_111 - 0.00383753817138476*x_112 - 0.00563440645736404*x_113 - 0.000254477548985972*x_114 - 3.72757840714057e-5*x_115 - 0.00754756639237644*x_116 + 0.00178903376220597*x_117 - 0.000702515007317955*x_118 - 0.00181917425603157*x_119 + 0.00274531357985419*x_12 - 0.00185690783567837*x_120 + 0.00180797510785899*x_13 + 0.00305099407402127*x_14 + 0.000865480592911172*x_15 - 0.000784697251517055*x_16 + 0.00234967439598835*x_17 + 0.000629551312450689*x_18 + 0.0026745352326337*x_19 + 0.00495856234523315*x_2 + 0.0011261607673561*x_20 - 0.00018678694976204*x_21 + 0.00148063204862055*x_22 - 0.00104593026004626*x_23 + 0.00563168477818049*x_24 + 0.00193491412166164*x_25 - 0.00110486933632016*x_26 + 0.00545568578406131*x_27 + 0.000485866577044084*x_28 - 0.00272574444955406*x_29 + 0.000514899555907589*x_3 + 0.000915515069731845*x_30 - 0.000434128036162272*x_31 - 0.000546931239113414*x_32 - 0.000300160007217643*x_33 - 0.000544592401938656*x_34 - 0.00103516820924666*x_35 + 0.00472716629223718*x_36 + 0.000944602188855463*x_37 + 0.0042815168295265*x_38 + 0.000325381844851923*x_39 + 0.000759169123100751*x_4 + 0.000417601465161757*x_40 + 0.00177767925442136*x_41 + 0.00138804343623959*x_42 + 0.000880173726038074*x_43 + 0.000698325017708597*x_44 + 0.000445021464946776*x_45 - 0.00158840701747729*x_46 + 0.0010565781983977*x_47 + 0.00770066182210095*x_48 + 0.00209380397534282*x_49 + 0.000392594863844253*x_5 + 0.0023512110804603*x_50 - 0.00496628066749901*x_51 + 0.000279327095923202*x_52 + 0.000337587584749583*x_53 + 0.000853074650052427*x_54 - 0.000529806163827789*x_55 - 0.00162648559118025*x_56 + 0.00153207937181527*x_57 - 0.00069342001471544*x_58 - 0.00175312997168088*x_59 + 0.000725312915054511*x_6 + 0.00751656339133863*x_60 + 0.000184010925610053*x_61 + 0.0001149261582186*x_62 - 0.00195950293012073*x_63 - 0.00122627354894505*x_64 - 0.000445406857324359*x_65 + 0.000156666889142882*x_66 - 0.000815264923965678*x_67 - 0.00141153191255716*x_68 - 0.000392215315790934*x_69 + 0.00190343826188888*x_7 - 0.000874203373045543*x_70 - 0.000470511088021718*x_71 + 0.000948923703800585*x_72 - 0.000773747169930017*x_73 + 0.00095264314166259*x_74 + 0.000749679441525556*x_75 + 0.00299606248919547*x_76 + 0.00422449126000232*x_77 + 0.00119067786989269*x_78 - 0.000848051055669031*x_79 + 0.000872205471469917*x_8 + 6.17242420109665e-5*x_80 + 0.000208343992466383*x_81 - 0.000188896544884648*x_82 - 0.000816124514841075*x_83 - 0.00225433926287041*x_84 - 0.00110407248489953*x_85 + 0.00119708309526069*x_86 - 0.00110771373150953*x_87 - 0.000511966790699397*x_88 + 6.29604509509247e-5*x_89 + 0.000604946204408143*x_9 - 0.00177066668404433*x_90 + 0.000164134078172422*x_91 - 0.00126159755539611*x_92 - 0.00109032711267499*x_93 + 0.00141492703160519*x_94 - 0.00229231710294938*x_95 + 0.000815905225467475*x_96 - 0.00257251920904217*x_97 + 0.00546428277773757*x_98 + 0.000154602140944344*x_99 + 6.62605054760884e-7*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) - 0.0305125335535659*std::sin(0.333279848098755*x_1 - 4.25399971008301) + 0.0390443881219753*std::sin(0.339599847793579*x_1 - 4.24663972854614) - 0.00427059888642086*std::sin(0.362479835748672*x_1 - 4.21680021286011) + 0.012399473776025*std::sin(0.367519825696945*x_1 + 8.36279964447021) - 0.312437241621086*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.000463411396487459*std::sin(0.387519836425781*x_1 + 8.3884801864624) - 0.00412079614817672*std::sin(0.224879994988441*x_101 + 1.97831988334656) + 0.00579549409431651*std::sin(0.247599974274635*x_108 - 7.41831970214844) - 0.168056234802626*std::sin(0.278799951076508*x_11 + 5.15200042724609) + 0.0157996871602483*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.000968332891286068*std::sin(0.316479921340942*x_11 - 4.28007984161377) + 0.00041454811607673*std::sin(0.327039837837219*x_11 + 8.27447986602783) - 0.00116220793236069*std::sin(0.277519941329956*x_112 + 1.97351980209351) - 0.0109586758712049*std::sin(0.260159969329834*x_113 + 5.17639970779419) - 0.00371963240576947*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.0169675247363692*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.00202612958515167*std::sin(0.284079939126968*x_113 + 5.1561598777771) + 0.00883089197164301*std::sin(0.260399967432022*x_116 - 7.44079971313477) - 0.00603001301479551*std::sin(0.213119998574257*x_118 + 5.19831991195679) - 0.00611551939035557*std::sin(0.280639946460724*x_12 + 5.1448802947998) - 0.0886396174868116*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.000436307969275809*std::sin(0.297759920358658*x_12 - 7.4475998878479) - 0.00068942874194866*std::sin(0.299919933080673*x_12 - 7.45160007476807) + 0.00181879243704002*std::sin(0.207120001316071*x_120 - 0.981359839439392) + 0.00347633809437963*std::sin(0.269119948148727*x_120 + 5.15200042724609) + 0.0194708034186286*std::sin(0.270399957895279*x_120 + 5.14656019210815) - 0.023831733495807*std::sin(0.270559966564178*x_120 + 5.14432001113892) + 0.0205450769653848*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.000833180722610384*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.00393902622765179*std::sin(0.304639935493469*x_15 + 5.14416027069092) + 0.0117000713329957*std::sin(0.31143993139267*x_15 + 5.14224004745483) + 0.0145986144754825*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.00118934680391197*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.00306736626992568*std::sin(0.347039848566055*x_16 - 1.15951991081238) - 0.00697952711895098*std::sin(0.352239847183228*x_16 + 8.24815940856934) + 0.012238111866676*std::sin(0.342879861593246*x_17 + 2.01807975769043) + 0.00152419742666073*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.00227299581659474*std::sin(0.359039843082428*x_17 + 1.99607980251312) + 0.0104289693865671*std::sin(0.289999932050705*x_18 - 1.16223990917206) + 0.0236431166720088*std::sin(0.326159834861755*x_18 - 1.14807987213135) + 0.038424207920979*std::sin(0.326719850301743*x_18 - 1.16375982761383) + 0.0182373301698589*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.00475402270460466*std::sin(0.345119833946228*x_2 + 5.16480016708374) + 0.00156789083019863*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.00107071811715469*std::sin(0.378879845142365*x_2 - 7.41175985336304) + 0.0232919920293097*std::sin(0.311599940061569*x_21 + 1.98407983779907) - 0.0236271859716361*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.00063367053252901*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.00402324721210456*std::sin(0.277439951896667*x_22 + 8.23896026611328) - 0.010594635315278*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.00125503502271934*std::sin(0.363519847393036*x_22 + 2.02551984786987) + 0.18643134520407*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.000778176947510877*std::sin(0.306639939546585*x_23 - 1.1671998500824) - 0.000273950132941366*std::sin(0.308479934930801*x_23 - 4.34592008590698) + 0.00624726383317251*std::sin(0.321359902620316*x_23 - 1.14807987213135) + 0.0116028410810041*std::sin(0.283759921789169*x_24 - 1.16415989398956) + 0.00357627031291236*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.00107540900808374*std::sin(0.269519954919815*x_25 - 7.3997597694397) + 0.0110886066008602*std::sin(0.292479932308197*x_25 - 7.39152002334595) - 0.0133245524650379*std::sin(0.299039930105209*x_25 - 7.3854398727417) + 0.000550955104281301*std::sin(0.33231982588768*x_25 - 1.16279983520508) - 0.0056468396790578*std::sin(0.375679850578308*x_25 - 1.19015979766846) - 0.00457712857036701*std::sin(0.268079966306686*x_26 + 1.99735975265503) + 0.0132685046357633*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.0116599567326482*std::sin(0.304159939289093*x_26 + 1.99455988407135) + 0.000154787987023524*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.00241904782888806*std::sin(0.256639957427979*x_28 - 1.167839884758) - 0.00104526937713483*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.000895026336569026*std::sin(0.175040021538734*x_29 - 1.19559991359711) + 0.00351057986064517*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.00368975897279207*std::sin(0.344559848308563*x_29 - 1.16015994548798) - 0.00054111528771487*std::sin(0.321119844913483*x_3 + 5.1866397857666) + 0.00274246622332243*std::sin(0.326239854097366*x_3 - 7.39215993881226) + 0.0143165456235862*std::sin(0.350879848003387*x_3 - 7.39895963668823) - 0.00646568448200004*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.0301111376530387*std::sin(0.363599836826324*x_3 + 2.00703978538513) - 0.00247742719370108*std::sin(0.394879847764969*x_3 + 1.97239983081818) - 0.0637345341639267*std::sin(0.39711982011795*x_3 + 1.98215973377228) + 0.00427708173124118*std::sin(0.411679863929749*x_3 - 1.17503976821899) + 0.02200182518495*std::sin(0.288559943437576*x_30 - 1.17079985141754) - 0.0560720155825685*std::sin(0.308159917593002*x_30 - 1.16127991676331) + 0.177610677507588*std::sin(0.344319850206375*x_30 - 1.14927983283997) + 0.00689657050267143*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.00548803987105539*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.00189877865087863*std::sin(0.359519839286804*x_31 + 5.17639970779419) + 0.00911917862919841*std::sin(0.368639826774597*x_31 + 5.17511987686157) + 0.047300325299585*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 0.000164359642242688*std::sin(0.406399875879288*x_31 - 7.58871984481812) + 9.06960605312431e-5*std::sin(0.432479858398438*x_31 + 2.00671982765198) + 0.00332879172278282*std::sin(0.441199868917465*x_31 + 8.22439956665039) + 0.0181614373004156*std::sin(0.296959936618805*x_32 - 1.13887989521027) + 0.000575499329151246*std::sin(0.301519930362701*x_32 - 1.13487982749939) - 0.0158874815593487*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.0288318199160608*std::sin(0.307359933853149*x_32 - 1.14471983909607) + 0.00700994748235346*std::sin(0.307519912719727*x_32 - 1.13815987110138) + 0.00108507971985807*std::sin(0.227999985218048*x_34 + 1.99599981307983) + 0.00860366667182142*std::sin(0.347839832305908*x_4 + 1.99647974967957) + 0.00287127505747391*std::sin(0.223999992012978*x_44 + 1.78319990634918) - 0.00119858677071195*std::sin(0.335439831018448*x_5 + 2.00743985176086) + 0.00897798627104123*std::sin(0.349999845027924*x_5 + 2.03919982910156) + 0.0106985303971773*std::sin(0.352959841489792*x_5 + 2.00391983985901) + 0.0231658889575432*std::sin(0.362559854984283*x_5 + 8.22663974761963) + 0.0131025174316365*std::sin(0.210720002651215*x_6 + 2.01455974578857) - 0.00121975441313626*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.00219038464999271*std::sin(0.283119946718216*x_6 - 1.15295994281769) - 0.0959251564449336*std::sin(0.283759921789169*x_6 - 1.15247988700867) - 0.00669541715748649*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.0028327360160905*std::sin(0.347519844770432*x_6 + 2.03223991394043) - 0.00111948881787699*std::sin(0.381839841604233*x_6 + 2.00863981246948) - 0.00184562988122674*std::sin(0.812399864196777*x_6 + 1.78415989875793) + 0.00352379164224536*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.00568414643965366*std::sin(0.321439921855927*x_7 - 7.40119981765747) + 0.0808269423901207*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.00764257990901513*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.00112553786776245*std::sin(0.3504798412323*x_7 + 2.00343990325928) + 0.00216677249973263*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.00257311959215699*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.00372967771233172*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.00460319438118118*std::sin(0.380799859762192*x_9 - 1.16319990158081) + 0.0130743105975612*std::sin(0.352719843387604*x_91 + 1.98895990848541) - 0.00282385335648483*std::sin(0.363119840621948*x_91 + 2.00071978569031) - 0.00666909648863405*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.000260312184089562*std::sin(0.381119847297668*x_91 + 2.00167965888977) - 0.000929170667036441*std::sin(0.279999971389771*x_92 - 1.17543983459473) + 0.14244337424032*std::sin(0.301919937133789*x_92 + 1.9864798784256) + 0.00046139434515775*std::sin(0.222079992294312*x_93 - 7.41519975662231) - 0.000482766290454263*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.162899144815989);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00620709950137136*x_1 - 0.00394449789517883*x_10 + 0.000888498822813417*x_100 + 0.000276207114721655*x_101 + 0.00131806982846069*x_102 - 0.00143872882859922*x_103 + 0.000689436842444659*x_104 + 0.00087072325321772*x_105 + 0.00098651854203023*x_106 + 0.00512164214976307*x_107 - 0.000377418805158044*x_108 - 0.000153065030314284*x_109 + 0.000519777257176152*x_11 - 0.000807387155492285*x_110 + 0.000615185203452489*x_111 - 0.00452130902057476*x_112 + 0.000921468274498776*x_113 + 0.00428240262439837*x_114 + 0.000651297450054277*x_115 + 0.00179048996678856*x_116 + 0.00340907475587303*x_117 - 0.000433658692379048*x_118 - 0.00125398805074213*x_119 - 0.00237742059497206*x_12 + 0.00639968295198375*x_120 + 0.00294172569167975*x_13 + 0.00384766644854235*x_14 - 0.000590424269745107*x_15 + 0.00204516018517209*x_16 + 0.00221950157054621*x_17 + 0.000645374631100776*x_18 - 0.00126367154157678*x_19 + 0.00436119054717673*x_2 - 0.00348714109442966*x_20 + 0.000375223714377835*x_21 - 0.000854194049699339*x_22 + 0.000768514834981802*x_23 - 0.00145011343182419*x_24 + 0.000190037993163165*x_25 - 6.98052994428634e-5*x_26 - 0.000767058455473539*x_27 - 0.00361329774304124*x_28 + 0.00260665545078592*x_29 - 0.000349833027117448*x_3 - 0.0185930542174953*x_30 + 0.00168106930822101*x_31 - 0.000795647807535588*x_32 - 0.00356263150376652*x_33 - 0.00260575901921056*x_34 + 0.000109619876843956*x_35 - 0.00083142538349628*x_36 - 0.00118569540878764*x_37 - 0.00349144659222994*x_38 - 0.00256906727750124*x_39 - 0.000272282260838495*x_4 + 0.000312921177579321*x_40 - 0.000889230464922156*x_41 + 0.00112213330664127*x_42 - 0.00845448099893733*x_43 - 0.000686516361319271*x_44 - 0.000358256427697723*x_45 + 4.79248276365e-5*x_46 + 0.00326802553340568*x_47 - 0.00111948369270924*x_48 + 0.00217963284379036*x_49 - 6.34451312572573e-5*x_5 - 0.00254932808341156*x_50 + 0.000807946766829243*x_51 - 0.00181382049115826*x_52 + 0.000635080715494756*x_53 - 0.00159197131795552*x_54 - 0.000494644374193573*x_55 - 0.000361094790284007*x_56 + 0.000326263965877873*x_57 - 4.2853144177407e-5*x_58 - 0.000461528736841108*x_59 + 0.00247614903561078*x_6 - 0.000535212847861501*x_60 + 0.000258822379156079*x_61 + 0.000950127513823352*x_62 + 0.00149355646138049*x_63 - 0.000498241984327448*x_64 + 0.000259192286115362*x_65 + 0.0022918298720587*x_66 - 0.00148983735872594*x_67 + 0.000412662613778773*x_68 - 0.00107169801575451*x_69 - 0.000944089697653103*x_7 + 0.000955854900249231*x_70 + 0.00116116223987861*x_71 + 0.000804319192917224*x_72 + 0.00042656813471668*x_73 - 0.000615188627333858*x_74 + 0.00118575005024887*x_75 - 0.000407072621430419*x_76 - 0.00104958969714798*x_77 + 0.000662336250636302*x_78 - 0.00105962113222842*x_79 - 0.0003547905608828*x_8 - 0.000791598188793997*x_80 + 0.00141400227796738*x_81 + 0.00104456441655907*x_82 + 0.000974451060447904*x_83 + 0.00065231205392037*x_84 + 0.000660730471349236*x_85 - 0.000936262629524244*x_86 - 0.000675424721422891*x_87 - 0.000738105144295431*x_88 - 0.0013979193503509*x_89 - 0.00111806184872462*x_9 - 0.00116051453055552*x_90 + 0.000781718262563048*x_91 + 0.000919312871176577*x_92 + 0.000235878312161642*x_93 - 0.00202745913157767*x_94 + 0.00182724326736958*x_95 - 0.00202828353426603*x_96 - 0.00529837473518134*x_97 - 0.0036661693645636*x_98 - 0.00387761200700117*x_99 + 1.44574797069703e-6*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.0409470310938133*std::sin(0.333279848098755*x_1 - 4.25399971008301) + 0.0237431921445641*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.059014359443009*std::sin(0.362479835748672*x_1 - 4.21680021286011) - 0.0163455072912671*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.0651851517587734*std::sin(0.373199850320816*x_1 - 4.20703983306885) + 0.02554306806453*std::sin(0.387519836425781*x_1 + 8.3884801864624) + 0.00441443119226603*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.00777740322570675*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.0350623091945704*std::sin(0.278799951076508*x_11 + 5.15200042724609) - 0.0208278114331694*std::sin(0.307279914617538*x_11 - 7.46184015274048) + 0.0533741576895218*std::sin(0.316479921340942*x_11 - 4.28007984161377) + 0.00695587092492291*std::sin(0.327039837837219*x_11 + 8.27447986602783) - 0.019501158133176*std::sin(0.277519941329956*x_112 + 1.97351980209351) - 0.00308309980419869*std::sin(0.260159969329834*x_113 + 5.17639970779419) + 0.00499165051336087*std::sin(0.268879950046539*x_113 - 4.22904014587402) - 0.00677739331238182*std::sin(0.283439934253693*x_113 - 7.42184019088745) + 0.00733242706855278*std::sin(0.284079939126968*x_113 + 5.1561598777771) - 0.0118508286935325*std::sin(0.260399967432022*x_116 - 7.44079971313477) + 0.00794901650506762*std::sin(0.213119998574257*x_118 + 5.19831991195679) + 0.00655129217339183*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 0.0184932720815811*std::sin(0.284399926662445*x_12 - 7.44591999053955) - 0.0240491369888234*std::sin(0.297759920358658*x_12 - 7.4475998878479) - 0.0115682044012455*std::sin(0.299919933080673*x_12 - 7.45160007476807) - 0.00244077242363135*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.0480386642022195*std::sin(0.269119948148727*x_120 + 5.15200042724609) + 0.0118403450281589*std::sin(0.270399957895279*x_120 + 5.14656019210815) - 0.00670478931379866*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.00428640949758629*std::sin(0.376319825649261*x_13 - 4.56640005111694) + 0.0459246191807181*std::sin(0.27975994348526*x_15 + 5.17375993728638) + 0.0142550717126078*std::sin(0.304639935493469*x_15 + 5.14416027069092) + 0.00467339735398574*std::sin(0.31143993139267*x_15 + 5.14224004745483) + 0.0494123395473196*std::sin(0.314319908618927*x_15 - 7.44855976104736) + 0.0655563643771478*std::sin(0.343999862670898*x_16 - 1.16511988639832) + 0.0111005927910999*std::sin(0.347039848566055*x_16 - 1.15951991081238) - 0.0236238010436214*std::sin(0.352239847183228*x_16 + 8.24815940856934) - 0.0161327932427971*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.0210625107136792*std::sin(0.357919842004776*x_17 + 1.99319982528687) - 0.125286704845297*std::sin(0.359039843082428*x_17 + 1.99607980251312) + 0.00416567699023609*std::sin(0.289999932050705*x_18 - 1.16223990917206) + 0.00665172409868004*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.00801661098895914*std::sin(0.326719850301743*x_18 - 1.16375982761383) - 0.0240412148651875*std::sin(0.365919858217239*x_18 + 1.99887979030609) + 0.00756893443624925*std::sin(0.345119833946228*x_2 + 5.16480016708374) + 0.00342100466899119*std::sin(0.368799835443497*x_2 + 5.17743968963623) + 0.0590175941975302*std::sin(0.378879845142365*x_2 - 7.41175985336304) - 0.0249517065263445*std::sin(0.311599940061569*x_21 + 1.98407983779907) + 0.0311463492360649*std::sin(0.326479852199554*x_21 - 1.15463984012604) + 0.0349276898789292*std::sin(0.249279975891113*x_22 - 4.37048006057739) - 0.00640545833736701*std::sin(0.277439951896667*x_22 + 8.23896026611328) - 0.0115808919514588*std::sin(0.357919842004776*x_22 + 1.98535978794098) + 0.00454188756731478*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.038895989052604*std::sin(0.291679948568344*x_23 - 1.16535985469818) - 0.042892831050728*std::sin(0.306639939546585*x_23 - 1.1671998500824) - 0.000597735930214252*std::sin(0.308479934930801*x_23 - 4.34592008590698) + 0.00249536480903864*std::sin(0.321359902620316*x_23 - 1.14807987213135) + 0.00326432841754075*std::sin(0.283759921789169*x_24 - 1.16415989398956) + 0.00142848122390234*std::sin(0.329999834299088*x_24 - 1.14263987541199) + 0.00171217109805843*std::sin(0.269519954919815*x_25 - 7.3997597694397) + 0.0121208471188822*std::sin(0.292479932308197*x_25 - 7.39152002334595) + 0.0175649848859932*std::sin(0.299039930105209*x_25 - 7.3854398727417) + 0.0012021372584417*std::sin(0.33231982588768*x_25 - 1.16279983520508) + 0.00604921581184928*std::sin(0.375679850578308*x_25 - 1.19015979766846) - 0.0050032143480122*std::sin(0.268079966306686*x_26 + 1.99735975265503) - 0.0174911002826128*std::sin(0.279839962720871*x_26 + 2.01703977584839) - 0.0124908087782621*std::sin(0.304159939289093*x_26 + 1.99455988407135) + 0.000337734245339097*std::sin(0.252399981021881*x_27 - 1.16151988506317) + 0.00385139397783491*std::sin(0.256639957427979*x_28 - 1.167839884758) - 0.000417515329802139*std::sin(0.352239847183228*x_28 + 1.79639983177185) - 0.0493335269866378*std::sin(0.175040021538734*x_29 - 1.19559991359711) + 0.00383738041407349*std::sin(0.343199849128723*x_29 - 1.14407992362976) + 0.0058745078612215*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.00747753955325825*std::sin(0.321119844913483*x_3 + 5.1866397857666) + 0.00299776293073747*std::sin(0.326239854097366*x_3 - 7.39215993881226) + 0.00402779857052449*std::sin(0.350879848003387*x_3 - 7.39895963668823) - 0.0218845834696831*std::sin(0.352559864521027*x_3 - 7.38783979415894) + 0.0322567631376289*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.00332464323734537*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.0132972153389729*std::sin(0.39711982011795*x_3 + 1.98215973377228) + 0.00170840859655216*std::sin(0.411679863929749*x_3 - 1.17503976821899) + 0.0240499793168299*std::sin(0.288559943437576*x_30 - 1.17079985141754) + 0.0739164867877753*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.0370556944724009*std::sin(0.344319850206375*x_30 - 1.14927983283997) - 0.00738799854492315*std::sin(0.353439837694168*x_30 + 2.03903985023499) - 0.00587910042623821*std::sin(0.350719839334488*x_31 + 5.17671966552734) - 0.104659990424258*std::sin(0.359519839286804*x_31 + 5.17639970779419) + 0.00996808471911317*std::sin(0.368639826774597*x_31 + 5.17511987686157) + 0.0287636909196777*std::sin(0.379279851913452*x_31 + 5.17120027542114) + 0.000594806521058584*std::sin(0.406399875879288*x_31 - 7.58871984481812) + 0.00152182597384558*std::sin(0.432479858398438*x_31 + 2.00671982765198) + 0.000936517990800064*std::sin(0.441199868917465*x_31 + 8.22439956665039) - 0.0239411696960741*std::sin(0.296959936618805*x_32 - 1.13887989521027) + 0.00125569067316906*std::sin(0.301519930362701*x_32 - 1.13487982749939) - 0.00966129949785345*std::sin(0.304719924926758*x_32 - 1.13631987571716) - 0.0308862852202893*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.00940716827142596*std::sin(0.307519912719727*x_32 - 1.13815987110138) + 0.0182069925827071*std::sin(0.227999985218048*x_34 + 1.99599981307983) + 0.00523195574991902*std::sin(0.347839832305908*x_4 + 1.99647974967957) + 0.00174604440403889*std::sin(0.223999992012978*x_44 + 1.78319990634918) - 0.0201115734122629*std::sin(0.335439831018448*x_5 + 2.00743985176086) + 0.0303880417433381*std::sin(0.349999845027924*x_5 + 2.03919982910156) + 0.00427334861700393*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.00483320099578819*std::sin(0.362559854984283*x_5 + 8.22663974761963) + 0.0443484579542811*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.0168554873176928*std::sin(0.225599989295006*x_6 - 1.17279982566833) + 0.0079268551310092*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.0200132860215505*std::sin(0.283759921789169*x_6 - 1.15247988700867) - 0.00267437214159416*std::sin(0.321599900722504*x_6 - 1.17895984649658) - 0.00451003171697597*std::sin(0.347519844770432*x_6 + 2.03223991394043) - 0.0187843567900947*std::sin(0.381839841604233*x_6 + 2.00863981246948) + 0.00243298685295041*std::sin(0.812399864196777*x_6 + 1.78415989875793) + 0.00214284474833788*std::sin(0.231199979782104*x_61 - 1.15639984607697) + 0.0090497951736972*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.0168632794175266*std::sin(0.333679854869843*x_7 + 2.04503989219666) - 0.0276579840742246*std::sin(0.343439847230911*x_7 + 2.00559997558594) - 0.0620392389642929*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.0299420981766835*std::sin(0.365919858217239*x_7 + 2.01863980293274) + 0.141829418479613*std::sin(0.325679838657379*x_8 - 1.13759982585907) - 0.0134974534774546*std::sin(0.326079845428467*x_8 + 8.27583980560303) + 0.00493120361446194*std::sin(0.380799859762192*x_9 - 1.16319990158081) + 0.0036783097627051*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.039022137509526*std::sin(0.363119840621948*x_91 + 2.00071978569031) - 0.004055528770629*std::sin(0.380799859762192*x_91 + 2.00823974609375) - 0.0143483131546293*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.0128399817418454*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.0297185857828939*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.00637589538476451*std::sin(0.222079992294312*x_93 - 7.41519975662231) - 0.0081005313329711*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.370505974667405);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0104228235719147*x_1 - 0.00519726881822113*x_10 - 0.00154343663841484*x_100 - 0.00463888965590391*x_101 - 0.00126140094842872*x_102 - 0.00121622243976271*x_103 + 2.12785038812596e-5*x_104 + 0.000541942077076561*x_105 + 0.00340357396233903*x_106 + 0.00175846800494401*x_107 - 0.000741650220771359*x_108 + 0.00191761224119158*x_109 - 0.00175157946980951*x_11 - 0.00441214329462003*x_110 - 0.000215965329383655*x_111 + 0.0228857673207956*x_112 + 0.0157890883906643*x_113 + 0.00625160932728033*x_114 + 0.00239676013377054*x_115 + 0.0171334380824501*x_116 - 0.000614672892282618*x_117 + 0.00622028417105819*x_118 + 0.00725625544484019*x_119 - 0.00227746021100484*x_12 + 0.0181961383369399*x_120 - 0.0142986930878239*x_13 - 0.0199167787383301*x_14 - 0.00192087747704119*x_15 + 0.000309551886944394*x_16 - 9.73285035242579e-5*x_17 - 0.00101102091851355*x_18 + 0.00027941401040106*x_19 - 0.00714859644932446*x_2 - 0.001624089017901*x_20 - 0.00192668323871183*x_21 + 0.000739027731341654*x_22 + 0.00154195225459317*x_23 + 0.000352380323472283*x_24 - 0.00113724792008054*x_25 - 0.00152743992021948*x_26 - 0.00264268408988934*x_27 - 0.00407602395349111*x_28 - 0.00393063191006266*x_29 + 0.000515341988244113*x_3 - 0.0122290389465014*x_30 - 0.00227684209367244*x_31 - 0.000146316902581366*x_32 + 0.00101453106448827*x_33 - 0.00196023374252734*x_34 - 0.00227035390651543*x_35 - 0.000823252631026476*x_36 - 0.000479808832803315*x_37 - 0.00338912041396096*x_38 - 0.00246793575350455*x_39 - 0.000288429760602574*x_4 - 0.00102750866823422*x_40 - 0.00448908232631838*x_41 - 0.00106828275136966*x_42 - 0.00364450157464081*x_43 - 0.00187770859096664*x_44 + 0.000948152369834432*x_45 - 3.37719112256477e-5*x_46 - 0.00238390629744466*x_47 - 0.00729191092867557*x_48 - 0.003577479510039*x_49 - 0.000131635066606882*x_5 - 0.0131943562082709*x_50 - 0.0075683463978152*x_51 + 0.000113822961874433*x_52 + 0.000187100899501723*x_53 - 0.00467364068860184*x_54 - 0.00316992384892977*x_55 + 0.000749679431390101*x_56 - 0.00156075755460429*x_57 - 0.00202221167918151*x_58 - 0.00445371044286334*x_59 + 0.00194423684013875*x_6 + 0.000795331752276842*x_60 - 6.23335002702082e-5*x_61 - 3.48028796762274e-5*x_62 - 0.0010436612132762*x_63 - 0.000933155341072724*x_64 + 0.000505862536483496*x_65 - 0.00245681785333118*x_66 - 0.00149311975027989*x_67 - 0.000498928505898767*x_68 - 0.000937384279913365*x_69 + 0.00215763702083227*x_7 - 0.000801766177708928*x_70 - 0.000464153200060518*x_71 - 0.000345282492044187*x_72 - 0.000364709777145781*x_73 - 0.00419466065364861*x_74 - 0.00105258557881643*x_75 - 0.000363681221155427*x_76 + 0.000164842481540991*x_77 + 0.00103351475276067*x_78 + 0.00023769621486108*x_79 - 0.000336110265903223*x_8 - 0.00174261626117035*x_80 - 0.000845687505138833*x_81 - 0.000173405830843044*x_82 + 0.00136329459972455*x_83 - 0.000725530698896733*x_84 - 0.000659646244539888*x_85 - 0.0013961061322427*x_86 - 0.00129477275622584*x_87 + 0.00243196954089893*x_88 + 0.000830864209503046*x_89 - 0.00076842599794882*x_9 + 4.50945528574472e-5*x_90 - 0.00125200337656462*x_91 - 7.49901095218071e-6*x_92 + 0.00119443895784831*x_93 + 0.000494847483512722*x_94 - 0.000245118003888733*x_95 - 0.00275357998496749*x_96 - 0.00200537733466768*x_97 + 0.00115485015275889*x_98 - 0.00174870962079972*x_99 - 2.27196240414634e-5*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) - 0.0191165878491272*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.0285785328396657*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.00352446332903764*std::sin(0.362479835748672*x_1 - 4.21680021286011) - 0.0108543671738358*std::sin(0.367519825696945*x_1 + 8.36279964447021) - 0.0716093994462426*std::sin(0.373199850320816*x_1 - 4.20703983306885) + 0.00699342159886053*std::sin(0.387519836425781*x_1 + 8.3884801864624) + 0.00205492843383673*std::sin(0.224879994988441*x_101 + 1.97831988334656) + 0.00363096927984048*std::sin(0.247599974274635*x_108 - 7.41831970214844) - 0.0385178347657022*std::sin(0.278799951076508*x_11 + 5.15200042724609) - 0.0138308777264943*std::sin(0.307279914617538*x_11 - 7.46184015274048) + 0.0146132792765495*std::sin(0.316479921340942*x_11 - 4.28007984161377) + 0.0351889304346347*std::sin(0.327039837837219*x_11 + 8.27447986602783) - 0.0986540584708661*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00192230788985522*std::sin(0.260159969329834*x_113 + 5.17639970779419) - 0.00233040889661038*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.0499895844952263*std::sin(0.283439934253693*x_113 - 7.42184019088745) + 0.000188053325746912*std::sin(0.284079939126968*x_113 + 5.1561598777771) + 0.00553269435544257*std::sin(0.260399967432022*x_116 - 7.44079971313477) + 0.00527860911744125*std::sin(0.213119998574257*x_118 + 5.19831991195679) + 0.00304964240671839*std::sin(0.280639946460724*x_12 + 5.1448802947998) - 0.0203158552496543*std::sin(0.284399926662445*x_12 - 7.44591999053955) - 0.00658439908732584*std::sin(0.297759920358658*x_12 - 7.4475998878479) - 0.0585221813806981*std::sin(0.299919933080673*x_12 - 7.45160007476807) + 0.00113950240614943*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.00286897141568031*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.0142516510484325*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.00418042561586226*std::sin(0.270559966564178*x_120 + 5.14432001113892) + 0.00470885165748674*std::sin(0.376319825649261*x_13 - 4.56640005111694) + 0.0125736745048206*std::sin(0.27975994348526*x_15 + 5.17375993728638) + 0.000365597041641727*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.0344706557726298*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.0774425535106003*std::sin(0.314319908618927*x_15 - 7.44855976104736) + 0.0179486384885203*std::sin(0.343999862670898*x_16 - 1.16511988639832) + 0.000284694736492012*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.0370249110486344*std::sin(0.352239847183228*x_16 + 8.24815940856934) - 0.0107131126783966*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.00125789803241894*std::sin(0.357919842004776*x_17 + 1.99319982528687) - 0.0343021733137792*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.030725745472494*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.00414733953750681*std::sin(0.326159834861755*x_18 - 1.14807987213135) + 0.0088066788681864*std::sin(0.326719850301743*x_18 - 1.16375982761383) - 0.0159647644335422*std::sin(0.365919858217239*x_18 + 1.99887979030609) - 0.00129343158527166*std::sin(0.345119833946228*x_2 + 5.16480016708374) - 0.0537603659136371*std::sin(0.368799835443497*x_2 + 5.17743968963623) + 0.0161583924425637*std::sin(0.378879845142365*x_2 - 7.41175985336304) - 0.0116150799458751*std::sin(0.311599940061569*x_21 + 1.98407983779907) + 0.0206829867503342*std::sin(0.326479852199554*x_21 - 1.15463984012604) + 0.00956283169196889*std::sin(0.249279975891113*x_22 - 4.37048006057739) + 0.00109460878561895*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.00206283217196081*std::sin(0.357919842004776*x_22 + 1.98535978794098) + 0.000116484903868355*std::sin(0.363519847393036*x_22 + 2.02551984786987) + 0.0427293385345186*std::sin(0.291679948568344*x_23 - 1.16535985469818) - 0.0117436030138831*std::sin(0.306639939546585*x_23 - 1.1671998500824) + 0.0093932939113826*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.0184056383063907*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00203530364588638*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.0105363787448562*std::sin(0.329999834299088*x_24 - 1.14263987541199) - 0.000292587575737473*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.00215901102376654*std::sin(0.292479932308197*x_25 - 7.39152002334595) + 0.0116641711975075*std::sin(0.299039930105209*x_25 - 7.3854398727417) - 0.0188913331449209*std::sin(0.33231982588768*x_25 - 1.16279983520508) + 0.00281592464187959*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.000891191418031963*std::sin(0.268079966306686*x_26 + 1.99735975265503) - 0.0116151075251911*std::sin(0.279839962720871*x_26 + 2.01703977584839) - 0.00581450180150897*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 0.00530742234162167*std::sin(0.252399981021881*x_27 - 1.16151988506317) - 0.000658152697742922*std::sin(0.256639957427979*x_28 - 1.167839884758) + 0.00307956420635434*std::sin(0.352239847183228*x_28 + 1.79639983177185) - 0.0135069973702734*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.00068352867873929*std::sin(0.343199849128723*x_29 - 1.14407992362976) - 0.00100387631569918*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.000446574599735137*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.000533972844523243*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.00251132608821892*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.0342990848426659*std::sin(0.352559864521027*x_3 - 7.38783979415894) + 0.0150156015278209*std::sin(0.363599836826324*x_3 + 2.00703978538513) - 0.00155214756274045*std::sin(0.394879847764969*x_3 + 1.97239983081818) - 0.0146077071087444*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.0126011036918413*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.00428387306242846*std::sin(0.288559943437576*x_30 - 1.17079985141754) + 0.0490848447526098*std::sin(0.308159917593002*x_30 - 1.16127991676331) + 0.0407076758377714*std::sin(0.344319850206375*x_30 - 1.14927983283997) - 0.00343913125335493*std::sin(0.353439837694168*x_30 + 2.03903985023499) - 0.00273673551700712*std::sin(0.350719839334488*x_31 + 5.17671966552734) - 0.028654797290617*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.0017755528622152*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0346214645668949*std::sin(0.379279851913452*x_31 + 5.17120027542114) + 1.52548867401274e-5*std::sin(0.406399875879288*x_31 - 7.58871984481812) + 0.00769873807396246*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.000583917497660838*std::sin(0.441199868917465*x_31 + 8.22439956665039) - 0.0158983286245963*std::sin(0.296959936618805*x_32 - 1.13887989521027) - 0.0197329137477666*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.011628839260203*std::sin(0.304719924926758*x_32 - 1.13631987571716) - 0.0143776407311456*std::sin(0.307359933853149*x_32 - 1.14471983909607) + 0.00439184365431094*std::sin(0.307519912719727*x_32 - 1.13815987110138) + 0.0921070276219782*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.00629745226776387*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.00210162926014833*std::sin(0.223999992012978*x_44 + 1.78319990634918) - 0.101742077357914*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.0476263129888265*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.0315199239473091*std::sin(0.352959841489792*x_5 + 2.00391983985901) + 0.00530953156314147*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.0695060760065414*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.00100664562836842*std::sin(0.225599989295006*x_6 - 1.17279982566833) + 0.000203298506233144*std::sin(0.283119946718216*x_6 - 1.15295994281769) - 0.0219856724158999*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.0197259840150721*std::sin(0.321599900722504*x_6 - 1.17895984649658) + 0.000770705245559564*std::sin(0.347519844770432*x_6 + 2.03223991394043) - 0.0950278450362885*std::sin(0.381839841604233*x_6 + 2.00863981246948) + 0.00161564472490543*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.00257923865661424*std::sin(0.231199979782104*x_61 - 1.15639984607697) - 0.00154649125533971*std::sin(0.321439921855927*x_7 - 7.40119981765747) + 0.0185252205326152*std::sin(0.333679854869843*x_7 + 2.04503989219666) - 0.000709338918748989*std::sin(0.343439847230911*x_7 + 2.00559997558594) - 0.0169856867880424*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.00178820592164654*std::sin(0.365919858217239*x_7 + 2.01863980293274) + 0.0388313931608906*std::sin(0.325679838657379*x_8 - 1.13759982585907) - 0.000346166554650852*std::sin(0.326079845428467*x_8 + 8.27583980560303) + 0.00229548725057705*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.00229342036496844*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.00233048522378363*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00488144397130548*std::sin(0.380799859762192*x_91 + 2.00823974609375) - 0.00392841622898622*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.000766831076737338*std::sin(0.279999971389771*x_92 - 1.17543983459473) + 0.0326474668369281*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.000380782061950262*std::sin(0.222079992294312*x_93 - 7.41519975662231) - 0.0409796324049325*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.220065802263605);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.001197455759894*x_1 - 0.00370857628299447*x_10 + 0.00133148561769786*x_100 - 0.00193180681968331*x_101 - 0.0037474634777631*x_102 + 0.000201379030010106*x_103 + 0.000954620154777222*x_104 + 0.000750885028107528*x_105 - 0.00025521329235341*x_106 - 0.0011615728987195*x_107 + 0.00140920447510128*x_108 + 0.002276224502859*x_109 - 0.000635258240582921*x_11 + 0.00065623911152967*x_110 + 0.00118087701711372*x_111 + 0.000884320874777987*x_112 + 0.0124615305680505*x_113 - 0.00604403126872431*x_114 - 0.00145854599530359*x_115 + 0.00509520187051323*x_116 - 0.000582182263538835*x_117 - 0.000314990146245128*x_118 - 0.000634831700593466*x_119 - 0.0074432333009779*x_12 + 0.00748539865457892*x_120 - 5.45633670305544e-5*x_13 - 0.00461801260823145*x_14 - 0.00234080676672596*x_15 + 0.00150423358143537*x_16 - 0.000298459758406953*x_17 + 0.00185062115071737*x_18 + 0.00282907437602334*x_19 - 0.00354017481387896*x_2 - 0.000997969456606004*x_20 + 0.00100659351660096*x_21 + 0.000657459362387538*x_22 + 0.00686413027362694*x_23 + 0.00302569817222918*x_24 + 0.00019655583822344*x_25 + 0.000667959542173753*x_26 - 0.00241169145950843*x_27 + 0.00464647347447393*x_28 + 0.00423406214978334*x_29 - 0.00189004724915543*x_3 + 0.0378036777615691*x_30 + 0.000155572569984625*x_31 + 0.000829654978601843*x_32 - 0.00326063444554819*x_33 + 0.00350417774906564*x_34 + 0.00343038477049235*x_35 + 0.00180611463163993*x_36 - 0.000212322902415975*x_37 - 0.00615689521894751*x_38 - 6.86301700348313e-5*x_39 - 0.00156881821686205*x_4 + 0.00101485038602664*x_40 - 0.00381946172027518*x_41 - 0.000791378778314341*x_42 - 0.00168433334619094*x_43 + 0.00185566249061692*x_44 + 0.0010384178003748*x_45 + 0.00148396691791441*x_46 - 0.00097684722375683*x_47 - 0.00347271691746262*x_48 - 0.000163242510852241*x_49 - 0.00184862030687932*x_5 - 0.00422346097274203*x_50 - 0.000481671807330234*x_51 - 0.00325947996634546*x_52 - 0.00238560097404091*x_53 - 0.0139448533393512*x_54 - 0.00367618142846042*x_55 + 0.000224908891352913*x_56 - 0.00158755858731548*x_57 - 0.000990413699115134*x_58 - 0.00427587838987941*x_59 - 0.00697945677369205*x_6 + 7.81712742276003e-5*x_60 + 0.000507520985305044*x_61 + 0.000104756858652796*x_62 - 0.000865589373445112*x_63 + 0.000890878914617558*x_64 + 0.000782009323992824*x_65 - 0.000233701201447352*x_66 + 0.00243243484167269*x_67 + 0.000533200054684201*x_68 + 6.29977197723725e-5*x_69 - 0.00411546418961544*x_7 + 7.39304757731839e-5*x_70 - 0.00146986439115389*x_71 - 0.000762312530204758*x_72 + 0.00178606892143232*x_73 - 0.00121038597782391*x_74 - 0.00181924225560257*x_75 + 4.65977819790378e-5*x_76 - 0.000269092382319461*x_77 - 0.000143774614038806*x_78 + 0.0013038228677438*x_79 - 0.00266662270007759*x_8 + 0.00352658453271528*x_80 + 0.000194642575805784*x_81 + 0.000593614161262717*x_82 + 0.00117815633408847*x_83 - 0.000109920928276449*x_84 + 0.000397558992184718*x_85 - 0.000155864854001709*x_86 + 0.00136532143844858*x_87 + 0.0022627483907136*x_88 + 0.000434321421421741*x_89 - 0.002367277967109*x_9 + 0.000968436976046566*x_90 - 8.96095689406548e-5*x_91 + 0.00046241516660514*x_92 + 0.00378861714106742*x_93 + 0.000630942437086539*x_94 - 0.00112109476261561*x_95 + 0.00106011796972174*x_96 + 0.00692192563069849*x_97 - 0.000638611291238229*x_98 + 0.00505521719894605*x_99 + 1.69697848470357e-5*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.0645471930435099*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.01222224893622*std::sin(0.339599847793579*x_1 - 4.24663972854614) - 0.00229354632828825*std::sin(0.362479835748672*x_1 - 4.21680021286011) - 0.0429276730035677*std::sin(0.367519825696945*x_1 + 8.36279964447021) - 0.0217256494154325*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.0402055064436249*std::sin(0.387519836425781*x_1 + 8.3884801864624) + 0.0035754369023686*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.0122599742637448*std::sin(0.247599974274635*x_108 - 7.41831970214844) - 0.0116859655412892*std::sin(0.278799951076508*x_11 + 5.15200042724609) - 0.0546994022669916*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.0840124230764997*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.00142864638225282*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.00400528694643812*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00474412853458677*std::sin(0.260159969329834*x_113 + 5.17639970779419) + 0.00786862980501461*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00751028898394463*std::sin(0.283439934253693*x_113 - 7.42184019088745) - 0.0093291814478899*std::sin(0.284079939126968*x_113 + 5.1561598777771) - 0.018681152380852*std::sin(0.260399967432022*x_116 - 7.44079971313477) + 0.0208762429424148*std::sin(0.213119998574257*x_118 + 5.19831991195679) + 0.00530617213741637*std::sin(0.280639946460724*x_12 + 5.1448802947998) - 0.00616364823810601*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.0378540169773278*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.00237596032838745*std::sin(0.299919933080673*x_12 - 7.45160007476807) - 0.00384753191122596*std::sin(0.207120001316071*x_120 - 0.981359839439392) + 0.00186698462775444*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.00609503741298848*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.0103170135000712*std::sin(0.270559966564178*x_120 + 5.14432001113892) + 0.00142862335183573*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.0722866402628974*std::sin(0.27975994348526*x_15 + 5.17375993728638) - 0.0181369892010189*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.00517877051655132*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.0109417958663232*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.103187558508138*std::sin(0.343999862670898*x_16 - 1.16511988639832) - 0.0141234878109397*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.00523121979193878*std::sin(0.352239847183228*x_16 + 8.24815940856934) - 0.0423690290316632*std::sin(0.342879861593246*x_17 + 2.01807975769043) + 0.0008185777930631*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.197204791774915*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.0046161461447553*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.0102353592503789*std::sin(0.326159834861755*x_18 - 1.14807987213135) + 0.00267186736774895*std::sin(0.326719850301743*x_18 - 1.16375982761383) - 0.0631386589569271*std::sin(0.365919858217239*x_18 + 1.99887979030609) + 0.0169224931692969*std::sin(0.345119833946228*x_2 + 5.16480016708374) + 0.0401547948675287*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.0928953506212136*std::sin(0.378879845142365*x_2 - 7.41175985336304) - 0.020209455851903*std::sin(0.311599940061569*x_21 + 1.98407983779907) + 0.0817986417573621*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.0549771647219725*std::sin(0.249279975891113*x_22 - 4.37048006057739) - 0.014321213358802*std::sin(0.277439951896667*x_22 + 8.23896026611328) - 0.0138432955398227*std::sin(0.357919842004776*x_22 + 1.98535978794098) - 0.00577872685745757*std::sin(0.363519847393036*x_22 + 2.02551984786987) + 0.0129636980051924*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.0675145206064772*std::sin(0.306639939546585*x_23 - 1.1671998500824) - 0.00701605697304779*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.00276520927330684*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00502299457540348*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.00158295472981414*std::sin(0.329999834299088*x_24 - 1.14263987541199) + 0.00382804263342508*std::sin(0.269519954919815*x_25 - 7.3997597694397) + 0.0144887345087922*std::sin(0.292479932308197*x_25 - 7.39152002334595) + 0.0461303472607042*std::sin(0.299039930105209*x_25 - 7.3854398727417) + 0.0141103505215544*std::sin(0.33231982588768*x_25 - 1.16279983520508) + 0.00489951898717332*std::sin(0.375679850578308*x_25 - 1.19015979766846) - 0.00598062525398915*std::sin(0.268079966306686*x_26 + 1.99735975265503) - 0.0459363065351766*std::sin(0.279839962720871*x_26 + 2.01703977584839) - 0.0101168410382002*std::sin(0.304159939289093*x_26 + 1.99455988407135) + 0.00396423000069455*std::sin(0.252399981021881*x_27 - 1.16151988506317) + 0.00861088028059068*std::sin(0.256639957427979*x_28 - 1.167839884758) + 0.000462664720418746*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.0776523568796475*std::sin(0.175040021538734*x_29 - 1.19559991359711) + 0.00458703797543461*std::sin(0.343199849128723*x_29 - 1.14407992362976) + 0.0131341234346541*std::sin(0.344559848308563*x_29 - 1.16015994548798) - 0.000290608650993962*std::sin(0.321119844913483*x_3 + 5.1866397857666) + 0.00358339568165095*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.00619778643038751*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.00484609000785052*std::sin(0.352559864521027*x_3 - 7.38783979415894) + 0.0261261340929496*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.0052408290200594*std::sin(0.394879847764969*x_3 + 1.97239983081818) - 0.00443184729745075*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.00189315296772304*std::sin(0.411679863929749*x_3 - 1.17503976821899) + 0.0287483013229876*std::sin(0.288559943437576*x_30 - 1.17079985141754) + 0.194124459880998*std::sin(0.308159917593002*x_30 - 1.16127991676331) + 0.0123503436784498*std::sin(0.344319850206375*x_30 - 1.14927983283997) - 0.00598385646568526*std::sin(0.353439837694168*x_30 + 2.03903985023499) - 0.00476173524995252*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.164737764029039*std::sin(0.359519839286804*x_31 + 5.17639970779419) + 0.0119154157823994*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0148066438836144*std::sin(0.379279851913452*x_31 + 5.17120027542114) - 0.000756783246456334*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 0.000312563472700864*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00144106970434685*std::sin(0.441199868917465*x_31 + 8.22439956665039) - 0.0628759135903404*std::sin(0.296959936618805*x_32 - 1.13887989521027) + 0.0147389455077948*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.00497333327343588*std::sin(0.304719924926758*x_32 - 1.13631987571716) - 0.0250161253271267*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.0148290679492085*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.00373948199524371*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.0026932463507624*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.000898808771369987*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.00413065839015119*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.00672908331358192*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.00473546119629887*std::sin(0.352959841489792*x_5 + 2.00391983985901) + 0.00161086424677504*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.00982045736687412*std::sin(0.210720002651215*x_6 + 2.01455974578857) - 0.000655075161602607*std::sin(0.225599989295006*x_6 - 1.17279982566833) - 0.0100854831745252*std::sin(0.283119946718216*x_6 - 1.15295994281769) - 0.00667025578714651*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.00296357415133169*std::sin(0.321599900722504*x_6 - 1.17895984649658) - 0.0100834511867774*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.00385806517411943*std::sin(0.381839841604233*x_6 + 2.00863981246948) + 0.00638967406666139*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.00110306911498644*std::sin(0.231199979782104*x_61 - 1.15639984607697) + 0.0202333760848795*std::sin(0.321439921855927*x_7 - 7.40119981765747) + 0.00562038572795609*std::sin(0.333679854869843*x_7 + 2.04503989219666) + 0.0351897604297914*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.0976515043390642*std::sin(0.3504798412323*x_7 + 2.00343990325928) + 0.00116367592536013*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.223243487594041*std::sin(0.325679838657379*x_8 - 1.13759982585907) + 0.0171730576244899*std::sin(0.326079845428467*x_8 + 8.27583980560303) + 0.00399399302159927*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.00566000953992269*std::sin(0.352719843387604*x_91 + 1.98895990848541) - 0.00151656446077946*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00208765872342815*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.0225846478401189*std::sin(0.381119847297668*x_91 + 2.00167965888977) - 0.000499015718500461*std::sin(0.279999971389771*x_92 - 1.17543983459473) + 0.00990494857219857*std::sin(0.301919937133789*x_92 + 1.9864798784256) + 0.000247794123113353*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.00166374490097415*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.237465939085942);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000101778537932307*x_1 + 0.000474384478565082*x_10 + 6.22382558817882e-7*x_100 + 0.00134072362238151*x_101 - 9.88921336513105e-5*x_102 + 0.000966569081127729*x_103 - 0.0014944332979536*x_104 - 0.00143739886320973*x_105 - 0.00222982701689124*x_106 - 0.00275764001953365*x_107 - 0.00186458248582534*x_108 + 0.00201574640233045*x_109 + 0.0016708600508082*x_11 + 0.00130918233002698*x_110 - 0.00137507446330108*x_111 - 0.00141634942339113*x_112 + 0.00143944910095352*x_113 + 0.0142845641854172*x_114 - 0.00125575272522622*x_115 - 0.00125342305793021*x_116 + 0.0421701726164106*x_117 + 0.0218486346172256*x_118 + 0.00482179566355708*x_119 + 0.000427254937999199*x_12 + 4.15954032518943e-5*x_120 + 0.00199262976765695*x_13 + 0.00412997096899696*x_14 + 0.00178002520568615*x_15 + 0.000171873849793691*x_16 - 0.000341087104636215*x_17 + 0.000195743991505415*x_18 + 0.000426975916258517*x_19 + 0.00297722364154053*x_2 + 0.00168662854702863*x_20 + 0.000913461439138282*x_21 - 0.014557205888461*x_22 - 0.0199049785686544*x_23 + 0.000146040456032104*x_24 + 0.00134795029845611*x_25 - 1.45997405743176e-5*x_26 + 0.000172478564799875*x_27 + 0.00245987600158038*x_28 + 0.00335492061443766*x_29 + 0.000188185080847292*x_3 + 9.88513893158909e-5*x_30 + 3.2568090444996e-5*x_31 + 0.000407866343784066*x_32 - 0.00249956988640929*x_33 - 0.00541548288836344*x_34 - 0.00192494529923762*x_35 + 0.00259903968359349*x_36 - 0.00156456071431839*x_37 - 0.00379194162922521*x_38 - 0.00230376328249142*x_39 - 4.65329460792425e-6*x_4 - 0.000146493819617565*x_40 - 0.000938912109881319*x_41 - 0.00247669849913209*x_42 - 0.00948720274736368*x_43 - 0.000210963634303648*x_44 - 0.00593306574645951*x_45 - 0.00250430617660852*x_46 - 0.00126744035567837*x_47 - 0.00462111447017748*x_48 - 0.00404170918196567*x_49 + 5.01509386367257e-5*x_5 - 0.000819801353369061*x_50 - 0.00850213693377128*x_51 - 0.0116297446685947*x_52 - 0.00217935800522363*x_53 + 0.000273562873074736*x_54 - 0.00503786579149289*x_55 - 0.00529708766338439*x_56 - 0.00181724759047653*x_57 - 0.000802643255719526*x_58 - 0.00174920836385718*x_59 + 0.000786190128101904*x_6 - 0.000754881908854449*x_60 - 0.000119982390461688*x_61 - 0.000607432640569002*x_62 - 0.00356682537478091*x_63 + 0.00135829602326907*x_64 + 0.000454234409932209*x_65 - 0.000289424952752363*x_66 + 0.00282883423797847*x_67 - 0.000797454817842173*x_68 - 0.000532071834187227*x_69 + 9.80581532358304e-5*x_7 - 0.000431831565408308*x_70 + 0.000312997710099666*x_71 + 0.00129030445039482*x_72 + 0.000713149098548158*x_73 + 0.00301835734124716*x_74 + 0.00116062459306892*x_75 + 0.00192039747584707*x_76 + 0.000284496074658141*x_77 - 0.000209169997412115*x_78 - 0.00088943852952352*x_79 + 0.000218391225916451*x_8 + 0.00123136991109276*x_80 + 0.00546986536791857*x_81 + 0.00219740033993645*x_82 - 0.000659567900924055*x_83 + 0.00118689077709185*x_84 - 0.000553037194642123*x_85 + 0.00028153212062172*x_86 + 0.00107012402395231*x_87 - 0.00101441667809402*x_88 - 0.00084445858508408*x_89 + 0.000529669946280554*x_9 - 0.00094497961164265*x_90 - 0.000216958658350899*x_91 - 0.00683333788022356*x_92 + 0.000880518751250237*x_93 - 0.00398603111915618*x_94 - 0.00355405280825277*x_95 - 0.00198799528044791*x_96 - 0.000641791606348247*x_97 - 0.00313247020484307*x_98 - 0.000983972500670024*x_99 + 4.1169631106733e-7*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) - 0.0121569548946993*std::sin(0.333279848098755*x_1 - 4.25399971008301) + 0.476687317426742*std::sin(0.339599847793579*x_1 - 4.24663972854614) - 0.0115918135775438*std::sin(0.362479835748672*x_1 - 4.21680021286011) - 0.00201208910652187*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 4.81802632194231e-5*std::sin(0.373199850320816*x_1 - 4.20703983306885) - 0.000187112059016569*std::sin(0.387519836425781*x_1 + 8.3884801864624) - 0.000552272667930446*std::sin(0.224879994988441*x_101 + 1.97831988334656) + 0.00230906949019539*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 2.59155841552188e-5*std::sin(0.278799951076508*x_11 + 5.15200042724609) - 0.00256384899841938*std::sin(0.307279914617538*x_11 - 7.46184015274048) - 0.000390984689792597*std::sin(0.316479921340942*x_11 - 4.28007984161377) - 0.000665726248243334*std::sin(0.327039837837219*x_11 + 8.27447986602783) + 0.00186639933094261*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.0076648683971022*std::sin(0.260159969329834*x_113 + 5.17639970779419) - 0.00148199438445244*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00556533798912922*std::sin(0.283439934253693*x_113 - 7.42184019088745) + 9.85375555091318e-5*std::sin(0.284079939126968*x_113 + 5.1561598777771) + 0.00351844776149964*std::sin(0.260399967432022*x_116 - 7.44079971313477) + 0.000978503097664901*std::sin(0.213119998574257*x_118 + 5.19831991195679) - 0.000819607204056046*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 1.36689214129054e-5*std::sin(0.284399926662445*x_12 - 7.44591999053955) + 0.000176168482508919*std::sin(0.297759920358658*x_12 - 7.4475998878479) + 0.00110715931880788*std::sin(0.299919933080673*x_12 - 7.45160007476807) + 0.000724652300049064*std::sin(0.207120001316071*x_120 - 0.981359839439392) + 0.0094359278860617*std::sin(0.269119948148727*x_120 + 5.15200042724609) + 0.237716237754168*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.016668720114275*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 3.1682113531652e-6*std::sin(0.376319825649261*x_13 - 4.56640005111694) - 0.000336414170480507*std::sin(0.27975994348526*x_15 + 5.17375993728638) + 0.000191568208866616*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.00383761641587425*std::sin(0.31143993139267*x_15 + 5.14224004745483) + 0.000683030942380247*std::sin(0.314319908618927*x_15 - 7.44855976104736) - 0.000480223686882866*std::sin(0.343999862670898*x_16 - 1.16511988639832) + 0.000149176427956366*std::sin(0.347039848566055*x_16 - 1.15951991081238) - 0.000326553796829956*std::sin(0.352239847183228*x_16 + 8.24815940856934) - 0.00198590456467169*std::sin(0.342879861593246*x_17 + 2.01807975769043) + 0.00413717440928543*std::sin(0.357919842004776*x_17 + 1.99319982528687) + 0.00091776967636703*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.00342069573590306*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.0165367951309208*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 5.92531300694235e-6*std::sin(0.326719850301743*x_18 - 1.16375982761383) - 0.00295941053867687*std::sin(0.365919858217239*x_18 + 1.99887979030609) + 0.000894941452130095*std::sin(0.345119833946228*x_2 + 5.16480016708374) + 0.000974177402226442*std::sin(0.368799835443497*x_2 + 5.17743968963623) - 0.00043232486953432*std::sin(0.378879845142365*x_2 - 7.41175985336304) + 0.00312161294004634*std::sin(0.311599940061569*x_21 + 1.98407983779907) + 0.00383403395741006*std::sin(0.326479852199554*x_21 - 1.15463984012604) - 0.000255857751834201*std::sin(0.249279975891113*x_22 - 4.37048006057739) - 0.000757373476317596*std::sin(0.277439951896667*x_22 + 8.23896026611328) - 0.00459639187558714*std::sin(0.357919842004776*x_22 + 1.98535978794098) + 6.10366109470011e-5*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 2.87491697138226e-5*std::sin(0.291679948568344*x_23 - 1.16535985469818) + 0.000314205244048048*std::sin(0.306639939546585*x_23 - 1.1671998500824) - 0.000170213399879761*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.00204909880958323*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00811541932288296*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.00117301452870051*std::sin(0.329999834299088*x_24 - 1.14263987541199) + 0.00020244499429842*std::sin(0.269519954919815*x_25 - 7.3997597694397) + 0.00481069709103419*std::sin(0.292479932308197*x_25 - 7.39152002334595) + 0.00216220360222228*std::sin(0.299039930105209*x_25 - 7.3854398727417) + 0.000342324862097805*std::sin(0.33231982588768*x_25 - 1.16279983520508) - 0.000756794343323341*std::sin(0.375679850578308*x_25 - 1.19015979766846) - 0.00198574806477902*std::sin(0.268079966306686*x_26 + 1.99735975265503) - 0.00215310860119524*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.00156267749753707*std::sin(0.304159939289093*x_26 + 1.99455988407135) + 9.61743995118167e-5*std::sin(0.252399981021881*x_27 - 1.16151988506317) + 0.000455384063408099*std::sin(0.256639957427979*x_28 - 1.167839884758) + 0.000342847731995513*std::sin(0.352239847183228*x_28 + 1.79639983177185) + 0.000361385632677291*std::sin(0.175040021538734*x_29 - 1.19559991359711) + 0.00152303503328712*std::sin(0.343199849128723*x_29 - 1.14407992362976) + 0.000694594548301633*std::sin(0.344559848308563*x_29 - 1.16015994548798) - 0.00146876531979961*std::sin(0.321119844913483*x_3 + 5.1866397857666) + 0.0011897955043128*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.0100134760253506*std::sin(0.350879848003387*x_3 - 7.39895963668823) - 0.000302512445430398*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.00403552074116126*std::sin(0.363599836826324*x_3 + 2.00703978538513) - 0.000987068825204316*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 9.82836302181098e-6*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.00140288025574323*std::sin(0.411679863929749*x_3 - 1.17503976821899) + 0.00954530359174891*std::sin(0.288559943437576*x_30 - 1.17079985141754) + 0.009098925790912*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 2.73889538535668e-5*std::sin(0.344319850206375*x_30 - 1.14927983283997) + 0.000924284350432136*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.000735511855551861*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 0.000766671656492633*std::sin(0.359519839286804*x_31 + 5.17639970779419) + 0.00395627761748737*std::sin(0.368639826774597*x_31 + 5.17511987686157) + 0.57748286668068*std::sin(0.379279851913452*x_31 + 5.17120027542114) + 7.99336700359053e-6*std::sin(0.406399875879288*x_31 - 7.58871984481812) - 0.000145649553734165*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00232826947127218*std::sin(0.441199868917465*x_31 + 8.22439956665039) - 0.00294709524057408*std::sin(0.296959936618805*x_32 - 1.13887989521027) + 0.000357574922091099*std::sin(0.301519930362701*x_32 - 1.13487982749939) - 0.193967976691899*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.00386406547030441*std::sin(0.307359933853149*x_32 - 1.14471983909607) + 0.00279293803012378*std::sin(0.307519912719727*x_32 - 1.13815987110138) - 0.00174253849657426*std::sin(0.227999985218048*x_34 + 1.99599981307983) + 0.105040928622367*std::sin(0.347839832305908*x_4 + 1.99647974967957) + 0.0350549840982451*std::sin(0.223999992012978*x_44 + 1.78319990634918) + 0.0019248204083322*std::sin(0.335439831018448*x_5 + 2.00743985176086) + 0.000420056467254816*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.00350911158653809*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 3.57236103447609e-6*std::sin(0.362559854984283*x_5 + 8.22663974761963) + 0.000613032479480454*std::sin(0.210720002651215*x_6 + 2.01455974578857) - 0.00331081568264815*std::sin(0.225599989295006*x_6 - 1.17279982566833) + 0.000106525836558894*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 1.47924084302546e-5*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.00219609283254835*std::sin(0.321599900722504*x_6 - 1.17895984649658) - 0.000533260575572298*std::sin(0.347519844770432*x_6 + 2.03223991394043) + 0.00179779635167289*std::sin(0.381839841604233*x_6 + 2.00863981246948) + 0.000299494304820254*std::sin(0.812399864196777*x_6 + 1.78415989875793) + 0.0430214652068604*std::sin(0.231199979782104*x_61 - 1.15639984607697) + 0.00107003659530204*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 1.24641458853359e-5*std::sin(0.333679854869843*x_7 + 2.04503989219666) - 0.000371684588950504*std::sin(0.343439847230911*x_7 + 2.00559997558594) + 0.000454459492223234*std::sin(0.3504798412323*x_7 + 2.00343990325928) + 0.00588133504219111*std::sin(0.365919858217239*x_7 + 2.01863980293274) - 0.00103895093783564*std::sin(0.325679838657379*x_8 - 1.13759982585907) - 0.000181386880337443*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.000616924096820997*std::sin(0.380799859762192*x_9 - 1.16319990158081) - 0.00914461485045519*std::sin(0.352719843387604*x_91 + 1.98895990848541) - 0.00766486915518475*std::sin(0.363119840621948*x_91 + 2.00071978569031) - 0.0814220395744349*std::sin(0.380799859762192*x_91 + 2.00823974609375) + 0.000105106497426021*std::sin(0.381119847297668*x_91 + 2.00167965888977) - 0.00252207557779685*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 2.1965880985099e-5*std::sin(0.301919937133789*x_92 + 1.9864798784256) + 0.00125237639428225*std::sin(0.222079992294312*x_93 - 7.41519975662231) + 0.000775278378693634*std::sin(0.271759957075119*x_94 - 7.41368007659912) + 0.266680160070362);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0032730852086765*x_1 + 0.00810469123593878*x_10 - 0.0018496394719752*x_100 + 0.00309883257983636*x_101 + 0.000613976272197062*x_102 - 0.00052156000469175*x_103 - 0.0010619817067432*x_104 - 0.00177116273995828*x_105 - 0.00225212309135481*x_106 - 0.00246106313939612*x_107 + 0.000316735358181899*x_108 - 9.3253301059241e-5*x_109 + 0.00110278898121786*x_11 - 6.94772684444198e-5*x_110 - 0.000673266681771364*x_111 - 0.00335746030405316*x_112 - 0.0149474132137859*x_113 - 0.000369756969574605*x_114 + 0.00182005379493639*x_115 - 0.0036247988753648*x_116 - 0.00500731392274327*x_117 - 0.000794952332061857*x_118 - 0.00230764011831105*x_119 + 0.00877394941463768*x_12 - 0.00691983604314917*x_120 - 0.00232460678326806*x_13 + 0.00160368447548948*x_14 + 0.00303086665599738*x_15 - 0.00119312253474804*x_16 - 0.000254015029908577*x_17 + 0.000462348016018637*x_18 - 0.000381083591112647*x_19 - 0.00097590238056197*x_2 + 0.00473126929884549*x_20 - 0.00102160286001375*x_21 + 0.00123081272828951*x_22 - 0.00686541060794582*x_23 + 0.000161982501690388*x_24 + 0.000455123433656385*x_25 + 0.000832170805649119*x_26 + 0.00357910603137856*x_27 + 0.00333318070555691*x_28 - 0.00495710300452936*x_29 + 0.00272612926891524*x_3 - 0.00117668472673127*x_30 - 0.00137878957814044*x_31 + 0.000360300722775516*x_32 + 0.00615722312209748*x_33 + 0.00194607508663654*x_34 - 0.00163626820955742*x_35 - 0.0036369845386199*x_36 + 0.000696298470701028*x_37 + 0.00630307638961677*x_38 + 0.00244657933164769*x_39 + 0.00216509487470889*x_4 - 0.00151226610750279*x_40 + 0.00337745660997933*x_41 - 0.000877171463291177*x_42 + 0.00805968782625715*x_43 - 0.000183696058634605*x_44 + 0.000299517529520782*x_45 - 0.000675507885138103*x_46 - 0.00254326950256735*x_47 + 0.00220184116100893*x_48 - 0.00211583071601083*x_49 + 0.00211986995488348*x_5 + 0.00693893181493997*x_50 + 0.00664514938956522*x_51 + 0.00530470187417243*x_52 + 0.000435785738028654*x_53 + 0.0148992305583824*x_54 + 0.00566717189242383*x_55 + 0.00129328891578214*x_56 + 0.00117720454705395*x_57 + 0.00387874264040416*x_58 + 0.00616118013749284*x_59 + 0.000581068152417687*x_6 + 0.000484979611839457*x_60 - 0.00111100874068355*x_61 - 0.000400045738240147*x_62 + 0.000780805989161437*x_63 + 1.42680322767005e-5*x_64 - 0.000878719786023332*x_65 - 0.00248624279047971*x_66 + 0.000657029467071265*x_67 + 0.00064519517560303*x_68 + 0.00134385280052372*x_69 + 0.00409778228165733*x_7 - 0.000952848031591888*x_70 + 0.000786642863612252*x_71 - 0.000367055727359482*x_72 - 0.00137651238678039*x_73 + 0.000548409946797209*x_74 - 0.000275744278873204*x_75 - 0.000186888696734871*x_76 + 0.00046721629983882*x_77 - 4.81446634028029e-5*x_78 + 7.86728310446984e-5*x_79 + 0.00323524538482959*x_8 - 0.00150112292600422*x_80 - 0.00276974344979967*x_81 - 0.00151949838004292*x_82 - 0.00157664985770414*x_83 + 0.000668007198878077*x_84 + 0.000513464927886132*x_85 + 0.00105370102638156*x_86 - 0.000842066315772867*x_87 - 0.0010101058312383*x_88 + 0.00129835017256993*x_89 + 0.00371014755155277*x_9 + 0.00114502690864487*x_90 - 0.002544582771622*x_91 + 0.000459809273145541*x_92 - 0.00323585986333847*x_93 + 0.00131150607085519*x_94 - 0.000255517504265187*x_95 - 0.000796206037553127*x_96 - 0.000989767803366588*x_97 + 0.00210492090556671*x_98 - 0.00083028731259015*x_99 + 1.50882780952008e-5*std::pow(-5.132080078125*x_1 - 7.67144012451172, 2) + 0.167438801410869*std::exp(0.0102759259447415*x_1 + 0.00196803829441655*x_10 - 0.0021256934803271*x_100 - 0.00648299015620995*x_102 - 0.0013514147986321*x_103 - 0.00668587585899181*x_104 - 0.00521414537912539*x_105 - 0.0125392447821534*x_106 - 0.0384606039238271*x_107 - 0.00226682297776485*x_108 - 0.00896908307358261*x_109 - 0.00197927537964992*x_11 - 0.00905616307473332*x_110 - 0.0290511767961416*x_111 - 0.0183221074812088*x_112 - 0.0210242750303398*x_113 - 0.00603571671665225*x_114 - 0.00237454540469445*x_115 - 0.0159375532545472*x_116 - 0.00559681015989727*x_117 - 0.0120158037625603*x_118 - 0.00756345657356565*x_119 - 0.157502496039224*x_120 - 0.045701601647752*x_13 - 0.00740026500711588*x_14 - 0.00427110664262299*x_15 - 0.0134236625320127*x_16 - 0.0139057754297636*x_17 - 0.0102209051996736*x_18 - 0.00615185243186441*x_19 + 0.0327309938514451*x_2 - 0.0075267526028101*x_20 - 0.0123341908743358*x_22 - 0.00845239131034881*x_23 - 0.0148067463080994*x_24 + 0.00110628832892369*x_27 - 0.00493061445477077*x_28 - 0.00232234407956658*x_29 - 0.00442920316036006*x_33 - 0.00786435998990486*x_34 - 0.00633828915030106*x_35 - 0.00212768182671093*x_36 - 0.00416488797391026*x_37 - 0.00280599201607438*x_38 - 0.00778850459589543*x_39 - 0.0047028596314016*x_4 - 0.00186339324990675*x_40 + 0.020889393968577*x_41 - 0.0152523127107936*x_42 - 0.0105696215701382*x_43 - 0.00390227634382946*x_44 - 0.00496256009701236*x_45 - 0.019259059726689*x_46 - 0.00834562262656012*x_47 - 0.000703813552411795*x_48 - 0.00715076266799219*x_49 - 0.00704535308458134*x_5 - 0.00575131535199929*x_50 - 0.0843393220844361*x_51 + 0.00158720582586961*x_52 + 0.0345343733302426*x_53 - 0.00291840214023814*x_54 + 5.94537254099408e-5*x_55 - 0.0154028108216503*x_56 + 7.26360426126607e-5*x_57 - 0.0157322185467617*x_58 - 0.00760203366719239*x_59 + 0.0198414577254291*x_6 - 0.00508575219502815*x_60 - 0.00537488412888559*x_61 - 0.00868098061390405*x_62 - 0.0124487352115384*x_63 - 0.00373713062598819*x_64 - 0.00155146797102153*x_65 - 0.00918149059048995*x_66 + 0.00857428726408018*x_67 - 0.00289569272413748*x_68 + 0.000763364484194555*x_69 + 0.0246506236168493*x_7 - 0.0184462992873381*x_70 - 0.00194545449631762*x_71 - 0.00227502292291248*x_72 - 0.00386929111027339*x_73 + 0.00853433791110999*x_74 + 0.00216984713600127*x_75 - 0.0017075671920928*x_76 + 0.00697601399601988*x_77 - 0.00248309281312978*x_78 - 0.00188601242800748*x_79 - 0.00761086887134236*x_8 + 0.00383263930387347*x_80 + 0.00282407935432416*x_81 - 0.00304073625979993*x_82 - 0.00201804392885169*x_83 + 0.00025279781871522*x_84 - 0.00356609821471673*x_85 + 0.0053763057991844*x_86 - 0.000358381767977277*x_87 + 0.000543545243063935*x_88 + 0.00129517299921162*x_89 + 0.00401136686187844*x_90 - 0.00795893565023187*x_91 - 0.015756950140613*x_92 - 0.0145549752963827*x_93 + 0.00213991082448723*x_94 - 0.0011342446314796*x_95 - 0.0107831828216585*x_96 - 0.0115095639072277*x_97 - 0.00864594668289776*x_98 - 0.00427399526737108*x_99 - 0.189458087962578*std::sin(0.224879994988441*x_101 + 1.97831988334656) - 0.281167660066728*std::sin(0.280639946460724*x_12 + 5.1448802947998) + 1.07087468441387*std::sin(0.311599940061569*x_21 + 1.98407983779907) - 0.259619600231588*std::sin(0.375679850578308*x_25 - 1.19015979766846) + 0.536079201411439*std::sin(0.304159939289093*x_26 + 1.99455988407135) - 1.38439232638257*std::sin(0.363599836826324*x_3 + 2.00703978538513) + 0.317077335046861*std::sin(0.353439837694168*x_30 + 2.03903985023499) + 0.252318606221905*std::sin(0.350719839334488*x_31 + 5.17671966552734) + 1.32557430102315*std::sin(0.307359933853149*x_32 - 1.14471983909607) - 0.211636871764341*std::sin(0.380799859762192*x_9 - 1.16319990158081)) - 0.17644075065296*std::sin(0.333279848098755*x_1 - 4.25399971008301) - 0.0321967549786051*std::sin(0.339599847793579*x_1 - 4.24663972854614) + 0.0205833331671208*std::sin(0.362479835748672*x_1 - 4.21680021286011) + 0.0515796804429126*std::sin(0.367519825696945*x_1 + 8.36279964447021) + 0.00367015012669478*std::sin(0.373199850320816*x_1 - 4.20703983306885) + 0.00450453051780306*std::sin(0.387519836425781*x_1 + 8.3884801864624) + 0.0335128292972084*std::sin(0.247599974274635*x_108 - 7.41831970214844) + 0.00197412961480671*std::sin(0.278799951076508*x_11 + 5.15200042724609) + 0.0657239838999723*std::sin(0.307279914617538*x_11 - 7.46184015274048) + 0.00941255457516269*std::sin(0.316479921340942*x_11 - 4.28007984161377) + 0.00486888621080288*std::sin(0.327039837837219*x_11 + 8.27447986602783) - 0.0136501842765806*std::sin(0.277519941329956*x_112 + 1.97351980209351) + 0.00734794267559914*std::sin(0.260159969329834*x_113 + 5.17639970779419) - 0.0215090212903786*std::sin(0.268879950046539*x_113 - 4.22904014587402) + 0.00601370400524409*std::sin(0.283439934253693*x_113 - 7.42184019088745) + 0.00298115259035564*std::sin(0.284079939126968*x_113 + 5.1561598777771) + 0.0510652190083309*std::sin(0.260399967432022*x_116 - 7.44079971313477) - 0.0250838180706621*std::sin(0.213119998574257*x_118 + 5.19831991195679) + 0.00104123535869625*std::sin(0.284399926662445*x_12 - 7.44591999053955) - 0.00424107516056038*std::sin(0.297759920358658*x_12 - 7.4475998878479) - 0.00809737148674845*std::sin(0.299919933080673*x_12 - 7.45160007476807) + 0.0105172879960918*std::sin(0.207120001316071*x_120 - 0.981359839439392) - 0.0167551734782891*std::sin(0.269119948148727*x_120 + 5.15200042724609) - 0.016055999775121*std::sin(0.270399957895279*x_120 + 5.14656019210815) + 0.0159795046085337*std::sin(0.270559966564178*x_120 + 5.14432001113892) - 0.000241339721334847*std::sin(0.376319825649261*x_13 - 4.56640005111694) + 0.00809882540716766*std::sin(0.27975994348526*x_15 + 5.17375993728638) + 0.00579569950910316*std::sin(0.304639935493469*x_15 + 5.14416027069092) - 0.00414679023193421*std::sin(0.31143993139267*x_15 + 5.14224004745483) - 0.0268979443865294*std::sin(0.314319908618927*x_15 - 7.44855976104736) + 0.0115608917153983*std::sin(0.343999862670898*x_16 - 1.16511988639832) + 0.00451317969401939*std::sin(0.347039848566055*x_16 - 1.15951991081238) + 0.0128597773853886*std::sin(0.352239847183228*x_16 + 8.24815940856934) + 0.050908442625065*std::sin(0.342879861593246*x_17 + 2.01807975769043) - 0.00734629130007559*std::sin(0.357919842004776*x_17 + 1.99319982528687) - 0.0220943617276075*std::sin(0.359039843082428*x_17 + 1.99607980251312) - 0.00369628074483581*std::sin(0.289999932050705*x_18 - 1.16223990917206) - 0.0158530344377565*std::sin(0.326159834861755*x_18 - 1.14807987213135) - 0.000451363002814996*std::sin(0.326719850301743*x_18 - 1.16375982761383) + 0.0758641599865355*std::sin(0.365919858217239*x_18 + 1.99887979030609) + 0.0171306332093814*std::sin(0.345119833946228*x_2 + 5.16480016708374) + 0.0357026749176992*std::sin(0.368799835443497*x_2 + 5.17743968963623) + 0.0104077769153838*std::sin(0.378879845142365*x_2 - 7.41175985336304) - 0.0982850340422221*std::sin(0.326479852199554*x_21 - 1.15463984012604) + 0.00615951241951532*std::sin(0.249279975891113*x_22 - 4.37048006057739) - 0.0144973586757325*std::sin(0.277439951896667*x_22 + 8.23896026611328) + 0.00119611456722409*std::sin(0.357919842004776*x_22 + 1.98535978794098) + 0.00184660000840308*std::sin(0.363519847393036*x_22 + 2.02551984786987) - 0.00218997908722549*std::sin(0.291679948568344*x_23 - 1.16535985469818) - 0.00756416832836444*std::sin(0.306639939546585*x_23 - 1.1671998500824) - 0.00623815915731008*std::sin(0.308479934930801*x_23 - 4.34592008590698) - 0.00221418245260242*std::sin(0.321359902620316*x_23 - 1.14807987213135) - 0.00777986429558766*std::sin(0.283759921789169*x_24 - 1.16415989398956) - 0.00126751729782353*std::sin(0.329999834299088*x_24 - 1.14263987541199) + 0.00387512605896973*std::sin(0.269519954919815*x_25 - 7.3997597694397) - 0.00125188300406904*std::sin(0.292479932308197*x_25 - 7.39152002334595) - 0.0554278488430986*std::sin(0.299039930105209*x_25 - 7.3854398727417) + 0.0125458804934208*std::sin(0.33231982588768*x_25 - 1.16279983520508) + 0.000516749278871232*std::sin(0.268079966306686*x_26 + 1.99735975265503) + 0.0551946995033989*std::sin(0.279839962720871*x_26 + 2.01703977584839) + 0.00352470023768543*std::sin(0.252399981021881*x_27 - 1.16151988506317) + 0.00871679073650488*std::sin(0.256639957427979*x_28 - 1.167839884758) + 0.000370468924460213*std::sin(0.352239847183228*x_28 + 1.79639983177185) - 0.0086999876953215*std::sin(0.175040021538734*x_29 - 1.19559991359711) - 0.000396337918745157*std::sin(0.343199849128723*x_29 - 1.14407992362976) + 0.0132956680103153*std::sin(0.344559848308563*x_29 - 1.16015994548798) + 0.00260805487592683*std::sin(0.321119844913483*x_3 + 5.1866397857666) - 0.000309619321686859*std::sin(0.326239854097366*x_3 - 7.39215993881226) - 0.00959944046078854*std::sin(0.350879848003387*x_3 - 7.39895963668823) + 0.0119130224248171*std::sin(0.352559864521027*x_3 - 7.38783979415894) - 0.0143258871957419*std::sin(0.394879847764969*x_3 + 1.97239983081818) + 0.000748679342522982*std::sin(0.39711982011795*x_3 + 1.98215973377228) - 0.00151590193251873*std::sin(0.411679863929749*x_3 - 1.17503976821899) - 0.00248396502815785*std::sin(0.288559943437576*x_30 - 1.17079985141754) - 0.233249950585086*std::sin(0.308159917593002*x_30 - 1.16127991676331) - 0.00208636411963773*std::sin(0.344319850206375*x_30 - 1.14927983283997) - 0.0184568321889926*std::sin(0.359519839286804*x_31 + 5.17639970779419) - 0.00102953825921442*std::sin(0.368639826774597*x_31 + 5.17511987686157) - 0.0390047598984375*std::sin(0.379279851913452*x_31 + 5.17120027542114) + 0.000241831113277504*std::sin(0.406399875879288*x_31 - 7.58871984481812) + 0.00106522929756356*std::sin(0.432479858398438*x_31 + 2.00671982765198) - 0.00223200056699257*std::sin(0.441199868917465*x_31 + 8.22439956665039) + 0.0755484586894895*std::sin(0.296959936618805*x_32 - 1.13887989521027) + 0.013104780682618*std::sin(0.301519930362701*x_32 - 1.13487982749939) + 0.0131011235057761*std::sin(0.304719924926758*x_32 - 1.13631987571716) + 0.0405354866272559*std::sin(0.307519912719727*x_32 - 1.13815987110138) + 0.0127443099624674*std::sin(0.227999985218048*x_34 + 1.99599981307983) - 0.00709474936282368*std::sin(0.347839832305908*x_4 + 1.99647974967957) - 0.00236770875273716*std::sin(0.223999992012978*x_44 + 1.78319990634918) - 0.0140774553641681*std::sin(0.335439831018448*x_5 + 2.00743985176086) - 0.0165419379919278*std::sin(0.349999845027924*x_5 + 2.03919982910156) - 0.00379181973206884*std::sin(0.352959841489792*x_5 + 2.00391983985901) - 0.000272125979129072*std::sin(0.362559854984283*x_5 + 8.22663974761963) - 0.0241413858686094*std::sin(0.210720002651215*x_6 + 2.01455974578857) + 0.0058789439456561*std::sin(0.225599989295006*x_6 - 1.17279982566833) + 0.00322282983332095*std::sin(0.283119946718216*x_6 - 1.15295994281769) + 0.00112681741540452*std::sin(0.283759921789169*x_6 - 1.15247988700867) + 0.00237301890537114*std::sin(0.321599900722504*x_6 - 1.17895984649658) - 0.0102074736882617*std::sin(0.347519844770432*x_6 + 2.03223991394043) - 0.0131484463615326*std::sin(0.381839841604233*x_6 + 2.00863981246948) - 0.00767750319159787*std::sin(0.812399864196777*x_6 + 1.78415989875793) - 0.00290578650500543*std::sin(0.231199979782104*x_61 - 1.15639984607697) + 0.02048223868847*std::sin(0.321439921855927*x_7 - 7.40119981765747) - 0.000949461118381072*std::sin(0.333679854869843*x_7 + 2.04503989219666) - 0.0112449356940094*std::sin(0.343439847230911*x_7 + 2.00559997558594) - 0.0109406452079262*std::sin(0.3504798412323*x_7 + 2.00343990325928) - 0.0104433596892379*std::sin(0.365919858217239*x_7 + 2.01863980293274) + 0.0250116760543281*std::sin(0.325679838657379*x_8 - 1.13759982585907) - 0.00548767386587323*std::sin(0.326079845428467*x_8 + 8.27583980560303) - 0.0087665048152661*std::sin(0.352719843387604*x_91 + 1.98895990848541) + 0.0136103427171389*std::sin(0.363119840621948*x_91 + 2.00071978569031) + 0.00549946550327353*std::sin(0.380799859762192*x_91 + 2.00823974609375) - 0.00253033090311393*std::sin(0.381119847297668*x_91 + 2.00167965888977) + 0.004478395165966*std::sin(0.279999971389771*x_92 - 1.17543983459473) - 0.00167325945301029*std::sin(0.301919937133789*x_92 + 1.9864798784256) - 0.0022238177315142*std::sin(0.222079992294312*x_93 - 7.41519975662231) - 0.0056701117276291*std::sin(0.271759957075119*x_94 - 7.41368007659912) - 0.00838433683660289);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
