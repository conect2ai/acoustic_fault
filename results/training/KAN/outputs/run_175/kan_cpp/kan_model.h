
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000211390793924922*x_1 - 0.000909646984340496*x_10 + 0.000617148332541261*x_100 - 1.56754708820424e-5*x_101 + 0.000918326243525033*x_102 + 0.00100514061573235*x_103 + 0.00120781414326289*x_104 - 0.000572245845288672*x_105 + 0.000235382919042283*x_106 - 0.00140918827016654*x_107 - 0.00148579042891955*x_108 - 0.000490626742056068*x_109 - 0.00131200017128294*x_11 + 0.00135362972966706*x_110 - 0.000778687264193671*x_111 - 0.00183847669838178*x_112 + 0.00111713035755277*x_113 - 0.00163828009900334*x_114 + 0.000479637838955865*x_115 - 0.000447953034285672*x_116 + 0.00110703600013889*x_117 - 0.000309587610353682*x_118 - 0.00216468274329705*x_119 + 7.98415459885283e-5*x_12 + 0.000612295605826914*x_120 + 0.000458155587704042*x_13 + 0.00077359532380384*x_14 + 0.000298768556627409*x_15 + 9.48345478785411e-6*x_16 - 0.000141981705590698*x_17 + 0.000147774811383942*x_18 - 0.000814900962046793*x_19 + 8.66158160377887e-5*x_2 + 2.08038727912479e-5*x_20 + 0.000565366887160994*x_21 - 0.000513450844346209*x_22 - 0.000541276201156287*x_23 + 0.000302203191713147*x_24 + 0.00076424200397608*x_25 + 0.000175680987435953*x_26 + 0.000261002328211147*x_27 + 0.00160126766948551*x_28 + 0.00401900692979767*x_29 - 0.000569144757355479*x_3 + 0.00132768837994832*x_30 - 4.24083164643303e-6*x_31 + 0.000699416445311502*x_32 + 0.000780627584532808*x_33 + 0.00143052046441854*x_34 - 0.000213395625191089*x_35 + 0.002197463324807*x_36 + 0.000163923745612237*x_37 + 0.00205780352548066*x_38 + 0.000964516383088499*x_39 + 0.000100862927190836*x_4 + 0.000205011327503149*x_40 - 0.000162409646253633*x_41 + 0.00110587828666952*x_42 - 0.00111929690335683*x_43 + 0.000527100156588688*x_44 - 0.000503690542115221*x_45 + 0.00049046706718276*x_46 + 0.000626147939665745*x_47 + 0.000407857699482073*x_48 + 0.000345268701615139*x_49 - 0.000480342361363595*x_5 + 0.00148856120884817*x_50 + 0.00169602879587296*x_51 - 0.000701372545606984*x_52 - 0.00026742059881006*x_53 + 6.36075858026739e-5*x_54 - 0.00163436463233476*x_55 - 0.00217547850264323*x_56 + 0.000420447847107762*x_57 + 0.00125585542550698*x_58 + 0.00133311758581881*x_59 - 0.000352542749484415*x_6 + 0.00135629928035649*x_60 + 0.00014640129307056*x_61 - 0.000601429490164969*x_62 + 0.000540199159750435*x_63 + 0.000489159683320285*x_64 - 0.00031125390943439*x_65 - 0.000454500149202097*x_66 + 0.000274590067682328*x_67 - 0.00101839971245838*x_68 - 0.000276524332107283*x_69 - 0.00069627767651229*x_7 - 0.000359150339036586*x_70 + 1.32009457501992e-6*x_71 + 0.000736882560980243*x_72 - 0.000449430430080409*x_73 + 0.000142829411264774*x_74 - 7.64574434748587e-5*x_75 + 0.000285158210127508*x_76 + 0.000105599865679073*x_77 + 0.000383931703497184*x_78 - 0.000399702349246794*x_79 + 3.16972112587836e-5*x_8 + 0.000755615591316827*x_80 + 0.000267627178759763*x_81 - 0.00024514128053197*x_82 - 0.000306864997371818*x_83 - 3.33557549655659e-5*x_84 + 0.0005812785055893*x_85 - 0.00062545588587621*x_86 + 0.000740025260909616*x_87 + 0.000400331952496428*x_88 - 2.62825936416463e-5*x_89 - 0.00092347116480648*x_9 + 0.000244451624843254*x_90 + 0.00013943131072661*x_91 + 0.000233047125557723*x_92 - 0.000423932913879123*x_93 - 5.81581463281699e-5*x_94 + 0.000481932920161173*x_95 + 0.00186254616794303*x_96 + 0.000861242475060975*x_97 + 8.48107992368265e-5*x_98 + 0.00303521485288091*x_99 + 9.6490382609446e-7*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) - 0.0279388168702692*std::sin(0.151120036840439*x_1 + 4.9399995803833) + 0.0166363365396292*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.0105600786871677*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.000464003046300633*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.00184889496534897*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.0107384497157666*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.00553069089196169*std::sin(0.260159969329834*x_113 + 5.18175983428955) - 0.00757749754073824*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.00596743442178317*std::sin(0.250319957733154*x_116 + 5.15336036682129) + 0.00622519290070883*std::sin(0.233919993042946*x_118 + 5.16031980514526) - 0.0079556407463751*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00232684789450125*std::sin(0.292479932308197*x_12 + 5.13503980636597) - 0.023059502018739*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.0167080163725903*std::sin(0.284959942102432*x_13 + 1.96391975879669) + 0.00301550251472481*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.0388146501821149*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.0013720210993125*std::sin(0.317359924316406*x_16 - 1.18911993503571) - 0.00729929665488043*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.057527762858994*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.0542489994139325*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.000148202150416043*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.013571865063719*std::sin(0.296639919281006*x_18 - 1.14375984668732) + 0.0124209737659859*std::sin(0.34623983502388*x_18 + 2.01407980918884) + 0.00725374020495974*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.0107959993741786*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.0388110908527674*std::sin(0.377999842166901*x_2 + 5.174880027771) - 0.00209286859904048*std::sin(0.389039844274521*x_2 + 5.18200016021729) - 0.0099726220362765*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.000253276047460767*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.00140382587035008*std::sin(0.319359928369522*x_23 + 5.05087995529175) + 0.00634560832294379*std::sin(0.234959989786148*x_26 + 8.20392036437988) + 0.00145731460734174*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.00331627196655025*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.00579437432139404*std::sin(0.225999996066093*x_29 + 2.00271987915039) + 0.00322876561530056*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00360494529020489*std::sin(0.352239847183228*x_3 - 7.39423990249634) - 0.00260689174889101*std::sin(0.361839860677719*x_3 - 7.40983963012695) + 0.0222207248228895*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.00162019400633507*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.00913548004447175*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.0177404301617887*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.00629584984358967*std::sin(0.38239985704422*x_31 - 7.39735984802246) + 0.00812535977902898*std::sin(0.385359823703766*x_31 - 7.40199947357178) - 0.00619616041400561*std::sin(0.392639845609665*x_31 - 7.41215991973877) + 0.00253525360382677*std::sin(0.285599917173386*x_32 - 1.1373598575592) + 0.00211688076752834*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.00729331079457456*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.0237954909538375*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.0107359721955194*std::sin(0.359679847955704*x_4 - 1.1697598695755) + 0.00103683510351425*std::sin(0.244479969143867*x_41 - 1.19223988056183) + 0.00524548182873731*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.00911448010116171*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.024963955179329*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00143409566181942*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.00720622246787402*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.000699457476467925*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.00932156649448007*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.000545347314252502*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.0947244877146136*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 5.79261449379471e-5*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.0137511407097059*std::sin(0.348079830408096*x_8 + 8.25920009613037) - 0.00545239116834027*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.0264689582717752*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.0180403101680183*std::sin(0.23871998488903*x_93 + 1.96887981891632) - 0.00318259988609955*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.0210987150496709*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00394257199353682*std::sin(0.294399946928024*x_94 + 1.96591985225677) - 0.324833547863303);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000690373350743443*x_1 + 0.00236405635356018*x_10 + 0.000937556306247984*x_100 + 0.000129433158818379*x_101 - 0.00138344284187749*x_102 - 0.00232227622500608*x_103 - 0.00371499664461688*x_104 + 0.00228701480383062*x_105 + 0.000673462754411905*x_106 + 0.00264363416122847*x_107 + 0.003622589594911*x_108 + 0.00109983924023113*x_109 + 0.00260239625835946*x_11 - 0.00173516347984642*x_110 + 0.00242682186981139*x_111 + 0.00120235800930017*x_112 - 0.00144702340150309*x_113 + 0.0039386158200888*x_114 - 0.00122213184903047*x_115 - 0.00033328835969128*x_116 - 0.00110246947459898*x_117 - 0.00122686587200202*x_118 + 0.00702335178452494*x_119 + 0.000115293454638259*x_12 + 3.44722147865543e-5*x_120 - 0.00350006560515502*x_13 - 0.00403541140397334*x_14 - 0.00213188600336665*x_15 - 5.17715683025599e-5*x_16 - 0.000935249383180966*x_17 - 0.00133103036002154*x_18 + 0.00253719860245432*x_19 + 0.000154750482855438*x_2 - 0.0010154181524842*x_20 - 0.00216281923949893*x_21 - 0.00201720100317347*x_22 - 0.000105694007729506*x_23 - 0.00297311386022932*x_24 - 0.00458861118151281*x_25 - 0.00233069221324023*x_26 - 0.00249738493950498*x_27 - 0.00281126440979876*x_28 - 0.00678512703976048*x_29 + 0.000920865882169931*x_3 - 0.00226631687883875*x_30 - 9.55162401090389e-5*x_31 - 0.0016796372966142*x_32 - 0.000286593215283364*x_33 - 0.00249947333585473*x_34 + 0.000364815554636493*x_35 - 0.00249278508362609*x_36 - 0.000208094661006922*x_37 - 0.00594275524387941*x_38 - 0.000337216728477258*x_39 - 0.00124509174409998*x_4 + 0.00115785865398409*x_40 - 9.49899062812914e-5*x_41 - 0.00270303748319813*x_42 + 0.000708660743404035*x_43 - 0.000713527544453004*x_44 + 0.00206692536607399*x_45 + 0.00119424218868492*x_46 - 0.00199997056415059*x_47 - 0.00112603763677668*x_48 - 0.00124945945563086*x_49 + 0.00388370843836589*x_5 - 0.00269518586029549*x_50 - 0.0130145304039194*x_51 - 0.000741245210673975*x_52 + 0.000165442253780079*x_53 + 0.00033714412623982*x_54 + 0.00273088346248436*x_55 + 0.00532100831160406*x_56 + 1.44733747470434e-5*x_57 - 0.00291132003505308*x_58 - 0.00181816477146537*x_59 + 0.000134561978571559*x_6 - 0.00184408971944742*x_60 - 0.000702646126346589*x_61 + 0.000996344345301038*x_62 - 0.000731227813585323*x_63 - 0.000200205019805132*x_64 + 0.00100479707170756*x_65 + 0.00132909782944423*x_66 + 0.0004982387401212*x_67 + 0.00161380290702257*x_68 - 8.33191364575977e-5*x_69 - 0.00136307890375454*x_7 + 0.000110012075190366*x_70 - 0.000949875713584878*x_71 - 0.00271205508750142*x_72 + 0.000225379308191615*x_73 - 0.00158539211602283*x_74 - 0.000257036980612335*x_75 - 0.000233384507346106*x_76 + 0.000551911399878134*x_77 - 0.000100350666888785*x_78 + 0.00101524176719581*x_79 - 0.000669459608530933*x_8 - 0.00241076134548388*x_80 - 0.000798126379167042*x_81 - 0.000355340668358187*x_82 + 0.000297952623852785*x_83 + 0.000761324216666447*x_84 - 0.00163778057271827*x_85 + 0.00117590343187525*x_86 - 0.00203081664127446*x_87 + 0.000485930255547955*x_88 - 4.96710243651565e-5*x_89 + 0.0017843348183956*x_9 - 0.000619175073957063*x_90 - 0.00123773657755705*x_91 + 0.00139057880960727*x_92 + 0.00170761430404081*x_93 - 9.53068415688994e-6*x_94 - 0.000522668213190218*x_95 - 0.00270894183624953*x_96 - 0.000807118307116573*x_97 + 0.000252641425754597*x_98 - 0.0047334426890292*x_99 - 7.8803297204621e-6*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) + 0.00427732372534175*std::sin(0.151120036840439*x_1 + 4.9399995803833) + 0.0193599177027386*std::sin(0.329999834299088*x_1 - 4.25616025924683) - 0.086243726761593*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.0104507394013281*std::sin(0.263279944658279*x_11 + 1.97639977931976) - 0.0150998488672444*std::sin(0.29479992389679*x_11 - 1.08255982398987) + 0.0877004755897397*std::sin(0.279519945383072*x_112 - 7.44312000274658) + 0.0451689242305358*std::sin(0.260159969329834*x_113 + 5.18175983428955) + 0.00116008527348231*std::sin(0.278319954872131*x_113 + 5.16416025161743) + 0.0487357906116157*std::sin(0.250319957733154*x_116 + 5.15336036682129) + 0.00724433663350756*std::sin(0.233919993042946*x_118 + 5.16031980514526) - 0.00925808093359294*std::sin(0.269359946250916*x_12 - 4.25047969818115) - 0.019003270711705*std::sin(0.292479932308197*x_12 + 5.13503980636597) + 0.00353031968165687*std::sin(0.269039958715439*x_120 + 5.14904022216797) - 0.0291179989856553*std::sin(0.284959942102432*x_13 + 1.96391975879669) + 0.0035091788614884*std::sin(0.286239922046661*x_13 + 5.15136003494263) - 0.0676444719365669*std::sin(0.285599917173386*x_15 + 8.3473596572876) - 0.0112052396867114*std::sin(0.317359924316406*x_16 - 1.18911993503571) + 0.00111749380459456*std::sin(0.324959844350815*x_16 - 1.13615989685059) + 0.100256864921632*std::sin(0.329759836196899*x_16 - 1.13863980770111) - 0.0945427796263767*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.00333795664718759*std::sin(0.380799859762192*x_17 + 2.00471973419189) + 0.0236524518737679*std::sin(0.296639919281006*x_18 - 1.14375984668732) - 0.00190160256347989*std::sin(0.34623983502388*x_18 + 2.01407980918884) - 0.00111051929006902*std::sin(0.306159913539886*x_19 + 1.98039984703064) - 0.0881704812745775*std::sin(0.361359834671021*x_2 + 5.1780800819397) + 0.0676382688933079*std::sin(0.377999842166901*x_2 + 5.174880027771) - 0.00243549796817063*std::sin(0.389039844274521*x_2 + 5.18200016021729) + 0.00152676947766616*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.00570453575620687*std::sin(0.291999936103821*x_23 + 2.00887989997864) - 0.0114649879390056*std::sin(0.319359928369522*x_23 + 5.05087995529175) - 0.000971487846371072*std::sin(0.234959989786148*x_26 + 8.20392036437988) + 0.00169589565574897*std::sin(0.319119930267334*x_26 - 1.20175993442535) - 0.0270838562687831*std::sin(0.301679939031601*x_28 - 1.19359982013702) + 0.0473224159149451*std::sin(0.225999996066093*x_29 + 2.00271987915039) - 0.000494311403164285*std::sin(0.341999858617783*x_3 - 4.2087197303772) + 0.029441439387826*std::sin(0.352239847183228*x_3 - 7.39423990249634) - 0.00303367328487594*std::sin(0.361839860677719*x_3 - 7.40983963012695) - 0.00340190616949056*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.0364916253778881*std::sin(0.335759848356247*x_30 - 1.15191984176636) - 0.0746090884482529*std::sin(0.368719846010208*x_30 - 1.15703988075256) + 0.0309172445092574*std::sin(0.367359846830368*x_31 + 8.36415958404541) - 0.051417945805875*std::sin(0.38239985704422*x_31 - 7.39735984802246) + 0.00945558514354569*std::sin(0.385359823703766*x_31 - 7.40199947357178) + 0.000948607955301517*std::sin(0.392639845609665*x_31 - 7.41215991973877) - 0.000388137423276004*std::sin(0.285599917173386*x_32 - 1.1373598575592) + 0.00246344123588957*std::sin(0.293199926614761*x_32 + 2.02391982078552) + 0.0595641682214934*std::sin(0.231999978423119*x_33 - 7.41767978668213) + 0.0414697391961909*std::sin(0.229999989271164*x_37 + 1.9883998632431) + 0.0187101820184949*std::sin(0.359679847955704*x_4 - 1.1697598695755) + 0.00120657827686586*std::sin(0.244479969143867*x_41 - 1.19223988056183) - 0.000803062777535969*std::sin(0.360559850931168*x_5 + 2.01591968536377) + 0.0158843166311344*std::sin(0.371839851140976*x_5 - 1.16791987419128) - 0.043506087460037*std::sin(0.19336000084877*x_53 + 1.98367977142334) + 0.0117122000765235*std::sin(0.242479979991913*x_57 - 4.42295980453491) - 0.0588529214519771*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.0157538789177274*std::sin(0.385039836168289*x_6 + 2.00575971603394) - 0.0162452177253228*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.0122828561361954*std::sin(0.360079854726791*x_7 - 1.15847992897034) + 0.165081687477615*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 0.00130467041131842*std::sin(0.339919835329056*x_8 - 1.13207995891571) - 0.0239648856158466*std::sin(0.348079830408096*x_8 + 8.25920009613037) - 0.00634501736910401*std::sin(0.360959857702255*x_91 + 2.01151990890503) - 0.0461289409180423*std::sin(0.277999937534332*x_92 + 2.01671981811523) + 0.0314398622469045*std::sin(0.23871998488903*x_93 + 1.96887981891632) - 0.00370363221066494*std::sin(0.242879971861839*x_93 + 1.95855975151062) + 0.0367699162913677*std::sin(0.293279945850372*x_94 + 1.96727979183197) - 0.0321988227380998*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 0.676592857348474);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000823612341250912*x_1 + 0.00362377388527986*x_10 - 0.00314236273633442*x_100 - 0.000443820632988879*x_101 - 0.00170322239132734*x_102 - 0.00231181972865009*x_103 - 0.00142222799898982*x_104 + 0.000731036993804964*x_105 + 0.000163790664290624*x_106 + 0.00361645890055007*x_107 + 0.00419184199483005*x_108 + 0.000654111789416427*x_109 + 0.00403348645200861*x_11 - 0.00211788951847795*x_110 + 0.00112839322375353*x_111 + 0.00016867163697925*x_112 - 0.0026045317135044*x_113 - 0.00282466121947552*x_114 - 0.00105502677904922*x_115 - 0.00218473212430596*x_116 - 0.00406324989986185*x_117 - 0.00399149433278034*x_118 - 0.00392077521284637*x_119 + 0.000481503878575055*x_12 - 0.00135411975564232*x_120 + 0.000155619121093186*x_13 + 0.00122017872994692*x_14 + 0.000127367303380894*x_15 - 5.77128794437175e-5*x_16 - 0.000304167238368278*x_17 - 0.00032684202431525*x_18 + 0.001522184903502*x_19 + 0.000219731029091647*x_2 - 0.00257517069861717*x_20 - 0.000903462395907941*x_21 + 0.00100410617474096*x_22 + 0.000508297574457035*x_23 - 0.00182317179206603*x_24 - 0.00459740551026241*x_25 + 0.000236676694303629*x_26 - 0.000942955727773994*x_27 - 0.00461206564970739*x_28 - 0.0106203165731859*x_29 + 0.00144415991541577*x_3 - 0.00347107165420228*x_30 - 7.36535277325448e-5*x_31 - 0.00144008620995642*x_32 - 0.00140845829416843*x_33 - 0.00316130343831495*x_34 + 0.0008552198225764*x_35 - 0.00699843695375723*x_36 + 0.000123441166153736*x_37 - 0.00360678224197947*x_38 - 0.000948837279230073*x_39 - 0.000117631446019538*x_4 - 0.00234860752283354*x_40 + 0.000220988461724676*x_41 - 0.0019827494003998*x_42 + 0.00446440514001502*x_43 - 0.00123555812859082*x_44 + 0.00142478385328014*x_45 - 0.0011038127513598*x_46 - 0.00262370393565409*x_47 - 0.000494571910052726*x_48 - 6.26520396728256e-6*x_49 - 0.000374026584208352*x_5 - 0.00336480333655367*x_50 + 0.00133753432454582*x_51 + 0.00163863073482021*x_52 + 0.000488255055570398*x_53 + 0.000947840594649036*x_54 + 0.00498205002883169*x_55 + 0.00560302258342154*x_56 - 0.000440126079501675*x_57 - 0.00156328280521508*x_58 - 0.00140559431381653*x_59 - 0.000508333132361161*x_6 - 0.00327867959782399*x_60 - 0.000970310207259087*x_61 + 0.00114358491044555*x_62 - 0.000311137718810103*x_63 - 0.00165744234067568*x_64 + 0.00059433564498276*x_65 + 0.000612032022606128*x_66 - 0.0011122143189888*x_67 + 0.00232790935379637*x_68 + 0.0015692959616738*x_69 - 0.000186156644688984*x_7 + 0.000899525581907668*x_70 + 0.000625077618593072*x_71 - 0.000871022856551524*x_72 + 0.00099919172120388*x_73 + 0.000221547265949299*x_74 + 0.000321073307931589*x_75 - 0.000338674983412148*x_76 - 0.0011897313677348*x_77 - 0.00105030269271162*x_78 + 0.000946601224169443*x_79 + 9.10674587753772e-5*x_8 - 0.00149385445482451*x_80 - 0.00118607089415848*x_81 + 0.000821736576007952*x_82 + 0.000773820486984599*x_83 - 0.000666675815193774*x_84 - 0.000218321046052675*x_85 + 0.00233619245536374*x_86 - 0.000466122759389069*x_87 - 0.00106275584239634*x_88 - 0.000114161072100596*x_89 + 0.00243700576967313*x_9 - 0.000561202997613289*x_90 - 0.00112492511227134*x_91 + 0.0010050659689205*x_92 - 0.000350071057078592*x_93 - 4.78632309605403e-5*x_94 - 0.000714804095749801*x_95 - 0.00424664024892897*x_96 - 0.00186810377983099*x_97 - 0.00101569560520879*x_98 - 0.00442740906631765*x_99 + 4.74954533558364e-7*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) - 0.0321166184499031*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.00889482391473073*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.00519798669210828*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.00805866964028953*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.000910081421710274*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.00528578624932574*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.00272237153777231*std::sin(0.260159969329834*x_113 + 5.18175983428955) - 0.00871059066140851*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.00293734977071247*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.003328376686486*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.00425358211522697*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00114534415400475*std::sin(0.292479932308197*x_12 + 5.13503980636597) - 0.0265076803867348*std::sin(0.269039958715439*x_120 + 5.14904022216797) - 0.0441142117562596*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.00161227586488238*std::sin(0.286239922046661*x_13 + 5.15136003494263) - 0.102482404804676*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.000675349836567449*std::sin(0.317359924316406*x_16 - 1.18911993503571) - 0.00839078929884515*std::sin(0.324959844350815*x_16 - 1.13615989685059) + 0.151890676668765*std::sin(0.329759836196899*x_16 - 1.13863980770111) - 0.143233750455106*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.00257393174399458*std::sin(0.380799859762192*x_17 + 2.00471973419189) + 0.035833824674153*std::sin(0.296639919281006*x_18 - 1.14375984668732) + 0.0142783310070274*std::sin(0.34623983502388*x_18 + 2.01407980918884) + 0.00833842061312632*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.00531411391310765*std::sin(0.361359834671021*x_2 + 5.1780800819397) + 0.102473007099704*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.00111897818493814*std::sin(0.389039844274521*x_2 + 5.18200016021729) - 0.011463867577908*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.00439882455634176*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.000691005096485143*std::sin(0.319359928369522*x_23 + 5.05087995529175) + 0.00729449218579426*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.000779171351204144*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.00163236828627868*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.00285216441126522*std::sin(0.225999996066093*x_29 + 2.00271987915039) + 0.00371157568383374*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00177446193341663*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.00139380704495335*std::sin(0.361839860677719*x_3 - 7.40983963012695) + 0.0255434775255806*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.0281390571771634*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.00449675661554383*std::sin(0.368719846010208*x_30 - 1.15703988075256) + 0.0468400961162662*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.00309900566766216*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.00434432450354297*std::sin(0.385359823703766*x_31 - 7.40199947357178) - 0.00712269674106263*std::sin(0.392639845609665*x_31 - 7.41215991973877) + 0.00291436008353283*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.00113181658899432*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.00358998579221535*std::sin(0.231999978423119*x_33 - 7.41767978668213) + 0.0628272862183581*std::sin(0.229999989271164*x_37 + 1.9883998632431) + 0.0283462106022004*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.000554356763125231*std::sin(0.244479969143867*x_41 - 1.19223988056183) + 0.00602985943398086*std::sin(0.360559850931168*x_5 + 2.01591968536377) + 0.0240649815193188*std::sin(0.371839851140976*x_5 - 1.16791987419128) - 0.0659123848394911*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00070590479353207*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.0035471183120916*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.0121479735429011*std::sin(0.385039836168289*x_6 + 2.00575971603394) - 0.0246117521713797*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.00947143317230001*std::sin(0.360079854726791*x_7 - 1.15847992897034) + 0.250101269735459*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 0.00100604439844129*std::sin(0.339919835329056*x_8 - 1.13207995891571) - 0.0363071665498998*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.00291518864391167*std::sin(0.360959857702255*x_91 + 2.01151990890503) - 0.069886047758742*std::sin(0.277999937534332*x_92 + 2.01671981811523) + 0.0476318699451443*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.00170161654944067*std::sin(0.242879971861839*x_93 + 1.95855975151062) + 0.0557069829673542*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00194065189873881*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 0.689404712280208);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00227484077433969*x_1 + 0.00229112770945904*x_10 - 0.000516319212130894*x_100 + 0.000262202384289977*x_101 + 0.00042229331926838*x_102 + 0.00105512166555086*x_103 + 0.00194724718504657*x_104 - 0.00111785473900678*x_105 - 0.000138772631464854*x_106 + 0.00168908733251685*x_107 + 0.0027718215399418*x_108 - 0.000433851300257645*x_109 + 0.00102882557478247*x_11 + 0.000189419397224164*x_110 - 0.000857042104911173*x_111 + 0.000327252299531377*x_112 - 0.00194607539935521*x_113 - 0.00216691986887313*x_114 + 0.000835553857490856*x_115 - 0.00161701907040175*x_116 - 0.00148644476748652*x_117 - 0.000614388937814395*x_118 - 0.0024872139887411*x_119 - 0.000133480846368954*x_12 - 0.00118831638549341*x_120 - 0.000490757485379574*x_13 + 0.000546361296578026*x_14 + 0.000147934380829005*x_15 - 0.000484313515066768*x_16 - 0.000135494953802608*x_17 - 0.00319724550899527*x_18 - 0.00144667259872534*x_19 + 0.00125226202243356*x_2 - 0.00096156511503871*x_20 - 0.00168513259574191*x_21 - 0.00760933199308877*x_22 + 0.000382819595835594*x_23 - 0.00237932945061405*x_24 - 0.00982540839100041*x_25 - 0.00106064509826208*x_26 - 0.00120673673908316*x_27 - 0.00208280872319254*x_28 - 0.000925727205186324*x_29 - 0.000100589845097945*x_3 - 0.000870885482109388*x_30 - 0.000680296827525954*x_31 + 0.000631881736205955*x_32 - 0.00180589451130625*x_33 - 0.00181332059419681*x_34 + 0.000239761088015642*x_35 - 0.00271118294489623*x_36 + 0.000117493176760243*x_37 - 0.00190579007196012*x_38 - 0.00116475378688718*x_39 - 0.00128106365280248*x_4 - 0.00091198331775406*x_40 + 0.0022471354020093*x_41 + 0.00256427362932785*x_42 + 0.00170714059028524*x_43 + 0.00071920583165621*x_44 + 0.000332589141721629*x_45 + 8.96902933813488e-5*x_46 - 0.00102478794230551*x_47 - 0.00149843867205*x_48 + 0.000194885203476017*x_49 - 0.00170461062087705*x_5 - 0.00140928618084242*x_50 + 0.00122550472811784*x_51 - 0.00045023634504534*x_52 + 0.00337850435775644*x_53 + 0.00376429096927085*x_54 + 0.00213050823532949*x_55 - 0.00113055289814536*x_56 + 0.00368157592949628*x_57 + 0.00247375960118152*x_58 + 0.00323045137698652*x_59 - 0.00039490936573474*x_6 + 0.0014279553253048*x_60 - 0.00118089148659321*x_61 - 0.000240921005941307*x_62 + 0.00271140601365657*x_63 + 0.000502289607929638*x_64 + 0.00110220110578664*x_65 + 0.000652936855462141*x_66 - 0.00110858879879458*x_67 - 0.00015175425155693*x_68 + 0.00169099520872604*x_69 + 0.000224747746400066*x_7 + 0.000428653287718576*x_70 + 0.00179326976492029*x_71 + 6.95863778569378e-5*x_72 - 8.01461838784773e-5*x_73 - 0.000984967543023732*x_74 - 0.000630285421378024*x_75 - 4.78847684476691e-5*x_76 - 0.000762466829084721*x_77 + 0.000587815430208802*x_78 + 0.000382226941419529*x_79 + 0.000160813609325537*x_8 - 0.000300536134368483*x_80 - 0.00114154724976642*x_81 + 0.00046010052828827*x_82 + 0.000221782088554768*x_83 - 0.000121497825970156*x_84 + 0.00175874595566195*x_85 - 0.000282665328238294*x_86 - 0.00040184218775419*x_87 + 0.00106639845564345*x_88 - 2.11125891412685e-5*x_89 + 0.00022075675020608*x_9 - 0.0005784734641622*x_90 + 0.000248064956723929*x_91 + 0.00430721904851394*x_92 - 0.000381834544266054*x_93 - 4.06806780023477e-5*x_94 + 0.000667267262225183*x_95 - 0.00226950108890925*x_96 - 0.000548904505155763*x_97 - 0.00213997826137144*x_98 - 0.00319352726326727*x_99 + 1.10085921129683e-6*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) - 0.0224738284744712*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.0168800405775301*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.0120479985470073*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.074433466517399*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.00210940510160801*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.0122515021341538*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.00630996773833442*std::sin(0.260159969329834*x_113 + 5.18175983428955) - 0.00609529676174287*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.00680824862890184*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.00631638513182301*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.0080721821357226*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00265470181449728*std::sin(0.292479932308197*x_12 + 5.13503980636597) - 0.0185489348200474*std::sin(0.269039958715439*x_120 + 5.14904022216797) - 0.0108847513068145*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.0030596763108841*std::sin(0.286239922046661*x_13 + 5.15136003494263) - 0.0252865334143687*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.00156533949231526*std::sin(0.317359924316406*x_16 - 1.18911993503571) - 0.00587151352069705*std::sin(0.324959844350815*x_16 - 1.13615989685059) + 0.037477542396044*std::sin(0.329759836196899*x_16 - 1.13863980770111) - 0.0353415303227068*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.0237739814183284*std::sin(0.380799859762192*x_17 + 2.00471973419189) + 0.00884164659011061*std::sin(0.296639919281006*x_18 - 1.14375984668732) + 0.00999136202505861*std::sin(0.34623983502388*x_18 + 2.01407980918884) + 0.00583486816645111*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.0123171605654466*std::sin(0.361359834671021*x_2 + 5.1780800819397) + 0.0252842146223647*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.00212352682281273*std::sin(0.389039844274521*x_2 + 5.18200016021729) - 0.00802192154824238*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.0406295052341435*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.00160162556996678*std::sin(0.319359928369522*x_23 + 5.05087995529175) + 0.00510437194524772*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.00147866266395596*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.003783536185486*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.00661080428215025*std::sin(0.225999996066093*x_29 + 2.00271987915039) + 0.00259720105398423*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00411288371091468*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.00264507984661686*std::sin(0.361839860677719*x_3 - 7.40983963012695) + 0.0178742271216022*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.259904880547048*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.0104226733116825*std::sin(0.368719846010208*x_30 - 1.15703988075256) + 0.0115573366748529*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.00718293793207414*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.00824438736559111*std::sin(0.385359823703766*x_31 - 7.40199947357178) - 0.00498415688077521*std::sin(0.392639845609665*x_31 - 7.41215991973877) + 0.00203934385970077*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.00214789074316647*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.00832094158187324*std::sin(0.231999978423119*x_33 - 7.41767978668213) + 0.0155020198376739*std::sin(0.229999989271164*x_37 + 1.9883998632431) + 0.00699415087818633*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.00105202359773363*std::sin(0.244479969143867*x_41 - 1.19223988056183) + 0.00421943632876041*std::sin(0.360559850931168*x_5 + 2.01591968536377) + 0.00593779937604132*std::sin(0.371839851140976*x_5 - 1.16791987419128) - 0.0162632378196152*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00163616038873513*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.00822158247057946*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.112204100964646*std::sin(0.385039836168289*x_6 + 2.00575971603394) - 0.00607270969932741*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.087482380513224*std::sin(0.360079854726791*x_7 - 1.15847992897034) + 0.0617100479462319*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 0.00929227470400511*std::sin(0.339919835329056*x_8 - 1.13207995891571) - 0.00895843907932183*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.00553226270380571*std::sin(0.360959857702255*x_91 + 2.01151990890503) - 0.0172437003719585*std::sin(0.277999937534332*x_92 + 2.01671981811523) + 0.0117526991414023*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.00322922147501836*std::sin(0.242879971861839*x_93 + 1.95855975151062) + 0.0137451544867865*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00449808216934256*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 0.127296297786644);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000409367059711701*x_1 - 0.000981440297219091*x_10 + 0.00145330212605063*x_100 - 0.000189042650688909*x_101 + 0.000760110331377248*x_102 + 0.000514589817020679*x_103 + 0.000187700283491338*x_104 + 6.04266744382661e-5*x_105 + 0.00042737299972525*x_106 - 0.0014729464062486*x_107 - 0.0014353141847163*x_108 - 0.000337587056793132*x_109 - 0.00136319208150852*x_11 + 0.00157744545685888*x_110 - 0.000293306857475146*x_111 - 0.00262965541885411*x_112 + 0.00139332281975985*x_113 - 0.000940532324358923*x_114 + 0.000224557137344907*x_115 - 0.000808261766976263*x_116 + 0.00118340405511304*x_117 - 0.000924911520649825*x_118 - 0.000365128478807841*x_119 + 0.000200929786269715*x_12 + 0.00101181330299668*x_120 - 0.00064449538163442*x_13 - 0.00092873520470813*x_14 - 0.000441237728585223*x_15 + 5.42339884949362e-5*x_16 - 0.000653922615801019*x_17 + 0.000105692254922073*x_18 - 0.000175865713505613*x_19 + 2.86171183417777e-5*x_2 - 0.000282708456964378*x_20 + 0.000210499955263707*x_21 - 0.000656396792152388*x_22 - 0.000729566916399562*x_23 - 0.000388182515510117*x_24 + 0.0007694334392126*x_25 - 0.000544676056063343*x_26 - 0.000487394131175904*x_27 + 0.00179381355125708*x_28 + 0.00421004826285796*x_29 - 0.000581594491122913*x_3 + 0.00145431568794842*x_30 + 5.24918828465268e-5*x_31 + 0.000401577570780624*x_32 + 0.00107820003268001*x_33 + 0.00167143100956844*x_34 - 0.00027605216701308*x_35 + 0.00328088859229648*x_36 + 0.000145945533738481*x_37 + 0.0012061902411633*x_38 + 0.00168616252461364*x_39 - 0.000175018235464667*x_4 + 0.000942411112344587*x_40 - 0.000651718449489994*x_41 + 0.000385221110069427*x_42 - 0.00211208187938182*x_43 + 0.00044178543215058*x_44 - 8.6333872178999e-5*x_45 + 0.00122400139622424*x_46 + 0.000663682552948843*x_47 + 0.000390029559483972*x_48 - 5.35849664589655e-6*x_49 + 0.00107818460194444*x_5 + 0.00162654802099558*x_50 - 0.00288228701126205*x_51 - 0.0012620112768433*x_52 - 0.000624530894496062*x_53 - 0.000268862157592693*x_54 - 0.0019189074909831*x_55 - 0.00143588100587991*x_56 + 0.000154683038552894*x_57 + 0.000521719393254721*x_58 + 0.00101388772675792*x_59 - 0.00054066861037173*x_6 + 0.00126234319087823*x_60 + 6.16578427252044e-5*x_61 - 0.000608748599116524*x_62 + 0.000251623323442325*x_63 + 0.000712445861059641*x_64 - 0.000206451468043915*x_65 - 0.000305144221965375*x_66 + 0.000776565929891845*x_67 - 0.00110529201904084*x_68 - 0.000773068028661463*x_69 - 0.00142712885435985*x_7 - 0.000624876560090654*x_70 - 0.000626790138026532*x_71 + 6.18491468247281e-5*x_72 - 0.000745671101910346*x_73 - 0.000352177671358413*x_74 - 0.000219205932667438*x_75 + 0.000349603139162699*x_76 + 0.000441583913630325*x_77 + 0.000583592902810366*x_78 - 0.000364603831287728*x_79 - 0.00020044505983973*x_8 + 0.000261988393591389*x_80 + 0.000261789962790474*x_81 - 0.000561501886144202*x_82 - 0.000466299354187858*x_83 + 0.00019377401321643*x_84 - 8.01867045343808e-7*x_85 - 0.000602243997045168*x_86 + 0.000420694146799041*x_87 + 0.000779326379716699*x_88 - 5.57375535371646e-5*x_89 - 0.000875043342353853*x_9 + 0.000188334829861369*x_90 - 0.000316236395452743*x_91 + 0.000493231686430003*x_92 + 6.48837914283949e-5*x_93 - 8.59183364485236e-5*x_94 + 0.000665099924402503*x_95 + 0.00238103066830473*x_96 + 0.00118521273326283*x_97 + 0.000574743231109562*x_98 + 0.00372624333357348*x_99 - 1.89070372294178e-6*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) - 0.0424429250342099*std::sin(0.151120036840439*x_1 + 4.9399995803833) + 0.0238845175416364*std::sin(0.329999834299088*x_1 - 4.25616025924683) - 0.0206921970339784*std::sin(0.369519829750061*x_1 - 4.20887994766235) + 0.00574330593088518*std::sin(0.263279944658279*x_11 + 1.97639977931976) - 0.0036228611596068*std::sin(0.29479992389679*x_11 - 1.08255982398987) + 0.0210417103830983*std::sin(0.279519945383072*x_112 - 7.44312000274658) + 0.0108372436475845*std::sin(0.260159969329834*x_113 + 5.18175983428955) - 0.0115112662630572*std::sin(0.278319954872131*x_113 + 5.16416025161743) + 0.0116930311317595*std::sin(0.250319957733154*x_116 + 5.15336036682129) + 0.0089374081056168*std::sin(0.233919993042946*x_118 + 5.16031980514526) - 0.0114217839071191*std::sin(0.269359946250916*x_12 - 4.25047969818115) - 0.00455939738021319*std::sin(0.292479932308197*x_12 + 5.13503980636597) - 0.0350305712676416*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.0182306392091502*std::sin(0.284959942102432*x_13 + 1.96391975879669) + 0.00432930787004859*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.042351878746083*std::sin(0.285599917173386*x_15 + 8.3473596572876) - 0.00268843933485539*std::sin(0.317359924316406*x_16 - 1.18911993503571) - 0.0110886406594842*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.0627703412424462*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.0591927799038586*std::sin(0.350719839334488*x_17 + 2.00255990028381) - 0.00183440668383653*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.0148086864325697*std::sin(0.296639919281006*x_18 - 1.14375984668732) + 0.0188691762020397*std::sin(0.34623983502388*x_18 + 2.01407980918884) + 0.0110194341144187*std::sin(0.306159913539886*x_19 + 1.98039984703064) - 0.0211544774283425*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.0423479950505135*std::sin(0.377999842166901*x_2 + 5.174880027771) - 0.00300469737715685*std::sin(0.389039844274521*x_2 + 5.18200016021729) - 0.0151497914691803*std::sin(0.282959938049316*x_21 - 1.16959989070892) - 0.00313498335222156*std::sin(0.291999936103821*x_23 + 2.00887989997864) - 0.00275075994897448*std::sin(0.319359928369522*x_23 + 5.05087995529175) + 0.00963985624723296*std::sin(0.234959989786148*x_26 + 8.20392036437988) + 0.00209224285766418*std::sin(0.319119930267334*x_26 - 1.20175993442535) - 0.00649814788155914*std::sin(0.301679939031601*x_28 - 1.19359982013702) + 0.0113539244070792*std::sin(0.225999996066093*x_29 + 2.00271987915039) + 0.00490494130798589*std::sin(0.341999858617783*x_3 - 4.2087197303772) + 0.00706379568291252*std::sin(0.352239847183228*x_3 - 7.39423990249634) - 0.00374267204544796*std::sin(0.361839860677719*x_3 - 7.40983963012695) + 0.033756352756201*std::sin(0.319199919700623*x_30 + 1.98799991607666) + 0.0200543292117523*std::sin(0.335759848356247*x_30 - 1.15191984176636) - 0.0179007333827819*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.0193571381833973*std::sin(0.367359846830368*x_31 + 8.36415958404541) - 0.012336552531394*std::sin(0.38239985704422*x_31 - 7.39735984802246) + 0.0116654467593892*std::sin(0.385359823703766*x_31 - 7.40199947357178) - 0.00941282421416457*std::sin(0.392639845609665*x_31 - 7.41215991973877) + 0.00385140069279152*std::sin(0.285599917173386*x_32 - 1.1373598575592) + 0.00303917125655301*std::sin(0.293199926614761*x_32 + 2.02391982078552) + 0.0142910510860838*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.0259640043862821*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.0117143550312214*std::sin(0.359679847955704*x_4 - 1.1697598695755) + 0.00148856727914104*std::sin(0.244479969143867*x_41 - 1.19223988056183) + 0.00796861202316414*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.00994509429472729*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.0272389522465608*std::sin(0.19336000084877*x_53 + 1.98367977142334) + 0.00281007281091575*std::sin(0.242479979991913*x_57 - 4.42295980453491) - 0.0141204037955823*std::sin(0.283359944820404*x_6 + 2.00127983093262) + 0.00865769805829555*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.0101710527351263*std::sin(0.477679848670959*x_6 - 4.27952003479004) - 0.00675016358041188*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.103356851064001*std::sin(0.362399846315384*x_7 - 1.14935994148254) - 0.00071699436981686*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.0150042996967713*std::sin(0.348079830408096*x_8 + 8.25920009613037) - 0.00782790923914488*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.0288811081898632*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.0196843466369741*std::sin(0.23871998488903*x_93 + 1.96887981891632) - 0.00456920684589909*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.0230214678552883*std::sin(0.293279945850372*x_94 + 1.96727979183197) - 0.00772536634694236*std::sin(0.294399946928024*x_94 + 1.96591985225677) - 0.411067266726752);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000113505736223097*x_1 + 0.000267719083908782*x_10 + 0.000508008108949657*x_100 - 0.000500187364225124*x_101 - 0.000819161880393958*x_102 - 0.000897621342473342*x_103 - 0.00138423878646161*x_104 + 0.00056790154427929*x_105 - 0.000534090497357721*x_106 + 0.000776433895803109*x_107 + 0.000849106847535852*x_108 + 0.000252648665067869*x_109 + 0.000354676467839585*x_11 - 0.000238321982266078*x_110 + 0.000479316325947915*x_111 + 0.000202261491322565*x_112 - 0.000758955862940591*x_113 + 0.00112945796982812*x_114 - 0.000251299429753792*x_115 - 0.000542220979234197*x_116 - 0.00141326099996354*x_117 - 0.000301086435651731*x_118 + 0.0028082112235768*x_119 + 4.01237080314571e-5*x_12 - 0.000430476621874585*x_120 - 0.00147601967177601*x_13 - 0.00312719840192998*x_14 - 0.00096377059833121*x_15 - 3.66366199427369e-5*x_16 - 0.000542025097946361*x_17 - 0.000593398715949068*x_18 + 0.000665519300666962*x_19 + 3.4211048477557e-5*x_2 - 0.000379332823724235*x_20 - 0.000986765286913452*x_21 - 0.00094813319638653*x_22 + 0.000716284230518785*x_23 - 0.00105198852299556*x_24 - 0.00139131310668721*x_25 - 0.00100442640311677*x_26 - 0.00111882519355639*x_27 - 0.000721164664940803*x_28 - 0.00116994483748031*x_29 + 0.000150894682743925*x_3 - 0.000408488553398791*x_30 - 1.57631257875971e-5*x_31 - 0.000481678421256372*x_32 - 0.00106363089605624*x_33 - 0.000462818365416555*x_34 - 4.03376313563128e-5*x_35 + 0.000474280557309777*x_36 - 0.00015126090202344*x_37 - 0.00209341528320217*x_38 + 0.000214663912106157*x_39 - 0.000501671975723483*x_4 + 0.000607695763553234*x_40 - 0.000183208854467832*x_41 - 0.000849463146918685*x_42 - 0.00103724918749083*x_43 - 0.000306921235419627*x_44 + 0.000539303024013078*x_45 + 0.000366278108349742*x_46 + 0.000358233393321059*x_47 - 0.000477415168530794*x_48 - 0.000589601186731179*x_49 + 0.00168306679439205*x_5 - 0.00054417384067745*x_50 - 0.00570978902089523*x_51 + 1.2251149257602e-5*x_52 + 0.000685801968490908*x_53 + 9.45392709749078e-5*x_54 + 0.000570375635981173*x_55 + 0.00112474723995812*x_56 - 8.21116655810171e-5*x_57 - 0.00106269355647295*x_58 - 0.000566369921730384*x_59 - 0.000161478518153363*x_6 - 0.000561982445555085*x_60 - 0.000390058994727575*x_61 + 0.000117514918116774*x_62 - 0.000146491033941846*x_63 + 0.000211675491049652*x_64 + 0.000494109293581581*x_65 + 0.000433780910075185*x_66 + 0.000171742959637304*x_67 + 0.000120362254279569*x_68 - 0.000295048837078699*x_69 + 0.000402341008446879*x_7 - 8.51836534407505e-5*x_70 - 0.000395073597071833*x_71 - 0.00109293179211442*x_72 - 0.000330513439642241*x_73 - 0.000862203465747964*x_74 - 0.000356578537461537*x_75 - 0.00015745990518948*x_76 + 8.67655541508891e-5*x_77 + 0.000263769659906474*x_78 + 0.000111931711076042*x_79 - 0.000131351499749273*x_8 - 0.000955863050794649*x_80 - 0.000267809593023804*x_81 - 3.63622480319837e-5*x_82 - 0.000104681625412079*x_83 + 8.10015034809441e-5*x_84 - 0.000758281941869198*x_85 + 2.45053191127124e-5*x_86 - 0.000808001512508754*x_87 + 0.000478998195145752*x_88 + 9.58424886088735e-8*x_89 + 0.000362334055696559*x_9 - 0.000329508932806618*x_90 - 0.000446076091707973*x_91 + 0.000919238212692222*x_92 + 0.000708444989809286*x_93 + 2.11179219717675e-5*x_94 + 0.00041458021531371*x_95 - 0.000398461055493789*x_96 - 0.000106929626539847*x_97 + 0.0002826035213188*x_98 - 0.00075332529079338*x_99 - 3.42710667438069e-6*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) - 0.00235316946741532*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.0344225692623897*std::sin(0.329999834299088*x_1 - 4.25616025924683) - 0.0375068635568193*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.00172469435112263*std::sin(0.263279944658279*x_11 + 1.97639977931976) - 0.00656683091580572*std::sin(0.29479992389679*x_11 - 1.08255982398987) + 0.0381403946156625*std::sin(0.279519945383072*x_112 - 7.44312000274658) + 0.0196436858857713*std::sin(0.260159969329834*x_113 + 5.18175983428955) - 0.000638220864365045*std::sin(0.278319954872131*x_113 + 5.16416025161743) + 0.0211948940223397*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.0128806683662558*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.0164611718431185*std::sin(0.269359946250916*x_12 - 4.25047969818115) - 0.0082644049426054*std::sin(0.292479932308197*x_12 + 5.13503980636597) - 0.00194220522423202*std::sin(0.269039958715439*x_120 + 5.14904022216797) - 0.00477359980877857*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.00623943522221743*std::sin(0.286239922046661*x_13 + 5.15136003494263) - 0.0110896232416383*std::sin(0.285599917173386*x_15 + 8.3473596572876) - 0.0048730894620628*std::sin(0.317359924316406*x_16 - 1.18911993503571) - 0.000614789169549609*std::sin(0.324959844350815*x_16 - 1.13615989685059) + 0.0164360934092488*std::sin(0.329759836196899*x_16 - 1.13863980770111) - 0.0154993272363324*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.000550865805051561*std::sin(0.380799859762192*x_17 + 2.00471973419189) + 0.00387757894343583*std::sin(0.296639919281006*x_18 - 1.14375984668732) + 0.00104616657023827*std::sin(0.34623983502388*x_18 + 2.01407980918884) + 0.00061095214067702*std::sin(0.306159913539886*x_19 + 1.98039984703064) - 0.0383447971821341*std::sin(0.361359834671021*x_2 + 5.1780800819397) + 0.0110886063157798*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.00433039534490912*std::sin(0.389039844274521*x_2 + 5.18200016021729) - 0.000839952163858861*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.000941424354458285*std::sin(0.291999936103821*x_23 + 2.00887989997864) - 0.00498605237106196*std::sin(0.319359928369522*x_23 + 5.05087995529175) + 0.000534463997780017*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.00301535815224807*std::sin(0.319119930267334*x_26 - 1.20175993442535) - 0.0117786016422256*std::sin(0.301679939031601*x_28 - 1.19359982013702) + 0.0205802261051099*std::sin(0.225999996066093*x_29 + 2.00271987915039) + 0.000271945397639614*std::sin(0.341999858617783*x_3 - 4.2087197303772) + 0.0128038999646675*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.0053939706961322*std::sin(0.361839860677719*x_3 - 7.40983963012695) + 0.00187155853592012*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.00602224376052558*std::sin(0.335759848356247*x_30 - 1.15191984176636) - 0.0324470312868423*std::sin(0.368719846010208*x_30 - 1.15703988075256) + 0.00506856781436315*std::sin(0.367359846830368*x_31 + 8.36415958404541) - 0.0223613467335889*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.0168123408124861*std::sin(0.385359823703766*x_31 - 7.40199947357178) - 0.000521876626671378*std::sin(0.392639845609665*x_31 - 7.41215991973877) + 0.000213533787074153*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.00438007939229206*std::sin(0.293199926614761*x_32 + 2.02391982078552) + 0.0259040884971808*std::sin(0.231999978423119*x_33 - 7.41767978668213) + 0.00679854200127409*std::sin(0.229999989271164*x_37 + 1.9883998632431) + 0.0030673440626775*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.00214533578828357*std::sin(0.244479969143867*x_41 - 1.19223988056183) + 0.000441804953251322*std::sin(0.360559850931168*x_5 + 2.01591968536377) + 0.00260407217097287*std::sin(0.371839851140976*x_5 - 1.16791987419128) - 0.00713238058982858*std::sin(0.19336000084877*x_53 + 1.98367977142334) + 0.00509356340125092*std::sin(0.242479979991913*x_57 - 4.42295980453491) - 0.0255947716744835*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.00259987594506677*std::sin(0.385039836168289*x_6 + 2.00575971603394) - 0.00266323823506453*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.00202705012346361*std::sin(0.360079854726791*x_7 - 1.15847992897034) + 0.0270634638102778*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 0.000215310860032713*std::sin(0.339919835329056*x_8 - 1.13207995891571) - 0.00392879927805353*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.0112816491894566*std::sin(0.360959857702255*x_91 + 2.01151990890503) - 0.00756237074031099*std::sin(0.277999937534332*x_92 + 2.01671981811523) + 0.00515424567752007*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.00658517966096503*std::sin(0.242879971861839*x_93 + 1.95855975151062) + 0.00602805383239925*std::sin(0.293279945850372*x_94 + 1.96727979183197) - 0.0140030689358607*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 0.179384291524204);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00414603969019189*x_1 - 0.00409569840743643*x_10 - 0.000967333767401602*x_100 - 0.00236384038325645*x_101 - 0.00238248359243698*x_102 - 0.00290402394345938*x_103 - 0.0034475554092531*x_104 + 0.00107297165319835*x_105 - 0.0020527418452438*x_106 - 0.00194461900586404*x_107 - 0.00460687967963137*x_108 + 0.000471435831110478*x_109 - 0.0016196003049479*x_11 - 0.000117214969189441*x_110 + 0.000429145122738151*x_111 - 0.00151502584715623*x_112 + 0.00154066983764192*x_113 - 2.09488438220225e-5*x_114 - 0.00129707971967262*x_115 + 0.000351427310903349*x_116 - 0.00258171467353399*x_117 - 0.000788550849680677*x_118 + 0.00049170202983855*x_119 + 0.000523901159818316*x_12 - 2.87555183401827e-5*x_120 + 0.00144850375696013*x_13 - 0.00369005183881834*x_14 - 8.51916449444417e-5*x_15 + 0.000799000280561328*x_16 - 0.000258098182520557*x_17 + 0.00562721538661766*x_18 + 0.00213752474788676*x_19 - 0.00221778207744383*x_2 + 0.000282967309779006*x_20 + 0.00250715792231063*x_21 + 0.0143670573060067*x_22 + 0.00182299917421338*x_23 + 0.00403323566308836*x_24 + 0.0167849648630809*x_25 + 0.0023137993396869*x_26 + 0.00168546803432846*x_27 + 0.00237017212783551*x_28 + 0.000294647834981502*x_29 + 0.000346976587180455*x_3 + 0.00111119581888509*x_30 + 0.00125896617184961*x_31 - 0.00123252218909766*x_32 - 0.000324307314551112*x_33 + 0.00317311141675435*x_34 - 0.000461815692082188*x_35 + 0.00488798435206621*x_36 - 0.000281386207113885*x_37 + 0.00298821780362103*x_38 + 0.0025312552648915*x_39 + 0.00245984221380177*x_4 + 0.000263714998221761*x_40 - 0.00429813235103157*x_41 - 0.00475990310720716*x_42 - 0.00399274351131472*x_43 - 0.00204211502562482*x_44 - 0.000865454963938485*x_45 - 0.00144199912980257*x_46 + 0.00377568196294571*x_47 + 0.00251271685368486*x_48 - 0.000368041747259435*x_49 + 0.00244059565134338*x_5 + 0.00233822320622749*x_50 - 0.000233699197615279*x_51 + 0.00292177583896829*x_52 - 0.00403439994831234*x_53 - 0.00632946535836302*x_54 - 0.00253097116373287*x_55 + 0.00188977407432014*x_56 - 0.0071787884634022*x_57 - 0.00464458557400544*x_58 - 0.00594438717167382*x_59 - 0.000268995028237426*x_6 - 0.00390092341571069*x_60 + 0.00130577842146489*x_61 + 0.000203413566254166*x_62 - 0.00453471146748701*x_63 - 0.0011413215770287*x_64 - 0.00152246606684579*x_65 - 0.00130482056962393*x_66 + 0.00108249390687686*x_67 + 1.83072213573121e-5*x_68 - 0.00272889321570627*x_69 + 0.00242146420353812*x_7 - 0.000562518386570748*x_70 - 0.00267453098314104*x_71 - 0.000203886412494569*x_72 - 0.00043064089287777*x_73 + 0.0015805205027604*x_74 + 0.000677746740203671*x_75 - 0.000275318690729492*x_76 + 9.25293902742144e-5*x_77 - 0.000875026974735686*x_78 - 0.0010907565721438*x_79 + 0.000287897482343211*x_8 + 3.61098129403603e-5*x_80 + 0.00156616913085281*x_81 + 8.72633161833019e-5*x_82 - 0.000578640082575217*x_83 - 0.0010089008547126*x_84 - 0.00328977595166373*x_85 + 0.000572525809969246*x_86 + 0.000820931435247798*x_87 - 0.00191323120266384*x_88 + 2.78373993884789e-5*x_89 - 0.000118022260205882*x_9 + 0.000555545072893191*x_90 - 0.000820820277056429*x_91 - 0.00632384816611666*x_92 + 0.000194918491612412*x_93 + 0.000113583791067741*x_94 + 0.000197210440039864*x_95 + 0.00373460906616612*x_96 + 0.000516244093433449*x_97 + 0.00364613996405878*x_98 + 0.00697099834862388*x_99 - 9.26741205837032e-7*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) + 0.0064333194838124*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.0990198480244597*std::sin(0.329999834299088*x_1 - 4.25616025924683) - 0.0101424201994217*std::sin(0.369519829750061*x_1 - 4.20887994766235) + 0.137747542847876*std::sin(0.263279944658279*x_11 + 1.97639977931976) - 0.00177576987811196*std::sin(0.29479992389679*x_11 - 1.08255982398987) + 0.0103137365292566*std::sin(0.279519945383072*x_112 - 7.44312000274658) + 0.00531194820428322*std::sin(0.260159969329834*x_113 + 5.18175983428955) + 0.00174482916702343*std::sin(0.278319954872131*x_113 + 5.16416025161743) + 0.0057314182224575*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.0370524876966017*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.0473521520658551*std::sin(0.269359946250916*x_12 - 4.25047969818115) - 0.00223481943509088*std::sin(0.292479932308197*x_12 + 5.13503980636597) + 0.00530978617716734*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.0153978625896979*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.0179483385668563*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.0357710117492984*std::sin(0.285599917173386*x_15 + 8.3473596572876) - 0.00131775670654895*std::sin(0.317359924316406*x_16 - 1.18911993503571) + 0.00168076936135186*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.0530167416551427*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.0499950814014453*std::sin(0.350719839334488*x_17 + 2.00255990028381) - 0.0439964397374978*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.0125076315869487*std::sin(0.296639919281006*x_18 - 1.14375984668732) - 0.00286011010801511*std::sin(0.34623983502388*x_18 + 2.01407980918884) - 0.00167027932527592*std::sin(0.306159913539886*x_19 + 1.98039984703064) - 0.0103690100584829*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.0357677315236281*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.0124568008178063*std::sin(0.389039844274521*x_2 + 5.18200016021729) + 0.00229634146458602*std::sin(0.282959938049316*x_21 - 1.16959989070892) - 0.0751894917029018*std::sin(0.291999936103821*x_23 + 2.00887989997864) - 0.00134830357667801*std::sin(0.319359928369522*x_23 + 5.05087995529175) - 0.00146116873345765*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.00867396921185516*std::sin(0.319119930267334*x_26 - 1.20175993442535) - 0.00318511109402883*std::sin(0.301679939031601*x_28 - 1.19359982013702) + 0.00556520276991228*std::sin(0.225999996066093*x_29 + 2.00271987915039) - 0.000743470306492492*std::sin(0.341999858617783*x_3 - 4.2087197303772) + 0.00346236718610954*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.0155162781286919*std::sin(0.361839860677719*x_3 - 7.40983963012695) - 0.00511664551191682*std::sin(0.319199919700623*x_30 + 1.98799991607666) + 0.480983357951735*std::sin(0.335759848356247*x_30 - 1.15191984176636) - 0.00877416542805281*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.0163493199804067*std::sin(0.367359846830368*x_31 + 8.36415958404541) - 0.00604684458495037*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.0483623235528417*std::sin(0.385359823703766*x_31 - 7.40199947357178) + 0.00142675617587329*std::sin(0.392639845609665*x_31 - 7.41215991973877) - 0.00058377906557885*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.0125997217829323*std::sin(0.293199926614761*x_32 + 2.02391982078552) + 0.00700485525864896*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.0219295751087886*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.00989411435486857*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.00617126577908805*std::sin(0.244479969143867*x_41 - 1.19223988056183) - 0.00120784858598325*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.00839977104669701*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.0230064145841563*std::sin(0.19336000084877*x_53 + 1.98367977142334) + 0.00137737617675285*std::sin(0.242479979991913*x_57 - 4.42295980453491) - 0.00692121133609611*std::sin(0.283359944820404*x_6 + 2.00127983093262) + 0.207646371027503*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.00859061882643364*std::sin(0.477679848670959*x_6 - 4.27952003479004) - 0.161896033088325*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.0872966971771658*std::sin(0.362399846315384*x_7 - 1.14935994148254) - 0.017196404625935*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.0126728493902491*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.0324527544614696*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.0243934033384033*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.01662568499145*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.018942905867139*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.0194442660283111*std::sin(0.293279945850372*x_94 + 1.96727979183197) - 0.00378664051750992*std::sin(0.294399946928024*x_94 + 1.96591985225677) - 0.15817915352266);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000909111280902556*x_1 + 0.00285186021568372*x_10 - 0.00414454565554058*x_100 - 0.000513678309691984*x_101 - 0.00274811406762038*x_102 - 0.0040003984924216*x_103 - 0.00358367624080179*x_104 + 0.00194183318164398*x_105 + 0.000306741670584846*x_106 + 0.00356462023717894*x_107 + 0.00327528145004981*x_108 + 0.001408773396226*x_109 + 0.00474672574538109*x_11 - 0.00368461615744092*x_110 + 0.00240708310476183*x_111 + 0.00141702411380352*x_112 - 0.00196208709013701*x_113 - 0.000766888491282541*x_114 - 0.00221650302195074*x_115 - 0.000498958867510757*x_116 - 0.00379880797010679*x_117 - 0.00369537388122321*x_118 - 0.00230554352353888*x_119 + 0.000588065461129107*x_12 - 0.000930998063228142*x_120 + 0.00112306063904979*x_13 + 0.00200926094610335*x_14 + 0.000346347324823541*x_15 + 0.000365043898241363*x_16 + 0.000204355839844386*x_17 + 0.00262819135546874*x_18 + 0.00332545677422804*x_19 - 0.000934512388523492*x_2 - 0.00199136572384145*x_20 + 0.000487981532824413*x_21 + 0.00886331650996709*x_22 + 0.000433689379305363*x_23 + 0.000325814225997328*x_24 + 0.00336000802696814*x_25 + 0.00167255478361641*x_26 + 0.000387084847002365*x_27 - 0.0045934555868426*x_28 - 0.0144584469756356*x_29 + 0.00218778521633567*x_3 - 0.00422827373238361*x_30 + 0.000522301278942108*x_31 - 0.0025575988897029*x_32 - 0.000292010494120046*x_33 - 0.00309319053581591*x_34 + 0.000995443751749004*x_35 - 0.00800651569779982*x_36 - 2.01744991950969e-5*x_37 - 0.00311533970497575*x_38 - 0.00107081970039664*x_39 + 0.00120278887557211*x_4 - 0.00254399738145334*x_40 - 0.00145248550024442*x_41 - 0.00501231259970117*x_42 + 0.00527414445403036*x_43 - 0.00238064769204317*x_44 + 0.00146848814380598*x_45 - 0.00208778722590695*x_46 - 0.00282760136374967*x_47 + 0.000645176153560664*x_48 - 0.0001307722111625*x_49 + 0.000425309194327175*x_5 - 0.00368781576430262*x_50 + 0.00253313744729124*x_51 + 0.00302003916716467*x_52 - 0.00245068782555333*x_53 - 0.00227618265853511*x_54 + 0.00509755740836464*x_55 + 0.00873153365565069*x_56 - 0.00407199442011541*x_57 - 0.00445828636997511*x_58 - 0.00530704642435758*x_59 + 0.000129136492434219*x_6 - 0.00598259660623798*x_60 - 2.66181840806178e-5*x_61 + 0.00199335400280642*x_62 - 0.00310367890509821*x_63 - 0.00293643523074078*x_64 - 0.000269858940813414*x_65 + 0.000279488710205558*x_66 - 0.000719816666919921*x_67 + 0.00365886174502418*x_68 + 0.000787415350004122*x_69 + 0.000120625059192712*x_7 + 0.00105480072703718*x_70 - 0.000570401980843936*x_71 - 0.00107025441406702*x_72 + 0.00180599693905304*x_73 + 0.0015018479964896*x_74 + 0.00118434994484295*x_75 - 0.000530617715991096*x_76 - 0.000922403662048369*x_77 - 0.00222562026705437*x_78 + 0.00103463735604622*x_79 + 4.58717657273193e-5*x_8 - 0.00158903652588066*x_80 - 0.000478656259214272*x_81 + 0.000839280167272797*x_82 + 0.00103455250547751*x_83 - 0.000744048404215362*x_84 - 0.00185322642908539*x_85 + 0.0034985520358282*x_86 - 0.000362180373469125*x_87 - 0.00281243425099173*x_88 - 8.98330380596412e-5*x_89 + 0.0032521868810187*x_9 - 0.000188960741408753*x_90 - 0.00138504203879365*x_91 - 0.00329418790009739*x_92 - 0.00014424023785917*x_93 + 2.23632958294447e-5*x_94 - 0.00202879534864798*x_95 - 0.00439454973582914*x_96 - 0.00242046337277065*x_97 + 0.000429658067447711*x_98 - 0.00457222168299706*x_99 + 8.66537328734645e-7*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) + 0.00775951389024989*std::sin(0.151120036840439*x_1 + 4.9399995803833) + 0.003867295529153*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.00948353828572151*std::sin(0.369519829750061*x_1 - 4.20887994766235) + 0.0571466647867748*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.00166041056223109*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.00964372539501235*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.00496686818102465*std::sin(0.260159969329834*x_113 + 5.18175983428955) + 0.0021045163685246*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.00535908817377302*std::sin(0.250319957733154*x_116 + 5.15336036682129) + 0.00144711310784549*std::sin(0.233919993042946*x_118 + 5.16031980514526) - 0.00184937433891859*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00208963888871093*std::sin(0.292479932308197*x_12 + 5.13503980636597) + 0.00640437020105378*std::sin(0.269039958715439*x_120 + 5.14904022216797) - 0.0539216731286998*std::sin(0.284959942102432*x_13 + 1.96391975879669) + 0.000700986023309002*std::sin(0.286239922046661*x_13 + 5.15136003494263) - 0.12526626937943*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.00123215129447464*std::sin(0.317359924316406*x_16 - 1.18911993503571) + 0.00202725097650327*std::sin(0.324959844350815*x_16 - 1.13615989685059) + 0.185658976836824*std::sin(0.329759836196899*x_16 - 1.13863980770111) - 0.175077444786079*std::sin(0.350719839334488*x_17 + 2.00255990028381) - 0.0182525926888364*std::sin(0.380799859762192*x_17 + 2.00471973419189) + 0.043800392302298*std::sin(0.296639919281006*x_18 - 1.14375984668732) - 0.00344970651102122*std::sin(0.34623983502388*x_18 + 2.01407980918884) - 0.0020145984755906*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.00969540819066643*std::sin(0.361359834671021*x_2 + 5.1780800819397) + 0.125254782378858*std::sin(0.377999842166901*x_2 + 5.174880027771) - 0.000486509836879892*std::sin(0.389039844274521*x_2 + 5.18200016021729) + 0.00276971997676271*std::sin(0.282959938049316*x_21 - 1.16959989070892) - 0.031193505081822*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.00126071374867018*std::sin(0.319359928369522*x_23 + 5.05087995529175) - 0.00176238085358456*std::sin(0.234959989786148*x_26 + 8.20392036437988) + 0.000338768469375272*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.00297819676276289*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.00520367057354571*std::sin(0.225999996066093*x_29 + 2.00271987915039) - 0.000896732734124706*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00323744147087968*std::sin(0.352239847183228*x_3 - 7.39423990249634) - 0.000606000051841749*std::sin(0.361839860677719*x_3 - 7.40983963012695) - 0.00617141462057088*std::sin(0.319199919700623*x_30 + 1.98799991607666) + 0.199543267027568*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.00820416943156596*std::sin(0.368719846010208*x_30 - 1.15703988075256) + 0.0572535754702632*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.00565402349751336*std::sin(0.38239985704422*x_31 - 7.39735984802246) + 0.00188882735519*std::sin(0.385359823703766*x_31 - 7.40199947357178) + 0.00172087433129124*std::sin(0.392639845609665*x_31 - 7.41215991973877) - 0.000704121997919462*std::sin(0.285599917173386*x_32 - 1.1373598575592) + 0.000492091723950832*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.00654979893606878*std::sin(0.231999978423119*x_33 - 7.41767978668213) + 0.0767950339846855*std::sin(0.229999989271164*x_37 + 1.9883998632431) + 0.0346481335986299*std::sin(0.359679847955704*x_4 - 1.1697598695755) + 0.000241023481987033*std::sin(0.244479969143867*x_41 - 1.19223988056183) - 0.00145684011245493*std::sin(0.360559850931168*x_5 + 2.01591968536377) + 0.0294151026545041*std::sin(0.371839851140976*x_5 - 1.16791987419128) - 0.0805660110189726*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00128789770579818*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.00647158877258699*std::sin(0.283359944820404*x_6 + 2.00127983093262) + 0.0861452575775068*std::sin(0.385039836168289*x_6 + 2.00575971603394) - 0.0300834312316913*std::sin(0.477679848670959*x_6 - 4.27952003479004) - 0.067165033523861*std::sin(0.360079854726791*x_7 - 1.15847992897034) + 0.305703726278972*std::sin(0.362399846315384*x_7 - 1.14935994148254) - 0.00713419020316995*std::sin(0.339919835329056*x_8 - 1.13207995891571) - 0.0443789674345742*std::sin(0.348079830408096*x_8 + 8.25920009613037) - 0.00126746702546483*std::sin(0.360959857702255*x_91 + 2.01151990890503) - 0.0854230977609811*std::sin(0.277999937534332*x_92 + 2.01671981811523) + 0.0582213762739706*std::sin(0.23871998488903*x_93 + 1.96887981891632) - 0.000739829606192253*std::sin(0.242879971861839*x_93 + 1.95855975151062) + 0.0680917465588737*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00354064903799954*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 1.06643460170432);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00104898377252582*x_1 - 0.00349916849140847*x_10 + 0.00670540123089886*x_100 - 6.80899420323919e-5*x_101 + 4.3980923107246e-6*x_102 - 0.000298259470218441*x_103 - 0.00396021739702047*x_104 + 0.00223181225773461*x_105 - 0.000307783095829288*x_106 - 0.00238006732819712*x_107 - 0.00247053176160809*x_108 + 0.00050607512087141*x_109 - 0.00349112964962238*x_11 + 0.00135645875027489*x_110 + 0.00151491303449162*x_111 + 0.000688753823988172*x_112 + 0.00208563893053365*x_113 + 0.0100540041892166*x_114 - 0.000143184614277304*x_115 + 0.00240602139876454*x_116 + 0.00344798992052162*x_117 + 0.0043409876082042*x_118 + 0.0173216905741244*x_119 - 0.000481534966872341*x_12 + 0.00186750222881114*x_120 - 0.00575720291027022*x_13 - 0.0106552135530657*x_14 - 0.00377503980231786*x_15 + 0.00011415047708762*x_16 - 0.00132193889154831*x_17 - 0.000836417905159346*x_18 + 0.00148322809215731*x_19 - 0.000444733551180938*x_2 + 0.00250378534828049*x_20 - 0.0017292508839425*x_21 - 0.0030008741097774*x_22 + 8.49685693158597e-6*x_23 - 0.00114360813989688*x_24 + 0.0030370981382885*x_25 - 0.00389548525701957*x_26 - 0.00242122561787022*x_27 + 0.00394081913975138*x_28 + 0.00854313321773038*x_29 - 0.00111932370325058*x_3 + 0.00286442945897225*x_30 + 0.000177768381620707*x_31 - 0.000270349806256003*x_32 + 0.000856756666570764*x_33 + 0.00237529732209655*x_34 - 0.00109539401981498*x_35 + 0.0100040127170686*x_36 - 0.000616334720195608*x_37 - 0.00273842887358733*x_38 + 0.00198689390129309*x_39 - 0.00146323962785216*x_4 + 0.00590077619074348*x_40 - 0.00137510768873348*x_41 - 0.00148376992363336*x_42 - 0.0083241243453498*x_43 + 0.00058885805158627*x_44 + 0.000551385366727498*x_45 + 0.00350425386109216*x_46 + 0.00292384666278843*x_47 - 0.000605628322361927*x_48 - 0.00211628189406746*x_49 + 0.00738998288740226*x_5 + 0.00225975257842439*x_50 - 0.0237306836594093*x_51 - 0.00321441870582338*x_52 - 0.000499576754721979*x_53 - 0.00195604480847722*x_54 - 0.00482847439910489*x_55 - 0.00154986166807199*x_56 - 0.000370581059332157*x_57 - 0.00258345743318916*x_58 - 0.001147166761899*x_59 + 0.00065588209211799*x_6 + 0.00212778876087151*x_60 + 0.000503098057468173*x_61 - 0.000618542378286768*x_62 - 0.00110361896341256*x_63 + 0.00258629457955607*x_64 + 0.00049788005030511*x_65 + 0.000786997833166137*x_66 + 0.00279769592327224*x_67 - 0.00189661792563221*x_68 - 0.00342009199725107*x_69 - 0.000694025229301553*x_7 - 0.0015750004496609*x_70 - 0.00298797837848071*x_71 - 0.00293118033447651*x_72 - 0.00187381268466341*x_73 - 0.00293994092348188*x_74 - 0.00113468259000214*x_75 + 0.000114147382664834*x_76 + 0.00269365912770436*x_77 + 0.00181202805291711*x_78 - 0.000435572506629996*x_79 - 0.00104215218455105*x_8 - 0.00138335575517464*x_80 + 0.000940774668359944*x_81 - 0.00182450959871863*x_82 - 0.00116050181940683*x_83 + 0.00190020537154926*x_84 - 0.0028221519524978*x_85 - 0.00235479894773113*x_86 - 0.00228054597460088*x_87 + 0.00262050470641733*x_88 + 0.000119683467547339*x_89 - 0.00159056656116914*x_9 - 6.99065801842511e-5*x_90 - 0.000284338961712162*x_91 + 0.000185997800174073*x_92 + 0.003318697353199*x_93 + 9.0815996094251e-5*x_94 + 0.00113183388391143*x_95 + 0.0041221584525623*x_96 + 0.00218838680819522*x_97 + 0.00281959988334589*x_98 + 0.00238803853762527*x_99 - 1.3939203656359e-5*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) + 0.0473205311036628*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.0122006626990023*std::sin(0.329999834299088*x_1 - 4.25616025924683) - 0.152553118214288*std::sin(0.369519829750061*x_1 - 4.20887994766235) + 0.0194502110635116*std::sin(0.263279944658279*x_11 + 1.97639977931976) - 0.0267095256172124*std::sin(0.29479992389679*x_11 - 1.08255982398987) + 0.155129903616931*std::sin(0.279519945383072*x_112 - 7.44312000274658) + 0.079897524104*std::sin(0.260159969329834*x_113 + 5.18175983428955) + 0.0128341586449211*std::sin(0.278319954872131*x_113 + 5.16416025161743) + 0.0862068130125329*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.0045653968730946*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.00583446295822082*std::sin(0.269359946250916*x_12 - 4.25047969818115) - 0.0336141341776046*std::sin(0.292479932308197*x_12 + 5.13503980636597) + 0.0390563382687078*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.0366490197447936*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.00221149223343199*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.0851399022594473*std::sin(0.285599917173386*x_15 + 8.3473596572876) - 0.0198205054295911*std::sin(0.317359924316406*x_16 - 1.18911993503571) + 0.0123629642585078*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.126187099047366*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.118995134211032*std::sin(0.350719839334488*x_17 + 2.00255990028381) - 0.00621237970017694*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.0297698745082566*std::sin(0.296639919281006*x_18 - 1.14375984668732) - 0.0210376508840853*std::sin(0.34623983502388*x_18 + 2.01407980918884) - 0.0122858043910927*std::sin(0.306159913539886*x_19 + 1.98039984703064) - 0.15596127808894*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.0851320948735418*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.00153485617397805*std::sin(0.389039844274521*x_2 + 5.18200016021729) + 0.0168908287506932*std::sin(0.282959938049316*x_21 - 1.16959989070892) - 0.0106168970650509*std::sin(0.291999936103821*x_23 + 2.00887989997864) - 0.0202799638426965*std::sin(0.319359928369522*x_23 + 5.05087995529175) - 0.0107476833185825*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.00106875717067587*std::sin(0.319119930267334*x_26 - 1.20175993442535) - 0.0479075624652906*std::sin(0.301679939031601*x_28 - 1.19359982013702) + 0.0837067503960563*std::sin(0.225999996066093*x_29 + 2.00271987915039) - 0.00546862468925282*std::sin(0.341999858617783*x_3 - 4.2087197303772) + 0.0520777980263485*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.00191182757365285*std::sin(0.361839860677719*x_3 - 7.40983963012695) - 0.0376356846107687*std::sin(0.319199919700623*x_30 + 1.98799991607666) + 0.0679157510673666*std::sin(0.335759848356247*x_30 - 1.15191984176636) - 0.131973066532363*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.0389136185159079*std::sin(0.367359846830368*x_31 + 8.36415958404541) - 0.0909511712839465*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.00595893054554561*std::sin(0.385359823703766*x_31 - 7.40199947357178) + 0.0104945604159154*std::sin(0.392639845609665*x_31 - 7.41215991973877) - 0.00429400957000518*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.00155246608272774*std::sin(0.293199926614761*x_32 + 2.02391982078552) + 0.10536070201544*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.0521953892285444*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.0235493459067125*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.00076038828274055*std::sin(0.244479969143867*x_41 - 1.19223988056183) - 0.00888437714392273*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.0199926043727725*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.0547584145162964*std::sin(0.19336000084877*x_53 + 1.98367977142334) + 0.020717247618049*std::sin(0.242479979991913*x_57 - 4.42295980453491) - 0.104102605727353*std::sin(0.283359944820404*x_6 + 2.00127983093262) + 0.029320056529193*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.020446848200906*std::sin(0.477679848670959*x_6 - 4.27952003479004) - 0.0228600231177315*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.207778083475155*std::sin(0.362399846315384*x_7 - 1.14935994148254) - 0.00242816454357639*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.0301631154857023*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.00399864389551606*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.058059637523327*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.0395714050552729*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.0023340371615883*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.0462800135696349*std::sin(0.293279945850372*x_94 + 1.96727979183197) - 0.0569552244084347*std::sin(0.294399946928024*x_94 + 1.96591985225677) - 0.213730658556326);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00347455039192667*x_1 - 0.00248642931168281*x_10 - 0.00183533931235329*x_100 - 0.00094181358678818*x_101 - 0.00138001014633151*x_102 - 0.00226154904906013*x_103 - 0.0024167386076731*x_104 + 0.00114357051380455*x_105 - 0.000289730119726097*x_106 - 0.00144592096755628*x_107 - 0.00338312225842907*x_108 + 0.000623223231655231*x_109 - 0.000217439714474632*x_11 - 0.000983546295067446*x_110 + 0.00091797081750389*x_111 - 0.000732037004152698*x_112 + 0.00185424503482037*x_113 - 0.000195139346662345*x_114 - 0.00146039986799112*x_115 + 0.00129089882574435*x_116 - 0.00026509808907966*x_117 - 0.000935527448806424*x_118 - 0.00174850557069644*x_119 + 0.000460607063844118*x_12 + 0.000740162673707555*x_120 + 0.00256469300994594*x_13 + 0.00139784871322548*x_14 + 0.000840354128200336*x_15 + 0.000762585377710563*x_16 + 0.000472623526367954*x_17 + 0.00557019754218514*x_18 + 0.00212474031523584*x_19 - 0.00197786502660395*x_2 + 0.000349686735796028*x_20 + 0.00306609492168262*x_21 + 0.0140406321426462*x_22 + 0.000105842446440854*x_23 + 0.00411239950745393*x_24 + 0.0150865682553108*x_25 + 0.00300102787037099*x_26 + 0.00250130455728901*x_27 + 0.00149644100926561*x_28 - 0.00252984541465527*x_29 + 0.000712757602361002*x_3 + 0.000110062287541809*x_30 + 0.00110427161790269*x_31 - 0.0012148162801993*x_32 + 0.00168387522761008*x_33 + 0.00194675212890166*x_34 - 1.06642931184563e-5*x_35 + 0.000937116954774122*x_36 - 5.40393828649917e-5*x_37 + 0.00335207290696518*x_38 + 0.00131950084125732*x_39 + 0.00260114777586299*x_4 - 0.000690602734589736*x_40 - 0.00343758205510913*x_41 - 0.00424478449649433*x_42 - 0.000280247757265613*x_43 - 0.00173719134216727*x_44 - 0.000616967746258426*x_45 - 0.00162459900961602*x_46 + 0.00112338955700714*x_47 + 0.00256936304990638*x_48 + 0.000221876886031736*x_49 + 0.000655312504374908*x_5 + 0.00124580939581169*x_50 + 0.00506087837916612*x_51 + 0.00243315162141087*x_52 - 0.00497480397131779*x_53 - 0.00563528420836927*x_54 - 0.00131231144208753*x_55 + 0.00301544055244605*x_56 - 0.00635265518882922*x_57 - 0.00378009973989128*x_58 - 0.00545152045308042*x_59 + 0.000238537847251791*x_6 - 0.0037839638391508*x_60 + 0.00155282693119085*x_61 + 0.000687867411457005*x_62 - 0.00427809541891546*x_63 - 0.00183314182545755*x_64 - 0.00180255226079676*x_65 - 0.00125672879316813*x_66 + 0.000726185267579077*x_67 + 0.00103651158307661*x_68 - 0.00165452499182707*x_69 + 0.000623589920972717*x_7 - 0.000109545429501418*x_70 - 0.00199518156056146*x_71 + 0.000534593347995156*x_72 + 0.000653608272706364*x_73 + 0.00245059996404453*x_74 + 0.00130518370343494*x_75 - 0.000107195194189276*x_76 + 9.24880221515515e-5*x_77 - 0.00159080513650657*x_78 - 0.000503954314369822*x_79 + 0.000175661468618674*x_8 + 0.000562344031051451*x_80 + 0.00141511882718727*x_81 + 6.93351792843613e-5*x_82 + 6.27658391112616e-6*x_83 - 0.000695776350841152*x_84 - 0.00229711071491988*x_85 + 0.00141892045293091*x_86 + 0.0012216151937558*x_87 - 0.0026790665000864*x_88 - 5.85107586585782e-6*x_89 + 0.000452234942268316*x_9 + 0.000799846072121475*x_90 - 0.000536109293339989*x_91 - 0.00692843929266183*x_92 - 0.000394725529441672*x_93 + 5.75629772270183e-5*x_94 - 0.00120710700895788*x_95 + 0.00201765086073111*x_96 - 6.68105107175767e-5*x_97 + 0.00267902996693443*x_98 + 0.00431067983905398*x_99 + 2.28284929402242e-6*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) + 0.0171388687405219*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.00415087522183861*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.024983907746949*std::sin(0.369519829750061*x_1 - 4.20887994766235) + 0.120821913569982*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.00437426865996832*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.0254059126822587*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.0130849660419265*std::sin(0.260159969329834*x_113 + 5.18175983428955) + 0.00464836203821286*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.0141182500146488*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.00155322651120725*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.00198498461300748*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00550504923869972*std::sin(0.292479932308197*x_12 + 5.13503980636597) + 0.0141456877059648*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.00145430102813911*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.000752387681022606*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.00337850911849197*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.00324604101802243*std::sin(0.317359924316406*x_16 - 1.18911993503571) + 0.00447770168103475*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.00500733796320831*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.00472194746903809*std::sin(0.350719839334488*x_17 + 2.00255990028381) - 0.0385904091604844*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.00118132379546332*std::sin(0.296639919281006*x_18 - 1.14375984668732) - 0.0076195581220633*std::sin(0.34623983502388*x_18 + 2.01407980918884) - 0.00444975540044956*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.0255420684249597*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.00337819930694916*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.000522184459879583*std::sin(0.389039844274521*x_2 + 5.18200016021729) + 0.00611763414579168*std::sin(0.282959938049316*x_21 - 1.16959989070892) - 0.0659506375219453*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.00332128737641192*std::sin(0.319359928369522*x_23 + 5.05087995529175) - 0.00389266834850939*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.00036360956510039*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.00784591055905345*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.0137088101126475*std::sin(0.225999996066093*x_29 + 2.00271987915039) - 0.00198066333057337*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00852887778882955*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.000650436611492618*std::sin(0.361839860677719*x_3 - 7.40983963012695) - 0.0136311457935796*std::sin(0.319199919700623*x_30 + 1.98799991607666) + 0.421882877193845*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.0216134744272811*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.00154416450454551*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.0148952423879215*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.00202733062624419*std::sin(0.385359823703766*x_31 - 7.40199947357178) + 0.00380099059040208*std::sin(0.392639845609665*x_31 - 7.41215991973877) - 0.00155523331362541*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.000528175653611535*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.0172551180213174*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.00207120978262936*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.000934481691532847*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.000258697167495849*std::sin(0.244479969143867*x_41 - 1.19223988056183) - 0.00321780356559012*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.000793343595462247*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.00217291537631454*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00339290215315674*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.0170490772535752*std::sin(0.283359944820404*x_6 + 2.00127983093262) + 0.182131974006331*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.000811368832450317*std::sin(0.477679848670959*x_6 - 4.27952003479004) - 0.142003175611798*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.00824501944463652*std::sin(0.362399846315384*x_7 - 1.14935994148254) - 0.0150834088977087*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.00119692832627446*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.0013604074037889*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.00230391402366371*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.00157026669355783*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.000794079572553025*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.00183647671302786*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00932766297394392*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 0.179898346783689);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000292007137875463*x_1 + 0.000441027801625131*x_10 + 0.0021347934096853*x_100 + 0.00289272520684625*x_101 + 0.0031101376158199*x_102 + 0.00210486025478577*x_103 + 0.00127060492829119*x_104 + 0.000825147125868489*x_105 + 0.00399285728906124*x_106 - 0.00193338983224051*x_107 - 0.000657595978233159*x_108 + 8.33770668140005e-5*x_109 - 0.000258859584224158*x_11 + 0.000376994381797265*x_110 + 0.00107425160146975*x_111 - 0.000499569090233257*x_112 + 0.00330352529190631*x_113 + 0.00263678695955147*x_114 - 6.10448219180239e-5*x_115 + 0.00267888627284774*x_116 + 0.00802526653685305*x_117 + 0.00111859663801125*x_118 + 0.00115522408909839*x_119 - 0.000190738126921281*x_12 + 0.00349792877276876*x_120 + 0.000162170467875502*x_13 + 0.00653297756950106*x_14 + 0.000435340228308802*x_15 + 7.67854269006993e-5*x_16 + 0.000682258117893382*x_17 + 0.00020346523633755*x_18 + 9.09335323716471e-5*x_19 + 0.000197007606403865*x_2 + 0.00132048459353552*x_20 + 0.00127837819757001*x_21 - 0.00139820345817272*x_22 - 0.00442567146362084*x_23 + 0.000207753905979105*x_24 + 0.000217864593108296*x_25 - 6.61848060983082e-5*x_26 + 0.000965855153835016*x_27 + 0.00214270733660976*x_28 + 0.00264279873047033*x_29 - 0.000365240075608196*x_3 + 0.000858875975494359*x_30 - 0.000128410316744012*x_31 + 0.000550480004912129*x_32 + 0.0059750262395404*x_33 + 0.000477403471255556*x_34 + 0.000176308022095447*x_35 - 0.00071028674070599*x_36 + 0.000386456849097088*x_37 + 0.0020693275980536*x_38 - 0.000169217261144339*x_39 - 8.92869766529909e-5*x_4 + 0.00114813951280268*x_40 + 0.000526362143854038*x_41 + 0.00111622938385234*x_42 + 0.00239944215889786*x_43 + 0.00138537039711278*x_44 + 0.000249609016983418*x_45 + 0.00192558890287259*x_46 - 0.00347385076887429*x_47 + 0.000581327258305295*x_48 + 0.000607372738335089*x_49 - 0.000404551065078494*x_5 + 0.000683398793828983*x_50 + 0.00137692053385863*x_51 - 0.00336972589724538*x_52 - 0.00320996671266563*x_53 - 1.62133728893465e-5*x_54 - 0.00186729850367019*x_55 - 0.000424990847592952*x_56 + 0.00141109661228619*x_57 + 0.00157239119428938*x_58 + 0.00149799785393674*x_59 + 0.000959646280834053*x_6 + 0.00251343832365537*x_60 + 0.00108808051105263*x_61 + 9.26024803909398e-5*x_62 + 0.00017022160484459*x_63 + 0.000211098366954187*x_64 - 0.000899049915333536*x_65 - 0.000153680599923303*x_66 + 0.00111810701970457*x_67 + 0.000144929639227776*x_68 + 4.85285365400295e-5*x_69 - 0.00522862978633889*x_7 - 0.000294618523479482*x_70 - 0.000336639893254393*x_71 + 0.000953484835549423*x_72 + 0.000891771472796841*x_73 + 0.000758364232840226*x_74 + 0.000816364440416943*x_75 + 0.000773647878065144*x_76 + 0.00152574561906138*x_77 - 0.000322537885834841*x_78 + 0.000539566284671286*x_79 - 0.000753831894441287*x_8 + 0.00131245307154918*x_80 + 0.000589173404914259*x_81 - 0.00129517686818415*x_82 + 0.000296292187081025*x_83 + 0.00154608353040715*x_84 + 0.00111015411866603*x_85 + 9.87550191696749e-5*x_86 + 0.000706357119856854*x_87 - 8.19688166367689e-5*x_88 - 5.6621554822845e-5*x_89 - 0.000586269013461528*x_9 + 0.000858435560219807*x_90 + 0.000467405064913753*x_91 - 0.00156511668122788*x_92 - 0.00010330651140408*x_93 - 0.00015080144384061*x_94 - 0.00199156350368731*x_95 + 0.000860710757717951*x_96 + 0.000914720699309495*x_97 - 0.000235084754412767*x_98 - 0.000316809721111528*x_99 + 8.70204688243607e-7*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) + 0.00964317825622217*std::sin(0.151120036840439*x_1 + 4.9399995803833) + 0.222045576741215*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.00952367451893091*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.0140497862478852*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.00166743775224617*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.00968453957214753*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.00498788896183745*std::sin(0.260159969329834*x_113 + 5.18175983428955) + 0.0026153992082314*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.00538176890814156*std::sin(0.250319957733154*x_116 + 5.15336036682129) + 0.0830877966835131*std::sin(0.233919993042946*x_118 + 5.16031980514526) - 0.106184124952436*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00209848265896143*std::sin(0.292479932308197*x_12 + 5.13503980636597) + 0.00795906603701049*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.00816270132403128*std::sin(0.284959942102432*x_13 + 1.96391975879669) + 0.0402479832895698*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.0189628971727085*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.00123736600550488*std::sin(0.317359924316406*x_16 - 1.18911993503571) + 0.00251937722040626*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.0281051882872237*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.0265033484208171*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.00448748893228868*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.00663053461612196*std::sin(0.296639919281006*x_18 - 1.14375984668732) - 0.00428714160293315*std::sin(0.34623983502388*x_18 + 2.01407980918884) - 0.00250365325581084*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.00973644109974287*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.0189611582623717*std::sin(0.377999842166901*x_2 + 5.174880027771) - 0.0279335666245113*std::sin(0.389039844274521*x_2 + 5.18200016021729) + 0.00344208462456689*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.00766907535824109*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.00126604934172653*std::sin(0.319359928369522*x_23 + 5.05087995529175) - 0.00219020842888414*std::sin(0.234959989786148*x_26 + 8.20392036437988) + 0.019450812485656*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.00299080108787999*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.00522569354950598*std::sin(0.225999996066093*x_29 + 2.00271987915039) - 0.00111441950174479*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00325114297151818*std::sin(0.352239847183228*x_3 - 7.39423990249634) - 0.0347942457466854*std::sin(0.361839860677719*x_3 - 7.40983963012695) - 0.0076695592173628*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.0490586853913968*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.00823889111957671*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.00866708707612225*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.00567795245723606*std::sin(0.38239985704422*x_31 - 7.39735984802246) + 0.108449368889996*std::sin(0.385359823703766*x_31 - 7.40199947357178) + 0.00213862597166692*std::sin(0.392639845609665*x_31 - 7.41215991973877) - 0.000875051457617277*std::sin(0.285599917173386*x_32 - 1.1373598575592) + 0.0282540576044811*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.00657751899683646*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.0116252869989707*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.00524505916805866*std::sin(0.359679847955704*x_4 - 1.1697598695755) + 0.0138386626164326*std::sin(0.244479969143867*x_41 - 1.19223988056183) - 0.00181049600450747*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.00445287921261924*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.0121961401911036*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00129334834680498*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.00649897783228035*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.0211792317145528*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.00455405126914785*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.0165128510624941*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.046277648048916*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 0.00175397545561558*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.00671811973216632*std::sin(0.348079830408096*x_8 + 8.25920009613037) - 0.0727731937081749*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.0129314094451807*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.00881359345182327*std::sin(0.23871998488903*x_93 + 1.96887981891632) - 0.0424782358521133*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.0103077771430629*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00355563377378278*std::sin(0.294399946928024*x_94 + 1.96591985225677) + 0.144822060239552);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00173695339552763*x_1 - 0.00126442492863184*x_10 + 0.00120024037225616*x_100 - 0.000988653768258169*x_101 + 0.00101281785653486*x_102 + 0.0029534689338321*x_103 + 0.00404860796449132*x_104 - 0.00303034381974613*x_105 - 0.00236815987590195*x_106 - 0.00112506248708632*x_107 - 0.00108898211484611*x_108 - 0.00159530929108519*x_109 - 0.00312064421924982*x_11 + 0.00303024958708206*x_110 - 0.00336741973825045*x_111 - 0.00121919485688712*x_112 - 0.00108551258668683*x_113 - 0.00357527775890064*x_114 + 0.00238552798931156*x_115 - 0.00217097248795542*x_116 - 0.00206760172326061*x_117 + 0.00153473950944597*x_118 - 0.0028552564965306*x_119 - 0.000366009843527748*x_12 - 0.00178806002538539*x_120 - 0.000264947441203614*x_13 - 0.00314526769239379*x_14 + 0.000186074515937592*x_15 - 0.000578716120092321*x_16 - 0.000412762212825954*x_17 - 0.003577336705643*x_18 - 0.00387994917290086*x_19 + 0.00131953568885127*x_2 + 0.000174683852189015*x_20 - 0.00146171823757684*x_21 - 0.00971244986227976*x_22 + 0.00207150691261178*x_23 - 0.00119127469785572*x_24 - 0.00760090254207366*x_25 - 0.00120124798010261*x_26 - 0.000943097715720744*x_27 + 0.00150200098650507*x_28 + 0.00980984013837103*x_29 - 0.00162848177112805*x_3 + 0.00252964574410053*x_30 - 0.00070038074536895*x_31 + 0.0023174594059039*x_32 - 0.003736432702074*x_33 + 0.00145358389877199*x_34 - 0.000699237839229885*x_35 + 0.00479813665073565*x_36 - 1.27287691426352e-5*x_37 + 0.00149776250828307*x_38 + 0.000344435935941119*x_39 - 0.00128349371497683*x_4 + 0.000251983882394738*x_40 + 0.00212142806976208*x_41 + 0.00520466702135697*x_42 - 0.00389746328933145*x_43 + 0.00159282138876892*x_44 - 0.00141066219326756*x_45 + 0.000312874602194891*x_46 + 0.00346020053001049*x_47 - 0.00134605364430807*x_48 + 0.000265393023941396*x_49 - 0.00213983373106744*x_5 + 0.0020530124337658*x_50 + 0.00169204824950823*x_51 - 0.000571791000792973*x_52 + 0.00530481187746058*x_53 + 0.00390326422990307*x_54 - 0.00192220030993546*x_55 - 0.00781473518462467*x_56 + 0.00444032460018192*x_57 + 0.00465012519043378*x_58 + 0.00552674008409072*x_59 - 0.00095945713105312*x_6 + 0.00425827300872909*x_60 - 0.00112824363369423*x_61 - 0.00185408517679811*x_62 + 0.00399522609491276*x_63 + 0.00227624610175665*x_64 + 0.00105809303560937*x_65 - 7.360788871375e-5*x_66 - 0.000864901090188263*x_67 - 0.00312814033405426*x_68 + 0.000535135815544699*x_69 + 0.00278298858471263*x_7 - 0.000364571038927977*x_70 + 0.00191914909923326*x_71 + 0.00102045064249568*x_72 - 0.00182753654216334*x_73 - 0.0016212359194129*x_74 - 0.00155138396206983*x_75 + 4.71438108759238e-5*x_76 - 0.000772577851950679*x_77 + 0.0020993062746796*x_78 - 0.00100128448092013*x_79 + 0.000604763512401686*x_8 + 0.000866358156352462*x_80 - 0.000508463432529327*x_81 + 0.000426664536631793*x_82 - 0.000810227013482486*x_83 - 0.000554161795887172*x_84 + 0.00229377227665875*x_85 - 0.00288421961450235*x_86 + 0.000243023441294783*x_87 + 0.0025526182544815*x_88 + 7.39989408692499e-5*x_89 - 0.00226123940460338*x_9 - 0.000497521444867981*x_90 + 0.00110421651811187*x_91 + 0.00552356600798761*x_92 - 0.000586576144968827*x_93 + 1.95956397138002e-5*x_94 + 0.00298400738069842*x_95 + 0.00195359204588585*x_96 + 0.00113032244423882*x_97 - 0.00160319230318992*x_98 + 0.0028079446115653*x_99 + 1.6497829158687e-6*std::pow(-5.19888019561768*x_10 - 9.00167942047119, 2) - 0.0338265452989394*std::sin(0.151120036840439*x_1 + 4.9399995803833) - 0.124642403345785*std::sin(0.329999834299088*x_1 - 4.25616025924683) + 0.0180555169719195*std::sin(0.369519829750061*x_1 - 4.20887994766235) - 0.076630912640647*std::sin(0.263279944658279*x_11 + 1.97639977931976) + 0.00316122212864952*std::sin(0.29479992389679*x_11 - 1.08255982398987) - 0.0183604939734715*std::sin(0.279519945383072*x_112 - 7.44312000274658) - 0.00945631999765312*std::sin(0.260159969329834*x_113 + 5.18175983428955) - 0.00917435283693581*std::sin(0.278319954872131*x_113 + 5.16416025161743) - 0.0102030597188874*std::sin(0.250319957733154*x_116 + 5.15336036682129) - 0.0466402565605205*std::sin(0.233919993042946*x_118 + 5.16031980514526) + 0.0596050807472995*std::sin(0.269359946250916*x_12 - 4.25047969818115) + 0.00397842126889591*std::sin(0.292479932308197*x_12 + 5.13503980636597) - 0.0279189807224054*std::sin(0.269039958715439*x_120 + 5.14904022216797) + 0.0337914451404893*std::sin(0.284959942102432*x_13 + 1.96391975879669) - 0.0225926831808931*std::sin(0.286239922046661*x_13 + 5.15136003494263) + 0.0785014266820996*std::sin(0.285599917173386*x_15 + 8.3473596572876) + 0.00234586795973132*std::sin(0.317359924316406*x_16 - 1.18911993503571) - 0.0088375248706203*std::sin(0.324959844350815*x_16 - 1.13615989685059) - 0.116348116937079*std::sin(0.329759836196899*x_16 - 1.13863980770111) + 0.10971691951593*std::sin(0.350719839334488*x_17 + 2.00255990028381) + 0.0244758437088569*std::sin(0.380799859762192*x_17 + 2.00471973419189) - 0.0274486763435989*std::sin(0.296639919281006*x_18 - 1.14375984668732) + 0.0150385262805874*std::sin(0.34623983502388*x_18 + 2.01407980918884) + 0.00878236801397685*std::sin(0.306159913539886*x_19 + 1.98039984703064) + 0.0184588918041096*std::sin(0.361359834671021*x_2 + 5.1780800819397) - 0.0784942280488387*std::sin(0.377999842166901*x_2 + 5.174880027771) + 0.0156801451719818*std::sin(0.389039844274521*x_2 + 5.18200016021729) - 0.0120742174812093*std::sin(0.282959938049316*x_21 - 1.16959989070892) + 0.0418289811277644*std::sin(0.291999936103821*x_23 + 2.00887989997864) + 0.00240024743930422*std::sin(0.319359928369522*x_23 + 5.05087995529175) + 0.00768285959931979*std::sin(0.234959989786148*x_26 + 8.20392036437988) - 0.0109184612043225*std::sin(0.319119930267334*x_26 - 1.20175993442535) + 0.00567012865617274*std::sin(0.301679939031601*x_28 - 1.19359982013702) - 0.00990716328929592*std::sin(0.225999996066093*x_29 + 2.00271987915039) + 0.00390918437429775*std::sin(0.341999858617783*x_3 - 4.2087197303772) - 0.00616369941913688*std::sin(0.352239847183228*x_3 - 7.39423990249634) + 0.0195312983763019*std::sin(0.361839860677719*x_3 - 7.40983963012695) + 0.0269034425576052*std::sin(0.319199919700623*x_30 + 1.98799991607666) - 0.267577866891676*std::sin(0.335759848356247*x_30 - 1.15191984176636) + 0.0156197524541203*std::sin(0.368719846010208*x_30 - 1.15703988075256) - 0.0358794700227974*std::sin(0.367359846830368*x_31 + 8.36415958404541) + 0.0107645811239763*std::sin(0.38239985704422*x_31 - 7.39735984802246) - 0.0608766460389195*std::sin(0.385359823703766*x_31 - 7.40199947357178) - 0.00750191756140161*std::sin(0.392639845609665*x_31 - 7.41215991973877) + 0.00306952407012643*std::sin(0.285599917173386*x_32 - 1.1373598575592) - 0.0158600486250493*std::sin(0.293199926614761*x_32 + 2.02391982078552) - 0.0124700298865143*std::sin(0.231999978423119*x_33 - 7.41767978668213) - 0.0481256427589284*std::sin(0.229999989271164*x_37 + 1.9883998632431) - 0.021713170934514*std::sin(0.359679847955704*x_4 - 1.1697598695755) - 0.00776815369582394*std::sin(0.244479969143867*x_41 - 1.19223988056183) + 0.00635089630024254*std::sin(0.360559850931168*x_5 + 2.01591968536377) - 0.0184337534423147*std::sin(0.371839851140976*x_5 - 1.16791987419128) + 0.0504888254308758*std::sin(0.19336000084877*x_53 + 1.98367977142334) - 0.00245200242615628*std::sin(0.242479979991913*x_57 - 4.42295980453491) + 0.0123211271361297*std::sin(0.283359944820404*x_6 + 2.00127983093262) - 0.115516622579096*std::sin(0.385039836168289*x_6 + 2.00575971603394) + 0.0188525792528184*std::sin(0.477679848670959*x_6 - 4.27952003479004) + 0.0900650604138888*std::sin(0.360079854726791*x_7 - 1.15847992897034) - 0.191577339804406*std::sin(0.362399846315384*x_7 - 1.14935994148254) + 0.00956660389999517*std::sin(0.339919835329056*x_8 - 1.13207995891571) + 0.0278112557797989*std::sin(0.348079830408096*x_8 + 8.25920009613037) + 0.0408502880177015*std::sin(0.360959857702255*x_91 + 2.01151990890503) + 0.0535326475280396*std::sin(0.277999937534332*x_92 + 2.01671981811523) - 0.0364859680386758*std::sin(0.23871998488903*x_93 + 1.96887981891632) + 0.0238446065181794*std::sin(0.242879971861839*x_93 + 1.95855975151062) - 0.0426714970967698*std::sin(0.293279945850372*x_94 + 1.96727979183197) + 0.00674097018129424*std::sin(0.294399946928024*x_94 + 1.96591985225677) - 0.830196088169846);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
