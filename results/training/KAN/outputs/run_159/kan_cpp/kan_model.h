
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (117386.987598795*x_1 + 864772.944948509*x_10 - 44695.865292354*x_100 - 5470.77252441925*x_101 - 11493.0935347229*x_102 + 8609.78380321589*x_103 - 1090117.30697822*x_104 - 31184.771098163*x_105 + 133964.839653023*x_106 + 22086.1616154142*x_107 + 25756.9874482574*x_108 + 14928.2507985253*x_109 - 234402.815102944*x_11 + 46119.6027256946*x_110 - 15997.726237963*x_111 + 42545.4746173623*x_112 - 1076.10130054406*x_113 + 37692.4357071266*x_114 - 34102.5254569595*x_115 + 83725.1764870855*x_116 - 27407.6724473694*x_117 + 4268.65450781292*x_118 - 21589.444428542*x_119 - 103852.568635922*x_12 + 26304.0360319811*x_120 - 48354.4179446638*x_13 - 6621.40758022969*x_14 - 161457.860741426*x_15 + 66068.3347297097*x_16 + 147126.018370267*x_17 - 321232.056114411*x_18 + 71668.6766902865*x_19 - 34292.144796861*x_2 - 55955.3588779341*x_20 + 123787.083860203*x_21 + 96067.9641840719*x_22 + 375566.629468405*x_23 + 1578174.38306673*x_24 + 128574.315756197*x_25 - 145315.117396954*x_26 - 512323.521517962*x_27 - 137968.997441939*x_28 + 244328.20308556*x_29 + 4611.8552889219*x_3 + 294872.882222287*x_30 + 37440.7408656849*x_31 - 28181.4586768036*x_32 + 3144.15403087557*x_33 + 489424.982575458*x_34 + 55440.5492257054*x_35 + 233157.229427589*x_36 + 1610253.11685556*x_37 - 61286.3138157922*x_38 + 899962.182754278*x_39 - 19515.8810138008*x_4 - 57488.2710016579*x_40 - 58341533.7053679*x_41 + 3217046.53862793*x_42 - 1291096.98242924*x_43 + 17463.8145216368*x_44 + 4006869.57683766*x_45 + 3623252.18560488*x_46 + 461387.521243775*x_47 + 97582.4358281681*x_48 - 99507.6586710567*x_49 - 41.9043244855818*x_5 + 229403.827879171*x_50 + 151559.763455385*x_51 - 451622.396872418*x_52 + 30243.3546802144*x_53 - 33390.4477820229*x_54 - 369773.822462206*x_55 + 944295.160665846*x_56 + 263921.470546701*x_57 - 365293.372689161*x_58 + 5467324.85551406*x_59 - 2428.84287834059*x_6 - 75928.7008363854*x_60 + 40415.1228049303*x_61 + 135657.262557397*x_62 + 36887.335731441*x_63 - 9086.77727272552*x_64 - 1522.74165149236*x_65 - 87322.8342779843*x_66 - 27958.7231606498*x_67 - 25216.9707160943*x_68 - 5434.51343133519*x_69 + 19906.823634784*x_7 + 16210.1956066286*x_70 - 34069.1542750358*x_71 - 298.733484213964*x_72 - 79806.2156313827*x_73 + 32319.0228996074*x_74 - 5738.56285862189*x_75 - 99531.9037964083*x_76 - 21815.5904087789*x_77 + 56883.14171392*x_78 - 15047.3037388167*x_79 - 96919.5805546764*x_8 - 8878.51980384839*x_80 + 5672.53872236872*x_81 - 19860.3861665762*x_82 + 102832.999950644*x_83 + 132820.580625174*x_84 + 1034313.67527262*x_85 + 79536.2083659205*x_86 + 2101529.20914507*x_87 - 22907.5553168245*x_88 - 106673.618110353*x_89 - 37204.9890528485*x_9 + 115959.504179897*x_90 + 21497.8995365079*x_91 - 35955.2484288514*x_92 - 45419.7771729138*x_93 - 34266.9873956546*x_94 - 38842.1498851185*x_95 + 24768.083821149*x_96 - 34701.6943597583*x_97 + 159.18485328462*x_98 + 48960.6671399294*x_99 - 76.8259987288698*std::exp(1.05479979515076*x_1) + 42.0976711441695*std::exp(1.21727991104126*x_1) - 0.278737224343872*std::exp(0.597359836101532*x_22) - 0.000464701750945267*std::exp(0.880879878997803*x_23) + 0.299353293104242*std::exp(0.955039799213409*x_23) + 3.76773392508789*std::exp(0.962799787521362*x_23) - 8.358457162007e-5*std::exp(0.982959806919098*x_23) + 0.407602209363927*std::exp(0.987919807434082*x_23) - 0.0121805775931213*std::exp(0.994559824466705*x_23) - 51.0181654540294*std::exp(1.00807988643646*x_23) + 6.84497419257404*std::exp(0.904399812221527*x_24) + 4.47763293713075*std::exp(0.316319853067398*x_25) + 0.000909735260212585*std::exp(0.764399826526642*x_3) - 1.69658791267845*std::exp(0.810799837112427*x_3) + 4534.56481369878*std::exp(0.952639818191528*x_4) + 0.000654333310013278*std::exp(1.02783977985382*x_4) + 11.2780991355388*std::exp(1.03087985515594*x_5) - 1251.44404179182*std::exp(1.22399985790253*x_5) - 41.4834511821453*std::exp(1.27887988090515*x_5) - 0.000107410396655725*std::exp(1.30207979679108*x_5) - 1.43912897220301*std::exp(1.35575985908508*x_5) + 0.00800843526237216*std::exp(1.36415994167328*x_5) + 135.543602072342*std::exp(1.37703990936279*x_6) + 2.32882628765536e-5*std::exp(1.45175981521606*x_6) + 0.00855823560173296*std::exp(1.46799981594086*x_6) - 0.032596686646472*std::exp(1.52735984325409*x_6) - 5.74656270411917e-7*std::exp(1.53255987167358*x_6) - 8.35728889009767e-5*std::exp(1.55359983444214*x_6) - 0.00406515225090899*std::exp(1.59999990463257*x_6) + 0.0526052389177055*std::exp(1.63423991203308*x_6) + 1.27737152141426e-5*std::exp(1.6639997959137*x_6) + 2.34811685521545e-5*std::exp(0.870079874992371*x_8) - 0.334173088174938*std::exp(0.926959812641144*x_8) + 0.00112556391439888*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 25.4059770583585*std::sin(0.227679997682571*x_119 - 7.40967988967896) + 0.0284637931047097*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.0589924257163616*std::sin(0.276479959487915*x_16 - 1.17711985111237) + 0.0277497730550311*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 1905.04764786253*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 761.952506878205*std::sin(0.281439960002899*x_17 + 5.0383996963501) + 2775.88305501761*std::sin(0.364639848470688*x_31 - 7.40783977508545) - 0.0126756929326832*std::sin(0.338239848613739*x_32 - 1.21039986610413) - 1.96155919975981*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 4.83044073037185*std::sin(0.327439844608307*x_91 - 7.40367984771729) - 0.057150375966243*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0439978246757402*std::sin(0.332719832658768*x_91 - 7.40847969055176) + 0.0307663697241997*std::sin(0.359919846057892*x_91 + 1.99703979492188) + 176.805427399079*std::sin(0.372159838676453*x_91 + 2.00287985801697) - 0.063312943328618*std::sin(0.295439928770065*x_94 + 1.95695984363556) - 446.362969906022*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.0537162808721997*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 15935354.7052236 - 0.608110497557351*std::exp(-6.37967967987061*x_93) + 0.0967341399089576*std::exp(-6.11312007904053*x_93) - 6.76364672133095e-5*std::exp(-7.8121600151062*x_113) - 0.203024971357571*std::exp(-7.73320007324219*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (20295.3716294405*x_1 + 137039.364041349*x_10 - 7931.1653439528*x_100 - 1192.67319251902*x_101 - 2109.60978937125*x_102 + 1724.41586470627*x_103 - 188317.1390679*x_104 - 5023.92816615271*x_105 + 24495.7354531158*x_106 + 4045.14476916999*x_107 + 4894.22290423811*x_108 + 2717.9553238208*x_109 - 43819.567351327*x_11 + 8279.05420614272*x_110 - 2579.91553170558*x_111 + 6792.57407057577*x_112 - 237.647983260421*x_113 + 6285.48261572782*x_114 - 5736.20640845305*x_115 + 16755.2624895157*x_116 - 4432.86963071753*x_117 + 1316.64722937026*x_118 - 3671.17271015314*x_119 - 16737.7501810613*x_12 + 4140.22696342509*x_120 - 8036.72748989806*x_13 + 107.221826577059*x_14 - 26125.0138319342*x_15 + 11578.696225288*x_16 + 24847.9843515986*x_17 - 44969.5412599995*x_18 + 14982.1945115344*x_19 - 5560.69929133193*x_2 - 8341.33801945847*x_20 + 22624.8239361382*x_21 + 12975.3660196616*x_22 + 66264.1608657449*x_23 + 262801.501562902*x_24 + 22832.5656491352*x_25 - 21325.6564722885*x_26 - 87019.8201164448*x_27 + 6884.71251143906*x_28 + 62154.3754227812*x_29 + 1209.18985994654*x_3 + 47631.9852660056*x_30 + 6456.25044915119*x_31 - 4603.00530251595*x_32 - 679.643632315024*x_33 + 50606.7831985054*x_34 + 8758.24393155987*x_35 + 43579.7354987712*x_36 + 263435.757377141*x_37 - 11930.3327210147*x_38 + 149941.492766406*x_39 - 7089.3892861134*x_4 - 11066.2837111664*x_40 - 10107484.4012105*x_41 + 590961.171769517*x_42 - 213158.649499278*x_43 + 3744.24666048379*x_44 + 672769.399940089*x_45 + 623806.353436507*x_46 + 42725.8907975155*x_47 + 17562.67284479*x_48 - 23901.9121291539*x_49 - 99.9084047075495*x_5 + 40427.5342222491*x_50 + 29871.2509047144*x_51 - 77772.4941857387*x_52 + 1394.47167244436*x_53 - 3596.07156238051*x_54 - 22689.0676387174*x_55 + 170508.95719052*x_56 + 45642.5799210081*x_57 - 85500.0602852847*x_58 + 927171.176511015*x_59 - 1142.17833173189*x_6 - 18976.2502194383*x_60 + 6758.6605756348*x_61 + 23242.8373911767*x_62 + 6432.49767687112*x_63 - 1796.24573945998*x_64 - 575.127903469278*x_65 - 14633.212848959*x_66 - 4967.83198614202*x_67 - 4515.89768250956*x_68 - 1156.11765095835*x_69 + 2700.75152686595*x_7 + 3010.92998931266*x_70 - 5869.04552176535*x_71 + 257.485599717308*x_72 - 13761.763577731*x_73 + 4460.36787836758*x_74 - 779.606475284377*x_75 - 17919.2013393849*x_76 - 3807.80123820989*x_77 + 10254.4432887065*x_78 - 2811.84976643037*x_79 - 16010.0264228817*x_8 - 1101.27362686762*x_80 + 1216.40314856897*x_81 - 3248.67472405974*x_82 + 18041.8748595364*x_83 + 23155.5793796316*x_84 + 163706.672615601*x_85 + 13074.5028346286*x_86 + 341402.138497018*x_87 - 3846.60968131991*x_88 - 20446.5404852039*x_89 - 6323.02849561833*x_9 + 19232.3759077199*x_90 + 3793.21783215475*x_91 - 5804.22812970012*x_92 - 7694.52448122409*x_93 - 5390.18458181253*x_94 - 6047.39088351661*x_95 + 4180.7673186838*x_96 - 6270.13544891885*x_97 - 266.983350720767*x_98 + 8410.73998380282*x_99 - 215.162720295513*std::exp(1.05479979515076*x_1) + 2.08061543420752*std::exp(1.21727991104126*x_1) - 0.441784193967893*std::exp(0.597359836101532*x_22) + 0.00157606807896246*std::exp(0.880879878997803*x_23) + 0.231410370487746*std::exp(0.955039799213409*x_23) - 5.36592654463076*std::exp(0.962799787521362*x_23) - 0.00597567579762747*std::exp(0.982959806919098*x_23) + 0.646028581030943*std::exp(0.987919807434082*x_23) + 0.038819345945698*std::exp(0.994559824466705*x_23) - 9.72796050891223*std::exp(1.00807988643646*x_23) + 19.1703758102056*std::exp(0.904399812221527*x_24) - 6.37694962334752*std::exp(0.316319853067398*x_25) - 0.00308542995805613*std::exp(0.764399826526642*x_3) + 2.41624443151957*std::exp(0.810799837112427*x_3) + 776.680437884991*std::exp(0.952639818191528*x_4) + 0.0107716211614566*std::exp(1.02783977985382*x_4) + 0.557403449933468*std::exp(1.03087985515594*x_5) - 214.347384214498*std::exp(1.22399985790253*x_5) - 18.6373590468597*std::exp(1.27887988090515*x_5) - 0.00176818768641593*std::exp(1.30207979679108*x_5) - 0.274407942430565*std::exp(1.35575985908508*x_5) - 0.00198856985462734*std::exp(1.36415994167328*x_5) + 23.2159134415778*std::exp(1.37703990936279*x_6) - 7.89837517495082e-5*std::exp(1.45175981521606*x_6) + 0.00661580987060931*std::exp(1.46799981594086*x_6) + 0.046423508034537*std::exp(1.52735984325409*x_6) - 4.10836533644543e-5*std::exp(1.53255987167358*x_6) + 0.000136321580742673*std::exp(1.55359983444214*x_6) + 0.00100941556693481*std::exp(1.59999990463257*x_6) + 0.147328853442885*std::exp(1.63423991203308*x_6) + 8.92309464671733e-7*std::exp(1.6639997959137*x_6) + 0.00167872907520446*std::exp(0.870079874992371*x_8) + 0.475922206820193*std::exp(0.926959812641144*x_8) + 0.0804694564031385*std::sin(0.277119934558868*x_112 + 1.96535980701447) + 36.1826523316787*std::sin(0.227679997682571*x_119 - 7.40967988967896) + 0.468570362306319*std::sin(0.239919975399971*x_16 + 8.20735931396484) + 0.0962266690939426*std::sin(0.276479959487915*x_16 - 1.17711985111237) + 0.00193846384739202*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 363.247641718939*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 37.6583811611507*std::sin(0.281439960002899*x_17 + 5.0383996963501) + 1247.126931202*std::sin(0.364639848470688*x_31 - 7.40783977508545) - 0.208666989958139*std::sin(0.338239848613739*x_32 - 1.21039986610413) - 3.10897065157363*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 3.73409648326534*std::sin(0.327439844608307*x_91 - 7.40367984771729) + 0.182137521689707*std::sin(0.331839829683304*x_91 + 2.00687980651855) - 0.0717679272298768*std::sin(0.332719832658768*x_91 - 7.40847969055176) + 0.002149188582825*std::sin(0.359919846057892*x_91 + 1.99703979492188) + 495.170090224954*std::sin(0.372159838676453*x_91 + 2.00287985801697) + 0.201777545532977*std::sin(0.295439928770065*x_94 + 1.95695984363556) - 1250.10637587811*std::sin(0.272399961948395*x_96 + 1.98335981369019) + 0.0876203804417018*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 2640866.3152165 - 0.273207106934702*std::exp(-6.37967967987061*x_93) + 0.0184449182859359*std::exp(-6.11312007904053*x_93) - 0.000107200328987292*std::exp(-7.8121600151062*x_113) - 0.0912134641367073*std::exp(-7.73320007324219*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7455.39162413734*x_1 + 159595.169939682*x_10 + 1702.08470609267*x_100 + 1763.05701707353*x_101 + 1298.86078797773*x_102 - 2387.51210818753*x_103 - 75368.6943673914*x_104 - 4561.78496437033*x_105 - 7750.16675109408*x_106 - 670.050210246343*x_107 - 4218.29111039878*x_108 - 1170.11304214787*x_109 + 31256.3860501221*x_11 - 2210.66190717219*x_110 - 2789.74202133531*x_111 + 7492.63143436698*x_112 - 5.51819135109298*x_113 + 5125.80279173265*x_114 - 4397.90470229756*x_115 - 18546.8824185377*x_116 - 6179.09356269601*x_117 - 4390.58962512586*x_118 - 2393.76679801024*x_119 - 16865.6443975447*x_12 + 5720.06596803508*x_120 - 5053.13098670369*x_13 - 10153.1590494394*x_14 - 19709.0517201286*x_15 + 648.539813481075*x_16 + 15002.4762079214*x_17 - 134219.427630756*x_18 - 11749.6003695349*x_19 - 4977.18616284393*x_2 - 18217.1261670623*x_20 - 1869.23904482843*x_21 + 22174.9355654425*x_22 - 63453.3443162926*x_23 + 201453.436951956*x_24 - 389.276003222884*x_25 - 53162.3782988833*x_26 - 31454.9887442023*x_27 - 278561.651308374*x_28 - 219306.097449439*x_29 - 4466.57862268689*x_3 + 51208.4294775494*x_30 + 2692.72815388776*x_31 - 3638.82694440477*x_32 + 19227.366366158*x_33 + 379843.287118728*x_34 + 10095.6725786914*x_35 - 21902.7622644525*x_36 + 192016.142773527*x_37 + 11671.3504759499*x_38 + 54106.9847691864*x_39 + 38503.4580058171*x_4 + 7362.01730658044*x_40 - 2676081.26381803*x_41 - 106855.802114224*x_42 - 162180.746695125*x_43 - 7594.89570951951*x_44 + 570435.620291974*x_45 + 250025.472785771*x_46 + 378024.287217118*x_47 + 1180.05884555155*x_48 + 69491.4429594733*x_49 - 72.6389426305245*x_5 - 24252.5817622981*x_50 - 32891.8854313512*x_51 - 62829.5121602795*x_52 + 54898.5221015817*x_53 - 6635.90834790172*x_54 - 437888.553769056*x_55 - 145258.002083859*x_56 + 4491.75572550868*x_57 + 180006.740919949*x_58 + 392847.310333027*x_59 + 7743.23468897932*x_6 + 56738.6730284491*x_60 + 3134.30216274371*x_61 + 8725.54142648438*x_62 + 1699.23766047355*x_63 + 1570.10840241263*x_64 + 3493.86053205733*x_65 - 14317.0579725481*x_66 + 423.369230270947*x_67 - 509.473538377204*x_68 + 2560.41042262199*x_69 + 9564.31813355702*x_7 - 897.175850632063*x_70 - 1049.00671531732*x_71 - 2424.61539948431*x_72 - 3929.44755160139*x_73 + 10550.4876509074*x_74 - 1917.71266302359*x_75 + 2941.38438820163*x_76 - 1233.79029942219*x_77 - 4135.23304035294*x_78 + 1747.85424867324*x_79 - 13958.8058428252*x_8 - 4221.44446201823*x_80 - 1149.2985158746*x_81 - 2478.39233070807*x_82 - 1925.08060782533*x_83 + 5148.22678188974*x_84 + 258856.875998007*x_85 + 5288.52689450413*x_86 + 395124.488549657*x_87 - 2269.39889333776*x_88 + 13141.3010197178*x_89 - 395.03927825487*x_9 + 18589.2969973908*x_90 + 398.467001014253*x_91 - 5331.17150751718*x_92 - 3133.95498480151*x_93 - 6980.15066932425*x_94 - 8604.73094640872*x_95 + 2254.56586079918*x_96 + 183.441680282665*x_97 + 5140.27992128239*x_98 + 5173.70249170753*x_99 - 198.828802524912*std::exp(1.05479979515076*x_1) - 1.11863062720459*std::exp(1.21727991104126*x_1) - 0.356336134514759*std::exp(0.597359836101532*x_22) - 0.00167995723064517*std::exp(0.880879878997803*x_23) - 0.0977014470653803*std::exp(0.955039799213409*x_23) - 21.3750126386227*std::exp(0.962799787521362*x_23) + 0.00175137593886016*std::exp(0.982959806919098*x_23) + 0.521076422592319*std::exp(0.987919807434082*x_23) - 0.298714813950284*std::exp(0.994559824466705*x_23) - 38.9983181429444*std::exp(1.00807988643646*x_23) + 17.7150709986409*std::exp(0.904399812221527*x_24) - 25.4023937266351*std::exp(0.316319853067398*x_25) + 0.00328881121118694*std::exp(0.764399826526642*x_3) + 9.62503955880865*std::exp(0.810799837112427*x_3) + 319.16160586185*std::exp(0.952639818191528*x_4) - 0.0101734956009245*std::exp(1.02783977985382*x_4) - 0.299684680096863*std::exp(1.03087985515594*x_5) - 88.0818571206455*std::exp(1.22399985790253*x_5) + 124.513429670796*std::exp(1.27887988090515*x_5) + 0.00167000392788867*std::exp(1.30207979679108*x_5) - 1.10007110226793*std::exp(1.35575985908508*x_5) + 0.0104373290153051*std::exp(1.36415994167328*x_5) + 9.54012468209079*std::exp(1.37703990936279*x_6) + 8.41900972592627e-5*std::exp(1.45175981521606*x_6) - 0.00279319460275521*std::exp(1.46799981594086*x_6) + 0.184926696762248*std::exp(1.52735984325409*x_6) + 1.20409681548561e-5*std::exp(1.53255987167358*x_6) - 5.85861538226278e-5*std::exp(1.55359983444214*x_6) - 0.0052980801055358*std::exp(1.59999990463257*x_6) + 0.136144493187224*std::exp(1.63423991203308*x_6) + 4.09738355270428e-5*std::exp(1.6639997959137*x_6) - 0.000492008905728347*std::exp(0.870079874992371*x_8) + 1.89582229670325*std::exp(0.926959812641144*x_8) - 0.0235843232682683*std::sin(0.277119934558868*x_112 + 1.96535980701447) + 144.132545322001*std::sin(0.227679997682571*x_119 - 7.40967988967896) - 0.442551631569104*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.0413547906843785*std::sin(0.276479959487915*x_16 - 1.17711985111237) + 0.0890120546769939*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 1456.21963447028*std::sin(0.26623997092247*x_17 + 8.23527908325195) + 20.2468067117135*std::sin(0.281439960002899*x_17 + 5.0383996963501) - 8331.8699311607*std::sin(0.364639848470688*x_31 - 7.40783977508545) + 0.197080149085953*std::sin(0.338239848613739*x_32 - 1.21039986610413) - 2.50764649217416*std::sin(0.326799839735031*x_91 + 2.00583982467651) - 1.57653535201479*std::sin(0.327439844608307*x_91 - 7.40367984771729) - 1.40154798025226*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0308432956932736*std::sin(0.332719832658768*x_91 - 7.40847969055176) + 0.0986882948077502*std::sin(0.359919846057892*x_91 + 1.99703979492188) + 457.579621369164*std::sin(0.372159838676453*x_91 + 2.00287985801697) - 1.55267793686019*std::sin(0.295439928770065*x_94 + 1.95695984363556) - 1155.20548077857*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.0376561147441846*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 3766444.59016503 + 1.82525613255315*std::exp(-6.37967967987061*x_93) + 0.0739436381116615*std::exp(-6.11312007904053*x_93) - 8.646608767723e-5*std::exp(-7.8121600151062*x_113) + 0.609383616169009*std::exp(-7.73320007324219*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (14007.7763230083*x_1 + 85995.445018127*x_10 - 6301.6460338182*x_100 - 1032.82260452496*x_101 - 1853.89817554911*x_102 + 1586.41320366914*x_103 - 129440.730634551*x_104 - 3316.44064709274*x_105 + 19129.2258313459*x_106 + 3000.41744114713*x_107 + 4244.96426617014*x_108 + 2260.55419315595*x_109 - 37144.2492260421*x_11 + 6574.86007003435*x_110 - 1635.82702519597*x_111 + 4271.4317511874*x_112 - 144.158356690303*x_113 + 4017.32185174793*x_114 - 3672.43690447967*x_115 + 14156.2454619002*x_116 - 2359.22570976275*x_117 + 1281.68456591237*x_118 - 2424.18340826385*x_119 - 10740.7843081919*x_12 + 2399.87927938836*x_120 - 5549.91457184173*x_13 + 531.518765736324*x_14 - 18151.9623770433*x_15 + 8664.2988330127*x_16 + 16603.078610632*x_17 - 17356.5859070483*x_18 + 11081.3624959128*x_19 - 3638.44515627732*x_2 - 3895.6492239408*x_20 + 16510.9155407592*x_21 + 8582.06859008069*x_22 + 65547.056895452*x_23 + 170025.611241261*x_24 + 17168.6285851538*x_25 - 8745.85785770992*x_26 - 62620.2310340469*x_27 + 33190.987441473*x_28 + 74535.3343070426*x_29 + 1325.75606562179*x_3 + 29314.1972430604*x_30 + 4431.30631945446*x_31 - 3034.38065013222*x_32 - 3492.42307445795*x_33 - 3639.76615422321*x_34 + 5465.55837805625*x_35 + 34722.1595658643*x_36 + 180044.528171365*x_37 - 10453.695513526*x_38 + 111994.207470256*x_39 - 8923.2191149422*x_4 - 8947.97198933408*x_40 - 7250867.60240516*x_41 + 442471.619874049*x_42 - 141401.247680542*x_43 + 3857.91943075728*x_44 + 416052.16402763*x_45 + 430289.527227211*x_46 - 6409.97394884655*x_47 + 12418.5638816222*x_48 - 25216.9300880995*x_49 + 69.910840170897*x_5 + 35615.0379943783*x_50 + 26393.3262703873*x_51 - 45690.8461481216*x_52 - 7416.22067992026*x_53 - 4434.36739000776*x_54 + 33626.9072245287*x_55 + 158784.549695575*x_56 + 34679.3252299057*x_57 - 80475.897123538*x_58 + 658517.179027946*x_59 - 1798.22630827504*x_6 - 20310.0986509497*x_60 + 4857.10576722016*x_61 + 16363.5375227925*x_62 + 4532.01724463969*x_63 - 1511.50517613476*x_64 - 861.155986037476*x_65 - 8595.31197413976*x_66 - 3790.88460814889*x_67 - 3200.45685047075*x_68 - 1208.59164617674*x_69 + 799.820997471508*x_7 + 2301.31019520276*x_70 - 4326.87893879965*x_71 + 365.167474767029*x_72 - 9851.83550032636*x_73 + 2555.40687157074*x_74 - 420.883793601865*x_75 - 13804.6821164508*x_76 - 2628.39736704414*x_77 + 8389.50330332819*x_78 - 2335.87090544186*x_79 - 10080.6819899224*x_8 - 430.897223219053*x_80 + 882.964750571228*x_81 - 2197.31370074086*x_82 + 14251.0492870779*x_83 + 16516.7071599087*x_84 + 86098.2105493786*x_85 + 9786.9574344188*x_86 + 201970.953301386*x_87 - 2635.77106834737*x_88 - 16533.2682106246*x_89 - 5040.34610496431*x_9 + 11643.1906228998*x_90 + 2739.63821683876*x_91 - 3802.22843412862*x_92 - 5461.44220052975*x_93 - 3273.07788718645*x_94 - 3585.84992571628*x_95 + 2822.00745968899*x_96 - 4556.03528152855*x_97 - 1071.03479080014*x_98 + 5381.92278435838*x_99 + 153.748580663286*std::exp(1.05479979515076*x_1) + 0.566168111334477*std::exp(1.21727991104126*x_1) + 0.756321750383919*std::exp(0.597359836101532*x_22) - 0.00179816179239074*std::exp(0.880879878997803*x_23) + 0.0284424213701165*std::exp(0.955039799213409*x_23) + 4.45447712937726*std::exp(0.962799787521362*x_23) - 0.00510198798511866*std::exp(0.982959806919098*x_23) - 1.10598222814389*std::exp(0.987919807434082*x_23) - 0.0110789812788647*std::exp(0.994559824466705*x_23) + 9.91750668967011*std::exp(1.00807988643646*x_23) - 13.6985536693011*std::exp(0.904399812221527*x_24) + 5.29376912190794*std::exp(0.316319853067398*x_25) + 0.0035202173927199*std::exp(0.764399826526642*x_3) - 2.00582424482848*std::exp(0.810799837112427*x_3) + 539.8636254858*std::exp(0.952639818191528*x_4) + 0.00643482473790702*std::exp(1.02783977985382*x_4) + 0.151678226216924*std::exp(1.03087985515594*x_5) - 148.99094957323*std::exp(1.22399985790253*x_5) - 28.9083039577115*std::exp(1.27887988090515*x_5) - 0.00105629205625286*std::exp(1.30207979679108*x_5) + 0.279754692904078*std::exp(1.35575985908508*x_5) + 0.000244660825777388*std::exp(1.36415994167328*x_5) + 16.1371737823924*std::exp(1.37703990936279*x_6) + 9.01138513693757e-5*std::exp(1.45175981521606*x_6) + 0.000813142693855244*std::exp(1.46799981594086*x_6) - 0.0385380703752322*std::exp(1.52735984325409*x_6) - 3.50769206611655e-5*std::exp(1.53255987167358*x_6) - 8.96938343671958e-5*std::exp(1.55359983444214*x_6) - 0.000124191989325465*std::exp(1.59999990463257*x_6) - 0.105276611470993*std::exp(1.63423991203308*x_6) - 1.71774637020149e-5*std::exp(1.6639997959137*x_6) + 0.00143328652055773*std::exp(0.870079874992371*x_8) - 0.395082669881979*std::exp(0.926959812641144*x_8) + 0.0687042292188685*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 30.0367133152327*std::sin(0.227679997682571*x_119 - 7.40967988967896) + 0.27991776851638*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.0633130783284507*std::sin(0.276479959487915*x_16 - 1.17711985111237) - 0.0373165294043971*std::sin(0.332639843225479*x_16 + 2.03247976303101) + 370.325405150858*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 10.2474364975781*std::sin(0.281439960002899*x_17 + 5.0383996963501) + 1934.41164654228*std::sin(0.364639848470688*x_31 - 7.40783977508545) - 0.124654913948501*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 5.32246775053543*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 0.458954131527684*std::sin(0.327439844608307*x_91 - 7.40367984771729) - 0.0519817669211066*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0472202606715997*std::sin(0.332719832658768*x_91 - 7.40847969055176) - 0.0413731001764535*std::sin(0.359919846057892*x_91 + 1.99703979492188) - 353.833128966*std::sin(0.372159838676453*x_91 + 2.00287985801697) - 0.0575869993426014*std::sin(0.295439928770065*x_94 + 1.95695984363556) + 893.287093160961*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.0576505044007943*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 1289105.3076122 - 0.423770024004882*std::exp(-6.37967967987061*x_93) - 0.0188043115844888*std::exp(-6.11312007904053*x_93) + 0.000183523859767815*std::exp(-7.8121600151062*x_113) - 0.141480696898633*std::exp(-7.73320007324219*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-187607.860983249*x_1 - 1435896.90615796*x_10 + 70366.515093934*x_100 + 8209.91522881917*x_101 + 18488.8227861964*x_102 - 12705.1834558371*x_103 + 1756096.94252079*x_104 + 50950.8655044873*x_105 - 209122.464846696*x_106 - 34654.4661921323*x_107 - 39508.4677347342*x_108 - 23782.5528416694*x_109 + 360553.816014591*x_11 - 72422.4777203665*x_110 + 26738.6694807395*x_111 - 70216.8506694852*x_112 + 1994.15607913423*x_113 - 61800.0247216309*x_114 + 55955.617859475*x_115 - 122773.929844052*x_116 + 45049.9169119247*x_117 - 4877.13266553498*x_118 + 35582.1503750064*x_119 + 171710.785753384*x_12 - 43668.2538165214*x_120 + 79163.0704965772*x_13 + 17656.4259569477*x_14 + 263256.5946607*x_15 - 105231.119580293*x_16 - 238504.529680963*x_17 + 556812.20804617*x_18 - 109913.871279871*x_19 + 56080.5139068939*x_2 + 94418.8595598621*x_20 - 195687.729735851*x_21 - 150278.660778087*x_22 - 585064.871222004*x_23 - 2564042.29118045*x_24 - 204772.868168274*x_25 + 244959.054324014*x_26 + 825988.185377078*x_27 + 290775.599083644*x_28 - 324036.896064561*x_29 - 4215.18456471546*x_3 - 484065.016128089*x_30 - 60371.9206732642*x_31 + 45466.2572200601*x_32 - 10869.3202614879*x_33 - 935463.21009931*x_34 - 90942.4993377763*x_35 - 361138.678162279*x_36 - 2623669.40311424*x_37 + 95067.4213555675*x_38 - 1455153.00634973*x_39 + 7230.2938190536*x_4 + 89421.3039211903*x_40 + 93918231.4776862*x_41 - 5084011.30374157*x_42 + 2107537.16373538*x_43 - 26127.2766156807*x_44 - 6539091.69616873*x_45 - 5816731.93049214*x_46 - 880325.167874359*x_47 - 153628.037136135*x_48 + 122717.013366764*x_49 - 38.368901551033*x_5 - 352881.77617222*x_50 - 230797.576482804*x_51 + 728522.888625473*x_52 - 60173.064013299*x_53 + 59832.7101985315*x_54 + 715378.636454919*x_55 - 1470564.91812138*x_56 - 422476.394712604*x_57 + 521228.070749251*x_58 - 8871358.16518431*x_59 + 1448.44564757574*x_6 + 98539.6091963024*x_60 - 65610.0671438566*x_61 - 218451.151204296*x_62 - 59053.5194955225*x_63 + 14275.1815730004*x_64 + 1235.02052732973*x_65 + 142588.807907926*x_66 + 44137.0258407551*x_67 + 40181.0478424334*x_68 + 7658.90369195498*x_69 - 34496.1990083603*x_7 - 25554.9430657182*x_70 + 54086.4396084097*x_71 + 1443.98967751773*x_72 + 127741.283573587*x_73 - 56309.1446029046*x_74 + 9654.91313270751*x_75 + 157624.984139231*x_76 + 35015.1288628683*x_77 - 88564.0119261295*x_78 + 23445.0313839928*x_79 + 157515.220026035*x_8 + 15675.2380993748*x_80 - 8156.95915911754*x_81 + 32542.2763332867*x_82 - 163644.023060783*x_83 - 211507.035477722*x_84 - 1724248.23614044*x_85 - 127481.975632852*x_86 - 3469752.00754097*x_87 + 37371.392753676*x_88 + 165627.64118371*x_89 + 60081.661556488*x_9 - 189596.370679791*x_90 - 33935.7683631611*x_91 + 58776.1008419503*x_92 + 73114.2771166245*x_93 + 56986.224565928*x_94 + 64939.5733749009*x_95 - 39703.4895127127*x_96 + 54647.4833118442*x_97 - 1359.64016840861*x_98 - 79008.423902636*x_99 - 79.3406272285949*std::exp(1.05479979515076*x_1) + 6.18918838845002*std::exp(1.21727991104126*x_1) - 0.673288628650433*std::exp(0.597359836101532*x_22) + 0.00179992113666543*std::exp(0.880879878997803*x_23) + 0.401486102266076*std::exp(0.955039799213409*x_23) + 0.761228605884054*std::exp(0.962799787521362*x_23) - 0.00527421314675133*std::exp(0.982959806919098*x_23) + 0.984561474426403*std::exp(0.987919807434082*x_23) + 0.027416536644842*std::exp(0.994559824466705*x_23) - 1.33930766608233*std::exp(1.00807988643646*x_23) + 7.06902031588283*std::exp(0.904399812221527*x_24) + 0.904655781475614*std::exp(0.316319853067398*x_25) - 0.00352366161800694*std::exp(0.764399826526642*x_3) - 0.342776660243551*std::exp(0.810799837112427*x_3) - 7304.25066155716*std::exp(0.952639818191528*x_4) + 0.000395034741250549*std::exp(1.02783977985382*x_4) + 1.65810312818534*std::exp(1.03087985515594*x_5) + 2015.81879313875*std::exp(1.22399985790253*x_5) + 23.1012181685692*std::exp(1.27887988090515*x_5) - 6.48459089598419e-5*std::exp(1.30207979679108*x_5) - 0.0377794153866512*std::exp(1.35575985908508*x_5) - 0.0246744936979157*std::exp(1.36415994167328*x_5) - 218.332846873387*std::exp(1.37703990936279*x_6) - 9.02020199030127e-5*std::exp(1.45175981521606*x_6) + 0.0114781187752561*std::exp(1.46799981594086*x_6) - 0.00658579688101369*std::exp(1.52735984325409*x_6) - 3.62609940749144e-5*std::exp(1.53255987167358*x_6) - 4.94210667977882e-6*std::exp(1.55359983444214*x_6) + 0.012524990252142*std::exp(1.59999990463257*x_6) + 0.0543270861465864*std::exp(1.63423991203308*x_6) - 2.19794830309855e-5*std::exp(1.6639997959137*x_6) + 0.00148166923007978*std::exp(0.870079874992371*x_8) - 0.0675159443562468*std::exp(0.926959812641144*x_8) + 0.0710234422426115*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 5.13299422989521*std::sin(0.227679997682571*x_119 - 7.40967988967896) + 0.0171841888102869*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.00348853396146964*std::sin(0.276479959487915*x_16 - 1.17711985111237) - 0.0477484941343822*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 50.0105187304982*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 112.022054426023*std::sin(0.281439960002899*x_17 + 5.0383996963501) - 1545.82799253685*std::sin(0.364639848470688*x_31 - 7.40783977508545) - 0.0076525816448689*std::sin(0.338239848613739*x_32 - 1.21039986610413) - 4.73813824734657*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 6.47848166610601*std::sin(0.327439844608307*x_91 - 7.40367984771729) + 0.128636377459625*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0026018239417732*std::sin(0.332719832658768*x_91 - 7.40847969055176) - 0.0529390932819121*std::sin(0.359919846057892*x_91 + 1.99703979492188) + 182.592530385047*std::sin(0.372159838676453*x_91 + 2.00287985801697) + 0.142507333301019*std::sin(0.295439928770065*x_94 + 1.95695984363556) - 460.973089708159*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.00317652762758894*std::sin(0.288959950208664*x_97 + 1.9599198102951) + 25307995.8291823 + 0.338643311352934*std::exp(-6.37967967987061*x_93) + 0.00253942441871388*std::exp(-6.11312007904053*x_93) - 0.000163375610717243*std::exp(-7.8121600151062*x_113) + 0.113060124539913*std::exp(-7.73320007324219*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4322.86320652605*x_1 + 2729.59071989898*x_10 + 2691.96741463514*x_100 + 739.010298531677*x_101 + 883.815091820184*x_102 - 1086.95924159592*x_103 + 35577.9949087804*x_104 + 388.9038638918*x_105 - 9246.93560166268*x_106 - 1308.02924340949*x_107 - 2461.10783705756*x_108 - 1021.73871738788*x_109 + 20669.2711522376*x_11 - 2978.17148092305*x_110 + 9.53677831075285*x_111 - 86.9131471663814*x_112 - 13.5713755609382*x_113 - 450.074050143678*x_114 + 471.804353215597*x_115 - 10048.9868433046*x_116 - 203.464618700178*x_117 - 1528.09374771414*x_118 + 373.959221091182*x_119 + 442.124695380067*x_12 + 273.575865814415*x_120 + 939.495280794871*x_13 - 3220.57632720847*x_14 + 3484.93276017571*x_15 - 3114.14808190905*x_16 - 3439.05720417243*x_17 - 20606.5087267104*x_18 - 6665.22137835479*x_19 + 427.302761848697*x_2 - 1923.35737628121*x_20 - 6693.94603806472*x_21 + 238.186129956489*x_22 - 34824.9973961905*x_23 - 27780.9425963171*x_24 - 6454.86013198324*x_25 - 6740.44340050214*x_26 + 17229.8199099453*x_27 - 65809.5700195321*x_28 - 68132.6736479057*x_29 - 1734.11247753319*x_3 - 1320.72971997398*x_30 - 1203.03362720813*x_31 + 549.942660523621*x_32 + 4960.3833117896*x_33 + 86534.97928511*x_34 - 52.4195032604911*x_35 - 18205.0107975574*x_36 - 30599.0785033682*x_37 + 5900.10694806664*x_38 - 28963.9211989499*x_39 + 13121.8391119115*x_4 + 4848.21788083243*x_40 + 2150450.43913524*x_41 - 192623.993373701*x_42 + 20404.9509116132*x_43 - 2823.58077034131*x_44 - 56211.5613110946*x_45 - 123549.877602822*x_46 + 86147.4522894662*x_47 - 5179.73339345065*x_48 + 24506.6818027705*x_49 + 10.8609701939145*x_5 - 17219.0158068119*x_50 - 16518.7763739363*x_51 + 8266.83168656111*x_52 + 12643.7603626988*x_53 - 1030.13492177103*x_54 - 98383.3891670979*x_55 - 82979.7785552003*x_56 - 11970.8870895586*x_57 + 68318.3048413863*x_58 - 157505.24358742*x_59 + 2247.46638619933*x_6 + 19689.7525218369*x_60 - 1108.0815014621*x_61 - 4440.40253138847*x_62 - 1390.14079598199*x_63 + 857.823470145584*x_64 + 1002.62972285906*x_65 + 781.013303674971*x_66 + 1590.70668186834*x_67 + 1187.89668266915*x_68 + 998.312303790498*x_69 + 1452.06576608633*x_7 - 1071.92471880753*x_70 + 1513.69808037021*x_71 - 721.885733639078*x_72 + 3114.08637475531*x_73 + 1638.77343747293*x_74 - 230.5465797332*x_75 + 5838.67060082597*x_76 + 781.328778819139*x_77 - 4083.37627998265*x_78 + 1184.15389393381*x_79 + 1299.52871462068*x_8 - 808.144104947965*x_80 - 706.206462342849*x_81 + 263.18095614743*x_82 - 5528.54512771607*x_83 - 5580.21899695258*x_84 + 15661.7260399272*x_85 - 2994.56222115831*x_86 - 210.031952568075*x_87 + 515.4915602404*x_88 + 9016.64928622873*x_89 + 1561.69990390605*x_9 - 982.94588274973*x_90 - 1058.04930654706*x_91 + 499.597791827076*x_92 + 1443.48288181599*x_93 - 176.847021988333*x_94 - 439.415251393369*x_95 - 683.595874203421*x_96 + 1935.10620811198*x_97 + 1229.71997872077*x_98 - 1189.73275656273*x_99 + 18.3187456921943*std::exp(1.05479979515076*x_1) + 0.0560160651724226*std::exp(1.21727991104126*x_1) - 1.59827905260094*std::exp(0.597359836101532*x_22) - 0.00148020925240649*std::exp(0.880879878997803*x_23) + 0.18302234714268*std::exp(0.955039799213409*x_23) + 2.0456140003329*std::exp(0.962799787521362*x_23) + 3.45872540110394e-6*std::exp(0.982959806919098*x_23) + 2.33719078803962*std::exp(0.987919807434082*x_23) + 0.0282388162589513*std::exp(0.994559824466705*x_23) + 14.5172556930712*std::exp(1.00807988643646*x_23) - 1.63214723632713*std::exp(0.904399812221527*x_24) + 2.43103913563449*std::exp(0.316319853067398*x_25) + 0.00289776947615954*std::exp(0.764399826526642*x_3) - 0.921127674080557*std::exp(0.810799837112427*x_3) - 144.695210036064*std::exp(0.952639818191528*x_4) - 0.0060263146931866*std::exp(1.02783977985382*x_4) + 0.0150068808802713*std::exp(1.03087985515594*x_5) + 39.9328195571089*std::exp(1.22399985790253*x_5) + 36.4268090839046*std::exp(1.27887988090515*x_5) + 0.000989234143611395*std::exp(1.30207979679108*x_5) + 0.409505184650419*std::exp(1.35575985908508*x_5) + 0.00309090263291429*std::exp(1.36415994167328*x_5) - 4.32511404659017*std::exp(1.37703990936279*x_6) + 7.41798413976909e-5*std::exp(1.45175981521606*x_6) + 0.00523244074246338*std::exp(1.46799981594086*x_6) - 0.0176977036845648*std::exp(1.52735984325409*x_6) + 2.3779247782854e-8*std::exp(1.53255987167358*x_6) + 8.54546022169161e-6*std::exp(1.55359983444214*x_6) - 0.00156896939088325*std::exp(1.59999990463257*x_6) - 0.0125434359429739*std::exp(1.63423991203308*x_6) + 1.74199784210352e-5*std::exp(1.6639997959137*x_6) - 9.71649582510258e-7*std::exp(0.870079874992371*x_8) - 0.181432436922729*std::exp(0.926959812641144*x_8) - 4.65757785897728e-5*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 13.7936551242807*std::sin(0.227679997682571*x_119 - 7.40967988967896) - 0.26214739794808*std::sin(0.239919975399971*x_16 + 8.20735931396484) + 0.00603206893969623*std::sin(0.276479959487915*x_16 - 1.17711985111237) + 0.0378433713061071*std::sin(0.332639843225479*x_16 + 2.03247976303101) + 542.082679088572*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 1.01387036678136*std::sin(0.281439960002899*x_17 + 5.0383996963501) - 2437.51566475003*std::sin(0.364639848470688*x_31 - 7.40783977508545) + 0.116741289794646*std::sin(0.338239848613739*x_32 - 1.21039986610413) - 11.2475791017602*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 2.953295054945*std::sin(0.327439844608307*x_91 - 7.40367984771729) + 0.132494453050577*std::sin(0.331839829683304*x_91 + 2.00687980651855) - 0.00449884724043691*std::sin(0.332719832658768*x_91 - 7.40847969055176) + 0.041957213520446*std::sin(0.359919846057892*x_91 + 1.99703979492188) - 42.1583020736747*std::sin(0.372159838676453*x_91 + 2.00287985801697) + 0.146781428039989*std::sin(0.295439928770065*x_94 + 1.95695984363556) + 106.432846528662*std::sin(0.272399961948395*x_96 + 1.98335981369019) + 0.0054925747749906*std::sin(0.288959950208664*x_97 + 1.9599198102951) + 209099.402490933 + 0.533984621944232*std::exp(-6.37967967987061*x_93) - 0.0275257691218443*std::exp(-6.11312007904053*x_93) - 0.00038782745646344*std::exp(-7.8121600151062*x_113) + 0.178277160172501*std::exp(-7.73320007324219*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (211062.103471633*x_1 + 1527595.71472458*x_10 - 82288.6477947875*x_100 - 10713.9493287488*x_101 - 22074.8069892447*x_102 + 16458.8554229682*x_103 - 1965504.6388049*x_104 - 55329.636961327*x_105 + 247212.226801949*x_106 + 40419.760122051*x_107 + 48667.2144550513*x_108 + 28102.6909080292*x_109 - 439334.300985062*x_11 + 85124.0086718201*x_110 - 28547.3337234842*x_111 + 75143.4898231871*x_112 - 2131.52025462029*x_113 + 67137.5640084502*x_114 - 60936.6929577298*x_115 + 156981.234977901*x_116 - 47388.3161169532*x_117 + 9110.1534140622*x_118 - 38957.9577079166*x_119 - 184488.140679583*x_12 + 45903.8299926571*x_120 - 87033.6105232636*x_13 - 11001.6218406234*x_14 - 289205.063375469*x_15 + 120586.473945395*x_16 + 263346.920183994*x_17 - 539079.81482745*x_18 + 134779.360819503*x_19 - 60899.4393351684*x_2 - 95345.1260038592*x_20 + 226433.189077618*x_21 + 159977.532446151*x_22 + 719150.83813361*x_23 + 2804960.05941351*x_24 + 235654.884016604*x_25 - 243047.185018704*x_26 - 926901.421837661*x_27 - 135124.074717195*x_28 + 531288.204862192*x_29 + 8902.55571274196*x_3 + 519380.484207*x_30 + 67501.1331600503*x_31 - 49867.5230315636*x_32 - 1842.23337159431*x_33 + 775095.800606545*x_34 + 97226.3461194459*x_35 + 433043.654350597*x_36 + 2878314.86786847*x_37 - 117387.504042938*x_38 + 1631573.22844748*x_39 - 41494.4235300782*x_4 - 108222.016028592*x_40 - 105922340.132364*x_41 + 5927905.0530571*x_42 - 2302521.82492337*x_43 + 35442.1250701664*x_44 + 7108531.56643652*x_45 + 6521270.94797751*x_46 + 717814.279063597*x_47 + 176929.836118442*x_48 - 196920.732748918*x_49 + 69.0927568578889*x_5 + 424679.851664786*x_50 + 290028.937267879*x_51 - 795522.145442193*x_52 + 29946.5597546454*x_53 - 62256.7296392299*x_54 - 501406.09558609*x_55 + 1795578.58999358*x_56 + 482556.789176686*x_57 - 734813.011690995*x_58 + 9890966.88624482*x_59 - 7474.37471955785*x_6 - 157116.790384891*x_60 + 73015.6109830535*x_61 + 244811.233068545*x_62 + 66682.7001456378*x_63 - 17492.5106642337*x_64 - 4022.45932154393*x_65 - 153746.534593592*x_66 - 51235.8212035112*x_67 - 45916.2129684718*x_68 - 10809.4042401085*x_69 + 32752.174026723*x_7 + 30063.4763516151*x_70 - 61658.7068193706*x_71 + 265.985779718664*x_72 - 144331.428112417*x_73 + 56143.7473882554*x_74 - 9710.17150172368*x_75 - 183548.588423725*x_76 - 39390.7018202349*x_77 + 105285.584972663*x_78 - 28210.1346590841*x_79 - 171249.181477344*x_8 - 14720.1805061904*x_80 + 10452.205893232*x_81 - 35485.9994963983*x_82 + 189462.462647459*x_83 + 240131.421946539*x_84 + 1793313.79666595*x_85 + 143569.221785836*x_86 + 3697234.09296252*x_87 - 41235.116722059*x_88 - 200383.490849424*x_89 - 68477.9433495668*x_9 + 204529.805288226*x_90 + 38926.6246059802*x_91 - 63859.4320149068*x_92 - 81831.6595985312*x_93 - 60301.4990770992*x_94 - 68142.9043402431*x_95 + 44137.7005181126*x_96 - 63260.386468142*x_97 - 2019.5694931564*x_98 + 87247.3183324353*x_99 + 161.274642313198*std::exp(1.05479979515076*x_1) + 6.05003317844668*std::exp(1.21727991104126*x_1) + 0.703002891056662*std::exp(0.597359836101532*x_22) - 9.28122185534338e-5*std::exp(0.880879878997803*x_23) + 0.173900540437583*std::exp(0.955039799213409*x_23) + 8.4500385135681*std::exp(0.962799787521362*x_23) - 0.00287386739189726*std::exp(0.982959806919098*x_23) - 1.02801314843553*std::exp(0.987919807434082*x_23) + 0.170821592800034*std::exp(0.994559824466705*x_23) - 15.8979474385662*std::exp(1.00807988643646*x_23) - 14.369103985831*std::exp(0.904399812221527*x_24) + 10.0421557149881*std::exp(0.316319853067398*x_25) + 0.000181696211871085*std::exp(0.764399826526642*x_3) - 3.80500149130159*std::exp(0.810799837112427*x_3) + 8170.69063675702*std::exp(0.952639818191528*x_4) - 0.00938158433961223*std::exp(1.02783977985382*x_4) + 1.62082300767061*std::exp(1.03087985515594*x_5) - 2254.93791241089*std::exp(1.22399985790253*x_5) - 121.032609421668*std::exp(1.27887988090515*x_5) + 0.0015400097775191*std::exp(1.30207979679108*x_5) - 0.448451969093575*std::exp(1.35575985908508*x_5) - 2.53824712462238e-5*std::exp(1.36415994167328*x_5) + 244.23178095925*std::exp(1.37703990936279*x_6) + 4.65123133156236e-6*std::exp(1.45175981521606*x_6) + 0.00497165666995109*std::exp(1.46799981594086*x_6) - 0.0731058145436781*std::exp(1.52735984325409*x_6) - 1.97582626204374e-5*std::exp(1.53255987167358*x_6) + 2.76427836276824e-5*std::exp(1.55359983444214*x_6) + 1.28843658891807e-5*std::exp(1.59999990463257*x_6) - 0.110429948593238*std::exp(1.63423991203308*x_6) + 2.37937806785321e-5*std::exp(1.6639997959137*x_6) + 0.000807347137369031*std::exp(0.870079874992371*x_8) - 0.749462547361368*std::exp(0.926959812641144*x_8) + 0.0386999821664514*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 56.9789398313071*std::sin(0.227679997682571*x_119 - 7.40967988967896) - 0.408103135742376*std::sin(0.239919975399971*x_16 + 8.20735931396484) + 0.0195124864198688*std::sin(0.276479959487915*x_16 - 1.17711985111237) + 0.0516898962346852*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 593.638503151836*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 109.503395834575*std::sin(0.281439960002899*x_17 + 5.0383996963501) + 8098.94934061748*std::sin(0.364639848470688*x_31 - 7.40783977508545) + 0.181739307003309*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 4.94724661069566*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 2.80610326631972*std::sin(0.327439844608307*x_91 - 7.40367984771729) + 0.801482374463714*std::sin(0.331839829683304*x_91 + 2.00687980651855) - 0.0145528336233687*std::sin(0.332719832658768*x_91 - 7.40847969055176) + 0.057308953677137*std::sin(0.359919846057892*x_91 + 1.99703979492188) - 371.153418564065*std::sin(0.372159838676453*x_91 + 2.00287985801697) + 0.887906812429028*std::sin(0.295439928770065*x_94 + 1.95695984363556) + 937.013895094333*std::sin(0.272399961948395*x_96 + 1.98335981369019) + 0.017767335184421*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 27036125.4671378 - 1.77423040365922*std::exp(-6.37967967987061*x_93) + 0.0301436607549764*std::exp(-6.11312007904053*x_93) + 0.000170585870271694*std::exp(-7.8121600151062*x_113) - 0.592348065576145*std::exp(-7.73320007324219*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-30668.8322428764*x_1 - 263215.214281825*x_10 + 10638.9889546867*x_100 + 736.154750783061*x_101 + 2638.25543319385*x_102 - 1400.65618651351*x_103 + 287328.579149767*x_104 + 9140.13625489*x_105 - 30393.8280695608*x_106 - 5075.26416653084*x_107 - 5168.24925279664*x_108 - 3458.2843167659*x_109 + 48896.5933073621*x_11 - 10799.3009566846*x_110 + 4842.89903824009*x_111 - 12782.4589230257*x_112 + 248.160913172757*x_113 - 10711.6453178879*x_114 + 9586.22111142257*x_115 - 14048.8129420472*x_116 + 8268.69622372872*x_117 + 556.936092066264*x_118 + 6010.55093017768*x_119 + 30863.5012115631*x_12 - 8125.14838616175*x_120 + 13585.4996430041*x_13 + 5853.62514455098*x_14 + 46822.2527865125*x_15 - 16492.3024545899*x_16 - 40350.1330833569*x_17 + 118674.541127588*x_18 - 12171.5776534081*x_19 + 9989.17156650103*x_2 + 18929.2902471006*x_20 - 29054.7629844388*x_21 - 31046.1364279294*x_22 - 84054.8326816922*x_23 - 444110.156097855*x_24 - 31535.310816979*x_25 + 50202.4859457323*x_26 + 136830.31833662*x_27 + 121353.453138329*x_28 + 3356.52280797544*x_29 + 450.333241711279*x_3 - 87298.2850729051*x_30 - 9912.531084272*x_31 + 7994.10532558616*x_32 - 5662.09914623676*x_33 - 239469.981008253*x_34 - 16700.8315939993*x_35 - 49936.0903826322*x_36 - 460270.54847416*x_37 + 11826.3785219294*x_38 - 245007.094902791*x_39 - 8596.05014666825*x_4 + 11694.3531374021*x_40 + 15146304.6132075*x_41 - 744090.418251862*x_42 + 367068.016734499*x_43 - 2285.75804351934*x_44 - 1130871.05255451*x_45 - 956301.828385105*x_46 - 234998.208838671*x_47 - 23552.8987105629*x_48 + 1640.55899187302*x_49 - 147.605266100638*x_5 - 51486.2979127434*x_50 - 27621.6780444377*x_51 + 123179.170994897*x_52 - 21003.1490486354*x_53 + 13589.6419076162*x_54 + 222038.667072205*x_55 - 206030.956967544*x_56 - 67566.5118192729*x_57 + 30283.5016022218*x_58 - 1477214.76456944*x_59 - 1668.32552742458*x_6 + 679.952673174059*x_60 - 11089.3714393718*x_61 - 35942.2230584493*x_62 - 9451.05911292361*x_63 + 1768.36230952452*x_64 - 658.847046832283*x_65 + 24894.3751588332*x_66 + 6761.57494118005*x_67 + 6203.84010366228*x_68 + 601.766961757468*x_69 - 7635.09907943415*x_7 - 3651.80801272449*x_70 + 8725.97531516821*x_71 + 939.682257980865*x_72 + 20801.2581548684*x_73 - 11721.3398394675*x_74 + 2050.98070489121*x_75 + 23680.2103046795*x_76 + 5632.06877439931*x_77 - 12969.3372668001*x_78 + 3199.71260933352*x_79 + 27600.0274820564*x_8 + 3563.0275793033*x_80 - 828.214790921002*x_81 + 5691.09055697615*x_82 - 25356.2269566873*x_83 - 33850.263494507*x_84 - 324465.178020644*x_85 - 21858.2218400217*x_86 - 626489.032255509*x_87 + 6357.23674639416*x_88 + 21980.014184924*x_89 + 9727.97561410231*x_9 - 33352.4855484311*x_90 - 5315.00953045453*x_91 + 10535.9063910297*x_92 + 12172.9453407029*x_93 + 10601.9005721153*x_94 + 12234.6557736989*x_95 - 6666.80568860084*x_96 + 8257.81166143933*x_97 - 1240.74032629706*x_98 - 13183.6140350698*x_99 - 283.155575095199*std::exp(1.05479979515076*x_1) - 0.204981814652714*std::exp(1.21727991104126*x_1) + 0.250571815110755*std::exp(0.597359836101532*x_22) + 0.000258366394692724*std::exp(0.880879878997803*x_23) + 0.0150100989999519*std::exp(0.955039799213409*x_23) + 3.98683813297631*std::exp(0.962799787521362*x_23) - 0.00270080221520476*std::exp(0.982959806919098*x_23) - 0.366415449834119*std::exp(0.987919807434082*x_23) + 0.00929019884341058*std::exp(0.994559824466705*x_23) + 3.51424290386462*std::exp(1.00807988643646*x_23) + 25.2283424371776*std::exp(0.904399812221527*x_24) + 4.73801974718986*std::exp(0.316319853067398*x_25) - 0.000505797576247258*std::exp(0.764399826526642*x_3) - 1.79524921894673*std::exp(0.810799837112427*x_3) - 1204.49106927251*std::exp(0.952639818191528*x_4) - 0.00700750582568231*std::exp(1.02783977985382*x_4) - 0.0549152759239069*std::exp(1.03087985515594*x_5) + 332.414075873143*std::exp(1.22399985790253*x_5) - 26.8628641043774*std::exp(1.27887988090515*x_5) + 0.0011502990429886*std::exp(1.30207979679108*x_5) + 0.099130353537849*std::exp(1.35575985908508*x_5) - 0.00122811418573554*std::exp(1.36415994167328*x_5) - 36.0036883142472*std::exp(1.37703990936279*x_6) - 1.2947884327598e-5*std::exp(1.45175981521606*x_6) + 0.000429124939013757*std::exp(1.46799981594086*x_6) - 0.034492274644315*std::exp(1.52735984325409*x_6) - 1.85684139791313e-5*std::exp(1.53255987167358*x_6) + 7.40614491096674e-5*std::exp(1.55359983444214*x_6) + 0.000623401573834697*std::exp(1.59999990463257*x_6) + 0.193885753849182*std::exp(1.63423991203308*x_6) - 8.47832955478108e-6*std::exp(1.6639997959137*x_6) + 0.000758728444879983*std::exp(0.870079874992371*x_8) - 0.353606182771842*std::exp(0.926959812641144*x_8) + 0.036369457358481*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 26.8834052923263*std::sin(0.227679997682571*x_119 - 7.40967988967896) - 0.304829653251524*std::sin(0.239919975399971*x_16 + 8.20735931396484) + 0.0522784911770244*std::sin(0.276479959487915*x_16 - 1.17711985111237) - 0.0184184254217953*std::sin(0.332639843225479*x_16 + 2.03247976303101) + 131.223851709394*std::sin(0.26623997092247*x_17 + 8.23527908325195) + 3.71009614769892*std::sin(0.281439960002899*x_17 + 5.0383996963501) + 1797.54015520957*std::sin(0.364639848470688*x_31 - 7.40783977508545) + 0.135748846514531*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 1.76335059046383*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 0.242206767877558*std::sin(0.327439844608307*x_91 - 7.40367984771729) + 0.0435889310373841*std::sin(0.331839829683304*x_91 + 2.00687980651855) - 0.0389904273504218*std::sin(0.332719832658768*x_91 - 7.40847969055176) - 0.0204206385811078*std::sin(0.359919846057892*x_91 + 1.99703979492188) + 651.647141637818*std::sin(0.372159838676453*x_91 + 2.00287985801697) + 0.0482891577503363*std::sin(0.295439928770065*x_94 + 1.95695984363556) - 1645.1483291612*std::sin(0.272399961948395*x_96 + 1.98335981369019) + 0.0476028249650531*std::sin(0.288959950208664*x_97 + 1.9599198102951) + 4782597.12547624 - 0.393785695037817*std::exp(-6.37967967987061*x_93) - 0.00666325928639703*std::exp(-6.11312007904053*x_93) + 6.08020417696703e-5*std::exp(-7.8121600151062*x_113) - 0.131470069629137*std::exp(-7.73320007324219*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-33106.9340987452*x_1 - 150057.852507639*x_10 + 16326.8029284921*x_100 + 3314.52420012083*x_101 + 4844.25911141236*x_102 - 4970.35142681754*x_103 + 299318.863640353*x_104 + 6494.40766754216*x_105 - 51485.994211505*x_106 - 7994.50974647626*x_107 - 12254.5207999479*x_108 - 5928.13636202615*x_109 + 105164.350884865*x_11 - 17286.2464609075*x_110 + 2905.72506529097*x_111 - 7717.58772462627*x_112 + 360.145485150841*x_113 - 8188.08603570675*x_114 + 7554.91334582433*x_115 - 44448.0049227194*x_116 + 3947.86182845813*x_117 - 5263.15528984888*x_118 + 5092.97944086957*x_119 + 19966.8488887482*x_12 - 3848.56568112977*x_120 + 11699.5903715469*x_13 - 6775.13340482567*x_14 + 36782.0220108663*x_15 - 21407.4124819025*x_16 - 36247.0801647335*x_17 - 8190.0856790775*x_18 - 34065.9985783895*x_19 + 7137.46582480024*x_2 + 2956.73658500386*x_20 - 43305.134404849*x_21 - 13618.8406629316*x_22 - 177519.262697098*x_23 - 355614.657277331*x_24 - 43170.0435607142*x_25 + 3492.34679054873*x_26 + 143480.138810668*x_27 - 192180.196571606*x_28 - 267823.494994654*x_29 - 5578.15976864167*x_3 - 54454.1690314755*x_30 - 10193.1152366223*x_31 + 6287.58301695793*x_32 + 15271.4188316987*x_33 + 167617.609364551*x_34 - 9835.1290625442*x_35 - 96607.4048559632*x_36 - 372013.917884859*x_37 + 30340.5661040892*x_38 - 252536.980380193*x_39 + 41545.4395107659*x_4 + 25373.0992439828*x_40 + 17106520.7172874*x_41 - 1166019.08774404*x_42 + 291871.848437231*x_43 - 12292.8247841229*x_44 - 849371.445192687*x_45 - 999752.358946625*x_46 + 174420.532183768*x_47 - 31812.1530151147*x_48 + 95150.8480323626*x_49 - 40.3159903861872*x_5 - 97257.8911168672*x_50 - 78760.5441529518*x_51 + 98738.609999509*x_52 + 36256.2692721107*x_53 + 4975.82917117624*x_54 - 250650.25921349*x_55 - 434806.091664388*x_56 - 83905.6935022497*x_57 + 277268.8007203*x_58 - 1480654.98434845*x_59 + 7440.86610127814*x_6 + 74617.5315085721*x_60 - 10743.4592882828*x_61 - 37870.3614145619*x_62 - 10865.2007240585*x_63 + 4316.28503457671*x_64 + 3515.29877324376*x_65 + 17002.4432250079*x_66 + 9687.24523151994*x_67 + 7971.61410995624*x_68 + 3994.46673029469*x_69 + 1560.56616595594*x_7 - 6158.59501292341*x_70 + 10513.7557475859*x_71 - 2005.73233168682*x_72 + 23374.8828362344*x_73 - 1541.02270794459*x_74 + 278.097515638654*x_75 + 35703.4712578524*x_76 + 6220.64480353743*x_77 - 22568.495486395*x_78 + 6496.52320013133*x_79 + 20499.0900432041*x_8 - 689.356877386566*x_80 - 2969.19456161321*x_81 + 4467.03294185174*x_82 - 35818.2819630657*x_83 - 40109.4368850267*x_84 - 122957.073387191*x_85 - 21853.5211807438*x_86 - 362321.911245156*x_87 + 5671.98021030497*x_88 + 46974.7112928068*x_89 + 11964.2126776471*x_9 - 22972.7268045626*x_90 - 6876.2570652338*x_91 + 7367.64558108783*x_92 + 12484.6680060599*x_93 + 5385.72350284695*x_94 + 5504.86022957761*x_95 - 6353.48175499121*x_96 + 11788.7124318846*x_97 + 4236.74837882097*x_98 - 11980.7685667717*x_99 - 76.3223842670052*std::exp(1.05479979515076*x_1) - 25.8278938243965*std::exp(1.21727991104126*x_1) + 0.566573987625078*std::exp(0.597359836101532*x_22) - 0.00351134448284448*std::exp(0.880879878997803*x_23) - 0.0695112444410145*std::exp(0.955039799213409*x_23) + 0.495379217246607*std::exp(0.962799787521362*x_23) + 0.00326303074155969*std::exp(0.982959806919098*x_23) - 0.828510830111484*std::exp(0.987919807434082*x_23) - 0.00697688237738894*std::exp(0.994559824466705*x_23) - 4.74364769470134*std::exp(1.00807988643646*x_23) + 6.80010360121816*std::exp(0.904399812221527*x_24) + 0.5887162797627*std::exp(0.316319853067398*x_25) + 0.00687407327452223*std::exp(0.764399826526642*x_3) - 0.223066280391097*std::exp(0.810799837112427*x_3) - 1239.6870150871*std::exp(0.952639818191528*x_4) - 0.000869200509842218*std::exp(1.02783977985382*x_4) - 6.91937437622506*std::exp(1.03087985515594*x_5) + 342.127412983649*std::exp(1.22399985790253*x_5) + 121.017061378001*std::exp(1.27887988090515*x_5) + 0.000142681367594776*std::exp(1.30207979679108*x_5) - 0.133809610177379*std::exp(1.35575985908508*x_5) - 0.00339598934261395*std::exp(1.36415994167328*x_5) - 37.0557375119211*std::exp(1.37703990936279*x_6) + 0.00017596902357325*std::exp(1.45175981521606*x_6) - 0.00198726261110045*std::exp(1.46799981594086*x_6) - 0.00428579125724372*std::exp(1.52735984325409*x_6) + 2.24338181058988e-5*std::exp(1.53255987167358*x_6) + 0.000117638731374584*std::exp(1.55359983444214*x_6) + 0.00172383409091838*std::exp(1.59999990463257*x_6) + 0.0522603978544308*std::exp(1.63423991203308*x_6) - 3.45569143873283e-5*std::exp(1.6639997959137*x_6) - 0.000916673655775813*std::exp(0.870079874992371*x_8) - 0.0439368612902039*std::exp(0.926959812641144*x_8) - 0.0439405213556412*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 3.3403614158506*std::sin(0.227679997682571*x_119 - 7.40967988967896) - 0.037810612878863*std::sin(0.239919975399971*x_16 + 8.20735931396484) + 0.0830388205223464*std::sin(0.276479959487915*x_16 - 1.17711985111237) - 0.0750718577684267*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 177.130533853125*std::sin(0.26623997092247*x_17 + 8.23527908325195) + 467.475466267179*std::sin(0.281439960002899*x_17 + 5.0383996963501) - 8097.90893655935*std::sin(0.364639848470688*x_31 - 7.40783977508545) + 0.0168380832690117*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 3.98715464138905*std::sin(0.326799839735031*x_91 + 2.00583982467651) - 1.12165108619596*std::sin(0.327439844608307*x_91 - 7.40367984771729) - 0.0327350199850299*std::sin(0.331839829683304*x_91 + 2.00687980651855) - 0.0619321450551768*std::sin(0.332719832658768*x_91 - 7.40847969055176) - 0.0832326998640875*std::sin(0.359919846057892*x_91 + 1.99703979492188) + 175.646421702471*std::sin(0.372159838676453*x_91 + 2.00287985801697) - 0.0362648614314903*std::sin(0.295439928770065*x_94 + 1.95695984363556) - 443.436944203722*std::sin(0.272399961948395*x_96 + 1.98335981369019) + 0.0756120222606375*std::sin(0.288959950208664*x_97 + 1.9599198102951) + 2511107.9591357 + 1.77400248316801*std::exp(-6.37967967987061*x_93) + 0.00899429988699842*std::exp(-6.11312007904053*x_93) + 0.000137480966268939*std::exp(-7.8121600151062*x_113) + 0.592271971590947*std::exp(-7.73320007324219*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2507.83780265905*x_1 + 64091.87830422*x_10 + 498.791842969023*x_100 + 657.991951219608*x_101 + 427.957959375217*x_102 - 863.285462390278*x_103 - 27856.3070543949*x_104 - 1721.23836429784*x_105 - 3087.82682357494*x_106 - 244.654450998344*x_107 - 1524.50634242301*x_108 - 365.721026324826*x_109 + 11441.7150887756*x_11 - 773.363630640516*x_110 - 1091.95308091481*x_111 + 2894.01534287143*x_112 - 53.1898466019348*x_113 + 1998.69797545288*x_114 - 1701.65518886623*x_115 - 7549.70902999687*x_116 - 2225.57336824135*x_117 - 1794.63287444947*x_118 - 950.252985088841*x_119 - 6654.2306899851*x_12 + 2219.83423339899*x_120 - 2088.48133149866*x_13 - 4639.92059088093*x_14 - 7056.98933637973*x_15 + 390.752989724235*x_16 + 5665.66084770515*x_17 - 50760.6586506197*x_18 - 4522.05880568922*x_19 - 1869.11209041044*x_2 - 6611.43146723402*x_20 - 553.517299864135*x_21 + 8369.22469940435*x_22 - 20054.442268805*x_23 + 74249.3093880802*x_24 + 154.594769957275*x_25 - 19658.7113004591*x_26 - 12753.6662862542*x_27 - 103673.504877119*x_28 - 77447.4550505531*x_29 - 1892.85432995157*x_3 + 19153.7623214491*x_30 + 985.406214928625*x_31 - 1301.88888118502*x_32 + 6913.176136436*x_33 + 150196.093638186*x_34 + 3905.28135969885*x_35 - 8417.08184757361*x_36 + 73663.7862150949*x_37 + 3927.38314596372*x_38 + 24562.6619122164*x_39 + 15599.9041576368*x_4 + 2703.25158957041*x_40 - 1130434.65894656*x_41 - 40349.1711636787*x_42 - 63376.7626916181*x_43 - 2688.8464262942*x_44 + 204354.281155705*x_45 + 88661.6072993144*x_46 + 149170.491691231*x_47 - 98.4389630539133*x_48 + 25929.7767502715*x_49 + 29.0423771962523*x_5 - 6956.65020601772*x_50 - 11983.573679375*x_51 - 20624.1044474121*x_52 + 19546.9635619489*x_53 - 3887.59744758674*x_54 - 163153.480647819*x_55 - 46068.2682232272*x_56 + 2363.79985790145*x_57 + 68946.7257622109*x_58 + 166532.311029458*x_59 + 2913.28877858622*x_6 + 21480.4406731427*x_60 + 1337.43870012364*x_61 + 3494.34133027146*x_62 + 682.723529110544*x_63 + 574.455738644349*x_64 + 1268.973111793*x_65 - 5058.67855345123*x_66 + 177.458392921795*x_67 - 134.70757061784*x_68 + 963.98248287075*x_69 + 3436.874939959*x_7 - 345.151184394276*x_70 - 394.286660902183*x_71 - 1010.3174675813*x_72 - 1450.35136590587*x_73 + 4462.08982868339*x_74 - 746.911500971377*x_75 + 997.930295884318*x_76 - 454.728358336901*x_77 - 1466.62404995221*x_78 + 578.173275497795*x_79 - 5131.42641147942*x_8 - 1730.19342784384*x_80 - 548.950171386501*x_81 - 1030.2273339336*x_82 - 287.364704940133*x_83 + 1834.62772199036*x_84 + 93924.6585663401*x_85 + 1817.77812623196*x_86 + 147011.845269468*x_87 - 897.600759623651*x_88 + 4946.20450333586*x_89 - 471.477381911932*x_9 + 6819.01193400503*x_90 + 99.433889055017*x_91 - 1918.90720860293*x_92 - 1259.71888437934*x_93 - 2663.89226557346*x_94 - 3325.69644445571*x_95 + 843.082416542928*x_96 + 184.777560114031*x_97 + 1716.13403395013*x_98 + 1817.90562488613*x_99 + 59.6317013411304*std::exp(1.05479979515076*x_1) + 7.36667597269036*std::exp(1.21727991104126*x_1) + 0.331149673869451*std::exp(0.597359836101532*x_22) + 0.00131158573042969*std::exp(0.880879878997803*x_23) + 0.0485599081479516*std::exp(0.955039799213409*x_23) + 0.143283064703129*std::exp(0.962799787521362*x_23) - 0.00267988112927884*std::exp(0.982959806919098*x_23) - 0.484245830520339*std::exp(0.987919807434082*x_23) - 0.0247871644208245*std::exp(0.994559824466705*x_23) + 7.1843716281791*std::exp(1.00807988643646*x_23) - 5.31301204660987*std::exp(0.904399812221527*x_24) + 0.170279797513249*std::exp(0.316319853067398*x_25) - 0.0025676593284541*std::exp(0.764399826526642*x_3) - 0.0645195017748451*std::exp(0.810799837112427*x_3) + 122.08479545746*std::exp(0.952639818191528*x_4) + 0.00850643819195907*std::exp(1.02783977985382*x_4) + 1.97355577307038*std::exp(1.03087985515594*x_5) - 33.6928230482142*std::exp(1.22399985790253*x_5) + 46.8011662430621*std::exp(1.27887988090515*x_5) - 0.00139635241908621*std::exp(1.30207979679108*x_5) + 0.202657960457284*std::exp(1.35575985908508*x_5) - 0.00193377428627512*std::exp(1.36415994167328*x_5) + 3.6492615310247*std::exp(1.37703990936279*x_6) - 6.5729369887786e-5*std::exp(1.45175981521606*x_6) + 0.00138828315673135*std::exp(1.46799981594086*x_6) - 0.00123961862879293*std::exp(1.52735984325409*x_6) - 1.8424578424577e-5*std::exp(1.53255987167358*x_6) - 8.00173522456539e-5*std::exp(1.55359983444214*x_6) + 0.000981600853981645*std::exp(1.59999990463257*x_6) - 0.0408317489915118*std::exp(1.63423991203308*x_6) - 1.44156331119662e-5*std::exp(1.6639997959137*x_6) + 0.00075285114557224*std::exp(0.870079874992371*x_8) - 0.0127082605000822*std::exp(0.926959812641144*x_8) + 0.0360877304929622*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 0.966163303215228*std::sin(0.227679997682571*x_119 - 7.40967988967896) + 0.370033884946207*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.0564826437191226*std::sin(0.276479959487915*x_16 - 1.17711985111237) - 0.0313166953071534*std::sin(0.332639843225479*x_16 + 2.03247976303101) + 268.268569632621*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 133.334150611993*std::sin(0.281439960002899*x_17 + 5.0383996963501) - 3131.72025535556*std::sin(0.364639848470688*x_31 - 7.40783977508545) - 0.16478604531066*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 2.33040165627366*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 0.783575005133817*std::sin(0.327439844608307*x_91 - 7.40367984771729) - 0.116299555990448*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0421259750789838*std::sin(0.332719832658768*x_91 - 7.40847969055176) - 0.0347210416621878*std::sin(0.359919846057892*x_91 + 1.99703979492188) - 137.234902462658*std::sin(0.372159838676453*x_91 + 2.00287985801697) - 0.128840223236955*std::sin(0.295439928770065*x_94 + 1.95695984363556) + 346.46322536089*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.051430967917959*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 1015745.95055152 + 0.686063470596252*std::exp(-6.37967967987061*x_93) - 0.0136220893882285*std::exp(-6.11312007904053*x_93) + 8.03545135103218e-5*std::exp(-7.8121600151062*x_113) + 0.229050504845369*std::exp(-7.73320007324219*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (196822.790721548*x_1 + 1425813.68466226*x_10 - 76767.1281078754*x_100 - 9906.22728618244*x_101 - 20670.63961622*x_102 + 15291.1145103584*x_103 - 1831984.82265348*x_104 - 51743.3410524419*x_105 + 230460.642200707*x_106 + 37567.9647544917*x_107 + 45356.1700657565*x_108 + 26236.9488128742*x_109 - 409659.188761782*x_11 + 79422.3451969355*x_110 - 26671.3846799669*x_111 + 70190.8409601511*x_112 - 1915.95600899039*x_113 + 62543.9467352982*x_114 - 56764.9264715889*x_115 + 145935.626159294*x_116 - 44106.1196209789*x_117 + 8331.35555838641*x_118 - 36304.1885794959*x_119 - 172262.807288846*x_12 + 42804.0515505619*x_120 - 81229.105440004*x_13 - 10522.3909404547*x_14 - 271217.540581332*x_15 + 112434.070135635*x_16 + 245554.394640704*x_17 - 503808.482877479*x_18 + 124178.499341029*x_19 - 56931.0436298898*x_2 - 89187.3570452534*x_20 + 210323.418570748*x_21 + 150574.552386975*x_22 + 675305.369784166*x_23 + 2616591.55831785*x_24 + 219580.302107073*x_25 - 226541.49403194*x_26 - 865349.554067638*x_27 - 134382.013022525*x_28 + 490933.625554665*x_29 + 8254.67796875434*x_3 + 484818.995144554*x_30 + 62932.6087394496*x_31 - 46619.5606901671*x_32 - 1926.67107770177*x_33 + 725882.32859529*x_34 + 90797.5558391235*x_35 + 403276.356713821*x_36 + 2691125.97130981*x_37 - 109134.199710286*x_38 + 1524980.51356893*x_39 - 37677.4283000112*x_4 - 100623.859188404*x_40 - 98735861.903262*x_41 + 5515624.61276236*x_42 - 2148368.69360384*x_43 + 32999.8936070583*x_44 + 6625819.59170961*x_45 + 6081791.93605303*x_46 + 675330.895525787*x_47 + 164856.625935285*x_48 - 181144.543446534*x_49 + 151.807814287575*x_5 + 396237.935293019*x_50 + 269915.938734602*x_51 - 739899.192866896*x_52 + 27422.1227243897*x_53 - 59573.6593386264*x_54 - 474854.799986332*x_55 + 1680155.0740161*x_56 + 450630.937750673*x_57 - 679471.560262737*x_58 + 9226338.20125064*x_59 - 6910.10518656211*x_6 - 145200.201991427*x_60 + 68177.7482560551*x_61 + 228232.597132875*x_62 + 62091.0500064003*x_63 - 16283.093663184*x_64 - 3683.39848426039*x_65 - 143171.790885432*x_66 - 47816.7541129573*x_67 - 42767.16718365*x_68 - 10091.0526413708*x_69 + 30710.1486081035*x_7 + 27984.0795574858*x_70 - 57559.9765807074*x_71 + 186.536092046887*x_72 - 134672.684011793*x_73 + 52570.6207675693*x_74 - 9114.6772643895*x_75 - 171122.698124492*x_76 - 36688.3571087523*x_77 + 98263.1109659537*x_78 - 26250.1519039694*x_79 - 159702.146020709*x_8 - 13764.1753582714*x_80 + 9653.35813404786*x_81 - 33106.6922459347*x_82 + 176840.871434336*x_83 + 223854.502578588*x_84 + 1673113.05730196*x_85 + 134740.621569407*x_86 + 3447862.9212292*x_87 - 38481.974880726*x_88 - 186422.923654149*x_89 - 63966.4368665854*x_9 + 190544.324992312*x_90 + 36287.8688951986*x_91 - 59794.4183974146*x_92 - 76352.6165581057*x_93 - 56370.2120506136*x_94 - 63679.0549953075*x_95 + 41142.2766295711*x_96 - 58930.9073177757*x_97 - 1917.99653292116*x_98 + 81231.6387698103*x_99 + 328.048393946094*std::exp(1.05479979515076*x_1) - 6.20057230052833*std::exp(1.21727991104126*x_1) + 0.511236505958737*std::exp(0.597359836101532*x_22) - 0.00122017537889271*std::exp(0.880879878997803*x_23) + 0.23311488537776*std::exp(0.955039799213409*x_23) + 9.77357431254928*std::exp(0.962799787521362*x_23) + 0.000407139129267234*std::exp(0.982959806919098*x_23) - 0.747589884439693*std::exp(0.987919807434082*x_23) + 0.122686237425011*std::exp(0.994559824466705*x_23) - 18.1062458427931*std::exp(1.00807988643646*x_23) - 29.2281627005073*std::exp(0.904399812221527*x_24) + 11.6150660119517*std::exp(0.316319853067398*x_25) + 0.00238870751737858*std::exp(0.764399826526642*x_3) - 4.40098169669688*std::exp(0.810799837112427*x_3) + 7618.86592045444*std::exp(0.952639818191528*x_4) + 0.00428101422231433*std::exp(1.02783977985382*x_4) - 1.66115291420628*std::exp(1.03087985515594*x_5) - 2102.645954593*std::exp(1.22399985790253*x_5) - 111.470720414413*std::exp(1.27887988090515*x_5) - 0.000702738846809205*std::exp(1.30207979679108*x_5) - 0.510744021042331*std::exp(1.35575985908508*x_5) + 0.0200143600020991*std::exp(1.36415994167328*x_5) + 227.737075770729*std::exp(1.37703990936279*x_6) + 6.11483923212046e-5*std::exp(1.45175981521606*x_6) + 0.00666454038519337*std::exp(1.46799981594086*x_6) - 0.0845564324913802*std::exp(1.52735984325409*x_6) + 2.79914162420957e-6*std::exp(1.53255987167358*x_6) - 4.87709802564489e-5*std::exp(1.55359983444214*x_6) - 0.0101594653571484*std::exp(1.59999990463257*x_6) - 0.224625314680341*std::exp(1.63423991203308*x_6) + 2.79238876983716e-5*std::exp(1.6639997959137*x_6) - 0.0001143764014483*std::exp(0.870079874992371*x_8) - 0.866851421960656*std::exp(0.926959812641144*x_8) - 0.00548260406389334*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 65.9035934330201*std::sin(0.227679997682571*x_119 - 7.40967988967896) + 0.186226042962419*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.0344264565665754*std::sin(0.276479959487915*x_16 - 1.17711985111237) + 0.0606621905572207*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 676.097635958987*std::sin(0.26623997092247*x_17 + 8.23527908325195) + 112.228099086224*std::sin(0.281439960002899*x_17 + 5.0383996963501) + 7459.11140734968*std::sin(0.364639848470688*x_31 - 7.40783977508545) - 0.0829314676359742*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 3.59772783802734*std::sin(0.326799839735031*x_91 + 2.00583982467651) + 3.76160096823315*std::sin(0.327439844608307*x_91 - 7.40367984771729) + 0.575634820362111*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0256759945337028*std::sin(0.332719832658768*x_91 - 7.40847969055176) + 0.0672565998742441*std::sin(0.359919846057892*x_91 + 1.99703979492188) - 754.962349450393*std::sin(0.372159838676453*x_91 + 2.00287985801697) + 0.637705949320309*std::sin(0.295439928770065*x_94 + 1.95695984363556) + 1905.97789573094*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.0313474346563758*std::sin(0.288959950208664*x_97 + 1.9599198102951) - 25281779.2468101 - 1.63406161547766*std::exp(-6.37967967987061*x_93) + 0.0343307546046699*std::exp(-6.11312007904053*x_93) + 0.000124053151691238*std::exp(-7.8121600151062*x_113) - 0.545551037206966*std::exp(-7.73320007324219*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-268415.908196554*x_1 - 2036608.23599436*x_10 + 100962.580497601*x_100 + 12141.6462020473*x_101 + 26562.3392012634*x_102 - 18554.9658274246*x_103 + 2512986.10699159*x_104 + 72296.3798786136*x_105 - 301131.678997622*x_106 - 49983.8954173574*x_107 - 57169.2242303964*x_108 - 34196.0819200966*x_109 + 520577.549110256*x_11 - 104030.287830711*x_110 + 37962.6162220817*x_111 - 99606.5027153375*x_112 + 2972.60755794101*x_113 - 88150.6117074825*x_114 + 79871.8799842979*x_115 - 179160.164159878*x_116 + 64081.8556704941*x_117 - 7884.22096751762*x_118 + 50838.1665383126*x_119 + 243844.242214921*x_12 - 61917.7846412602*x_120 + 112775.889284399*x_13 + 23381.279726913*x_14 + 373105.172827285*x_15 - 150810.771299011*x_16 - 340450.65819277*x_17 + 781177.994616545*x_18 - 161800.30601454*x_19 + 79634.1038239539*x_2 + 133026.602126879*x_20 - 282270.951387796*x_21 - 209186.177577561*x_22 - 836284.324359315*x_23 - 3654123.37197349*x_24 - 293966.812742806*x_25 + 345291.575643973*x_26 + 1179133.77164211*x_27 + 368039.48234956*x_28 - 494637.508848186*x_29 - 6646.11209137046*x_3 - 687613.932251463*x_30 - 86362.7639855295*x_31 + 64601.9334120423*x_32 - 13951.774890009*x_33 - 1289099.02990646*x_34 - 128907.547259266*x_35 - 521619.296646926*x_36 - 3728789.59125732*x_37 + 138125.03668566*x_38 - 2072218.29836801*x_39 + 16338.9420429356*x_4 + 129702.305771404*x_40 + 134436277.541669*x_41 - 7330188.46926216*x_42 + 3000891.41971167*x_43 - 38429.5366892283*x_44 - 9329389.66994824*x_45 - 8318843.46903423*x_46 - 1204553.16380304*x_47 - 220844.741960849*x_48 + 187180.682175769*x_49 + 119.286018820313*x_5 - 506322.312290934*x_50 - 335716.635395545*x_51 + 1043056.7275896*x_52 - 81080.0106603835*x_53 + 81688.3613305374*x_54 + 961616.690186084*x_55 - 2111210.97188811*x_56 - 604136.616182419*x_57 + 780396.718937555*x_58 - 12667670.9190061*x_59 + 3114.64369818986*x_6 + 150061.487624278*x_60 - 93512.384970971*x_61 - 312343.080222552*x_62 - 84635.8255397966*x_63 + 20751.2039456098*x_64 + 2252.69019249945*x_65 + 203476.828501149*x_66 + 63313.7364629337*x_67 + 57733.0365098896*x_68 + 11251.6641394724*x_69 - 48196.939813834*x_7 - 36883.3283460904*x_70 + 77325.7069046622*x_71 + 1606.09567519555*x_72 + 182675.379877986*x_73 - 78876.6457920692*x_74 + 13485.6624864936*x_75 + 226559.400660939*x_76 + 50179.3880544589*x_77 - 127269.642100383*x_78 + 33880.718241723*x_79 + 224334.361211435*x_8 + 21813.5215662319*x_80 - 12056.7459199035*x_81 + 46301.1818928978*x_82 - 234440.071001156*x_83 - 302961.680907317*x_84 - 2445139.01294999*x_85 - 180876.204771911*x_86 - 4933646.38523113*x_87 + 53296.5301556576*x_88 + 240074.332700557*x_89 + 85765.4339761969*x_9 - 270259.642684679*x_90 - 48671.5109714312*x_91 + 83346.5711467093*x_92 + 104377.073226026*x_93 + 80700.459761849*x_94 + 91901.4849469202*x_95 - 56680.6125800744*x_96 + 78599.9269698389*x_97 - 1546.33391403526*x_98 - 113047.757843792*x_99 + 271.982177546084*std::exp(1.05479979515076*x_1) + 5.75827133940633*std::exp(1.21727991104126*x_1) + 1.35963952531909*std::exp(0.597359836101532*x_22) + 0.00413267277046167*std::exp(0.880879878997803*x_23) - 0.198245078701087*std::exp(0.955039799213409*x_23) + 10.9545989292977*std::exp(0.962799787521362*x_23) - 0.0114166921528466*std::exp(0.982959806919098*x_23) - 1.98822412673124*std::exp(0.987919807434082*x_23) - 0.104679783873295*std::exp(0.994559824466705*x_23) - 3.57189824765866*std::exp(1.00807988643646*x_23) - 24.2328250455069*std::exp(0.904399812221527*x_24) + 13.0186138283999*std::exp(0.316319853067398*x_25) - 0.00809043247752305*std::exp(0.764399826526642*x_3) - 4.93278997434864*std::exp(0.810799837112427*x_3) - 10441.4264200597*std::exp(0.952639818191528*x_4) - 0.00556172408072815*std::exp(1.02783977985382*x_4) + 1.54265908897317*std::exp(1.03087985515594*x_5) + 2881.61299221412*std::exp(1.22399985790253*x_5) + 49.9952868808906*std::exp(1.27887988090515*x_5) + 0.000912970470032442*std::exp(1.30207979679108*x_5) - 0.100756705150415*std::exp(1.35575985908508*x_5) + 0.00404234179622159*std::exp(1.36415994167328*x_5) - 312.106807575608*std::exp(1.37703990936279*x_6) - 0.000207106535892141*std::exp(1.45175981521606*x_6) - 0.00566764465095492*std::exp(1.46799981594086*x_6) - 0.0947741097794653*std::exp(1.52735984325409*x_6) - 7.84914441246055e-5*std::exp(1.53255987167358*x_6) - 0.000105601233898129*std::exp(1.55359983444214*x_6) - 0.00205192828729768*std::exp(1.59999990463257*x_6) - 0.186234968212564*std::exp(1.63423991203308*x_6) - 7.00590367178951e-7*std::exp(1.6639997959137*x_6) + 0.00320725784140623*std::exp(0.870079874992371*x_8) - 0.97160049693156*std::exp(0.926959812641144*x_8) + 0.153739098735291*std::sin(0.277119934558868*x_112 + 1.96535980701447) - 73.8672885651724*std::sin(0.227679997682571*x_119 - 7.40967988967896) - 0.241937497475278*std::sin(0.239919975399971*x_16 + 8.20735931396484) - 0.0745417925384021*std::sin(0.276479959487915*x_16 - 1.17711985111237) - 0.00152197096677341*std::sin(0.332639843225479*x_16 + 2.03247976303101) - 133.376735414719*std::sin(0.26623997092247*x_17 + 8.23527908325195) - 104.222612869008*std::sin(0.281439960002899*x_17 + 5.0383996963501) - 3345.45621756611*std::sin(0.364639848470688*x_31 - 7.40783977508545) + 0.107741277334925*std::sin(0.338239848613739*x_32 - 1.21039986610413) + 9.56819967453105*std::sin(0.326799839735031*x_91 + 2.00583982467651) - 3.19893291576399*std::sin(0.327439844608307*x_91 - 7.40367984771729) - 0.491149862039574*std::sin(0.331839829683304*x_91 + 2.00687980651855) + 0.0555948781439986*std::sin(0.332719832658768*x_91 - 7.40847969055176) - 0.0016874199792693*std::sin(0.359919846057892*x_91 + 1.99703979492188) - 625.932964642307*std::sin(0.372159838676453*x_91 + 2.00287985801697) - 0.544110915377664*std::sin(0.295439928770065*x_94 + 1.95695984363556) + 1580.23031967896*std::sin(0.272399961948395*x_96 + 1.98335981369019) - 0.0678749486241164*std::sin(0.288959950208664*x_97 + 1.9599198102951) + 36001484.55249 + 0.732886438188786*std::exp(-6.37967967987061*x_93) + 0.00677257799755486*std::exp(-6.11312007904053*x_93) + 0.000329920821995106*std::exp(-7.8121600151062*x_113) + 0.244682913252287*std::exp(-7.73320007324219*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
