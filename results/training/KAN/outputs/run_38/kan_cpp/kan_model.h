
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.24607413840813e-6*x_1 + 4.45337368512146e-7*x_10 - 1.97412209410627e-6*x_100 - 1.45686274489134e-6*x_101 + 8.09902969237017e-7*x_102 - 2.19799895467698e-6*x_103 + 2.74422262806128e-6*x_104 - 1.33191118600634e-6*x_105 + 3.45626656846189e-7*x_106 - 3.95361963544005e-7*x_107 + 8.98556834923169e-7*x_108 - 1.11756512731434e-6*x_109 + 4.05490182410161e-6*x_11 - 1.73509226356987e-7*x_110 - 3.150940749925e-7*x_111 + 4.84398780136361e-6*x_112 + 1.17003877756804e-6*x_113 - 1.57824045482216e-7*x_114 + 2.41356930029645e-7*x_115 - 3.02983263275493e-6*x_116 - 9.84674149050663e-7*x_117 + 1.27632642870753e-6*x_118 - 1.92771716235279e-6*x_119 + 4.50242257948177e-6*x_12 + 1.33793980477311e-6*x_120 + 5.66990255339773e-7*x_13 + 7.13930041550798e-7*x_14 + 7.11715664056566e-7*x_15 - 4.84291814067841e-7*x_16 + 2.11134785353132e-7*x_17 + 3.68131738546069e-7*x_18 - 7.95907538830359e-7*x_19 - 2.80203919130078e-6*x_2 - 2.13874294424919e-6*x_20 + 4.89138659383734e-7*x_21 - 2.31395154942632e-7*x_22 + 1.63812316277843e-6*x_23 - 4.28346999501703e-8*x_24 - 3.23423290327349e-7*x_25 + 1.65034086378902e-6*x_26 - 2.82514594293999e-7*x_27 - 7.15730185341946e-7*x_28 + 5.24138728366297e-7*x_29 + 1.52160422059651e-7*x_3 + 1.89549177137688e-6*x_30 + 9.27317769836344e-6*x_31 + 1.48010017184377e-5*x_32 + 4.64880595044731e-6*x_33 + 6.67783873950751e-7*x_34 - 4.91429006429029e-7*x_35 + 7.5287331487651e-6*x_36 - 2.67786786503431e-6*x_37 + 1.49543790205053e-6*x_38 - 2.46170980375811e-6*x_39 + 2.59204373641007e-7*x_4 - 2.53957121802721e-6*x_40 - 6.1030673177201e-8*x_41 - 2.54709667763078e-7*x_42 - 2.5430594880336e-6*x_43 - 5.37800721631096e-7*x_44 - 3.00427290509634e-7*x_45 + 9.1977329909155e-7*x_46 - 1.60464225636103e-6*x_47 + 4.02428291320726e-6*x_48 - 9.39309092788423e-7*x_49 + 1.71609702801341e-6*x_5 - 2.84294931307927e-7*x_50 + 1.9990413498801e-7*x_51 + 2.91690629677488e-7*x_52 + 1.48850553150108e-6*x_53 - 9.15882055920727e-8*x_54 - 9.25452443926805e-7*x_55 - 7.55396694372444e-7*x_56 + 2.04981566647094e-6*x_57 + 4.45984365192788e-6*x_58 - 7.41409705237209e-7*x_59 - 8.31037597628717e-7*x_6 + 9.85434652068387e-7*x_60 - 2.71653335486445e-7*x_61 + 8.8949437612856e-7*x_62 + 1.31130230315331e-6*x_63 + 4.38575174503823e-7*x_64 - 6.56169971027155e-7*x_65 + 1.10975029065775e-6*x_66 - 2.33002707505598e-6*x_67 + 2.64819375439491e-6*x_68 + 9.7238809149112e-8*x_69 + 1.33236432149387e-6*x_7 + 5.60085763141032e-8*x_70 + 2.48654073331923e-7*x_71 + 2.69103538045977e-7*x_72 - 2.72704599447962e-7*x_73 + 7.80244238770212e-7*x_74 + 1.21462546816069e-6*x_75 - 7.08790217146911e-7*x_76 + 8.66803506108533e-7*x_77 + 2.09013794345308e-6*x_78 - 5.86918346586384e-7*x_79 - 1.3291868275412e-6*x_8 + 3.5964022838644e-7*x_80 - 1.75253826618816e-7*x_81 - 6.58444764527479e-7*x_82 + 7.57637772160191e-7*x_83 + 3.07753157447688e-7*x_84 + 7.12719179451664e-8*x_85 + 1.73313799702698e-6*x_86 + 9.67410676500445e-8*x_87 + 1.18720982910633e-6*x_88 + 2.90763312074097e-7*x_89 + 9.08713724794991e-8*x_9 + 3.47105699652641e-7*x_90 - 5.46602615969692e-6*x_91 + 1.2604846192998e-7*x_92 + 6.19522806289366e-6*x_93 + 1.40757494732583e-6*x_94 + 1.48823273028594e-6*x_95 + 6.99579669290608e-8*x_96 - 1.06676998362733e-6*x_97 + 1.66896650680116e-6*x_98 + 5.15901512108192e-6*x_99 - 1.33194830935857e-8*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 2.23177102202223e-9*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 1.14875632909557e-8*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 1.17667920386501e-8*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) + 8.60780604301991e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 5.02621324480683e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) + 4.79180441785584e-12*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 2.12804724015345e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) + 1.22292525517003e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) - 2.12174794543384e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 1.3996873879098e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 2.32846408724443e-10*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 1.30322541522072e-5*std::exp(0.00836000575428356*x_1 - 0.000534072008689903*x_10 + 0.00240467415227859*x_100 + 0.00604762275477868*x_101 - 0.000677344269065684*x_102 - 0.0259265429201204*x_104 + 0.000941861187262645*x_105 - 0.00102514180104338*x_106 + 0.00160180638371943*x_107 - 0.00770812282866229*x_108 - 0.0053746207948564*x_109 - 0.00242595839849861*x_11 - 0.00399321804929517*x_110 - 0.0128597918627012*x_111 + 0.000724306034115258*x_112 + 0.00231266527273257*x_113 - 0.0121061721639295*x_114 + 0.000766677675234268*x_115 - 0.0107629895355901*x_116 + 0.0010444114174986*x_117 + 0.00186478704615039*x_118 + 0.000814677090751327*x_119 - 0.00057108975190981*x_12 + 0.00111272106051959*x_120 - 0.000753071526889409*x_13 + 0.0016252755786214*x_14 - 0.00932723209444691*x_15 - 0.0161310739587282*x_16 + 0.00105097511642648*x_17 + 0.00260872117015838*x_18 + 0.00751702993056481*x_19 - 0.000853985252351706*x_2 + 0.00757198393357434*x_20 + 0.0013916405844672*x_21 + 0.00197534130551443*x_22 - 0.00055957804294448*x_23 - 0.00049195771367137*x_24 - 0.00553770376117213*x_25 + 0.000381057340072507*x_26 - 0.00132204182368942*x_27 - 0.00163149533379721*x_28 - 0.000467354984404686*x_29 + 0.00363865714460032*x_3 + 0.00365102546459305*x_30 + 0.0209067836374674*x_31 - 0.0013050898468083*x_32 + 0.0112266640796593*x_33 + 0.00393697738987309*x_34 - 0.00133817007350311*x_35 - 0.00182266658978279*x_36 - 0.00106892878389383*x_37 + 0.0011489286099558*x_38 - 0.00117738990603084*x_39 - 4.43441827250478e-5*x_4 - 0.00067437615695257*x_40 - 0.00180285425884567*x_41 + 0.000219430474369799*x_42 + 0.00150634051516705*x_43 - 0.00607684170322434*x_44 + 0.000682641681655996*x_45 + 0.00273482066172528*x_46 + 0.00143445020891378*x_47 + 0.00573052397820225*x_48 - 0.00276116351243588*x_49 - 0.00325664140710691*x_5 - 0.00281300782273365*x_50 + 0.00234616045947926*x_51 - 0.00220356630339842*x_52 + 0.00242580129025941*x_53 + 0.0156464234287281*x_54 + 0.00612856772296685*x_55 + 0.00102183264004455*x_56 - 0.00506289365109646*x_57 - 0.000686021531816461*x_58 - 0.0189785685241975*x_59 + 0.000209880855436365*x_6 - 0.000764180843630878*x_60 - 0.00283885018218466*x_61 - 0.0127901327218463*x_62 + 0.00471229712924177*x_63 + 0.0035091895229508*x_64 - 0.00136963543986726*x_65 + 0.00018363469907495*x_66 - 0.00105551635367056*x_67 - 0.00535487021170851*x_68 - 0.0136146105023013*x_69 - 0.00259843577590666*x_7 - 8.91957133446378e-5*x_70 + 0.00270367429265902*x_71 + 0.000897975824599869*x_72 - 0.00609086395409008*x_73 + 0.00894021284327661*x_74 + 0.000474698636359923*x_75 - 0.00124079863411924*x_76 - 0.00229782193543465*x_77 - 0.000478571415895458*x_78 - 0.000315670327676977*x_79 + 0.0164152106563038*x_8 + 0.000427683677881224*x_80 + 0.00437102807593656*x_81 - 0.00277402376529874*x_82 - 0.000636100321552388*x_83 + 0.000968673314627451*x_84 - 0.000156930029556345*x_85 + 8.38954754298082e-5*x_86 + 0.000445346480076764*x_88 + 0.010148943625139*x_89 - 0.00660688818469831*x_9 - 0.00237064308953068*x_90 + 0.0133667600615594*x_91 + 0.0131239109957916*x_92 + 0.0411092250720159*x_93 + 0.00194941524037272*x_94 + 0.0083383896628876*x_96 + 0.00225991008684821*x_97 + 0.00410653061625293*x_98 + 0.00130222604363727*x_99 - 0.0177179233591129*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 0.0029184660592807*std::sin(1.33839976787567*x_87 + 4.78111982345581) - 0.321449708536306*std::sin(0.401999861001968*x_95 - 1.40631985664368)) + 0.000102282515313145*std::sin(0.213839992880821*x_1 + 7.78743982315063) + 5.31117048440248e-7*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 4.1151223131913e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) - 2.10143154600424e-6*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 6.29357828215739e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 9.80514414331967e-7*std::sin(1.22023987770081*x_19 - 3.59943985939026) + 3.52040356004896e-7*std::sin(0.515839874744415*x_2 + 2.30847978591919) - 1.29987872438942e-6*std::sin(1.23471987247467*x_29 + 9.79176044464111) + 4.12482004668634e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) + 2.25444285475026e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 2.11954286966467e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 7.14536795402501e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 6.86171935713846e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 9.98290050179261e-8*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 2.77811842103147e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) - 1.77245825026576e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) + 2.04567218085488e-6*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 2.03869272475205e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 7.34011957048913e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 2.84289783775856e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) + 1.02757197758652e-6*std::sin(1.74439990520477*x_51 - 9.60255908966064) - 5.40604861470255e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 6.6949874033144e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 1.47721432973667e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) - 1.86756882031929e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 4.81242560223654e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 1.14120654576032e-6*std::sin(1.63103985786438*x_72 + 0.196399986743927) + 3.0540302201599e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 1.88286022694526e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 1.58348003144586e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 6.25892929973302e-8*std::sin(1.61631989479065*x_80 - 0.393119841814041) + 5.44295332813779e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) + 2.46435193022973e-8*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 1.12871998829382e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 0.00015918310209071*std::sin(0.238479986786842*x_91 - 8.02320003509521) - 5.25263222644499e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) - 1.42410251315192e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 2.68328325048621e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0846837734143241);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.55386334708385e-6*x_1 + 1.49505581755583e-6*x_10 + 7.23942333000205e-6*x_100 + 6.95317099913149e-7*x_101 - 7.37290378927317e-7*x_102 + 4.44669900082218e-6*x_103 - 7.16976003879569e-6*x_104 + 8.52762279308756e-7*x_105 - 1.4851936082772e-6*x_106 + 1.49778566561867e-6*x_107 - 2.76895522664672e-6*x_108 - 9.01328304645947e-7*x_109 + 3.74705389852213e-7*x_11 - 1.33882196733168e-6*x_110 - 4.60649893342493e-6*x_111 - 1.9360906253337e-7*x_112 + 1.31191181026577e-6*x_113 - 2.0341730404807e-6*x_114 - 2.91242272708216e-6*x_115 - 3.38671850647244e-6*x_116 + 2.50053534611041e-6*x_117 - 1.32945819248701e-6*x_118 + 2.04445628119743e-6*x_119 + 6.8693152228853e-7*x_12 - 8.58465036326485e-7*x_120 + 1.49647352662041e-6*x_13 + 6.92172571709913e-7*x_14 - 2.12614860927984e-6*x_15 - 3.83483745896498e-6*x_16 + 4.72114563193595e-7*x_17 + 4.09322626941034e-7*x_18 + 1.67179468366324e-6*x_19 + 1.18827655635741e-6*x_2 + 3.72983931895719e-6*x_20 - 3.12682004872531e-7*x_21 + 3.08693557423873e-6*x_22 + 4.19084134836445e-7*x_23 + 2.03122068681517e-7*x_24 - 1.21955089018553e-6*x_25 - 2.48568148525477e-6*x_26 + 5.9684062254582e-8*x_27 + 5.20353378453986e-7*x_28 + 3.99452884389438e-7*x_29 - 5.65418726926086e-7*x_3 + 8.52886318564818e-7*x_30 - 5.2377117970582e-8*x_31 + 7.25350368608646e-7*x_32 + 4.5906743030843e-6*x_33 + 1.17202335804943e-6*x_34 - 1.93981144971322e-8*x_35 - 1.07029487819755e-5*x_36 + 3.18994279478955e-6*x_37 + 3.62695299421841e-6*x_38 + 4.70679762487245e-6*x_39 + 5.0235579374816e-7*x_4 - 5.57862242531876e-8*x_40 - 1.36360255453333e-6*x_41 + 8.54041766727675e-7*x_42 + 3.3814475754566e-7*x_43 - 2.2845400449808e-7*x_44 - 1.16231153178899e-6*x_45 - 2.64177677395906e-7*x_46 + 8.8305801886711e-7*x_47 + 3.46008753117775e-7*x_48 + 1.93959429765738e-6*x_49 - 1.82102802416177e-6*x_5 + 5.82907639447152e-7*x_50 + 7.79191281891194e-7*x_51 - 1.46288915695281e-7*x_52 + 1.58087041480684e-7*x_53 + 3.36508591993253e-6*x_54 + 2.99511750808719e-6*x_55 + 1.47174943318075e-6*x_56 - 1.42578459275693e-6*x_57 - 1.06590724072092e-7*x_58 - 4.44176256225241e-6*x_59 + 1.32184813947313e-6*x_6 - 9.2671061880741e-7*x_60 - 2.15455417959412e-6*x_61 - 2.68262771818007e-7*x_62 + 6.20363701660267e-7*x_63 + 6.47966291295421e-7*x_64 + 1.97121482778839e-6*x_65 + 1.13934576725117e-6*x_66 - 7.23501356149654e-7*x_67 - 1.11001330536394e-6*x_68 - 1.71285370863141e-6*x_69 - 9.38415813058335e-7*x_7 - 4.62878617277572e-7*x_70 - 8.80093482804091e-7*x_71 + 6.53954775946913e-7*x_72 - 7.75485450716595e-7*x_73 + 3.26985271672804e-6*x_74 - 2.58183316857471e-7*x_75 - 8.29437622453371e-7*x_76 + 1.87520986057823e-7*x_77 + 4.98194816393468e-7*x_78 - 4.0223602444674e-7*x_79 + 2.64317636128844e-6*x_8 + 9.77028606766592e-7*x_80 + 1.60286844531221e-6*x_81 - 4.80412003859397e-7*x_82 + 2.23521104496519e-7*x_83 + 1.76435725996917e-7*x_84 - 4.68734569439796e-8*x_85 - 1.46601137818022e-7*x_86 - 3.68989804221715e-8*x_87 - 8.86906571037069e-7*x_88 + 1.12134625773389e-6*x_89 - 2.1189685822604e-6*x_9 - 7.01450419850188e-7*x_90 + 2.46017019371004e-5*x_91 + 4.24196534855915e-6*x_92 - 5.87432626193262e-6*x_93 - 3.12101725987309e-6*x_94 - 2.41466234828571e-7*x_95 + 2.56210996273601e-6*x_96 + 5.72945252192494e-7*x_97 + 4.80585927868717e-7*x_98 + 9.0190108557012e-7*x_99 - 4.6558758767939e-9*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 1.11659185948767e-8*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 4.01552135572443e-9*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) - 1.02473062951057e-10*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) + 4.37716129042432e-10*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 2.57109309192228e-10*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) - 6.3419406867155e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) + 4.67844607936689e-11*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) - 3.21094151325249e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 0.000131760090477521*std::exp(-0.00211688643621735*x_1 + 0.00170454732820383*x_10 - 0.0039387777936568*x_100 + 0.000422339296013447*x_101 - 0.000557489677014838*x_102 + 2.57866953696181e-6*x_103 + 0.000827202070866678*x_104 + 0.00070849640294194*x_105 - 0.000256618454290678*x_106 + 0.000427845833759922*x_107 + 0.00173057719858171*x_108 + 0.00435781365606163*x_109 + 0.0008610304529898*x_11 - 0.00313423375483416*x_110 - 0.00661893293849222*x_111 + 0.000420884626909384*x_112 + 0.000588669776912263*x_113 - 0.000267657096519197*x_114 - 0.00126960039473474*x_116 - 0.00278349013936753*x_117 - 2.15871979321694e-5*x_118 + 0.00170560345899687*x_119 + 0.00288061084060379*x_12 - 0.000738062568533567*x_120 - 0.00042994307816205*x_13 - 0.000736485841055891*x_14 + 0.000906683150575626*x_15 + 0.000782231811425744*x_16 - 0.00173681381317161*x_17 + 0.000467861546956014*x_18 + 0.0019887549354767*x_19 - 0.000531127403940233*x_2 - 0.00166135613664214*x_20 - 6.56937945082832e-5*x_21 - 0.00138366955623769*x_22 + 3.26044524081728e-8*x_23 - 0.000241417985203327*x_24 - 0.00268316869456048*x_25 + 0.00630412776205685*x_26 - 0.000919651035385974*x_27 - 0.000267175813226267*x_28 - 0.00144583901792134*x_29 + 0.000535069462356853*x_3 - 0.00157127915656911*x_30 + 0.000259705149470405*x_32 - 0.000447639168083772*x_33 - 0.00649267303286082*x_34 + 8.70590761108007e-5*x_35 + 0.000408416369093946*x_36 + 0.000679468041174734*x_37 - 0.000147928638561214*x_38 - 0.0026552860534736*x_39 - 0.000747820848175505*x_4 - 0.00492910153388345*x_40 - 0.000675502585633878*x_41 - 0.0080518624700888*x_42 - 0.00122695433355033*x_43 + 0.00284689619609972*x_44 - 0.0023939130785704*x_45 - 0.00149702246683828*x_46 - 0.00293639575805825*x_47 - 0.00109387494630387*x_48 - 0.00173828798343076*x_49 + 0.00274453271794989*x_5 + 0.000257856250641144*x_50 + 0.00107913351578336*x_51 - 0.00145002724388804*x_52 - 0.000274305894238304*x_53 + 2.52295963803231e-5*x_54 + 0.00393611342260685*x_55 - 0.000387411132998489*x_56 + 0.000211453033241292*x_57 - 0.000658879043956683*x_58 + 0.00401532167843157*x_59 + 0.000491858130644674*x_60 - 0.00400020945439815*x_61 - 0.00197772742646538*x_62 - 0.00139893857966813*x_63 - 0.00117885598020529*x_64 - 0.00175112687528731*x_65 + 0.00110002463538083*x_67 + 0.00137873484689868*x_68 - 0.00142719955655275*x_69 - 0.000939051434918757*x_7 + 0.00289130890283033*x_70 - 0.00082531192205569*x_71 - 0.0017169061443076*x_72 + 0.000182444104159831*x_73 + 0.000888484984989822*x_74 + 0.000474212736939753*x_75 + 0.000444388360208735*x_76 + 0.000688792325482442*x_77 + 0.00121003186693816*x_78 - 0.00153592183951685*x_79 - 0.00354578564271539*x_8 - 0.000614340068430839*x_80 - 0.000938534708514314*x_81 - 0.00146011414106219*x_82 - 0.000433626306163148*x_83 + 0.00371960025915734*x_84 + 0.000128352604261592*x_85 + 0.00219296152923187*x_86 - 0.000434424244143595*x_88 - 0.000351956021036966*x_89 - 0.00203339611835877*x_9 + 0.000995553926820815*x_90 - 0.000779127092453879*x_91 + 0.00116156312759356*x_93 + 0.00055313154493825*x_94 + 0.000532432700765006*x_95 - 0.00022517738597425*x_96 + 0.00188041493343314*x_97 - 0.000806365182127812*x_98 - 0.000559327253779396*x_99 + 1.02602514437935e-5*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 2.77546065670752e-6*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 0.0250484454995443*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 0.00644385082877169*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 0.00798022792657355*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 0.00626098300957895*std::sin(0.3781598508358*x_92 + 1.99599981307983)) - 0.00242827765004822*std::exp(6.18580271923038e-5*x_1 - 8.45280759578675e-5*x_10 - 1.353500240836e-5*x_100 - 0.000135685019340182*x_101 - 1.34228821884715e-5*x_102 + 2.63720208231502e-5*x_103 - 3.14927286633279e-5*x_104 - 4.44033231187447e-5*x_105 + 1.19921533381087e-5*x_106 + 3.28320593098976e-5*x_107 - 1.64097980529155e-5*x_108 + 6.53501338191138e-7*x_109 - 2.1838871398075e-5*x_11 - 5.63572283716789e-5*x_110 + 5.13412799003142e-5*x_112 + 2.36590027951669e-5*x_113 + 1.50048997986598e-5*x_114 + 9.55228094386249e-5*x_115 - 0.000127937715254845*x_116 - 0.000124617159654462*x_117 - 1.71424715668105e-5*x_118 + 0.000127176643603282*x_119 - 8.07907244927333e-6*x_12 + 1.64832460848385e-5*x_120 - 1.05750086848364e-5*x_13 + 1.28287367941598e-5*x_14 - 3.74235486223555e-5*x_15 + 0.000114647913702092*x_16 - 3.67185817927802e-5*x_17 + 1.53100691833892e-5*x_18 + 3.77216470295698e-5*x_19 + 3.05388831474263e-5*x_2 - 2.98108184979274e-6*x_20 - 0.000120323526500178*x_21 - 4.78232677204047e-5*x_22 + 0.000219386744504194*x_23 + 3.33142384740904e-5*x_24 - 1.34241212534011e-5*x_25 + 1.41333880451954e-5*x_26 + 6.85684367875359e-5*x_27 - 7.22436154461591e-5*x_28 - 3.55798610997722e-5*x_3 + 0.000155479310809127*x_30 + 0.000109969988255222*x_31 - 2.71463276493075e-5*x_32 + 0.000166259147937075*x_33 + 0.000159135967744139*x_34 - 6.64955232593056e-6*x_35 - 1.36103863101446e-5*x_36 + 3.0915164631471e-5*x_37 + 3.86938055836465e-5*x_38 + 3.86689951618515e-5*x_39 - 1.09470320889521e-5*x_4 - 2.76400466414208e-5*x_40 + 3.17225744836004e-5*x_41 - 5.91862605487311e-6*x_42 + 3.17022046646378e-6*x_43 - 1.27630932891938e-5*x_44 - 9.22927221702001e-5*x_45 + 2.10877628201113e-5*x_47 - 2.17906459255829e-5*x_48 - 4.52763745404537e-5*x_49 - 1.19098684750184e-5*x_5 + 0.000199243422122041*x_50 - 4.55239338284172e-5*x_51 + 0.000270363025791625*x_52 + 0.000142349826884093*x_53 - 0.000212292784236315*x_54 - 0.00025515335654287*x_55 + 7.975023604859e-5*x_56 + 0.000249769844375028*x_57 + 2.88495313970315e-5*x_58 + 9.29043661166024e-5*x_59 - 1.84927101354801e-6*x_6 + 3.81835746816014e-5*x_60 + 3.31866469204955e-6*x_61 - 5.76391528805912e-5*x_62 + 0.000124067683971821*x_63 + 1.01273801725481e-5*x_64 + 4.4271031656476e-5*x_65 - 7.65883608887834e-5*x_66 - 4.38540251300948e-5*x_67 - 6.42688792962349e-6*x_68 + 1.40081831192888e-5*x_69 - 0.000152770981470768*x_7 + 1.39552547050549e-6*x_70 + 1.72152995904575e-5*x_71 - 0.000115886095228495*x_72 + 1.06561832425785e-5*x_73 + 2.39301947687829e-5*x_74 - 2.19462914840581e-5*x_75 + 6.81033611484066e-5*x_76 - 0.00010654538481156*x_77 - 1.89442953268846e-5*x_78 - 4.21660002734462e-5*x_79 - 4.96742940860026e-5*x_8 - 3.78156906940019e-6*x_80 + 6.08277755223847e-6*x_81 - 5.21415737083313e-6*x_82 + 2.33211446552301e-5*x_83 - 1.79657262733238e-5*x_84 - 6.32862565909495e-5*x_85 - 7.26804600628722e-5*x_86 - 4.79199046151508e-5*x_87 + 6.80626780139111e-5*x_88 + 0.000156941623845442*x_89 - 1.24100867094157e-5*x_9 + 5.42035564737071e-5*x_90 - 0.000123403884808982*x_91 + 8.73230577996584e-5*x_92 - 0.000103303642061191*x_93 - 1.74091914031147e-5*x_94 - 0.00016915578117824*x_95 + 5.28005673510107e-5*x_97 + 5.47888472880548e-5*x_98 + 8.96507356618226e-5*x_99 + 3.07749931624857e-9*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 0.000144789848228404*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 0.000113834759885981*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 0.000172331790878218*std::sin(1.0402398109436*x_96 + 0.18376000225544)) + 0.000203310371234622*std::exp(-0.00563451262260794*x_10 + 0.000301576389479811*x_100 + 0.00266428376254764*x_101 + 0.000540048069111403*x_102 - 0.000783129925675347*x_103 + 0.000263354875670265*x_104 + 0.00287751007834276*x_105 - 0.000910796160083587*x_106 - 0.00690821578295548*x_107 + 0.0017231694701092*x_108 + 0.000514495399994171*x_109 - 0.00192261158340682*x_11 - 0.00192785228890805*x_110 + 0.00249877795582541*x_111 - 0.000152170722088932*x_112 + 0.00361061978093203*x_113 - 0.000358543877573533*x_114 + 5.6034691001344e-5*x_115 - 0.00450402676534461*x_116 - 0.000386859515898149*x_117 + 0.00616480079392869*x_118 - 0.000707690412780433*x_119 + 0.00150852203633244*x_12 + 0.000206029763490782*x_120 - 0.00138440674535402*x_13 - 0.00307932785987654*x_14 - 0.000398955255255501*x_15 + 0.000459071730886741*x_16 + 0.00039565401381231*x_17 + 0.00315068166302326*x_18 + 0.008541549415179*x_19 + 0.0143707512626337*x_20 + 0.000529743945161562*x_21 - 0.000462360036085745*x_22 - 0.00336327374495347*x_23 - 0.000121349834007531*x_24 + 0.00839862687851371*x_25 + 0.0016456375823348*x_26 + 0.00113723071424984*x_27 - 0.000494752497720674*x_28 + 0.00167445714791967*x_29 - 0.00507660957722277*x_3 - 0.000502645764189672*x_30 + 0.000692488516363979*x_31 - 0.00129467420833284*x_32 - 0.000868449717552096*x_33 - 0.0106024512950498*x_34 - 0.000617365637967689*x_35 + 0.00192546305281013*x_36 - 0.00268065437205099*x_37 - 0.00922876295365648*x_38 - 0.00760281877688653*x_39 - 0.000163726549572449*x_4 + 0.002536128807616*x_40 - 0.00302580545600561*x_41 + 0.00929504172561365*x_42 + 0.00521860398292597*x_43 - 0.00196478021560734*x_44 - 0.00239962920342144*x_45 + 0.00197474640870644*x_46 - 0.00494348699824251*x_47 + 0.00284485105905871*x_48 + 0.00206336960751014*x_49 - 0.00173588886675926*x_5 + 0.0029202732651198*x_50 + 0.0012163695566128*x_52 + 0.00519107535669118*x_53 + 0.0112746513137492*x_54 + 0.000137862216139225*x_55 + 0.00318812238817579*x_56 + 0.00110137092408082*x_57 - 0.00267402509059336*x_58 + 0.00510407104554437*x_59 + 0.00111085894100848*x_6 + 0.0017465811238687*x_60 + 0.00105132080238509*x_61 + 0.00486974755235435*x_62 + 0.000386909555748051*x_63 + 0.00264757536511222*x_64 - 0.0247165152148713*x_65 - 0.00247470819126736*x_66 + 0.00539942837766211*x_67 + 0.00381531917246155*x_68 - 0.00176597930100636*x_69 - 0.0016138455640069*x_7 + 0.00287708864493822*x_70 - 0.00260614333042442*x_71 - 0.00161608751822492*x_72 + 0.00219477431836646*x_73 - 0.00064213677553918*x_74 - 0.000733788850514117*x_75 + 0.000852195880075104*x_76 + 0.00458492438686782*x_77 - 0.00517117475296981*x_78 - 0.000141909351581418*x_79 - 0.000147569806207011*x_8 + 0.00202648150546916*x_80 - 0.00052766719683216*x_81 - 0.00510492913799963*x_82 + 0.00100005480875089*x_83 - 0.000236753918457568*x_84 - 0.000612499414178072*x_85 - 0.000597333526159726*x_86 - 0.00798211873127633*x_87 + 0.00296918515534763*x_88 + 0.00796756710113321*x_89 + 0.00652939469806303*x_9 + 0.000721516482537702*x_90 - 0.0123809605617433*x_91 + 0.00263886277510058*x_92 + 0.00273163054584303*x_93 + 0.00114499928618174*x_94 - 0.000683496996026356*x_95 + 0.000357786206716838*x_96 + 0.00140185069550769*x_97 - 0.0214542571880171*x_98 - 0.0044272448156827*x_99 - 1.40609774495955*std::sin(0.213839992880821*x_1 + 7.78743982315063) - 0.00483956763477861*std::sin(0.515839874744415*x_2 + 2.30847978591919) - 0.0141262329738809*std::sin(1.74439990520477*x_51 - 9.60255908966064)) + 2.65726621087741e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 4.16516408869569e-6*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 1.96595418643453e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) - 2.19994417926936e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) - 5.08482773732425e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 4.54377542515658e-7*std::sin(1.23471987247467*x_29 + 9.79176044464111) + 2.31281864726753e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) + 4.86232014956409e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 3.4136205375477e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) + 0.000157410717038938*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 4.99460980736134e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 1.32721535948762e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 9.8937001563514e-8*std::sin(1.68839979171753*x_46 + 1.82767987251282) + 2.46992183535821e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) + 8.8682856120277e-8*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 1.35816300959784e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) + 3.38879156609831e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) + 4.11798208367493e-7*std::sin(1.43927991390228*x_70 - 8.60223960876465) - 1.10399059669574e-6*std::sin(1.52583992481232*x_72 + 0.823119878768921) + 9.93838675993725e-9*std::sin(1.63103985786438*x_72 + 0.196399986743927) + 1.06754785670996e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) + 2.28112727876892e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) + 1.91315046641246e-8*std::sin(1.62847983837128*x_78 - 6.5827202796936) + 1.38009150928543e-8*std::sin(1.61631989479065*x_80 - 0.393119841814041) - 6.86078711246993e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) - 6.59425969925814e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) + 1.23295592471397e-7*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 5.39233494757953e-7*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 7.69874028098288e-6*std::sin(0.238479986786842*x_91 - 8.02320003509521) - 6.80349230123309e-6*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 7.55670264048457e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 0.0772655205736179);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.99338479366923e-8*x_1 + 1.34056218535911e-6*x_10 - 5.14785865103853e-6*x_100 + 3.07033311845749e-6*x_101 + 8.70737680217753e-7*x_102 - 5.01766825982839e-6*x_103 + 2.20116562319496e-7*x_104 + 9.10672970713854e-7*x_105 - 3.96663602438627e-10*x_106 - 1.69800974926785e-6*x_107 + 8.16401960697052e-7*x_108 - 3.61954967147423e-7*x_109 - 4.22312249140019e-6*x_11 + 9.77452324546599e-7*x_110 + 1.27959578673807e-6*x_111 - 3.88632082570259e-6*x_112 - 8.80381744052226e-9*x_113 + 3.56664167545364e-7*x_114 + 3.20948888010592e-6*x_115 - 2.35807026264483e-8*x_116 + 1.0693973796145e-6*x_117 - 7.14219628984192e-7*x_118 - 1.58023989910576e-6*x_119 - 3.07501233254363e-6*x_12 + 1.14621842537393e-6*x_120 + 2.62942089398023e-6*x_13 - 1.03823712919736e-6*x_14 - 1.13191808127868e-6*x_15 - 1.51184273162041e-6*x_16 - 1.66451427967552e-7*x_17 + 2.29962129231941e-7*x_18 - 3.67350504147717e-7*x_19 - 4.52418401420938e-6*x_2 - 3.97723374878812e-8*x_20 - 1.33017047505335e-7*x_21 - 8.86020054122159e-7*x_22 - 1.18028521243775e-7*x_23 - 1.33867379786079e-7*x_24 - 8.93321555654512e-7*x_25 - 4.09177142903175e-7*x_26 - 9.76697713968531e-7*x_27 + 4.8459963435051e-7*x_28 - 6.00820746813466e-7*x_29 + 3.02033227906385e-7*x_3 + 1.6774179482928e-6*x_30 + 7.5461401296128e-6*x_31 - 5.23080593759646e-6*x_32 - 6.04452912245359e-6*x_33 - 1.61609148303886e-6*x_34 + 1.19515693586281e-6*x_35 + 8.53932762092078e-6*x_36 - 1.52029260743982e-6*x_37 + 6.29410910103749e-8*x_38 - 2.6549970203243e-6*x_39 - 1.09195531747681e-6*x_4 + 1.94126329050782e-6*x_40 + 1.03924846817671e-6*x_41 + 8.91214697287993e-7*x_42 + 3.12750439710435e-8*x_43 - 2.46410880385199e-6*x_44 - 3.86085859794386e-6*x_45 + 9.94999019944751e-7*x_46 - 1.77932002070943e-7*x_47 - 2.2855167183707e-6*x_48 - 2.46053437633051e-6*x_49 - 1.34412454862347e-6*x_5 - 1.07495266521988e-6*x_50 + 9.73153112234542e-7*x_51 + 5.53329851702619e-7*x_52 + 1.39829194494722e-6*x_53 + 2.80331845603401e-6*x_54 + 2.61170904449109e-6*x_55 - 5.27715767330219e-7*x_56 + 1.261332893451e-6*x_57 - 2.00044401224349e-7*x_58 - 6.59801195220045e-7*x_59 - 6.96264520019176e-7*x_6 - 7.75371593268738e-7*x_60 + 2.27985216567814e-6*x_61 + 1.38493612467838e-6*x_62 - 1.71358493235354e-7*x_63 + 5.33011564883693e-8*x_64 + 3.23476196176514e-7*x_65 - 7.74733938665688e-7*x_66 - 1.50749382190431e-6*x_67 - 1.78928252809045e-7*x_68 + 4.44703381375575e-7*x_69 - 1.34677989559733e-7*x_7 + 1.89175623826278e-6*x_70 + 1.06465145676106e-6*x_71 + 1.36688033734003e-6*x_72 - 1.07120892866465e-7*x_73 - 3.41301102334452e-7*x_74 + 4.79010805224757e-8*x_75 + 1.20990532312953e-6*x_76 + 1.59948505637493e-6*x_77 - 1.98943489687496e-6*x_78 + 3.12880722100993e-6*x_79 + 3.90422126569887e-6*x_8 - 1.21881770674852e-6*x_80 - 2.19667092634954e-7*x_81 - 2.17139953369493e-7*x_82 - 4.05891586109519e-7*x_83 + 1.7181810678033e-7*x_84 - 1.45271251044395e-7*x_85 - 4.68713023988775e-7*x_86 - 7.52514674422051e-7*x_87 + 9.72560222242094e-7*x_88 + 2.35161582852758e-7*x_89 + 1.50527785733674e-7*x_9 + 2.85628197448405e-7*x_90 + 1.68064626034976e-6*x_91 - 2.18628039578431e-6*x_92 + 1.00303687636733e-5*x_93 + 1.23124282014886e-7*x_94 + 9.19201054801233e-7*x_95 + 8.93750937765459e-7*x_96 - 8.73679629947176e-7*x_97 + 2.55913566355948e-7*x_98 - 4.1408840684471e-6*x_99 + 1.9772282626638e-8*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) - 4.34763969708502e-9*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) + 1.70528650762394e-8*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 3.7243780303021e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 1.74036325420214e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 1.59087694616208e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 1.42358040141862e-11*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 4.96128985671165e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) - 2.40903924508822e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) - 1.32914012604625e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 2.17058668806045e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) + 4.70778885573938e-11*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 3.74723827999856e-5*std::sin(0.213839992880821*x_1 + 7.78743982315063) - 1.034651646971e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 6.51981204837632e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) + 6.18987172713437e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) + 4.24876469754176e-7*std::sin(0.903679847717285*x_115 + 6.89792013168335) + 9.34258541816934e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) - 1.93151437057531e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 1.28974057206856e-7*std::sin(0.515839874744415*x_2 + 2.30847978591919) + 1.92962214362196e-6*std::sin(1.23471987247467*x_29 + 9.79176044464111) + 2.76812884390721e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) - 6.69764536336564e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 3.28691361900306e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) - 1.07478970763062e-5*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 0.00010640916552126*std::sin(0.326879858970642*x_35 - 7.79839992523193) - 1.94473600048434e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) - 4.17878142135662e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 5.26573417314084e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 1.75638933879602e-6*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 6.29374929352962e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 1.71126185946382e-6*std::sin(0.438079863786697*x_49 - 4.16512012481689) + 4.27622112049117e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) - 3.76462882055381e-7*std::sin(1.74439990520477*x_51 - 9.60255908966064) + 1.09301816426127e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) - 1.35362135320451e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 2.29081278236478e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) - 1.16991307218241e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 7.46294282546542e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 3.61210138932164e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) - 4.53359550359539e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 5.81267107067008e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 3.69169596900081e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 3.92082108351502e-8*std::sin(1.61631989479065*x_80 - 0.393119841814041) - 1.07393229953718e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 1.68032108261182e-6*std::sin(1.35327982902527*x_87 + 4.78735971450806) - 4.80072291186338e-8*std::sin(1.50495994091034*x_87 + 4.99383974075317) + 1.69779447891385e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) + 0.00013667268198943*std::sin(0.238479986786842*x_91 - 8.02320003509521) + 1.06199977892807e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) + 2.1421020353254e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 1.18286530547844e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 7.97167228406261e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0698463025309383);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.52171394194066e-6*x_1 + 9.5799847262141e-7*x_10 - 3.91199874001813e-6*x_100 + 4.64790995586781e-7*x_101 + 8.50707321951917e-7*x_102 - 2.69778548113846e-6*x_103 + 4.59566807409963e-8*x_104 + 5.03384960216431e-7*x_105 + 4.729659821742e-7*x_106 - 5.56370084562426e-7*x_107 - 4.4978706910669e-7*x_108 - 1.4635877859626e-6*x_109 - 1.06057073419156e-6*x_11 - 8.40431212619745e-7*x_110 + 2.1786531640435e-6*x_111 - 2.53289146744206e-7*x_112 - 5.30863423437558e-8*x_113 + 1.72144132200813e-7*x_114 + 1.7022884013167e-6*x_115 - 9.31462967911573e-7*x_116 + 4.63522529941521e-7*x_117 + 9.44041623189949e-7*x_118 - 9.07413149259294e-7*x_119 - 1.01161399369943e-7*x_12 + 1.05511356437264e-6*x_120 + 1.3930098689765e-7*x_13 - 3.42982504366153e-7*x_14 - 2.3915548207734e-6*x_15 - 7.46992920279609e-7*x_16 - 7.94379545656073e-7*x_17 - 4.51619566181644e-7*x_18 - 2.42759580259074e-7*x_19 - 2.87367167704587e-6*x_2 - 5.56597496952954e-7*x_20 - 5.20078854519797e-7*x_21 - 2.42950329307529e-6*x_22 + 1.09103159063303e-6*x_23 - 1.65948529749421e-6*x_24 - 8.71214957954137e-7*x_25 - 9.76113913619844e-7*x_26 - 9.99889100382362e-7*x_27 - 6.15375866696007e-7*x_28 + 2.67986310885814e-7*x_29 + 1.1390682177166e-6*x_3 + 7.08674105237594e-7*x_30 + 1.43655530936344e-6*x_31 - 3.96446030009705e-6*x_32 + 5.45524635121719e-6*x_33 + 3.95217561092367e-7*x_34 - 2.83366580855224e-7*x_35 + 5.73929031693831e-6*x_36 - 2.61623097352321e-6*x_37 + 2.00870277904795e-7*x_38 - 3.73299670322219e-6*x_39 - 8.66718606943438e-8*x_4 + 9.20964178088983e-7*x_40 - 2.74224343567182e-7*x_41 + 7.31577796955594e-7*x_42 - 1.24812478067316e-6*x_43 - 1.09993561526207e-6*x_44 - 4.91093232122085e-7*x_45 + 3.01812982879727e-7*x_46 - 1.32024108609498e-6*x_47 - 1.73733127873534e-7*x_48 - 1.76648816491539e-6*x_49 - 1.14614920814616e-6*x_5 - 1.11060293012864e-6*x_50 + 3.72810885356901e-7*x_51 + 1.40070749380687e-6*x_52 - 3.89174482600146e-7*x_53 + 6.35165578470305e-7*x_54 + 4.91382628502092e-7*x_55 - 9.48483139519736e-7*x_56 + 2.52537727680923e-7*x_57 - 2.91421739207053e-6*x_58 - 1.63201755474728e-6*x_59 - 3.14864625394821e-7*x_6 + 4.11344959005905e-7*x_60 + 2.86213566343583e-6*x_61 + 7.32738949541603e-7*x_62 + 8.74677339546323e-7*x_63 - 5.42927537677824e-7*x_64 + 1.39544823148223e-6*x_65 - 1.74891644991245e-6*x_66 - 7.92627552246383e-7*x_67 + 4.60026556935884e-8*x_68 - 5.47111606975697e-7*x_69 - 5.76439230586016e-7*x_7 + 4.92731206285291e-7*x_70 + 8.32938459007482e-7*x_71 + 6.02835664811921e-7*x_72 + 4.77304226352903e-7*x_73 + 1.78375245414512e-6*x_74 + 8.21677353101768e-7*x_75 + 5.25307834127361e-7*x_76 - 4.62788421155145e-7*x_77 - 1.26101235521371e-6*x_78 - 4.16994539793124e-7*x_79 + 2.9220702387244e-6*x_8 - 3.41627345395599e-6*x_80 - 6.94011397358632e-7*x_81 - 3.99230548096584e-7*x_82 - 1.86358128112228e-7*x_83 + 2.6895878562051e-7*x_84 - 4.47348445557885e-7*x_85 - 3.94137711532039e-7*x_86 - 1.93681327567258e-7*x_87 + 4.03305970192821e-7*x_88 + 1.48141928899012e-6*x_89 + 1.38369065519959e-6*x_9 - 7.45312992101774e-7*x_90 - 1.33909376317347e-5*x_91 + 5.82553136919985e-7*x_92 + 1.22179656552736e-5*x_93 + 1.33718798319651e-6*x_94 + 1.51542321642314e-6*x_95 - 3.13773639113711e-7*x_96 - 2.68969478576465e-7*x_97 + 2.14568698073653e-7*x_98 - 1.40556037407334e-6*x_99 - 7.36144654080166e-9*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) - 5.98466923757681e-9*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 6.34897634212024e-9*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 2.66254349865548e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 3.37069079735973e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 1.1373117969502e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) + 2.20066527026958e-12*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 5.33356844665126e-10*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) - 1.41673740623236e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) + 2.3300455934374e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) + 9.11792439517363e-11*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 0.000102849867296636*std::exp(-0.00163353536816511*x_1 - 0.00285214634482577*x_10 + 0.000755731599933558*x_100 + 0.000975181165336488*x_101 - 0.0012055670501457*x_102 - 0.00311328159698402*x_103 - 0.00971949047253659*x_104 + 0.00102517262053328*x_105 - 0.000176265111968967*x_106 - 0.00144445923960854*x_107 - 8.9747917933314e-5*x_108 + 0.000213467387072945*x_109 - 0.00151403335251533*x_11 - 0.000129832367989785*x_110 - 0.000906267082867476*x_111 + 0.000215771695063379*x_112 - 0.00726318406479198*x_113 - 0.0038691245792823*x_114 + 0.0021931843836432*x_115 - 0.00060706465408993*x_116 + 5.79756823051227e-5*x_117 - 0.000470411082686782*x_118 + 0.00250956507126305*x_119 + 0.00132330173964473*x_12 - 0.00240923801896306*x_120 - 7.18400461768933e-5*x_13 - 0.00241724306697547*x_14 - 0.000454483071021199*x_15 + 0.000116869640830477*x_16 - 0.000784500210159457*x_17 - 0.000710803729843792*x_18 + 0.000364980689223494*x_19 - 0.000780755837814192*x_2 + 0.000442761437638512*x_20 - 0.000845183007262689*x_21 - 0.00221464080012369*x_22 + 0.00201072612174494*x_23 + 0.000325910744017919*x_24 - 0.000133797582103242*x_25 - 0.00405790454981556*x_26 + 0.00121688360593103*x_27 - 0.000586848207189207*x_28 + 0.000693005808973294*x_29 + 0.000629367853922096*x_3 - 0.00206984614075996*x_30 - 0.00148421895285659*x_31 + 0.000331462656852195*x_32 - 0.00442863163791206*x_33 - 0.00043085750571808*x_34 - 0.00327979742600414*x_35 - 0.000826555634861415*x_36 - 0.000352242281549581*x_37 - 0.000785598536186007*x_38 - 0.00458748357139581*x_39 + 0.00320962977735019*x_4 + 0.00128530803275292*x_40 + 0.00217974788110911*x_41 - 0.00199325391273152*x_42 + 0.00124398184096821*x_43 + 0.0027776558300867*x_44 + 0.000588271010443297*x_45 - 0.00458933429443049*x_46 + 0.00070086462650564*x_47 - 0.000645053096685153*x_48 - 0.000767158521689341*x_49 + 0.00143029741881956*x_5 + 0.00112221228319572*x_50 + 0.00162571063826568*x_51 - 0.00209683270727687*x_52 - 0.00795103633384793*x_53 + 0.0019731210577069*x_54 - 0.000187934373471971*x_55 + 0.000345542796534907*x_56 + 0.00520337532964665*x_57 - 0.00059885044293205*x_58 + 0.00236484212106671*x_59 + 0.000139073220223117*x_6 - 0.000211321474428529*x_60 + 0.000165989068102735*x_61 + 0.00333473741316413*x_62 + 0.000671629481311273*x_63 - 0.00144745621340312*x_64 + 0.00590171830401069*x_65 - 0.000150899925973094*x_66 - 0.00076809694453026*x_67 - 0.00100361841740945*x_68 + 0.00278337497821163*x_69 + 8.90187526631179e-5*x_7 + 8.08938612295177e-7*x_71 - 0.00494435058241297*x_72 - 0.000830009344597562*x_73 + 0.000544811957541485*x_74 - 0.001218745331726*x_75 - 0.000293163376059802*x_76 + 0.00155865633709882*x_77 + 0.000621309402750486*x_78 - 0.000241063407007355*x_79 + 0.00196684533989444*x_8 - 0.0020941524656707*x_81 - 0.00798005735656124*x_83 - 0.000267196477567029*x_84 + 0.00024883136257085*x_85 + 0.000165147185724745*x_86 - 0.000340053575949*x_87 + 0.000240988531668236*x_88 + 0.000205559992820953*x_89 - 0.00129485146277653*x_9 - 0.000528889851962482*x_90 + 0.00653384434586908*x_91 - 0.000362039574820269*x_92 + 0.000335663002549177*x_93 + 0.000591487841724941*x_94 - 0.000193124655336824*x_95 + 4.17434116924794e-5*x_96 + 0.000716843004237353*x_97 - 0.000121435012741027*x_98 - 0.000107418437383486*x_99 + 1.86094015386515e-6*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 0.0163800503038928*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 0.000548957423483903*std::sin(1.61631989479065*x_80 - 0.393119841814041)) - 4.24505636857679e-5*std::exp(0.00331041940086326*x_10 - 0.000177183795200049*x_100 - 0.00156533443931844*x_101 - 0.000317291969177921*x_102 + 0.000460108739298969*x_103 - 0.000154727684206918*x_104 - 0.00169061032027938*x_105 + 0.00053511589742023*x_106 + 0.00405875238640615*x_107 - 0.00101240586842176*x_108 - 0.000302279126496531*x_109 + 0.00112958318000688*x_11 + 0.00113266222771295*x_110 - 0.00146809557054203*x_111 + 8.94041675628389e-5*x_112 - 0.00212133090694998*x_113 + 0.000210653642626998*x_114 - 3.29218054225192e-5*x_115 + 0.00264623022161284*x_116 + 0.000227289799955234*x_117 - 0.00362197718198257*x_118 + 0.000415786107723533*x_119 - 0.000886295044520327*x_12 - 0.000121047723538414*x_120 + 0.000813374155932705*x_13 + 0.00180918339734516*x_14 + 0.00023439635431376*x_15 - 0.000269716311969488*x_16 - 0.000232456791044947*x_17 - 0.00185110557058061*x_18 - 0.00501837741635107*x_19 - 0.00844318168601124*x_20 - 0.000311238034416007*x_21 + 0.000271648274865989*x_22 + 0.00197600882302304*x_23 + 7.12961123164776e-5*x_24 - 0.00493440679282297*x_25 - 0.000966853913414309*x_26 - 0.000668151954191161*x_27 + 0.000290679669526057*x_28 - 0.000983786140818291*x_29 + 0.00298263717923271*x_3 + 0.00029531716423151*x_30 - 0.000406854607131091*x_31 + 0.000760654009339778*x_32 + 0.000510236285943043*x_33 + 0.00622920966101152*x_34 + 0.00036271800637277*x_35 - 0.00113125849076859*x_36 + 0.00157495258855931*x_37 + 0.00542213283987851*x_38 + 0.00446684930286008*x_39 + 9.61935099703736e-5*x_4 - 0.0014900401454659*x_40 + 0.00177773762447667*x_41 - 0.0054610733032776*x_42 - 0.00306606250222655*x_43 + 0.00115435832339449*x_44 + 0.00140984315804187*x_45 - 0.00116021371519105*x_46 + 0.00290442427996952*x_47 - 0.00167142231622428*x_48 - 0.0012122820973807*x_49 + 0.00101987883729376*x_5 - 0.00171573477959489*x_50 - 0.000714648035869815*x_52 - 0.00304988873450774*x_53 - 0.00662414426001026*x_54 - 8.09975565805115e-5*x_55 - 0.00187310294838929*x_56 - 0.000647083415874272*x_57 + 0.00157105771717983*x_58 - 0.0029987714899703*x_59 - 0.000652657867014374*x_6 - 0.00102616081015368*x_60 - 0.000617677697052681*x_61 - 0.002861100480978*x_62 - 0.000227319199639116*x_63 - 0.00155551783108055*x_64 + 0.0145215810078655*x_65 + 0.00145395397198611*x_66 - 0.00317230143087532*x_67 - 0.00224159700314173*x_68 + 0.00103755773234358*x_69 + 0.000948175294461006*x_7 - 0.00169036271744095*x_70 + 0.00153117545745672*x_71 + 0.000949492499556867*x_72 - 0.0012894857054511*x_73 + 0.000377271679403705*x_74 + 0.000431119603341086*x_75 - 0.000500686743236116*x_76 - 0.00269375963075811*x_77 + 0.00303819662392771*x_78 + 8.33753515351278e-5*x_79 + 8.67010125222165e-5*x_8 - 0.00119060939969829*x_80 + 0.000310017891979413*x_81 + 0.00299927564110135*x_82 - 0.000587557622558528*x_83 + 0.000139098945620884*x_84 + 0.000359858976191977*x_85 + 0.000350948631448795*x_86 + 0.00468969766825737*x_87 - 0.00174447175849408*x_88 - 0.00468114821563094*x_89 - 0.00383618536901191*x_9 - 0.00042390927517878*x_90 + 0.00727412906672082*x_91 - 0.00155039896296576*x_92 - 0.00160490238652868*x_93 - 0.000672716187686207*x_94 + 0.000401571860359083*x_95 - 0.00021020849173792*x_96 - 0.00082362292009106*x_97 + 0.0126049214871487*x_98 + 0.00260111887431068*x_99 + 0.826118169608378*std::sin(0.213839992880821*x_1 + 7.78743982315063) + 0.00284336901219784*std::sin(0.515839874744415*x_2 + 2.30847978591919) + 0.00829952097546371*std::sin(1.74439990520477*x_51 - 9.60255908966064)) - 1.42423206950363e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 6.19207424319024e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 2.83446247668218e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) + 8.22889820936633e-7*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 3.47835120544303e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) - 1.13590870927019e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 7.18420352492983e-7*std::sin(1.23471987247467*x_29 + 9.79176044464111) - 2.00593826325089e-6*std::sin(1.61495983600616*x_29 - 5.39687967300415) + 1.03536656791938e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 3.52838181312673e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 4.92167080498384e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 0.000114226355753481*std::sin(0.326879858970642*x_35 - 7.79839992523193) - 2.67699315679498e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 1.91354516849988e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) - 8.1401221214868e-8*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 4.39282844645296e-7*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 1.49698274931496e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 1.83966922336673e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 1.95816469909941e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) + 2.11692947361814e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) - 2.62165902856171e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 2.45910391798665e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) + 8.01119676085781e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 2.58227736077658e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) + 1.68790936117682e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 1.38255718720491e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 3.96870848177834e-8*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 1.01994788830612e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 3.99668235365861e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) - 6.60835320553867e-8*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 7.77453064577052e-7*std::sin(1.04919981956482*x_89 - 1.59895980358124) + 3.41826058741472e-5*std::sin(0.238479986786842*x_91 - 8.02320003509521) + 2.05685386254147e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) - 9.80910123506758e-6*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 1.12340505169017e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) - 1.23231412318021e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0758097203962367);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.85692776852922e-6*x_1 - 2.46455028690822e-6*x_10 + 9.63241729319893e-7*x_100 - 2.16999145862482e-6*x_101 + 1.88964133315031e-7*x_102 - 9.17572072648255e-7*x_103 + 2.52855186172222e-7*x_104 + 6.76314768528486e-7*x_105 + 1.16654725634745e-6*x_106 - 7.47368834413246e-7*x_107 + 3.86779575053833e-7*x_108 - 5.92359640976988e-7*x_109 - 9.37012769435095e-7*x_11 - 2.18833835540814e-7*x_110 + 1.8873483859995e-6*x_111 - 8.26205980411152e-7*x_112 - 2.99977475521685e-6*x_113 - 7.40033818987197e-7*x_114 - 1.05992457389275e-6*x_115 + 4.26482335023215e-7*x_116 - 2.38024854709474e-6*x_117 + 3.95892280057073e-7*x_118 + 2.20538587179684e-7*x_119 - 4.87427895190493e-7*x_12 - 7.0257102780129e-7*x_120 - 1.09548130457688e-6*x_13 - 1.72210283460311e-6*x_14 + 8.32546857868286e-7*x_15 + 8.63356040300474e-7*x_16 + 3.17425470117836e-7*x_17 - 2.32210577942755e-7*x_18 - 1.36102228850693e-6*x_19 + 1.52577181109097e-6*x_2 - 1.0514409588716e-6*x_20 + 1.32277671399764e-6*x_21 - 3.60695529654897e-7*x_22 - 1.24223885626326e-6*x_23 + 2.32094674547015e-7*x_24 + 1.53988424399226e-6*x_25 + 8.7462196631216e-7*x_26 + 1.02895039540215e-7*x_27 + 3.82503216662521e-7*x_28 + 2.24824002411486e-7*x_29 + 6.50318448091216e-8*x_3 - 1.87599302348465e-6*x_30 + 7.79854890252676e-8*x_31 - 3.14807517405431e-6*x_32 + 8.28401819311606e-6*x_33 - 5.55059203774908e-6*x_34 - 3.13644984292488e-6*x_35 - 3.45722994702957e-6*x_36 + 3.58803041339942e-7*x_37 - 4.34840640415349e-6*x_38 - 4.89036434107234e-6*x_39 + 1.00254833265211e-6*x_4 + 8.6604512940646e-7*x_40 + 1.5750971582428e-6*x_41 + 1.05698782046949e-6*x_42 + 8.07413673362428e-7*x_43 - 3.29456961688048e-7*x_44 + 2.22735721225166e-6*x_45 - 6.85523995132431e-7*x_46 + 2.93149339933263e-8*x_47 + 3.31850104769967e-7*x_48 + 4.24627733198884e-7*x_49 + 1.91990584545279e-6*x_5 - 1.18998686802631e-6*x_50 - 9.85412703303768e-8*x_51 - 1.66523798984947e-6*x_52 - 3.53954287916887e-6*x_53 + 4.41403933712784e-7*x_54 - 1.09385797848525e-6*x_55 - 1.08402704402906e-6*x_56 + 8.0875386022768e-7*x_57 + 2.36220815498173e-7*x_58 - 2.62341788788515e-7*x_59 + 2.8352464617654e-7*x_6 - 2.11017709790359e-7*x_60 + 4.71663164918618e-7*x_61 + 3.2159234629995e-6*x_62 - 3.59505898991453e-7*x_63 - 9.72123141501804e-7*x_64 - 3.33986170758285e-6*x_65 - 2.06458657774099e-6*x_66 + 1.36242364044341e-6*x_67 - 5.3382809063945e-7*x_68 + 1.36069197658308e-6*x_69 + 8.29844455440612e-7*x_7 - 4.23704640951069e-7*x_70 - 8.0054519415874e-7*x_71 - 7.55509775335328e-7*x_72 - 2.70210329666188e-7*x_73 - 1.7728628361746e-6*x_74 - 5.40314364332193e-7*x_75 - 1.13071891508643e-6*x_76 + 1.88890887675091e-6*x_77 - 5.93829202331367e-7*x_78 + 6.73940258723083e-7*x_79 + 9.5986519085259e-7*x_8 - 6.85532495909327e-7*x_80 - 8.06421546836429e-7*x_81 + 1.23498829553382e-6*x_82 - 2.33353203384861e-6*x_83 - 4.84497006103979e-7*x_84 + 4.40744723246243e-7*x_85 + 3.00204255810492e-7*x_86 - 4.90860601835678e-7*x_87 + 1.19052362496085e-7*x_88 - 1.35077459320088e-6*x_89 + 2.06054838770547e-6*x_9 - 3.90375874753917e-7*x_90 + 1.41806888384513e-5*x_91 - 2.78628628658515e-6*x_92 - 4.23057734634546e-6*x_93 + 2.07543639651403e-6*x_94 - 1.32808470550479e-6*x_95 - 1.13771799124583e-6*x_96 + 2.48534012963257e-7*x_97 - 5.27282727493932e-7*x_98 - 3.70401664055829e-7*x_99 + 3.66792122585152e-8*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 7.37574666423652e-9*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) + 3.16344687944389e-8*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) - 7.52478020392668e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 1.58144507960547e-11*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 9.41581290199293e-10*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) + 6.29107422196839e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) + 5.02113554947772e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) - 4.90058132226508e-10*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) + 2.03549898565141e-10*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) + 9.4322627214049e-5*std::exp(0.00312026177943648*x_1 + 0.000382319335735811*x_10 + 0.00103688143401329*x_100 + 0.000566942635546213*x_101 + 0.000452260780440753*x_103 + 0.00048277482767583*x_104 + 0.00154946706569755*x_105 + 0.0017726517355722*x_106 - 0.00123528765083111*x_107 + 0.0011720745959233*x_108 - 0.0038194944453516*x_109 - 0.000767753806950251*x_11 + 7.59488130717409e-5*x_110 - 0.000647997131022664*x_111 + 0.00777274954129131*x_112 + 0.000375376947943519*x_113 - 0.00166223896651728*x_114 - 3.89351100527795e-5*x_115 - 0.0070449688485799*x_116 + 0.000456779532881512*x_117 + 0.00462844370569744*x_118 - 0.000465848177124622*x_119 + 0.00600093162544706*x_12 + 0.00118779392416019*x_120 + 0.00285995856719237*x_13 + 0.0013047337488825*x_14 - 0.000599627153862727*x_15 - 0.000212657867562142*x_16 - 0.00068384863312062*x_17 + 9.10966465340928e-5*x_18 - 0.0023513753865075*x_19 - 0.00451215333945613*x_2 + 0.00102996408541467*x_20 + 8.39365591825181e-5*x_21 - 0.000128704062112715*x_22 + 0.00220205689558879*x_23 - 0.00145908377422013*x_24 + 0.000851817972341296*x_25 + 0.00202105282486765*x_26 - 0.000776321568500456*x_27 + 0.000622710903770886*x_28 + 7.50111689859374e-5*x_29 - 0.000527772057212511*x_3 + 0.00575177128677675*x_30 + 0.000350410358837007*x_31 + 0.03303096731417*x_32 - 0.00106604481321653*x_33 + 0.00511369077056142*x_34 - 0.00221332406459882*x_35 + 0.000498444782925438*x_36 + 0.000352648432044027*x_37 + 0.000848318222297809*x_38 - 0.000498766863606328*x_39 + 0.00205378330284286*x_4 + 0.000502948995574932*x_40 - 0.00319788700703438*x_41 + 0.000581734810447377*x_42 - 0.00502755323171904*x_43 + 0.0032051870191422*x_44 - 0.00127806970469131*x_45 + 0.000562827156273088*x_46 - 0.000761127079271916*x_47 + 0.00302531853124666*x_48 - 0.000909582731780419*x_49 - 0.000370095063701022*x_5 + 0.000635264538692475*x_50 + 0.000257930489959719*x_51 + 0.00228312313036845*x_52 + 0.000101696438103161*x_53 + 0.000392672864882678*x_54 + 0.00163217195491789*x_55 - 0.00239088257725781*x_56 + 0.00432126579624428*x_57 + 0.00420176484325935*x_58 - 0.00198542344837937*x_59 + 0.000306663670727664*x_6 + 0.0027443487052952*x_60 + 0.00586571301885467*x_61 + 0.000453030129502868*x_62 + 0.00289457701490159*x_63 + 7.40138741788761e-5*x_64 - 0.00066184929456368*x_65 - 0.000615837271793837*x_66 - 0.0162776098591673*x_67 + 0.00615002648144704*x_68 + 0.000373558001174597*x_69 + 0.00222706843214707*x_7 - 0.000568247218312195*x_70 - 0.000364198229867683*x_71 - 0.000223652309666619*x_73 - 0.000682897640433145*x_74 + 0.000706599442154106*x_75 + 0.000560490562983082*x_76 + 0.00285865188107117*x_77 - 2.97475510238579e-5*x_78 + 6.6755196620015e-5*x_79 - 0.000437847467034408*x_8 + 0.000684519624106556*x_80 + 9.01662560755164e-5*x_81 - 0.00276556985302788*x_82 - 0.00137387017264985*x_83 + 4.1796512419021e-5*x_84 + 0.000428031520969147*x_85 - 0.000507509883035512*x_86 - 8.80434882187464e-5*x_87 + 0.00269311178981956*x_88 + 0.00225848646357337*x_89 - 0.00024431853218163*x_9 + 0.000546481171536428*x_90 + 0.000624329220055635*x_91 + 0.000318236898763601*x_92 - 0.00202167694987873*x_93 + 0.00826182548378606*x_95 - 0.000307284308639967*x_96 - 0.00298575332533675*x_97 + 0.000346642666664585*x_98 + 0.000176863028526519*x_99 + 3.98471428717821e-5*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 0.000170208019834127*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 0.0038645894416896*std::sin(1.63103985786438*x_72 + 0.196399986743927)) - 1.14029369345127e-5*std::sin(0.213839992880821*x_1 + 7.78743982315063) + 1.75528078808135e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) + 1.54104467858868e-6*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 9.85958544984312e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) + 1.83703145938127e-6*std::sin(0.903679847717285*x_115 + 6.89792013168335) + 1.73312651891123e-6*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 5.04404413122911e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 3.92471182942383e-8*std::sin(0.515839874744415*x_2 + 2.30847978591919) + 3.57960795529432e-6*std::sin(1.23471987247467*x_29 + 9.79176044464111) - 1.64343408237619e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) - 7.4403653592603e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) + 7.42093719536188e-6*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 1.71198716712373e-5*std::sin(0.523439884185791*x_31 - 1.49191975593567) + 2.40242314181546e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 3.29923385279839e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 6.65620457358923e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 5.84966566716252e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 3.72064341746642e-7*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 2.00552802872689e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 3.2477283046122e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 6.81141215820083e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) - 1.14558567710406e-7*std::sin(1.74439990520477*x_51 - 9.60255908966064) + 4.72586480156183e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) - 5.8526305572197e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) + 5.17201842055631e-8*std::sin(1.6166398525238*x_66 - 6.19975996017456) + 4.41961836936477e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) - 1.68492502145989e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 8.41019294082892e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 1.85223055611437e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 7.00630673455396e-8*std::sin(1.62847983837128*x_78 - 6.5827202796936) + 1.48118123437754e-7*std::sin(1.61631989479065*x_80 - 0.393119841814041) + 2.53838246116071e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 5.35440938504369e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) + 8.14439982844967e-8*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 2.70434517531958e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) + 2.89520269429572e-5*std::sin(0.238479986786842*x_91 - 8.02320003509521) + 4.5917511150372e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) - 3.41206393130724e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) + 2.79586017352859e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 8.85567256847261e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0615277080534951);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.00935572774569e-6*x_1 - 1.0256103525067e-7*x_10 + 1.64953676228859e-6*x_100 - 9.97986977620257e-7*x_101 + 2.74048518867675e-7*x_102 + 4.7380629775661e-7*x_103 + 1.0617717556333e-6*x_104 - 1.19534299361524e-6*x_105 - 9.07599123484776e-7*x_106 + 1.83644460002935e-7*x_107 - 3.59845695956301e-7*x_108 - 9.21052873366105e-7*x_109 + 9.08235770332315e-6*x_11 + 5.16899671557971e-7*x_110 + 3.9721157485618e-7*x_111 + 9.1240913816652e-6*x_112 + 1.10918770468091e-6*x_113 + 4.57828817635777e-7*x_114 - 1.09309780421691e-6*x_115 - 8.70330189173324e-7*x_116 + 1.62087902967136e-7*x_117 + 2.63335928171915e-6*x_118 - 2.68270383009713e-6*x_119 + 7.60297760962325e-6*x_12 + 2.55440369604467e-7*x_120 - 2.33732003345256e-6*x_13 + 9.93650568473614e-7*x_14 + 6.71114209390882e-7*x_15 - 4.45282166425686e-7*x_16 + 4.27650253752294e-7*x_17 + 3.05286036229069e-7*x_18 + 1.37415803992078e-6*x_19 + 3.79063726809457e-7*x_2 - 1.50081713024434e-7*x_20 + 6.82690687520326e-7*x_21 + 4.03396331969559e-9*x_22 - 2.99082337438918e-6*x_23 - 4.74838446633308e-7*x_24 + 2.40061855433874e-6*x_25 + 3.06064643442007e-7*x_26 + 2.0058523329558e-7*x_27 - 1.46791123457259e-6*x_28 + 1.70799278399707e-6*x_29 - 1.46839612869018e-7*x_3 - 1.9675697783019e-6*x_30 + 6.31589344504883e-6*x_31 + 1.85232899355305e-5*x_32 - 7.6188558300578e-7*x_33 + 1.69043173949639e-6*x_34 - 1.27948062063196e-6*x_35 + 6.26314084705273e-6*x_36 - 3.12678276375682e-6*x_37 + 1.70574951749684e-6*x_38 - 1.4769161724475e-6*x_39 + 1.10256102794944e-6*x_4 - 3.43619586384643e-6*x_40 - 1.41855009980093e-6*x_41 - 1.04196414277392e-6*x_42 - 1.8223374040955e-6*x_43 + 3.01523364475129e-6*x_44 + 4.70166897249138e-6*x_45 - 2.26356364929397e-7*x_46 - 1.38362227385015e-6*x_47 + 6.4207804429504e-6*x_48 + 7.92630625814433e-7*x_49 + 1.73261759101092e-6*x_5 - 1.16445244281022e-6*x_50 - 6.77551766589472e-7*x_51 - 2.28807672462833e-6*x_52 - 8.28701017201917e-7*x_53 - 6.91498759601947e-8*x_54 - 1.65534881341078e-6*x_55 - 4.9682409597294e-7*x_56 - 2.45788559797436e-6*x_57 + 2.98220835365259e-6*x_58 + 1.57084632681864e-6*x_59 - 8.67067793907431e-7*x_6 + 1.80250150561943e-6*x_60 - 1.80939751500669e-6*x_61 - 1.13547295016125e-6*x_62 - 4.59812742146806e-7*x_63 + 6.81970561242018e-7*x_64 - 4.1857685266658e-6*x_65 + 1.4569020298996e-6*x_66 + 2.06412096421989e-6*x_67 + 3.23725781507874e-6*x_68 - 7.26296470185451e-7*x_69 + 1.64819019660366e-6*x_7 - 9.58266279427288e-7*x_70 + 3.08906886756068e-7*x_71 - 5.41130599662827e-7*x_72 - 7.7948214512995e-7*x_73 + 2.01185915722449e-6*x_74 + 1.60863016247649e-6*x_75 - 1.82158447799291e-6*x_76 - 8.94618769268214e-7*x_77 + 3.64008341991138e-6*x_78 - 4.2030746492498e-6*x_79 - 3.64089430688065e-6*x_8 + 1.13898249021516e-6*x_80 - 4.62167419243295e-7*x_81 - 7.92130053090937e-7*x_82 + 3.62804049542893e-7*x_83 - 2.88300856398794e-7*x_84 + 7.63168854369009e-7*x_85 + 2.56472086977848e-6*x_86 + 1.41857061378259e-6*x_87 - 2.72381624327461e-7*x_88 - 2.12388898439313e-7*x_89 - 8.55403392741611e-7*x_9 - 4.19463878694005e-7*x_90 - 1.74841746515429e-5*x_91 + 1.81835924189443e-6*x_92 + 7.30761702621222e-6*x_93 + 1.67329603797557e-6*x_94 + 2.13093486479246e-6*x_95 - 4.72649032929398e-7*x_96 - 1.33147721417128e-7*x_97 - 2.33535998658725e-6*x_98 + 9.11023747140922e-6*x_99 - 4.24408400730214e-9*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) - 3.62434595684185e-9*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 3.66036604449725e-9*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 2.61186523265953e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 1.11566445492733e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 6.99930239249513e-12*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) - 5.51243529321342e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) + 1.02097169405297e-11*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) + 8.1412396016859e-10*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 2.68269153382473e-5*std::exp(-0.00496484196328899*x_1 + 0.00399776197659458*x_10 - 0.0092378168896776*x_100 + 0.000990533938769211*x_101 - 0.00130750903552934*x_102 + 6.0478854734598e-6*x_103 + 0.00194007929915082*x_104 + 0.00166167282853915*x_105 - 0.000601860377873337*x_106 + 0.00100344870321212*x_107 + 0.00405881116210591*x_108 + 0.0102206031167499*x_109 + 0.00201941873287839*x_11 - 0.00735087863124262*x_110 - 0.0155237217467096*x_111 + 0.000987122228964194*x_112 + 0.00138063731758631*x_113 - 0.000627749869730924*x_114 - 0.00297765870126256*x_116 - 0.00652826170166557*x_117 - 5.06295587376777e-5*x_118 + 0.00400023897412749*x_119 + 0.00675604384658943*x_12 - 0.00173101586797265*x_120 - 0.00100836747770886*x_13 - 0.001727317888425*x_14 + 0.00212649033805928*x_15 + 0.0018346082510339*x_16 - 0.00407343821308749*x_17 + 0.0010972996007699*x_18 + 0.0046643286051737*x_19 - 0.00124568024898264*x_2 - 0.00389646346731171*x_20 - 0.000154075014191701*x_21 - 0.00324519093636868*x_22 + 7.6468888806057e-8*x_23 - 0.000566209940752386*x_24 - 0.00629297268923943*x_25 + 0.0147853930751821*x_26 - 0.00215690458115706*x_27 - 0.000626621091423269*x_28 - 0.00339100015264086*x_29 + 0.00125492576008504*x_3 - 0.00368520132167102*x_30 + 0.000609099761854451*x_32 - 0.00104987102193605*x_33 - 0.0152275979362704*x_34 + 0.000204184101218217*x_35 + 0.000957879786595955*x_36 + 0.00159359112790485*x_37 - 0.000346944597374479*x_38 - 0.00622757810588011*x_39 - 0.00175390246001033*x_4 - 0.0115604737779254*x_40 - 0.00158429074233104*x_41 - 0.018884444621206*x_42 - 0.00287763871411782*x_43 + 0.00667697116751352*x_44 - 0.0056145667077874*x_45 - 0.0035110433116224*x_46 - 0.00688687906493559*x_47 - 0.00256552082486976*x_48 - 0.00407689565994834*x_49 + 0.00643689286991025*x_5 + 0.000604763444923916*x_50 + 0.00253094699436333*x_51 - 0.00340082301308128*x_52 - 0.000643343634874143*x_53 + 5.91722619989479e-5*x_54 + 0.00923156800406512*x_55 - 0.000908615132700836*x_56 + 0.000495931607260444*x_57 - 0.00154530270032492*x_58 + 0.00941733917517252*x_59 + 0.00115358001507778*x_60 - 0.00938189570368719*x_61 - 0.00463846522461949*x_62 - 0.00328100215749461*x_63 - 0.0027648311874754*x_64 - 0.00410700736927813*x_65 + 0.00257994400500267*x_67 + 0.00323361731031875*x_68 - 0.00334728407113898*x_69 - 0.00220240532983069*x_7 + 0.00678113455875967*x_70 - 0.00193564623652965*x_71 - 0.00402674773972233*x_72 + 0.000427895483097324*x_73 + 0.00208380925011357*x_74 + 0.00111219537127918*x_75 + 0.00104224673606203*x_76 + 0.00161545984850153*x_77 + 0.0028379495881822*x_78 - 0.0036022759987028*x_79 - 0.00831611231032209*x_8 - 0.00144084316441909*x_80 - 0.00220119342498193*x_81 - 0.00342448032861451*x_82 - 0.00101700594060765*x_83 + 0.00872376861477932*x_84 + 0.000301031923504632*x_85 + 0.00514326476750634*x_86 - 0.00101887738533971*x_88 - 0.000825460446333142*x_89 - 0.0047690278532164*x_9 + 0.00233492351220754*x_90 - 0.0018273265949318*x_91 + 0.00272427337632277*x_93 + 0.00129728768560465*x_94 + 0.00124874162834589*x_95 - 0.000528120033243905*x_96 + 0.00441023326059309*x_97 - 0.00189120947891617*x_98 - 0.0013118187982428*x_99 + 2.40638921628067e-5*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 6.50942974555688e-6*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 0.0587473995787491*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 0.0151130927254783*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 0.0187164364647074*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 0.0146842034818562*std::sin(0.3781598508358*x_92 + 1.99599981307983)) - 3.7681311061098e-5*std::exp(-0.00284136166759083*x_1 - 0.00496100632559314*x_10 + 0.00131451503339673*x_100 + 0.00169622429739984*x_101 - 0.00209695613009116*x_102 - 0.00541522342428538*x_103 - 0.016906023705015*x_104 + 0.00178317913613272*x_105 - 0.000306594483500406*x_106 - 0.00251248377831649*x_107 - 0.000156106992680694*x_108 + 0.000371303898728033*x_109 - 0.0026335005749666*x_11 - 0.000225829645814828*x_110 - 0.00157635555375299*x_111 + 0.000375311998290456*x_112 - 0.0126335390029159*x_113 - 0.00672993219550239*x_114 + 0.00381481182414945*x_115 - 0.00105592463530062*x_116 + 0.000100842555701279*x_117 - 0.00081823022898946*x_118 + 0.00436512250348224*x_119 + 0.00230174314615927*x_12 - 0.00419061422763892*x_120 - 0.000124958147453069*x_13 - 0.00420453816036359*x_14 - 0.000790525140584571*x_15 + 0.00020328235557815*x_16 - 0.00136455498228229*x_17 - 0.00123636776437068*x_18 + 0.000634845231992367*x_19 - 0.00135804204337789*x_2 + 0.000770136601453931*x_20 - 0.0014701062773026*x_21 - 0.00385213298688621*x_22 + 0.00349744501263359*x_23 + 0.000566887202539543*x_24 - 0.000232726715572444*x_25 - 0.00705829494927896*x_26 + 0.00211664007966717*x_27 - 0.00102076026824861*x_28 + 0.00120541016705765*x_29 + 0.0010947186879442*x_3 - 0.00360027802077666*x_30 - 0.00258164158618465*x_31 + 0.000576544166579958*x_32 - 0.00770313543316647*x_33 - 0.000749430973335013*x_34 - 0.00570486006322533*x_35 - 0.00143770593694856*x_36 - 0.000612688121729455*x_37 - 0.00136646540401614*x_38 - 0.00797944153796199*x_39 + 0.00558281087403987*x_4 + 0.00223565711920452*x_40 + 0.00379144045185421*x_41 - 0.00346705395658034*x_42 + 0.00216377458792118*x_43 + 0.00483143796894564*x_44 + 0.001023235083735*x_45 - 0.00798266067456017*x_46 + 0.00121907974735825*x_47 - 0.0011220015055693*x_48 - 0.00133439095288289*x_49 + 0.00248785079177866*x_5 + 0.00195196934606537*x_50 + 0.00282775137911542*x_51 - 0.00364721829347316*x_52 - 0.0138299851334066*x_53 + 0.00343203498873861*x_54 - 0.000326891927296172*x_55 + 0.000601035077489172*x_56 + 0.00905071998554452*x_57 - 0.00104163688544938*x_58 + 0.00411339226787037*x_59 + 0.000241903129023921*x_6 - 0.000367571311084895*x_60 + 0.000288720394144881*x_61 + 0.0058004223489135*x_62 + 0.00116822831033364*x_63 - 0.00251769669664361*x_64 + 0.0102654135862213*x_65 - 0.000262474430402969*x_66 - 0.00133602323997023*x_67 - 0.0017456878838923*x_68 + 0.00484138582105228*x_69 + 0.000154838686962648*x_7 + 1.40706299306604e-6*x_71 - 0.00860017388651889*x_72 - 0.00144371329904583*x_73 + 0.000947642666557208*x_74 - 0.0021198783544009*x_75 - 0.00050992662620675*x_76 + 0.00271111752796312*x_77 + 0.00108070186608322*x_78 - 0.000419304251060644*x_79 + 0.00342111904264007*x_8 - 0.00364255629722375*x_81 - 0.013880464127066*x_83 - 0.000464759957984278*x_84 + 0.000432815786595045*x_85 + 0.000287256028962431*x_86 - 0.000591487159971313*x_87 + 0.000419174013342766*x_88 + 0.000357549824371275*x_89 - 0.00225225690441573*x_9 - 0.000919947851164058*x_90 + 0.0113649298497962*x_91 - 0.000629729475157111*x_92 + 0.000583850222810281*x_93 + 0.00102883042086261*x_94 - 0.00033591987258722*x_95 + 7.26082411002229e-5*x_96 + 0.00124687244219789*x_97 - 0.000211223336225238*x_98 - 0.000186842988723764*x_99 + 3.23690819428807e-6*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 0.0284913617138078*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 0.000954853265270061*std::sin(1.61631989479065*x_80 - 0.393119841814041)) + 2.26541931028563e-5*std::exp(0.00423618992980282*x_1 + 0.00219758857526764*x_10 + 0.000472073097147759*x_100 + 1.31818738051862e-5*x_101 + 0.00265240282843553*x_102 + 0.00201650286369295*x_103 + 0.00208102885666694*x_104 + 0.00343991601126067*x_105 + 0.00412008455730535*x_106 + 0.00224003468590777*x_107 - 0.00413668851043442*x_108 - 0.00652848194971947*x_109 + 0.00107471481368412*x_11 - 0.0032984911882417*x_110 + 0.0081140128287657*x_111 - 0.000876514834118263*x_112 + 0.00103080361468793*x_113 + 0.00305868787751255*x_114 + 0.000152428048245253*x_115 - 0.00558447116416115*x_116 - 0.000799223006107742*x_117 + 0.00776229495043957*x_118 + 0.000235697109152448*x_119 + 0.00441570201833906*x_12 + 8.48221844206395e-5*x_120 - 0.0024728928824569*x_13 - 0.000657666111754211*x_14 - 0.0109563660617372*x_15 - 0.00124722512406864*x_16 - 0.00630288115833639*x_17 - 0.00318258799412605*x_18 - 0.000358967436859491*x_19 + 0.000755020583621903*x_2 - 0.00218302262767188*x_20 - 0.00191978027201616*x_21 - 0.00633034215502745*x_22 - 0.000642691212173168*x_23 - 0.00803883996621204*x_24 - 0.00204130269931808*x_25 - 0.00224415260581622*x_26 - 0.00743877959623886*x_27 - 0.000914531185454478*x_28 - 0.000511265318017919*x_3 + 0.000186903302844484*x_30 - 0.00736781369944003*x_31 - 0.0274288091191139*x_32 + 0.00639805765326396*x_33 - 6.77945804181008e-5*x_34 - 0.00051190888720589*x_35 - 0.0180153733434481*x_36 - 5.61371082086583e-5*x_37 - 0.00247730391357511*x_38 - 0.0201123486842079*x_39 + 0.00135493194231592*x_4 + 0.000457467597343614*x_40 - 0.000351407177192882*x_41 + 0.00459836785617518*x_42 - 0.00551184811953639*x_43 - 0.00585188584413741*x_44 + 0.00377813478843744*x_45 - 0.000961297568612624*x_46 - 0.00488564190971324*x_47 + 0.00202865578457037*x_48 + 0.00191273419764447*x_49 - 0.00274851621168791*x_5 - 0.00510743053358371*x_50 - 0.00190930528346415*x_51 + 0.0020247574121982*x_52 - 0.00696573741710067*x_53 - 0.00071999217726207*x_54 - 0.0006233618422293*x_55 - 0.00475658815557799*x_56 - 0.00146793464246366*x_57 - 0.0167687950808592*x_58 - 0.00167984284271926*x_59 + 0.00182894739029606*x_6 + 0.000904910365930739*x_60 + 0.011069558095714*x_61 + 0.00376380168819155*x_62 - 0.000905842117150133*x_63 - 0.00446002812868068*x_64 - 0.000862715478951257*x_65 - 0.0126846064265241*x_66 + 0.00132624998067962*x_67 - 0.00134626368455702*x_68 - 0.00475348480740406*x_69 - 0.00435130880460821*x_7 - 6.84488442606434e-5*x_70 - 0.000312518652521352*x_71 + 0.00213422538588693*x_72 + 0.00319527651843379*x_73 + 0.00974109902004428*x_74 + 0.00221137520741454*x_75 - 0.00011667722117069*x_76 + 0.00218214416096031*x_77 - 0.00525861385619542*x_78 - 0.00593206830440135*x_79 - 0.00117565878841232*x_8 - 0.0207353324926911*x_80 - 0.00244771825950611*x_81 - 0.00128412842769238*x_82 + 0.00150016483342477*x_83 - 1.99753227205526e-5*x_84 - 0.000769593857102168*x_85 - 0.000503506280557404*x_86 + 0.000607460058811954*x_87 - 0.0016095590747627*x_88 + 0.0023998371277173*x_89 + 0.0079497362023461*x_9 - 0.00546855000384705*x_90 + 0.0118338155547829*x_91 + 0.00307464591952215*x_92 + 7.24303897928027e-5*x_93 + 0.00320190611221066*x_94 + 0.0029598519613441*x_95 - 0.00411175805820452*x_96 + 0.00200123980664465*x_97 - 0.00129384341940815*x_98 + 0.000189463600330337*x_99 - 0.0124308911962518*std::sin(1.61495983600616*x_29 - 5.39687967300415)) - 2.73295613119436e-6*std::sin(0.213839992880821*x_1 + 7.78743982315063) - 8.62522144131064e-7*std::sin(0.68207985162735*x_1 - 5.39999961853027) + 1.95311942930438e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 4.70491432331578e-8*std::sin(1.5123997926712*x_105 + 4.22128009796143) - 2.00536873303073e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 8.18592516927515e-8*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 9.40640583999974e-9*std::sin(0.515839874744415*x_2 + 2.30847978591919) - 4.14189835059754e-7*std::sin(1.23471987247467*x_29 + 9.79176044464111) - 3.2930240658816e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 1.23282573644915e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 8.16946410668961e-7*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 3.99109843015819e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) - 1.62120059424565e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 3.17628691353329e-7*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 2.58899783669261e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) + 4.41556086925267e-6*std::sin(1.68839979171753*x_46 + 1.82767987251282) + 2.84085522352197e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) + 1.90136447224043e-6*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 3.2503507158748e-8*std::sin(1.76543986797333*x_49 - 7.3996000289917) - 2.74563949448325e-8*std::sin(1.74439990520477*x_51 - 9.60255908966064) - 8.5921727275041e-8*std::sin(1.6166398525238*x_66 - 6.19975996017456) + 2.79913288006421e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 2.53312686275435e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) + 9.73127915259712e-8*std::sin(1.44383978843689*x_75 + 7.18752002716064) + 2.62370746014693e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) + 4.10180330903341e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) + 3.21714494899582e-8*std::sin(1.33839976787567*x_87 + 4.78111982345581) - 7.58458702770284e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) - 4.0020521220275e-8*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 1.29049161501547e-7*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 0.000343594972457542*std::sin(0.238479986786842*x_91 - 8.02320003509521) - 1.62820927351789e-6*std::sin(0.456079840660095*x_92 - 1.59135985374451) + 3.54347210201458e-6*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 3.91942350670358e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0810520953884567);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.20483352539963e-6*x_1 + 2.45998995452341e-6*x_10 - 1.73079431440442e-6*x_100 - 2.05466691899331e-7*x_101 - 1.58411610799382e-7*x_102 - 3.726585920723e-7*x_103 + 2.24715163537615e-6*x_104 - 4.3130567847714e-7*x_105 - 1.94662392327645e-6*x_106 + 4.38867378019968e-7*x_107 + 2.98050894972209e-8*x_108 + 5.26213972555226e-7*x_109 + 2.22663869040353e-6*x_11 - 4.19048895683895e-7*x_110 + 8.67514339261818e-7*x_111 + 4.15736162061225e-6*x_112 + 1.66817916138407e-6*x_113 + 1.75482121312877e-6*x_114 - 5.13155619869701e-7*x_115 + 1.23358019820056e-6*x_116 + 1.88976404094665e-6*x_117 - 7.46182771292305e-7*x_118 - 1.48135073548376e-6*x_119 + 1.58903385649466e-6*x_12 + 1.45607690574446e-6*x_120 - 4.70091783778723e-7*x_13 + 9.83359426768287e-7*x_14 + 7.95563858436632e-7*x_15 + 1.3272919984915e-6*x_16 + 6.83134357281102e-7*x_17 - 7.05419174745443e-8*x_18 + 5.04734884919039e-7*x_19 - 2.26506131656835e-6*x_2 + 4.95454355065614e-7*x_20 - 3.4627028852135e-7*x_21 - 1.28176619877078e-6*x_22 - 1.57449270998554e-6*x_23 - 3.37712541445785e-7*x_24 + 8.02605799059172e-7*x_25 - 7.82000106195981e-7*x_26 + 8.88692319328861e-7*x_27 - 5.33161138771021e-7*x_28 + 1.15203338996644e-6*x_29 + 1.49099044183692e-6*x_3 - 1.23940746651699e-6*x_30 + 2.06958240688678e-6*x_31 + 8.39486375593636e-6*x_32 + 5.52178561759885e-6*x_33 + 1.06248097542792e-6*x_34 + 3.7643767673125e-7*x_35 + 1.07891873242427e-5*x_36 - 2.64620147510449e-6*x_37 + 3.13466001334933e-6*x_38 + 4.20991850705242e-6*x_39 - 6.2788391408093e-7*x_4 + 1.44627936207782e-7*x_40 - 4.10086701159076e-6*x_41 - 1.350856713149e-6*x_42 - 1.00158172113642e-6*x_43 + 5.153891157911e-6*x_44 + 9.9775763589533e-7*x_45 + 4.31895191522754e-7*x_46 - 4.68415627052462e-7*x_47 - 3.21909638074955e-7*x_48 - 1.25716333190594e-6*x_49 - 1.47153547098924e-6*x_5 - 2.18350488549863e-7*x_50 + 3.57206377617536e-7*x_51 + 1.18634709465622e-6*x_52 + 1.30844751258395e-6*x_53 - 2.6039245807297e-6*x_54 + 1.00425583814519e-6*x_55 + 4.53394390965904e-7*x_56 - 3.92473693985258e-6*x_57 + 2.33367745284263e-7*x_58 + 2.81408281049856e-9*x_59 - 6.61380971202406e-7*x_6 + 1.35374010083324e-6*x_60 - 5.57429144305235e-7*x_61 - 2.30003515787337e-6*x_62 - 9.81343307698987e-7*x_63 + 5.26886755193875e-7*x_64 + 6.45200951473677e-7*x_65 + 2.59952104825294e-6*x_66 - 1.59878120644811e-8*x_67 + 2.08272163593755e-6*x_68 + 1.24360983903317e-6*x_69 + 1.09827958783827e-6*x_7 + 3.67346363857051e-7*x_70 - 2.06193350929078e-7*x_71 + 7.33170334823327e-7*x_72 + 2.59892770234573e-7*x_73 + 3.76231365537073e-7*x_74 + 1.37144566195888e-6*x_75 + 2.32424776174305e-7*x_76 - 3.88817182204178e-6*x_77 + 1.17747072936025e-6*x_78 - 2.16394728690879e-6*x_79 + 7.330669412485e-7*x_8 + 2.26556892388633e-6*x_80 - 2.58117295314266e-7*x_81 - 8.31600067881111e-8*x_82 + 9.42822873841268e-7*x_83 + 5.75368272676125e-7*x_84 - 6.85505606546652e-8*x_85 - 2.08041300419499e-7*x_86 + 1.21256195978676e-6*x_87 - 3.83868183004265e-8*x_88 - 1.16105407629723e-6*x_89 - 1.84643421732028e-6*x_9 + 5.63500993500721e-7*x_90 - 2.47856790205453e-5*x_91 + 1.49972879431258e-7*x_92 + 1.15489906431145e-5*x_93 - 5.12652021762889e-7*x_94 + 2.7610013819747e-6*x_95 - 2.43053272013845e-7*x_96 - 1.21895262206621e-6*x_97 - 1.698016517546e-6*x_98 - 1.10686455706403e-7*x_99 - 1.87330597144472e-8*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 1.12436115735428e-10*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 1.61565736140766e-8*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 2.4183991876899e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) + 2.84881306481886e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 1.03302497303177e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 7.34501018176959e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) - 6.27761991226613e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) - 3.66835457493236e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 2.20924806140057e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 7.70621326683174e-11*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 5.24205260159501e-5*std::exp(0.00309289534976288*x_1 - 0.0042263955855194*x_10 - 0.000676748805417032*x_100 - 0.00678423778445279*x_101 - 0.000671142805315714*x_102 + 0.00131859847896862*x_103 - 0.00157463337347218*x_104 - 0.00222016184190676*x_105 + 0.000599606501800863*x_106 + 0.00164159977567722*x_107 - 0.000820488308342378*x_108 + 3.26750034182575e-5*x_109 - 0.0010919414481356*x_11 - 0.00281785594316492*x_110 + 0.00256705900692405*x_112 + 0.00118294784115428*x_113 + 0.000750243532123298*x_114 + 0.0047761311913576*x_115 - 0.00639687333287975*x_116 - 0.00623084587547106*x_117 - 0.000857121912853812*x_118 + 0.00635881982424394*x_119 - 0.000403952837536723*x_12 + 0.000824160702802643*x_120 - 0.000528749406820753*x_13 + 0.000641435593324669*x_14 - 0.00187117379521132*x_15 + 0.00573238454642041*x_16 - 0.00183592552222402*x_17 + 0.000765501971710858*x_18 + 0.00188607868661012*x_19 + 0.00152694119034851*x_2 - 0.00014905380286091*x_20 - 0.00601616463490726*x_21 - 0.00239115873972308*x_22 + 0.010969315910564*x_23 + 0.00166570868704047*x_24 - 0.000671204758441812*x_25 + 0.000706668029122303*x_26 + 0.00342841517757077*x_27 - 0.00361217375343783*x_28 - 0.00177898959820668*x_3 + 0.00777395043477424*x_30 + 0.00549848872856345*x_31 - 0.00135731374504826*x_32 + 0.00831294124385034*x_33 + 0.00795678292626023*x_34 - 0.000332476970255436*x_35 - 0.000680517993182297*x_36 + 0.0015457552279929*x_37 + 0.00193468651986333*x_38 + 0.00193344600118405*x_39 - 0.000547350540882386*x_4 - 0.00138199964668637*x_40 + 0.001586125642155*x_41 - 0.000295930727716127*x_42 + 0.000158510715318591*x_43 - 0.000638153424454*x_44 - 0.00461462714175735*x_45 + 0.00105438609221181*x_47 - 0.00108953017919637*x_48 - 0.0022638143281704*x_49 - 0.000595492266640781*x_5 + 0.00996215174849247*x_50 - 0.00227619226851681*x_51 + 0.0135181250223056*x_52 + 0.00711747751412513*x_53 - 0.0106146185863878*x_54 - 0.012757643037572*x_55 + 0.00398750405424932*x_56 + 0.0124884679522181*x_57 + 0.00144247376695871*x_58 + 0.00464520927965284*x_59 - 9.24633710104088e-5*x_6 + 0.00190917502433285*x_60 + 0.000165932912175695*x_61 - 0.00288195204406442*x_62 + 0.00620337214472366*x_63 + 0.000506368024695943*x_64 + 0.00221354728164619*x_65 - 0.0038294106034528*x_66 - 0.00219269699584163*x_67 - 0.000321343772073171*x_68 + 0.000700407794991332*x_69 - 0.00763853423098557*x_7 + 6.97761379421924e-5*x_70 + 0.000860763306960516*x_71 - 0.00579429350244435*x_72 + 0.000532808126821298*x_73 + 0.00119650741348727*x_74 - 0.0010973124419983*x_75 + 0.003405161440799*x_76 - 0.0053272588890997*x_77 - 0.000947212925800291*x_78 - 0.00210829591701023*x_79 - 0.00248370987816544*x_8 - 0.000189078086069486*x_80 + 0.000304138286636162*x_81 - 0.00026070736195719*x_82 + 0.00116605496698225*x_83 - 0.000898284568195691*x_84 - 0.00316430668093471*x_85 - 0.00363401594183159*x_86 - 0.00239599057507157*x_87 + 0.00340312728802681*x_88 + 0.00784706594451809*x_89 - 0.000620503129761653*x_9 + 0.00271017255750756*x_90 - 0.00617018225107348*x_91 + 0.00436614440606087*x_92 - 0.00516517206653462*x_93 - 0.000870457878755704*x_94 - 0.00845777262448453*x_95 + 0.00264002323768096*x_97 + 0.00273943704136068*x_98 + 0.0044825280730222*x_99 + 1.53874666816207e-7*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 0.00723947834427896*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 0.00569172693461728*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 0.00861657280091638*std::sin(1.0402398109436*x_96 + 0.18376000225544)) - 8.32918950763176e-6*std::sin(0.213839992880821*x_1 + 7.78743982315063) + 2.67575559222813e-8*std::sin(0.68207985162735*x_1 - 5.39999961853027) + 6.19223010838233e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 3.83736816229648e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) - 6.95483333750753e-7*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 8.85154303277572e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) - 5.0332567633649e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 2.8667762329874e-8*std::sin(0.515839874744415*x_2 + 2.30847978591919) - 1.82820201012554e-6*std::sin(1.23471987247467*x_29 + 9.79176044464111) + 8.10239237781262e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) - 3.34545843329683e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 6.66308444995046e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 0.000108304470830952*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 5.02936253369651e-9*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 2.59060663781052e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 8.60546436186574e-7*std::sin(1.68839979171753*x_46 + 1.82767987251282) + 7.06510410409405e-8*std::sin(2.20567989349365*x_47 + 2.80191993713379) + 2.53346128616775e-6*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 2.65101370530492e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) - 8.36784440414528e-8*std::sin(1.74439990520477*x_51 - 9.60255908966064) - 1.78916925470214e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 2.21575247955615e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 2.3316155610414e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) - 3.22889655237464e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 7.5958689234547e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 2.34549312521867e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) + 4.29531161847663e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) + 6.52506547716471e-8*std::sin(1.9651198387146*x_75 + 6.40167999267578) + 5.46542235254138e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 1.08212532880097e-7*std::sin(1.61631989479065*x_80 - 0.393119841814041) + 1.01997356215422e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) - 1.88625933815974e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) + 1.24153488913513e-9*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 1.05253594366856e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 6.69630513076825e-5*std::sin(0.238479986786842*x_91 - 8.02320003509521) - 1.73839503778308e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) - 1.32798134001941e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) + 1.12343332973357e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 0.0834397259350776);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.57641500706889e-7*x_1 + 1.24302085009708e-6*x_10 + 2.80532993010269e-6*x_100 + 2.28870399191532e-7*x_101 - 1.96622906863579e-7*x_102 + 1.75190092124003e-6*x_103 - 1.16272807393302e-6*x_104 + 9.45754476468596e-7*x_105 - 1.78298238230125e-7*x_106 + 5.9213302389361e-7*x_107 - 5.45335775592167e-7*x_108 + 1.31290672673519e-7*x_109 - 2.15040172941968e-6*x_11 - 8.12228014121017e-7*x_110 - 1.52148401919906e-6*x_111 - 3.08354902305321e-6*x_112 + 1.50572361536219e-8*x_113 - 3.59146386914525e-7*x_114 - 2.11136392156544e-6*x_115 - 5.34153109683887e-7*x_116 + 9.10805118067403e-7*x_117 - 1.33260878554883e-6*x_118 + 1.16454836079336e-6*x_119 - 1.48699449215744e-6*x_12 - 5.17839871317438e-7*x_120 + 1.31088695075641e-6*x_13 - 2.91622466714379e-7*x_14 - 3.79349085248919e-7*x_15 - 9.80909485344871e-7*x_16 + 2.81109556660586e-8*x_17 - 2.36545716895374e-7*x_18 - 5.16075377373323e-7*x_19 + 4.17468133392887e-7*x_2 + 6.76594090636062e-7*x_20 + 4.15456210438572e-7*x_21 + 1.27555013288147e-6*x_22 - 1.66274958034463e-8*x_23 - 3.02710253718378e-8*x_24 - 1.13128936002062e-6*x_25 - 6.20575989953896e-7*x_26 - 6.21091757282016e-7*x_27 + 1.21757153514297e-6*x_28 - 3.29160282280749e-7*x_29 - 1.39333200032217e-7*x_3 - 2.37821564439637e-7*x_30 - 2.50110159218806e-6*x_31 - 5.91938268007209e-6*x_32 + 4.31780722886516e-6*x_33 - 2.69303631249908e-6*x_34 + 1.57647815427214e-7*x_35 - 7.6253982689649e-6*x_36 + 2.42233747962828e-6*x_37 + 3.53216837470909e-7*x_38 + 9.79282985082625e-7*x_39 - 5.5264856191236e-8*x_4 + 8.31571048972482e-7*x_40 - 4.50921651043465e-7*x_41 + 6.22610122479802e-7*x_42 + 2.77870846731488e-7*x_43 - 6.1288014312791e-7*x_44 - 1.34539077241724e-6*x_45 - 1.99399905738969e-7*x_46 + 1.90687651271159e-7*x_47 - 1.86208816101751e-6*x_48 + 1.11441926960479e-6*x_49 - 6.64819748800765e-7*x_5 - 5.81698789378459e-7*x_50 + 7.03843530185964e-7*x_51 - 6.84490989087523e-7*x_52 - 9.4800115018363e-7*x_53 + 1.33657740576838e-6*x_54 + 2.85052261045579e-6*x_55 + 9.26477363283647e-8*x_56 - 9.75002833731664e-7*x_57 - 1.13519075284699e-6*x_58 - 2.18068340440088e-6*x_59 + 9.73300222565187e-7*x_6 - 1.07712135439153e-6*x_60 - 4.13801179158574e-7*x_61 + 1.6903186927181e-6*x_62 - 7.63181604113753e-7*x_63 - 4.87053693039213e-7*x_64 + 1.47166260737448e-6*x_65 + 9.26607455014443e-8*x_66 - 2.92518008968973e-7*x_67 - 1.1088166720673e-6*x_68 + 2.6295906730273e-7*x_69 + 1.01142443962278e-7*x_7 + 2.90782167509746e-7*x_70 - 1.20472752304053e-6*x_71 + 1.08698634256744e-6*x_72 + 3.26736198823484e-7*x_73 + 3.88564070239024e-7*x_74 - 3.61035482451774e-7*x_75 - 3.58356274829979e-7*x_76 + 1.24999200290515e-6*x_77 - 7.61697283290596e-7*x_78 + 1.11565374424718e-6*x_79 + 1.36673794768788e-6*x_8 - 5.75657936684672e-7*x_80 + 4.03514571166446e-7*x_81 + 3.71764300229012e-7*x_82 - 3.81427309561019e-8*x_83 + 4.66906340478504e-7*x_84 + 7.93988185565808e-8*x_85 - 2.42984262558703e-7*x_86 - 2.08244321404981e-7*x_87 - 6.6267631656547e-7*x_88 - 1.37138373653893e-6*x_89 + 9.52966581453878e-8*x_9 - 4.29640725678527e-7*x_90 + 2.13926248661044e-5*x_91 - 3.40182459409731e-7*x_92 - 7.73784547943161e-6*x_93 - 1.60388866013356e-6*x_94 - 8.19614901599787e-8*x_95 + 5.1349146254989e-7*x_96 - 7.48814060793312e-8*x_97 + 6.04089057954952e-7*x_98 - 2.82996355284369e-6*x_99 + 1.07831368337603e-8*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) + 7.18784853132278e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 1.49423702742194e-11*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 1.64878857175359e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) - 2.14863492924674e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) - 1.54501803720624e-12*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) - 1.83290147289906e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 1.9443569111678e-10*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 8.84904625751465e-5*std::exp(-0.00300603810744172*x_1 - 0.000482055387429401*x_10 + 0.000237897156997331*x_100 - 0.0011746093805832*x_101 + 0.000673071816984887*x_102 + 0.000302462627624018*x_103 + 0.000128285466814508*x_104 + 0.00247442559212114*x_105 - 0.000100248667894816*x_106 - 3.77989993810524e-5*x_107 - 0.00117677866237068*x_108 - 0.000472601680146745*x_109 + 3.42559512870913e-5*x_11 + 0.000446340987075811*x_110 + 0.00195872850644219*x_111 + 0.000897329670010584*x_112 - 0.000621412015467696*x_113 + 0.00242246593885884*x_114 + 0.00150045797649399*x_115 - 0.00103463851915057*x_116 - 0.000868530995083127*x_117 - 0.000210342619487173*x_119 - 0.000486393933499528*x_12 - 0.000302897133807558*x_120 + 0.000264741143374993*x_13 - 0.00196267098281536*x_14 - 0.00174839703446611*x_15 - 0.000725896887320283*x_16 + 0.000297020876412704*x_17 + 0.000640193133205561*x_18 - 0.000241969650940551*x_19 + 0.000245200088122644*x_2 + 0.00105211218056302*x_20 - 0.000638211798617906*x_21 + 2.73152824161854e-5*x_22 - 0.00386927013787564*x_23 - 0.000306294978381704*x_24 + 0.00342676556933545*x_25 + 0.0015330830139319*x_26 + 0.000312861189836349*x_27 - 0.000339353822385782*x_28 - 0.000929398543733743*x_3 - 0.000138734112105638*x_30 + 0.000475760393695056*x_31 + 0.000247513024432181*x_32 + 0.00123713407313402*x_33 - 0.00262650954491813*x_34 - 0.00381837161883037*x_35 + 0.00176965317233038*x_36 + 0.00106851406833375*x_37 - 0.000168968847849842*x_38 + 0.000506430299341893*x_39 - 4.83071308207634e-5*x_4 + 0.000418947126235688*x_40 + 0.00211830491646549*x_41 - 0.000337758647989225*x_42 - 0.000203849987726741*x_43 + 0.000465831115951651*x_44 + 0.000221325056616223*x_45 + 0.00014629671523268*x_46 + 0.000724069723727803*x_47 - 0.000557329162500313*x_48 - 0.00149353714727329*x_49 - 0.000100696718459981*x_5 - 0.0010472405675644*x_51 + 0.000975361643515348*x_52 + 5.02904139031591e-5*x_53 + 0.000232081595736691*x_54 - 0.000193934925097203*x_55 - 0.00111964979553252*x_56 + 0.000519506454391252*x_57 + 0.00240292893504136*x_59 - 6.76386161869318e-5*x_6 + 0.000136290345584816*x_60 + 0.00117786004117308*x_61 + 0.00202332768820237*x_62 + 0.000264254554990973*x_63 - 0.000437120900543899*x_64 - 0.00782417981032664*x_65 - 0.0056606680977935*x_66 - 0.000514271319080164*x_67 + 0.0012380816650781*x_68 + 0.000112900396220718*x_69 - 0.00236400900867373*x_7 - 0.000554926935679416*x_70 + 0.00048843593689336*x_71 + 0.00016319141357243*x_72 - 0.00143733215989565*x_73 - 0.000352453775600815*x_74 + 0.00014059696019299*x_76 + 0.000915749069809429*x_77 - 0.00113984834861639*x_78 + 9.06688672341162e-5*x_79 + 0.00313052959093329*x_8 - 0.000593772936987515*x_80 + 0.000231874324312071*x_81 + 0.00107010004912599*x_82 - 0.000602041209402377*x_83 - 0.000440749453221457*x_84 + 0.000401354585889611*x_85 - 0.000182534953126857*x_86 + 0.000110784559638463*x_87 - 0.000450143278442343*x_88 + 0.0016877185711772*x_89 + 0.00012731384363586*x_9 + 0.000636847488022473*x_90 + 0.000300832994772669*x_91 - 0.00023534936742395*x_92 + 0.00311839111765086*x_93 + 0.00104566460868188*x_94 - 0.000914108773643106*x_95 + 0.000326027663431039*x_96 + 0.00171380641299425*x_97 - 0.00190271779087159*x_98 + 0.00246997355524161*x_99 + 0.000137093834790471*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 0.000118238380039971*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 0.00647780980082091*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 0.0133792999200479*std::sin(1.23471987247467*x_29 + 9.79176044464111) - 0.00314343065347134*std::sin(1.44383978843689*x_75 + 7.18752002716064)) - 0.000286389339974632*std::exp(-0.00161131206254677*x_1 - 0.000197430792978927*x_10 - 0.000535448523283245*x_100 - 0.000292770790402289*x_101 - 0.00023354875406403*x_103 - 0.000249306294893146*x_104 - 0.000800149202201976*x_105 - 0.000915402400864521*x_106 + 0.000637906058272682*x_107 - 0.00060526265682648*x_108 + 0.00197239780110273*x_109 + 0.000396470250784075*x_11 - 3.92201832054961e-5*x_110 + 0.000334627562531336*x_111 - 0.00401386998282544*x_112 - 0.000193845724166329*x_113 + 0.000858384932711731*x_114 + 2.01062016328514e-5*x_115 + 0.00363804196198985*x_116 - 0.00023588225068391*x_117 - 0.00239014150125438*x_118 + 0.000240565324378614*x_119 - 0.00309889816884132*x_12 - 0.000613380162662101*x_120 - 0.00147689074297263*x_13 - 0.000673768220936232*x_14 + 0.000309649168674589*x_15 + 0.000109817127991177*x_16 + 0.00035314138024098*x_17 - 4.70425675131824e-5*x_18 + 0.00121425694114017*x_19 + 0.00233008882518806*x_2 - 0.000531876384781515*x_20 - 4.33450780286416e-5*x_21 + 6.6463143941224e-5*x_22 - 0.00113714844749895*x_23 + 0.000753475013270123*x_24 - 0.000439881225021941*x_25 - 0.00104367743027689*x_26 + 0.000400894667230749*x_27 - 0.000321569682818933*x_28 - 3.87359811312382e-5*x_29 + 0.000272542992279073*x_3 - 0.00297023106089109*x_30 - 0.000180952906501769*x_31 - 0.017057285520615*x_32 + 0.000550508575296987*x_33 - 0.00264072446646698*x_34 + 0.00114296684563986*x_35 - 0.000257398304377626*x_36 - 0.000182108653874986*x_37 - 0.000438073944139891*x_38 + 0.000257564627757815*x_39 - 0.00106057954224773*x_4 - 0.00025972429260792*x_40 + 0.00165139795098432*x_41 - 0.000300409511616844*x_42 + 0.00259624279627843*x_43 - 0.00165516769801118*x_44 + 0.000659998832635325*x_45 - 0.00029064554519381*x_46 + 0.000393048189752631*x_47 - 0.00156228309899191*x_48 + 0.000469711111183346*x_49 + 0.000191118144112309*x_5 - 0.000328052415617596*x_50 - 0.000133196039034184*x_51 - 0.00117901128183758*x_52 - 5.25163300443521e-5*x_53 - 0.000202777384894458*x_54 - 0.000842858242357059*x_55 + 0.00123465856687325*x_56 - 0.00223151395464539*x_57 - 0.00216980332244798*x_58 + 0.00102527831886421*x_59 - 0.000158361992267712*x_6 - 0.00141718948128621*x_60 - 0.00302907089559168*x_61 - 0.00023394604810912*x_62 - 0.0014947678078869*x_63 - 3.82209752547686e-5*x_64 + 0.000341780859204425*x_65 + 0.000318020119704993*x_66 + 0.00840580405412118*x_67 - 0.00317589117677407*x_68 - 0.000192906414878496*x_69 - 0.00115006447615552*x_7 + 0.000293444480655225*x_70 + 0.000188073002339554*x_71 + 0.000115494689181929*x_73 + 0.000352650284910832*x_74 - 0.00036488996277016*x_75 - 0.00028943892176937*x_76 - 0.00147621596654107*x_77 + 1.53617200043467e-5*x_78 - 3.4472573506617e-5*x_79 + 0.000226105678003564*x_8 - 0.000353487881895625*x_80 - 4.65621112326669e-5*x_81 + 0.00142814814236654*x_82 + 0.000709470466918235*x_83 - 2.15838379577618e-5*x_84 - 0.000221036695521228*x_85 + 0.000262079547871944*x_86 + 4.54659078704549e-5*x_87 - 0.0013907305923245*x_88 - 0.00116628883699354*x_89 + 0.000126166785300648*x_9 - 0.00028220443215837*x_90 - 0.000322405385953785*x_91 - 0.00016433844016058*x_92 + 0.00104399973020875*x_93 - 0.00426643019134279*x_95 + 0.000158682491451837*x_96 + 0.00154185151406531*x_97 - 0.000179007259541826*x_98 - 9.13325712481732e-5*x_99 - 2.05771779760488e-5*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) + 8.7895905820588e-5*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) + 0.00199568498554309*std::sin(1.63103985786438*x_72 + 0.196399986743927)) + 1.89595550496003e-5*std::sin(0.213839992880821*x_1 + 7.78743982315063) + 2.56617177638803e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 6.53231875030918e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 3.867288772921e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) - 1.75477602261617e-6*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 1.72272795116219e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) + 6.52558112099728e-8*std::sin(0.515839874744415*x_2 + 2.30847978591919) - 1.70743686667747e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) - 7.03006987768925e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) + 2.77555780043323e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 6.71503764989204e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) + 8.98547463166078e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 4.82338828878173e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 2.61080603729811e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 5.52708857906954e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 1.29118713298475e-6*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 6.74455273570691e-8*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 5.68704727732202e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 2.67168410894667e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) + 1.90475443596903e-7*std::sin(1.74439990520477*x_51 - 9.60255908966064) - 4.51425815140888e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 5.59057152701072e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) + 1.93442360354855e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) - 1.35992944841867e-8*std::sin(1.43927991390228*x_70 - 8.60223960876465) - 6.30190859098097e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 6.22901624183797e-8*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 1.22686363826194e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 4.55763781107792e-10*std::sin(1.61631989479065*x_80 - 0.393119841814041) - 1.07599238210808e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 1.80067772420592e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) + 1.19068864180028e-7*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 1.06074274499877e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) + 0.000100473172159104*std::sin(0.238479986786842*x_91 - 8.02320003509521) - 4.38614957699321e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) - 1.33833583583812e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 1.18513434999883e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 8.36733063018394e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0701963519106396);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.69159542544771e-6*x_1 + 1.37361365766282e-8*x_10 - 9.30050797597423e-7*x_100 + 5.67324435193496e-7*x_101 + 1.12034612970366e-7*x_102 - 1.74684639408579e-6*x_103 - 7.71826513000731e-7*x_104 - 4.79390351832795e-7*x_105 + 1.50576233020435e-7*x_106 - 3.69758277959165e-8*x_107 + 2.639447737412e-7*x_108 - 6.54087157299311e-10*x_109 - 3.08018763786471e-7*x_11 + 8.42272301759387e-7*x_110 - 2.46956730624369e-7*x_111 - 1.09101258851878e-6*x_112 - 1.10760688248389e-6*x_113 - 4.79971595325811e-7*x_114 + 1.10003274948456e-6*x_115 - 2.35633767298881e-7*x_116 + 3.02660975152787e-7*x_117 - 8.69914264820876e-7*x_118 - 2.69437614756605e-7*x_119 - 4.31727670777027e-7*x_12 - 7.48433781515494e-8*x_120 + 1.03039245326247e-6*x_13 - 1.82862003088301e-7*x_14 + 3.01708766646365e-7*x_15 - 6.84697146407083e-7*x_16 + 9.6972044687449e-8*x_17 - 1.4140068233665e-7*x_18 - 9.28626197553089e-7*x_19 - 1.14087228744863e-6*x_2 - 1.4175006759339e-6*x_20 + 2.23956236217708e-8*x_21 - 5.44440460727179e-8*x_22 + 1.05051724640484e-6*x_23 + 4.68262278629999e-7*x_24 - 9.71009083003871e-7*x_25 - 8.1024664435106e-7*x_26 - 1.14506621404576e-7*x_27 + 1.88013254231853e-7*x_28 - 3.21265741316415e-7*x_29 + 9.89134762864332e-8*x_3 + 5.91712011331821e-7*x_30 + 2.32990091475585e-6*x_31 - 5.22095174510164e-7*x_32 - 4.15014338046383e-6*x_33 + 9.81060902244567e-7*x_34 + 4.081429664544e-7*x_35 + 1.6953854369002e-6*x_36 - 2.21647669715036e-7*x_37 + 9.26583806898874e-7*x_38 - 3.84895580469362e-7*x_39 + 2.28631755901379e-7*x_4 - 3.46602953652937e-9*x_40 + 1.57589423340583e-6*x_41 + 9.08132118152188e-8*x_42 - 6.72389427710127e-8*x_43 - 1.43875811327851e-6*x_44 - 1.06440507686822e-6*x_45 - 3.05065252967396e-7*x_46 + 5.07283203820497e-7*x_47 - 4.40351783024357e-8*x_48 - 3.93805269201941e-7*x_49 + 5.7910873630762e-7*x_5 + 4.22214307568876e-9*x_50 + 4.69660229997114e-7*x_51 - 7.8898748989205e-7*x_52 - 6.14775101834717e-7*x_53 + 4.82465642672148e-7*x_54 + 1.08870637326327e-7*x_55 - 7.89600357042843e-8*x_56 + 1.83540004940898e-6*x_57 + 1.52784794390089e-6*x_58 - 5.83300694087678e-9*x_59 - 2.99591756243678e-7*x_6 - 7.31662059722137e-7*x_60 - 9.46602994861034e-8*x_61 + 1.0588006989495e-6*x_62 + 1.52229252942753e-7*x_63 - 5.92547861455709e-8*x_64 + 2.97619854000131e-6*x_65 + 5.60343322174545e-7*x_66 - 5.83468817819599e-7*x_67 - 6.42080230840119e-7*x_68 + 7.14496710525812e-7*x_69 + 3.81497584939035e-7*x_7 - 1.77616315871512e-7*x_70 + 1.6224045858759e-7*x_71 - 1.1776267060095e-7*x_72 - 3.56347748960452e-7*x_73 - 1.5890941786647e-7*x_74 - 1.72294972792512e-7*x_75 - 5.42745386652578e-8*x_76 + 1.02073228290517e-6*x_77 + 4.8684869918647e-7*x_78 + 1.30811478315838e-6*x_79 + 4.22522736230132e-7*x_8 + 9.8762206161315e-8*x_80 - 5.03139924115608e-8*x_81 + 4.469806105418e-7*x_82 - 8.41541696187587e-7*x_83 - 2.16069985112991e-7*x_84 + 1.15390578776141e-7*x_85 + 4.02066096990914e-7*x_86 + 1.90810279396571e-7*x_87 + 4.14619068562738e-8*x_88 - 7.02329432093589e-7*x_89 - 5.22687532949504e-7*x_9 + 7.5821799309105e-8*x_90 + 4.42905462917492e-6*x_91 - 6.80085902556141e-7*x_92 - 5.50230167679626e-8*x_93 - 3.84508435587977e-8*x_94 - 4.6899548012932e-7*x_95 + 4.90037755484788e-7*x_96 - 2.95539150580269e-7*x_97 + 2.37958073001416e-6*x_98 + 7.90299655576725e-7*x_99 + 3.7462151850651e-9*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) + 4.65932846677464e-10*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 4.56232272013595e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 1.9902432519148e-9*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 3.22949578069247e-12*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 3.30667489552209e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) + 2.81234215088145e-11*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) + 1.92488875599486e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 2.31972554702852e-10*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) + 1.2341361498114e-10*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 3.51937447712019e-5*std::exp(-0.0066446197069681*x_1 - 0.00106554694673831*x_10 + 0.000525853658908346*x_100 - 0.00259638512861535*x_101 + 0.00148777430607783*x_102 + 0.000668570744714309*x_103 + 0.000283565314359479*x_104 + 0.00546953048004668*x_105 - 0.000221592092476196*x_106 - 8.35518270940233e-5*x_107 - 0.00260118016181184*x_108 - 0.00104465024234899*x_109 + 7.5720187458588e-5*x_11 + 0.000986602968009456*x_110 + 0.00432962110569594*x_111 + 0.00198347931592717*x_112 - 0.00137358422499754*x_113 + 0.00535467759937986*x_114 + 0.00331664878612412*x_115 - 0.00228699013392979*x_116 - 0.00191982202479575*x_117 - 0.00046494643936807*x_119 - 0.00107513697443816*x_12 - 0.000669531187744888*x_120 + 0.000585190258952447*x_13 - 0.00433833565130951*x_14 - 0.00386469930705739*x_15 - 0.00160454012568058*x_16 + 0.000656542165552388*x_17 + 0.00141509846419863*x_18 - 0.00053485559851937*x_19 + 0.000541996235395902*x_2 + 0.002325614339886*x_20 - 0.00141071887406148*x_21 + 6.03783642644668e-5*x_22 - 0.00855272877148983*x_23 - 0.000677041865990348*x_24 + 0.00757460591627165*x_25 + 0.00338876396196434*x_26 + 0.000691555979408819*x_27 - 0.000750115938409884*x_28 - 0.00205436513397241*x_3 - 0.000306661253908844*x_30 + 0.00105163233956187*x_31 + 0.000547108806040055*x_32 + 0.0027345912289528*x_33 - 0.00580570054634318*x_34 - 0.00844022144769164*x_35 + 0.00391168439091155*x_36 + 0.00236186947133064*x_37 - 0.000373492848779037*x_38 + 0.00111942584456346*x_39 - 0.000106779256272271*x_4 + 0.000926050912086542*x_40 + 0.00468235268158086*x_41 - 0.000746589926146376*x_42 - 0.000450594968294349*x_43 + 0.00102968442266539*x_44 + 0.000489222285372009*x_45 + 0.00032337781570143*x_46 + 0.00160050131885894*x_47 - 0.00123193392899774*x_48 - 0.0033013508169751*x_49 - 0.000222582474337172*x_5 - 0.00231484600808901*x_51 + 0.00215596308705429*x_52 + 0.000111163153409555*x_53 + 0.000512998800926384*x_54 - 0.000428678472831116*x_55 - 0.00247490112579767*x_56 + 0.00114832969555499*x_57 + 0.00531149253121345*x_59 - 0.000149510041457933*x_6 + 0.000301259492985293*x_60 + 0.00260357046780408*x_61 + 0.00447241270741088*x_62 + 0.000584114692159853*x_63 - 0.000966222664606704*x_64 - 0.0172947572520307*x_65 - 0.0125124783694824*x_66 - 0.00113675782520158*x_67 + 0.00273668580922118*x_68 + 0.000249557780320731*x_69 - 0.00522546297985949*x_7 - 0.0012266239884367*x_70 + 0.00107965066837928*x_71 + 0.000360722267607638*x_72 - 0.00317711394657921*x_73 - 0.000779072393445329*x_74 + 0.00031077893860541*x_76 + 0.00202419400500278*x_77 - 0.00251954849854423*x_78 + 0.000200416668218822*x_79 + 0.00691979870836198*x_8 - 0.00131249013404201*x_80 + 0.000512540643130809*x_81 + 0.00236537516182766*x_82 - 0.00133076652438263*x_83 - 0.000974243305652267*x_84 + 0.000887163933245592*x_85 - 0.000403479697664054*x_86 + 0.000244880883705094*x_87 - 0.000995007645276569*x_88 + 0.00373057415676074*x_89 + 0.000281417614866046*x_9 + 0.00140770316875608*x_90 + 0.000664968564644672*x_91 - 0.000520221962900706*x_92 + 0.00689296753194234*x_93 + 0.00231136247026484*x_94 - 0.00202056825448251*x_95 + 0.000720659472708514*x_96 + 0.00378823935648684*x_97 - 0.00420581365842491*x_98 + 0.00545968958950287*x_99 + 0.000303035545057624*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 0.000261356989516744*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 0.0143187082538874*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 0.0295739297828947*std::sin(1.23471987247467*x_29 + 9.79176044464111) - 0.00694831553061015*std::sin(1.44383978843689*x_75 + 7.18752002716064)) - 3.43975131451422e-5*std::exp(0.0116368842816417*x_1 - 0.000710063397697846*x_10 + 0.00557593745489027*x_100 - 0.00377307798110228*x_101 + 0.00201412628310905*x_102 - 0.000993571625496721*x_103 + 0.003425405934364*x_104 - 0.00383586492311752*x_105 - 0.00188194853277146*x_106 - 0.000398623195478828*x_107 - 0.000550553535134668*x_108 - 0.00231142463596838*x_109 + 0.0225407967133823*x_11 + 0.00150550365897725*x_110 + 0.000753500456104738*x_111 + 0.0166351391396896*x_112 + 0.00351933042262147*x_113 + 0.00167809150976791*x_114 - 0.00186480010854959*x_115 - 0.00480911749058659*x_116 - 0.00102311927856417*x_117 + 0.00424142610413032*x_118 - 0.00588591848534437*x_119 + 0.0174778559937049*x_12 + 0.000226083327967011*x_120 - 0.00248545363337391*x_13 + 0.000988052677823072*x_14 + 0.00104617526322997*x_15 - 0.00261940115570302*x_16 + 0.000776859452623763*x_17 + 0.00136606781539077*x_18 + 0.00326936155631889*x_19 + 0.000333576165322121*x_2 - 0.00154838979142369*x_20 + 0.000992989510782173*x_21 + 0.00276621744784086*x_22 - 0.00314449834325548*x_23 + 0.000376191900060346*x_24 + 0.004261729858063*x_25 - 0.000496348442441561*x_26 - 0.000246934081122845*x_27 - 0.00348429993336091*x_28 + 0.00395121919454254*x_29 - 0.00330460813302756*x_3 - 0.00188702615281058*x_30 + 0.02782885141109*x_31 + 0.0332504611404455*x_32 - 0.00222432681689524*x_33 + 8.92172697175629e-5*x_34 - 0.00163118971170835*x_35 + 0.00958988862355403*x_36 - 0.0061457278979854*x_37 + 0.00502511574469455*x_38 - 0.00884544889512576*x_39 + 0.00198201153953196*x_4 - 0.00997728850307869*x_40 + 0.00216290617816741*x_41 + 0.000756529471784093*x_42 - 0.00351674692216059*x_43 - 0.00120244383081782*x_44 + 0.00579227716550931*x_45 - 0.00419063497533042*x_47 + 0.0164083838389119*x_48 + 0.00320450042125529*x_49 + 0.00557242425802934*x_5 - 0.00151262251530906*x_50 - 0.00146845395453381*x_51 - 0.00435827869573559*x_52 + 0.000519193608186723*x_53 + 0.00248635210424479*x_54 - 0.00594282864767592*x_55 + 0.000218392654301831*x_56 + 0.000733747704536832*x_57 + 0.0101016412626569*x_58 + 0.00453676456197663*x_59 - 0.00189320326672937*x_6 + 0.00187108386734299*x_60 - 0.00648422111592273*x_61 + 0.00456719397307764*x_62 - 8.22189134932867e-6*x_63 + 0.00161079892183023*x_64 - 0.0102233196317719*x_65 + 0.00231899693628303*x_66 + 0.00968175926206086*x_67 + 0.00602226250306703*x_68 - 0.000753130641143384*x_69 + 0.00185831486305688*x_7 - 0.000843259492846575*x_70 + 0.000874748643250552*x_71 - 0.000957431007704386*x_72 - 0.00131332364573713*x_73 + 0.00663777652315699*x_74 + 0.00310035678858438*x_75 - 0.00489296445908283*x_76 + 0.00272985296700268*x_77 + 0.00862877288696218*x_78 - 0.00695287551453413*x_79 - 0.00995585586957073*x_8 + 0.00016528766889028*x_80 - 0.000908574386396851*x_81 - 0.00135647570932484*x_82 + 0.00205425258172909*x_83 - 0.00127411049627164*x_84 + 0.0010905061162674*x_85 + 0.00756994527188748*x_86 + 0.000894023168694358*x_87 + 7.1021338570687e-5*x_88 - 0.000190497589028318*x_89 + 0.000425421900010249*x_9 - 0.00102895159707166*x_90 + 0.00357300031526755*x_92 + 0.00522548442704773*x_93 + 0.00275174019382398*x_94 - 0.00114803317899976*x_95 + 0.000235066658147128*x_96 + 0.000716471084030446*x_97 - 0.00354654198729772*x_98 + 0.0259139263811344*x_99 + 0.0110612984281033*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 0.860730186104774*std::sin(0.238479986786842*x_91 - 8.02320003509521)) + 0.000120021040087543*std::sin(0.213839992880821*x_1 + 7.78743982315063) + 8.9152459292663e-7*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 1.18843378109271e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) + 2.8797803517348e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) + 1.11380400989867e-6*std::sin(0.903679847717285*x_115 + 6.89792013168335) + 2.25487371800922e-7*std::sin(1.22023987770081*x_19 - 3.59943985939026) + 4.13093572749345e-7*std::sin(0.515839874744415*x_2 + 2.30847978591919) + 4.98690567544071e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) - 1.5194096111473e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 3.51275419443881e-6*std::sin(0.206880003213882*x_31 - 4.59391975402832) - 5.00035932685537e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 1.13720433768172e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 1.67571373056555e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) - 1.94413925876109e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) + 1.19457013298722e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) - 1.52728266725713e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 1.14054747732558e-6*std::sin(0.438079863786697*x_49 - 4.16512012481689) + 1.9894721741132e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) + 1.20578045169463e-6*std::sin(1.74439990520477*x_51 - 9.60255908966064) + 2.8653222781451e-7*std::sin(1.26863980293274*x_6 + 7.78847980499268) - 3.54848761560259e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 2.44821225705549e-8*std::sin(1.6166398525238*x_66 - 6.19975996017456) + 1.69429277922272e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 7.97571422669816e-8*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 4.51886642312123e-8*std::sin(1.63103985786438*x_72 + 0.196399986743927) - 1.41054105631886e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 2.4604969141404e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) + 5.67821576523759e-8*std::sin(1.61631989479065*x_80 - 0.393119841814041) - 1.95756781622931e-8*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 4.07757783987059e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) + 4.13662178210645e-8*std::sin(1.50495994091034*x_87 + 4.99383974075317) + 7.89883118292572e-7*std::sin(1.04919981956482*x_89 - 1.59895980358124) + 2.78400828590474e-7*std::sin(0.3781598508358*x_92 + 1.99599981307983) + 9.96593083778989e-6*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 2.15613130728701e-6*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 1.80843189332956e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0783783508920913);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.73281215588659e-6*x_1 + 3.35211456835255e-7*x_10 + 1.22830024492939e-6*x_100 + 8.0342103215714e-7*x_101 - 1.23838886608662e-7*x_102 + 6.48615590233186e-7*x_103 + 4.94516613399745e-8*x_104 - 1.5231158263724e-7*x_105 - 1.43020302500987e-7*x_106 - 3.82381395356773e-10*x_107 + 3.04367797420911e-7*x_108 + 3.44634638476719e-7*x_109 + 1.91418663326512e-7*x_11 + 1.93109294262186e-7*x_110 - 1.96627042022387e-6*x_111 - 1.99747364715513e-7*x_112 + 2.06018705204162e-6*x_113 - 2.40415860590917e-7*x_114 - 4.97554531673836e-7*x_115 + 1.78574408503386e-6*x_116 - 2.11639422917208e-6*x_117 + 2.74876448651008e-7*x_118 - 4.30884731132416e-8*x_119 - 3.72383088771307e-7*x_12 - 1.85101622132491e-8*x_120 - 4.91906069136869e-7*x_13 + 5.00638915074008e-7*x_14 + 3.44654382665664e-8*x_15 - 1.63960283955409e-7*x_16 - 3.92851293561341e-7*x_17 + 6.34005856028129e-7*x_18 + 1.73151333598673e-6*x_19 + 1.98307826625204e-6*x_2 - 2.1968173133077e-7*x_20 + 3.58954501410409e-7*x_21 + 2.50504418815105e-6*x_22 - 2.17966398518999e-6*x_23 + 8.11632316289164e-7*x_24 - 5.86966114975294e-7*x_25 + 2.8075550293488e-6*x_26 - 5.67969313647974e-7*x_27 - 1.82434127971781e-7*x_28 - 2.78995765892444e-7*x_29 - 4.41240935152521e-7*x_3 + 4.28232182773724e-8*x_30 + 1.06968411933435e-5*x_31 + 3.82892551821321e-7*x_32 - 4.58246373328494e-6*x_33 - 2.85104215567066e-6*x_34 + 1.15823729204934e-6*x_35 - 3.10143628075561e-6*x_36 + 1.58960741310418e-6*x_37 - 1.70112295785841e-6*x_38 - 2.34841850897825e-6*x_39 - 1.45200677787866e-6*x_4 - 1.71265638850801e-6*x_40 - 1.80504338880631e-7*x_41 - 2.91185913793453e-6*x_42 + 3.98647593511862e-7*x_43 + 2.69719897071618e-7*x_44 + 2.74485661336333e-7*x_45 + 9.02068431369491e-7*x_46 + 3.7046305978743e-7*x_47 + 2.01238366152361e-7*x_48 + 1.16751634422686e-7*x_49 + 2.2837946886802e-7*x_5 - 1.1391439100574e-6*x_50 - 8.27984528195026e-7*x_51 + 2.23945403977591e-7*x_52 + 2.12859052227813e-6*x_53 - 2.12579735645979e-7*x_54 - 2.38618254691119e-7*x_55 + 7.59722663546356e-8*x_56 - 2.16507893794325e-6*x_57 + 6.54890146220554e-7*x_58 - 3.51425762753096e-7*x_59 - 3.68344325693104e-7*x_6 + 2.34093717918924e-7*x_60 - 1.94439203766284e-6*x_61 - 3.83909678863277e-6*x_62 - 1.08895869053212e-6*x_63 + 2.66542250921953e-7*x_64 - 3.63149506339455e-6*x_65 + 3.43656479686604e-7*x_66 + 2.55250137623848e-6*x_67 - 1.11029364813454e-7*x_68 - 1.95537523504666e-6*x_69 - 5.14757854930552e-7*x_7 + 2.34132450820454e-6*x_70 + 1.78375965131638e-6*x_71 + 3.20813116815586e-7*x_72 - 6.65066167820019e-7*x_73 + 4.1998750318142e-10*x_74 - 2.81742767067252e-7*x_75 + 5.86610805265734e-8*x_76 - 5.83418745858711e-7*x_77 + 1.51443824795332e-7*x_78 - 2.08912399828662e-7*x_79 - 2.06390137354745e-6*x_8 - 3.07777556947716e-8*x_80 + 3.94355829220353e-7*x_81 - 4.30430288735055e-7*x_82 + 1.34049417525259e-6*x_83 + 3.05367675280798e-7*x_84 + 1.42667533396044e-9*x_85 + 2.75204998168308e-7*x_86 + 4.48200445449843e-7*x_87 + 5.69319940887277e-7*x_88 - 6.00350188606208e-7*x_89 - 1.30308731575579e-6*x_9 + 1.10018174249078e-7*x_90 + 2.02867779978641e-5*x_91 - 1.46580803219362e-6*x_92 - 1.61193111099921e-6*x_93 - 3.29896045713798e-7*x_94 - 1.21650406860503e-6*x_95 + 9.81072401888444e-8*x_96 + 4.02724987320271e-7*x_97 - 2.86095185284541e-7*x_98 - 5.17188740168689e-7*x_99 + 4.17618354479541e-9*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) - 1.73362610948944e-8*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) + 3.60180439799411e-9*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) - 2.91972217919989e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) + 1.89889750751504e-9*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) + 1.24716628287877e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) - 1.59377338415639e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) + 1.58463997884487e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) - 4.58763246155646e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) - 9.18969185952782e-10*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 5.1366336898264e-10*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 0.000245554199778615*std::exp(-0.0116368842816417*x_1 + 0.000710063397697846*x_10 - 0.00557593745489027*x_100 + 0.00377307798110228*x_101 - 0.00201412628310905*x_102 + 0.000993571625496721*x_103 - 0.003425405934364*x_104 + 0.00383586492311752*x_105 + 0.00188194853277146*x_106 + 0.000398623195478828*x_107 + 0.000550553535134668*x_108 + 0.00231142463596838*x_109 - 0.0225407967133823*x_11 - 0.00150550365897725*x_110 - 0.000753500456104738*x_111 - 0.0166351391396896*x_112 - 0.00351933042262147*x_113 - 0.00167809150976791*x_114 + 0.00186480010854959*x_115 + 0.00480911749058659*x_116 + 0.00102311927856417*x_117 - 0.00424142610413032*x_118 + 0.00588591848534437*x_119 - 0.0174778559937049*x_12 - 0.000226083327967011*x_120 + 0.00248545363337391*x_13 - 0.000988052677823072*x_14 - 0.00104617526322997*x_15 + 0.00261940115570302*x_16 - 0.000776859452623763*x_17 - 0.00136606781539077*x_18 - 0.00326936155631889*x_19 - 0.000333576165322121*x_2 + 0.00154838979142369*x_20 - 0.000992989510782173*x_21 - 0.00276621744784086*x_22 + 0.00314449834325548*x_23 - 0.000376191900060346*x_24 - 0.004261729858063*x_25 + 0.000496348442441561*x_26 + 0.000246934081122845*x_27 + 0.00348429993336091*x_28 - 0.00395121919454254*x_29 + 0.00330460813302756*x_3 + 0.00188702615281058*x_30 - 0.02782885141109*x_31 - 0.0332504611404455*x_32 + 0.00222432681689524*x_33 - 8.92172697175629e-5*x_34 + 0.00163118971170835*x_35 - 0.00958988862355403*x_36 + 0.0061457278979854*x_37 - 0.00502511574469455*x_38 + 0.00884544889512576*x_39 - 0.00198201153953196*x_4 + 0.00997728850307869*x_40 - 0.00216290617816741*x_41 - 0.000756529471784093*x_42 + 0.00351674692216059*x_43 + 0.00120244383081782*x_44 - 0.00579227716550931*x_45 + 0.00419063497533042*x_47 - 0.0164083838389119*x_48 - 0.00320450042125529*x_49 - 0.00557242425802934*x_5 + 0.00151262251530906*x_50 + 0.00146845395453381*x_51 + 0.00435827869573559*x_52 - 0.000519193608186723*x_53 - 0.00248635210424479*x_54 + 0.00594282864767592*x_55 - 0.000218392654301831*x_56 - 0.000733747704536832*x_57 - 0.0101016412626569*x_58 - 0.00453676456197663*x_59 + 0.00189320326672937*x_6 - 0.00187108386734299*x_60 + 0.00648422111592273*x_61 - 0.00456719397307764*x_62 + 8.22189134932867e-6*x_63 - 0.00161079892183023*x_64 + 0.0102233196317719*x_65 - 0.00231899693628303*x_66 - 0.00968175926206086*x_67 - 0.00602226250306703*x_68 + 0.000753130641143384*x_69 - 0.00185831486305688*x_7 + 0.000843259492846575*x_70 - 0.000874748643250552*x_71 + 0.000957431007704386*x_72 + 0.00131332364573713*x_73 - 0.00663777652315699*x_74 - 0.00310035678858438*x_75 + 0.00489296445908283*x_76 - 0.00272985296700268*x_77 - 0.00862877288696218*x_78 + 0.00695287551453413*x_79 + 0.00995585586957073*x_8 - 0.00016528766889028*x_80 + 0.000908574386396851*x_81 + 0.00135647570932484*x_82 - 0.00205425258172909*x_83 + 0.00127411049627164*x_84 - 0.0010905061162674*x_85 - 0.00756994527188748*x_86 - 0.000894023168694358*x_87 - 7.1021338570687e-5*x_88 + 0.000190497589028318*x_89 - 0.000425421900010249*x_9 + 0.00102895159707166*x_90 - 0.00357300031526755*x_92 - 0.00522548442704773*x_93 - 0.00275174019382398*x_94 + 0.00114803317899976*x_95 - 0.000235066658147128*x_96 - 0.000716471084030446*x_97 + 0.00354654198729772*x_98 - 0.0259139263811344*x_99 - 0.0110612984281033*std::sin(1.68839979171753*x_46 + 1.82767987251282) + 0.860730186104774*std::sin(0.238479986786842*x_91 - 8.02320003509521)) - 0.000264858973565111*std::exp(-0.000734873384429319*x_1 + 0.00100419357160141*x_10 + 0.000160795833290461*x_100 + 0.00161193807666862*x_101 + 0.000159463845039425*x_102 - 0.000313299616496015*x_103 + 0.000374133627407592*x_104 + 0.000527511494001224*x_105 - 0.000142466785802503*x_106 - 0.000390044875951854*x_107 + 0.000194948406541617*x_108 - 7.76359612363068e-6*x_109 + 0.000259445799758981*x_11 + 0.000669523892538631*x_110 - 0.00060993442296477*x_112 - 0.000281068961385665*x_113 - 0.000178258214795377*x_114 - 0.00113481100915376*x_115 + 0.00151990010145652*x_116 + 0.00148045189977602*x_117 + 0.00020365256813998*x_118 - 0.00151085856997284*x_119 + 9.59793834903588e-5*x_12 - 0.000195820969186254*x_120 + 0.000125631106831711*x_13 - 0.000152405397549602*x_14 + 0.000444591770571164*x_15 - 0.00136201725441543*x_16 + 0.000436216764392098*x_17 - 0.000181883627191461*x_18 - 0.000448133179751925*x_19 - 0.000362801942348929*x_2 + 3.54152534061184e-5*x_20 + 0.00142944353641879*x_21 + 0.000568140437051245*x_22 - 0.00260631460055335*x_23 - 0.000395773164589158*x_24 + 0.000159478565131217*x_25 - 0.000167904654862932*x_26 - 0.000814593052740513*x_27 + 0.000858254176475491*x_28 + 0.0004226887621655*x_3 - 0.00184709426616271*x_30 - 0.00130644349848942*x_31 + 0.000322498381858448*x_32 - 0.0019751587349694*x_33 - 0.00189053535181479*x_34 + 7.89966839308515e-5*x_35 + 0.000161691394069723*x_36 - 0.000367272166509463*x_37 - 0.000459682423710439*x_38 - 0.000459387675890937*x_39 + 0.000130050745001216*x_4 + 0.000328363763655436*x_40 - 0.000376864195831888*x_41 + 7.03132795780027e-5*x_42 - 3.7662220237557e-5*x_43 + 0.000151625552687912*x_44 + 0.00109643757128821*x_45 - 0.000250522629593109*x_47 + 0.000258872881129103*x_48 + 0.000537883345192948*x_49 + 0.000141489241600544*x_5 - 0.00236701192368969*x_50 + 0.000540824349619537*x_51 - 0.00321191283987089*x_52 - 0.00169111599259435*x_53 + 0.00252203835011851*x_54 + 0.00303122196393759*x_55 - 0.000947432831827461*x_56 - 0.00296726583752251*x_57 - 0.000342732442970218*x_58 - 0.00110370390158292*x_59 + 2.19693402802563e-5*x_6 - 0.000453620880417752*x_60 - 3.94257376888341e-5*x_61 + 0.00068475315614768*x_62 - 0.0014739241284763*x_63 - 0.000120313279950977*x_64 - 0.000525939871383739*x_65 + 0.000909869753835877*x_66 + 0.000520985833706168*x_67 + 7.6351430825747e-5*x_68 - 0.000166417220299878*x_69 + 0.00181491931268671*x_7 - 1.65788430720481e-5*x_70 - 0.000204517765086085*x_71 + 0.00137672685137716*x_72 - 0.00012659546060575*x_73 - 0.000284290722125975*x_74 + 0.000260721950417595*x_75 - 0.000809067953986876*x_76 + 0.00126575920839482*x_77 + 0.000225058235032564*x_78 + 0.000500932097825621*x_79 + 0.00059013063091446*x_8 + 4.49250418517891e-5*x_80 - 7.22633994234516e-5*x_81 + 6.19441913680681e-5*x_82 - 0.000277055206566416*x_83 + 0.000213432834337963*x_84 + 0.00075184075017898*x_85 + 0.000863443890673063*x_86 + 0.000569288483394236*x_87 - 0.000808584638335005*x_88 - 0.00186446654553966*x_89 + 0.000147431834398112*x_9 - 0.000643938269646187*x_90 + 0.00146603819419228*x_91 - 0.00103739795684813*x_92 + 0.00122724730339974*x_93 + 0.000206821199887481*x_94 + 0.00200957073887583*x_95 - 0.000627270758383531*x_97 - 0.000650891524722976*x_98 - 0.00106505077065534*x_99 - 3.6560692940946e-8*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) - 0.00172010344700829*std::sin(1.68647980690002*x_29 - 5.62224006652832) + 0.00135235698679892*std::sin(1.2824798822403*x_46 - 2.21879982948303) + 0.00204730173520953*std::sin(1.0402398109436*x_96 + 0.18376000225544)) - 2.06092735863687e-5*std::sin(0.213839992880821*x_1 + 7.78743982315063) - 4.12568481840343e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 8.5775206387018e-7*std::sin(0.438479870557785*x_103 - 7.36199998855591) + 5.30026892088632e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) - 4.63579581716617e-6*std::sin(0.903679847717285*x_115 + 6.89792013168335) + 1.97328513990792e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 1.27052927741529e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 7.09338833537184e-8*std::sin(0.515839874744415*x_2 + 2.30847978591919) + 4.07563274106259e-7*std::sin(1.23471987247467*x_29 + 9.79176044464111) + 6.41654215738441e-7*std::sin(1.61495983600616*x_29 - 5.39687967300415) + 1.3915925815667e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) - 9.2032189598869e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) + 4.50508356818338e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) - 7.75465618451359e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) - 3.5782107079378e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) - 4.14158307557361e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) + 5.49728736619936e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) + 3.66164646101155e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) - 2.0704919067477e-7*std::sin(1.74439990520477*x_51 - 9.60255908966064) - 1.19258405552576e-6*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 1.47692627243935e-6*std::sin(1.31479978561401*x_66 - 8.57615947723389) + 9.6986974506008e-8*std::sin(1.6166398525238*x_66 - 6.19975996017456) - 4.03804766853946e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) - 3.15961326532337e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) + 2.83170302641531e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) - 9.57558987922115e-8*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 3.82501097635281e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) + 1.18592683510144e-7*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 1.35330246421758e-7*std::sin(1.61631989479065*x_80 - 0.393119841814041) - 1.41287454231793e-7*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 1.10573030998059e-6*std::sin(1.35327982902527*x_87 + 4.78735971450806) - 1.9142935395522e-7*std::sin(1.50495994091034*x_87 + 4.99383974075317) + 1.45378898098838e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 1.15874012411998e-6*std::sin(0.3781598508358*x_92 + 1.99599981307983) + 1.83424105437138e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 1.55618773904262e-5*std::sin(0.401999861001968*x_95 - 1.40631985664368) + 0.076943507321675);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.64050977935663e-9*x_1 - 1.2637110762487e-6*x_10 + 1.78815775100645e-6*x_100 - 6.34388363259152e-7*x_101 + 4.48032505784142e-7*x_102 - 9.36392441268416e-7*x_103 - 2.16808143596575e-6*x_104 + 9.98929652193393e-7*x_105 + 7.7771878734853e-7*x_106 - 1.6309917215378e-6*x_107 - 1.7595136735877e-7*x_108 - 1.83371711369777e-6*x_109 + 2.29111002742071e-8*x_11 - 9.31580767523578e-7*x_110 + 1.57495885224019e-6*x_111 + 2.27627915757497e-7*x_112 - 1.26791575686648e-6*x_113 - 1.17768096050561e-6*x_114 - 2.46011202768011e-7*x_115 - 5.94522988264796e-7*x_116 - 1.54916818393978e-6*x_117 + 1.87525299063483e-6*x_118 + 6.35368887091226e-7*x_119 + 1.65212358285997e-6*x_12 - 7.01404968384815e-7*x_120 - 4.25908359228967e-7*x_13 - 1.26570781787416e-6*x_14 - 1.97730379080503e-6*x_15 + 1.84571547187145e-8*x_16 - 1.18435347164208e-6*x_17 - 2.1833242947395e-7*x_18 + 9.00203722747017e-7*x_19 + 4.69746338742271e-7*x_2 + 6.99192592622713e-7*x_20 - 1.90912637989992e-7*x_21 + 2.47331001478623e-7*x_22 + 6.43089843524081e-7*x_23 - 8.53554326169965e-7*x_24 + 4.55749981047614e-7*x_25 - 1.03124884157608e-6*x_26 - 7.41400100241439e-7*x_27 - 6.53340409683334e-7*x_28 + 1.03062076034108e-6*x_29 - 6.98842701643505e-7*x_3 - 2.21590813424783e-7*x_30 + 5.47317686507675e-6*x_31 - 1.72574261970655e-6*x_32 + 5.33992748475434e-6*x_33 - 3.73755438424193e-6*x_34 - 1.81099102160257e-6*x_35 - 5.11439312671757e-6*x_36 - 1.38910164321449e-7*x_37 - 2.83641277272472e-6*x_38 - 8.37582304026028e-6*x_39 + 9.41713055039927e-7*x_4 + 7.52629586401942e-8*x_40 + 9.73957982755893e-7*x_41 + 4.28502169307994e-7*x_42 - 1.86366584648996e-7*x_43 - 7.70462183784901e-7*x_44 + 7.25643783996282e-7*x_45 - 9.94336758903021e-7*x_46 - 1.32996608208544e-6*x_47 + 1.30452690915357e-6*x_48 + 5.37373959463535e-7*x_49 + 2.64744365873508e-7*x_5 - 9.97255666923972e-7*x_50 - 2.0980103309973e-7*x_51 + 7.1669512943496e-7*x_52 - 2.52091608517797e-6*x_53 + 1.70064872375847e-6*x_54 - 1.24082071447045e-6*x_55 - 5.40597794981169e-7*x_56 + 1.84008598995335e-6*x_57 - 2.2328670129951e-6*x_58 - 4.16757391051465e-7*x_59 + 3.27606154781776e-7*x_6 + 4.94334158473078e-7*x_60 + 1.45680639100442e-6*x_61 + 2.99100419798281e-6*x_62 + 7.13343050822274e-7*x_63 - 1.06541005724242e-6*x_64 - 2.09319102868241e-6*x_65 - 2.27196927211414e-6*x_66 + 1.52511206252526e-6*x_67 + 2.60846509217897e-7*x_68 - 4.57284247504566e-8*x_69 - 7.33266210507284e-7*x_7 + 1.52783529104332e-6*x_70 + 1.15932785638046e-6*x_71 - 1.21068990220053e-6*x_72 + 4.76372568189858e-7*x_73 + 1.77368085204044e-6*x_74 - 2.70298335772094e-7*x_75 - 5.0883559477536e-7*x_76 + 1.78938793014416e-6*x_77 - 9.43056196328023e-7*x_78 - 9.80765072595489e-7*x_79 - 9.59947522032141e-8*x_8 - 3.72510527073076e-6*x_80 - 1.27874821775152e-6*x_81 - 7.94858981402236e-7*x_82 - 2.02880756903322e-6*x_83 - 3.25653411185124e-7*x_84 - 3.07675661285347e-7*x_85 + 1.47854965741997e-7*x_86 - 1.15273442477705e-6*x_87 + 9.52325148682883e-7*x_88 + 1.12762652059069e-6*x_89 + 2.44591991830876e-6*x_9 - 1.26865703601323e-6*x_90 + 1.85426205374333e-5*x_91 - 6.57545845785662e-7*x_92 - 1.67967318663613e-6*x_93 + 8.82336086635997e-7*x_94 - 4.03989714662926e-7*x_95 - 9.43144667089023e-7*x_96 + 4.49790406307923e-7*x_97 - 2.23976469240702e-6*x_98 - 9.52723025013629e-8*x_99 - 4.52593801025857e-9*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) - 1.48585576377095e-8*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 3.90345473457791e-9*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 1.63785230569176e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 1.32038315807883e-10*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 6.9961251332268e-9*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) + 1.90874964218005e-12*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 5.68351327606218e-10*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) + 1.37613959335729e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) + 5.0233590700775e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) - 4.87985437342349e-10*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) + 3.57171705498874e-11*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 0.000147848292235182*std::sin(0.213839992880821*x_1 + 7.78743982315063) - 3.53604074913963e-6*std::sin(0.68207985162735*x_1 - 5.39999961853027) + 2.02597765152329e-8*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 4.72995236037206e-7*std::sin(1.5123997926712*x_105 + 4.22128009796143) + 3.22346345553355e-7*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 2.13854734208651e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) + 1.10335828106857e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) - 5.08870604852053e-7*std::sin(0.515839874744415*x_2 + 2.30847978591919) - 4.41696609853701e-7*std::sin(1.23471987247467*x_29 + 9.79176044464111) - 2.03361142728821e-6*std::sin(1.61495983600616*x_29 - 5.39687967300415) + 8.98026425345101e-8*std::sin(1.68647980690002*x_29 - 5.62224006652832) + 7.38955043214135e-6*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 8.21293936064261e-6*std::sin(0.523439884185791*x_31 - 1.49191975593567) + 2.39226212248291e-5*std::sin(0.326879858970642*x_35 - 7.79839992523193) - 6.64635847646236e-7*std::sin(0.474879860877991*x_37 - 7.35743951797485) + 3.19319008837929e-6*std::sin(0.644079804420471*x_43 + 7.57352018356323) - 7.06034461332982e-8*std::sin(1.2824798822403*x_46 - 2.21879982948303) + 1.97410791632072e-7*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 3.14200441830505e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 1.96037316463664e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 3.26764803439699e-7*std::sin(1.76543986797333*x_49 - 7.3996000289917) - 1.48534440681056e-6*std::sin(1.74439990520477*x_51 - 9.60255908966064) + 8.29253761868496e-8*std::sin(1.26863980293274*x_6 + 7.78847980499268) - 1.02696884278132e-7*std::sin(1.31479978561401*x_66 - 8.57615947723389) + 5.15014343182312e-8*std::sin(1.6166398525238*x_66 - 6.19975996017456) + 4.42157551877662e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) - 1.6777986516631e-7*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 1.58847693245924e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) + 1.03775434532865e-7*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 2.90183757477841e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 4.22910244250637e-8*std::sin(1.62847983837128*x_78 - 6.5827202796936) + 1.48183714915104e-7*std::sin(1.61631989479065*x_80 - 0.393119841814041) + 3.33715576763167e-9*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 8.38860275410906e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) - 1.64070215239825e-7*std::sin(1.50495994091034*x_87 + 4.99383974075317) - 1.29735919530645e-6*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 1.53614359584456e-5*std::sin(0.238479986786842*x_91 - 8.02320003509521) + 8.05720655497817e-8*std::sin(0.3781598508358*x_92 + 1.99599981307983) - 1.6368740782995e-5*std::sin(0.456079840660095*x_92 - 1.59135985374451) + 3.67565607088075e-7*std::sin(0.401999861001968*x_95 - 1.40631985664368) - 1.06884912187736e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0759243670564163);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.71140772528702e-6*x_1 + 6.34439804738623e-7*x_10 - 4.82723585423249e-6*x_100 + 2.13553158585719e-6*x_101 + 7.70425827981628e-7*x_102 - 4.42733045920928e-6*x_103 - 6.77993819346361e-6*x_104 - 5.43525876419249e-7*x_105 - 6.36761468420745e-7*x_106 - 1.58952278715421e-7*x_107 - 2.1321447106281e-6*x_108 - 2.38829325292303e-6*x_109 + 1.64312494101703e-6*x_11 - 1.09272413062217e-6*x_110 - 2.74517894859161e-6*x_111 + 3.2776110929992e-6*x_112 + 1.24749456256434e-6*x_113 - 3.27180135290841e-6*x_114 + 2.97182645606693e-6*x_115 - 5.20875836606326e-6*x_116 + 7.49253042995308e-7*x_117 + 1.15796609943752e-6*x_118 - 2.28534439568199e-6*x_119 + 1.98966773461527e-6*x_12 + 2.06215923498408e-6*x_120 + 1.07579025894658e-7*x_13 + 5.49130099104861e-7*x_14 - 3.47721871589336e-6*x_15 - 6.10027028528485e-6*x_16 + 5.35373552075297e-7*x_17 + 1.09264070568651e-6*x_18 + 2.28773472905216e-6*x_19 - 4.61675851812014e-6*x_2 + 1.03573122743868e-6*x_20 + 1.9365873765521e-7*x_21 - 1.75271615280188e-6*x_22 + 5.14499059279332e-7*x_23 - 6.93222002701345e-7*x_24 - 1.83198036874488e-6*x_25 + 1.59459766545068e-7*x_26 - 5.33133664621411e-7*x_27 - 1.64829549371406e-6*x_28 + 3.13086087343263e-7*x_29 + 2.15980469831541e-6*x_3 + 2.18400943665234e-6*x_30 + 1.42230522547925e-5*x_31 + 6.09822586399947e-6*x_32 + 4.87864902010915e-6*x_33 + 2.93809008982064e-6*x_34 - 5.50895933991085e-7*x_35 + 1.41247864228855e-5*x_36 - 4.86014344450516e-6*x_37 + 2.50166856080359e-6*x_38 - 2.13820671781653e-6*x_39 - 2.02952783545766e-7*x_4 - 1.11867709638328e-6*x_40 - 4.32544468960003e-7*x_41 + 1.84457257512705e-7*x_42 - 1.12217560714393e-6*x_43 - 2.55285878060163e-6*x_44 - 4.75306429042759e-7*x_45 + 1.67672428338977e-6*x_46 - 8.9351744561054e-7*x_47 + 3.98375195529539e-6*x_48 - 3.4599979482777e-6*x_49 - 7.45002425474457e-7*x_5 - 1.26685289941831e-6*x_50 + 1.26728979541515e-6*x_51 - 1.6347850370167e-7*x_52 + 2.17322519385561e-6*x_53 + 5.50561532831785e-6*x_54 + 1.63739779474987e-6*x_55 - 1.94639008336598e-7*x_56 - 4.64113840084458e-7*x_57 + 1.67948818104159e-6*x_58 - 5.95498293374723e-6*x_59 - 1.22438002080213e-6*x_6 + 4.49699847763401e-7*x_60 - 1.22969264951593e-7*x_61 - 3.80439037790112e-6*x_62 + 2.48254045918022e-6*x_63 + 1.63034639245894e-6*x_64 - 3.619052957272e-7*x_65 + 2.48011950084995e-7*x_66 - 1.01344351840574e-6*x_67 - 1.12974207331143e-7*x_68 - 4.28329709389089e-6*x_69 - 4.62786531864708e-7*x_7 + 4.47052202299344e-8*x_70 + 1.60446807456455e-6*x_71 + 5.95256898296371e-7*x_72 - 2.33815802889128e-6*x_73 + 4.01176540290939e-6*x_74 + 1.53517337095263e-6*x_75 - 2.21037502303947e-7*x_76 - 1.29534392741161e-6*x_77 + 7.92166403265952e-7*x_78 - 4.88393298696176e-7*x_79 + 7.00113545148332e-6*x_8 - 9.72524624070986e-8*x_80 + 9.48584772008865e-7*x_81 - 1.22908505979118e-6*x_82 + 5.11860671561199e-8*x_83 + 5.45262008498234e-7*x_84 - 1.58254579045638e-7*x_85 + 1.02472820348762e-6*x_86 + 1.58355444380673e-7*x_87 + 8.86122054122723e-7*x_88 + 4.43983289892136e-6*x_89 - 2.34493276054063e-6*x_9 - 4.04744476473216e-7*x_90 - 2.0705604354396e-5*x_91 + 4.84466770703629e-6*x_92 + 3.05289363863806e-5*x_93 + 2.52162963900248e-6*x_94 + 1.39273448946957e-6*x_95 + 3.10166588118287e-6*x_96 + 1.05971167432202e-7*x_97 + 1.99886566707775e-6*x_98 + 3.73072803261018e-6*x_99 + 2.97771767126073e-9*std::pow(3.80999994277954 - 8.01719951629639*x_58, 2) + 2.5681717504246e-9*std::pow(4.96935987472534 - 9.74312019348145*x_50, 2) + 4.84193373881837e-9*std::pow(6.32263994216919 - 6.30367994308472*x_94, 2) - 2.06824352878746e-8*std::pow(7.69488000869751 - 4.54288005828857*x_102, 2) + 4.56116569324674e-12*std::pow(-6.80000019073486*x_111 - 9.99985980987549, 2) + 1.23698793992903e-9*std::pow(-5.29727983474731*x_6 - 9.24431991577148, 2) - 1.32737527105599e-10*std::pow(-6.1264796257019*x_82 - 8.37383937835693, 2) - 1.2111728356921e-10*std::pow(-4.85775995254517*x_82 - 7.4827995300293, 2) + 3.42797076731871e-9*std::pow(-6.4871997833252*x_87 - 7.85720014572144, 2) - 4.05934557948198e-5*std::exp(-0.00502107778936001*x_1 + 0.00404304387053026*x_10 - 0.0093424518947241*x_100 + 0.00100175352938457*x_101 - 0.001322318943126*x_102 + 6.11638872856796e-6*x_103 + 0.00196205421050505*x_104 + 0.00168049428244717*x_105 - 0.000608677536562251*x_106 + 0.00101481457692215*x_107 + 0.00410478454862154*x_108 + 0.0103363699555464*x_109 + 0.00204229230699543*x_11 - 0.00743414064345416*x_110 - 0.0156995560074127*x_111 + 0.000998303175787744*x_112 + 0.00139627553540534*x_113 - 0.000634860273798429*x_114 - 0.00301138607829918*x_116 - 0.00660220608747191*x_117 - 5.12030301754953e-5*x_118 + 0.00404554892454584*x_119 + 0.00683256827767792*x_12 - 0.00175062275737563*x_120 - 0.00101978906544748*x_13 - 0.00174688289151292*x_14 + 0.00215057669200106*x_15 + 0.00185538851177058*x_16 - 0.00411957727744362*x_17 + 0.00110972850584945*x_18 + 0.00471716057326415*x_19 - 0.00125978983360585*x_2 - 0.00394059797218821*x_20 - 0.000155820192742004*x_21 - 0.00328194860044224*x_22 + 7.7335037449365e-8*x_23 - 0.000572623293681497*x_24 - 0.00636425200089497*x_25 + 0.0149528644266402*x_26 - 0.00218133543147911*x_27 - 0.000633718710032335*x_28 - 0.00342940937013474*x_29 + 0.00126914006686419*x_3 - 0.00372694290017333*x_30 + 0.000615998919676758*x_32 - 0.00106176271247186*x_33 - 0.0154000780585695*x_34 + 0.000206496855921685*x_35 + 0.00096872950980452*x_36 + 0.00161164143326398*x_37 - 0.000350874373222028*x_38 - 0.00629811670545599*x_39 - 0.00177376858151349*x_4 - 0.0116914170783328*x_40 - 0.00160223570398146*x_41 - 0.0190983451543988*x_42 - 0.00291023318367374*x_43 + 0.00675259995731869*x_44 - 0.00567816184317699*x_45 - 0.00355081223527801*x_46 - 0.00696488544180147*x_47 - 0.00259457999411537*x_48 - 0.00412307388615127*x_49 + 0.00650980233823706*x_5 + 0.000611613486104345*x_50 + 0.00255961455236868*x_51 - 0.00343934349225788*x_52 - 0.000650630666570659*x_53 + 5.98424950211884e-5*x_54 + 0.00933613222916595*x_55 - 0.000918906844490633*x_56 + 0.000501548930795662*x_57 - 0.00156280605179615*x_58 + 0.00952400759519932*x_59 + 0.00116664639776762*x_60 - 0.00948816266221481*x_61 - 0.00469100424308914*x_62 - 0.00331816544849799*x_63 - 0.00279614790750884*x_64 - 0.00415352666511853*x_65 + 0.00260916654288224*x_67 + 0.00327024388211861*x_68 - 0.00338519812484436*x_69 - 0.00222735155852881*x_7 + 0.00685794318760029*x_70 - 0.00195757093542186*x_71 - 0.00407235794991578*x_72 + 0.000432742174319716*x_73 + 0.00210741216344314*x_74 + 0.00112479299793451*x_75 + 0.00105405206775348*x_76 + 0.0016337578567235*x_77 + 0.00287009450651382*x_78 - 0.00364307829775295*x_79 - 0.00841030734189174*x_8 - 0.00145716332248032*x_80 - 0.002226125926663*x_81 - 0.00346326876973058*x_82 - 0.001028525374582*x_83 + 0.00882258109222211*x_84 + 0.000304441655177303*x_85 + 0.00520152155494114*x_86 - 0.00103041801681465*x_88 - 0.000834810280714929*x_89 - 0.0048230457298909*x_9 + 0.00236137074929837*x_90 - 0.00184802437772677*x_91 + 0.00275513070569873*x_93 + 0.00131198181790356*x_94 + 0.00126288588863425*x_95 - 0.000534101948993435*x_96 + 0.00446018713876468*x_97 - 0.00191263085105784*x_98 - 0.00132667752170674*x_99 + 2.43364593188744e-5*std::pow(6.54527997970581 - 4.5603199005127*x_31, 2) - 6.58316082535748e-6*std::pow(-5.85391998291016*x_87 - 7.66320037841797, 2) - 0.0594128202646971*std::sin(0.903679847717285*x_115 + 6.89792013168335) - 0.0152842758689076*std::sin(1.26863980293274*x_6 + 7.78847980499268) + 0.0189284340012819*std::sin(1.31479978561401*x_66 - 8.57615947723389) - 0.0148505286779255*std::sin(0.3781598508358*x_92 + 1.99599981307983)) - 0.000120791388296314*std::exp(0.00081601348202905*x_10 + 0.000391706830775504*x_100 + 0.000212561239749896*x_101 + 0.000318008058241386*x_102 + 3.90805453230404e-5*x_103 - 0.000192150427866959*x_104 + 0.000572537450366276*x_105 + 4.0809463923526e-5*x_106 - 0.00301163266544534*x_107 + 0.0012215376426049*x_108 - 0.000329597294579232*x_109 + 0.000415978575305857*x_11 + 0.00126126977985578*x_110 + 0.000242730189985081*x_111 + 0.000355466797529896*x_112 + 0.000235353623574419*x_113 - 0.000447039428288493*x_114 + 0.000329149616372416*x_115 + 0.00686950657360047*x_116 - 4.16440096741189e-5*x_117 + 2.75000419741705e-5*x_118 - 0.000509603409938524*x_119 - 0.000584847981524878*x_12 - 0.00110693856537441*x_120 + 0.000680365945311225*x_13 - 6.71304145647599e-5*x_14 - 0.0003352540480623*x_15 - 0.000108896765687483*x_16 + 0.000145906087346341*x_17 + 0.000410835507950494*x_18 + 1.15531475720115e-5*x_19 + 0.000781528696140617*x_2 - 0.000201622057507732*x_20 - 0.00028748564580572*x_21 + 0.00504877804699001*x_22 + 0.000916487129055434*x_23 + 0.000166156250677303*x_24 + 0.000323932636096355*x_25 - 0.000204254314355476*x_26 + 0.000841364076613105*x_27 - 0.000974241806997985*x_28 + 0.00111265995184461*x_29 - 0.00020320668912979*x_3 + 0.00041000081909041*x_30 + 0.00184466184024435*x_31 + 0.0100862302910209*x_32 + 0.000309521304405105*x_33 + 0.000171406223368883*x_34 - 0.00117396758223941*x_35 + 6.4995583284313e-6*x_36 - 0.000568160259596757*x_38 + 0.000107636104288535*x_39 - 0.000542587443925335*x_4 - 0.00119626568543607*x_40 + 0.0028934243709588*x_41 - 0.00544918715954204*x_42 - 0.000421560446288761*x_43 + 0.000951499855931495*x_44 - 0.000123976384110231*x_45 - 0.000294263467287283*x_46 + 0.000201547902697425*x_47 - 9.9934560566656e-5*x_48 - 0.000856756334680031*x_49 - 8.97999892911273e-5*x_5 - 0.00133365685208691*x_50 - 0.00107807440414635*x_51 + 0.00161586838155929*x_52 + 0.00132397667305825*x_53 + 0.000989515782613468*x_54 - 0.000520155194692193*x_55 - 0.000865416456846216*x_56 + 0.000360534832346243*x_57 + 8.31865454302234e-6*x_59 - 0.000763007335959404*x_6 + 0.000744294078677526*x_60 - 0.000391162559005801*x_61 + 0.000480963038825249*x_62 + 0.00253030802900699*x_63 - 0.000301982525054144*x_64 + 0.000634076422077796*x_65 + 0.00060327433689601*x_66 - 0.00035666744517394*x_67 + 0.00171618230698398*x_68 - 0.000473982631588867*x_69 - 0.000316919405284652*x_7 + 0.00230427088983361*x_70 + 0.0063046996336086*x_71 - 0.000132090769584411*x_72 - 0.000205130869985448*x_73 - 0.000705765776667283*x_74 - 0.00082376297405048*x_75 + 0.000259619598056209*x_76 + 0.000273345070767993*x_77 + 0.000847551077837466*x_78 + 0.0001780603160136*x_79 - 0.000931230531610714*x_8 + 0.000116164507914645*x_80 - 0.000413561459630116*x_81 - 0.00103100237719115*x_82 - 0.000554433090222725*x_83 - 0.000203872151893423*x_84 - 0.000215128999494595*x_85 + 0.000119205649424169*x_86 + 0.000783407071303748*x_88 + 0.00190534594582958*x_89 + 0.000923207455122912*x_9 - 0.00032881122512192*x_90 - 0.000168201629002077*x_91 - 0.00113636932225853*x_92 + 0.00105636784206418*x_93 - 0.000768668731127003*x_94 + 0.00115544906934404*x_95 - 0.000509034132638985*x_96 + 2.19080281409259e-5*x_97 - 0.000134429979026091*x_98 - 0.000696675871353038*x_99 - 7.05041335114127e-5*std::pow(4.86168003082275 - 9.89960098266602*x_58, 2) - 0.0167785793990141*std::sin(0.68207985162735*x_1 - 5.39999961853027) - 0.00315370951080718*std::sin(0.474879860877991*x_37 - 7.35743951797485) - 0.000778516235731885*std::sin(1.50495994091034*x_87 + 4.99383974075317)) + 5.76926353260452e-5*std::sin(0.213839992880821*x_1 + 7.78743982315063) - 6.10928522973925e-6*std::sin(0.438479870557785*x_103 - 7.36199998855591) - 6.92706593646288e-9*std::sin(1.5123997926712*x_105 + 4.22128009796143) + 1.40699899046891e-7*std::sin(0.394879847764969*x_118 + 5.18639993667603) - 1.06426012627995e-6*std::sin(1.22023987770081*x_19 - 3.59943985939026) + 1.98568991160031e-7*std::sin(0.515839874744415*x_2 + 2.30847978591919) + 2.90602256927991e-7*std::sin(1.23471987247467*x_29 + 9.79176044464111) + 3.81348915021275e-8*std::sin(1.61495983600616*x_29 - 5.39687967300415) + 2.14593220210631e-7*std::sin(1.68647980690002*x_29 - 5.62224006652832) - 5.19096696880252e-5*std::sin(0.206880003213882*x_31 - 4.59391975402832) + 1.20279377356916e-7*std::sin(0.523439884185791*x_31 - 1.49191975593567) - 0.000168050191585575*std::sin(0.326879858970642*x_35 - 7.79839992523193) + 4.67646111516504e-8*std::sin(0.644079804420471*x_43 + 7.57352018356323) - 1.68714643980437e-7*std::sin(1.2824798822403*x_46 - 2.21879982948303) + 1.40772254968735e-6*std::sin(1.68839979171753*x_46 + 1.82767987251282) - 1.77343396745535e-7*std::sin(2.20567989349365*x_47 + 2.80191993713379) - 4.26665311512418e-7*std::sin(0.438079863786697*x_49 - 4.16512012481689) - 4.78550557529098e-9*std::sin(1.76543986797333*x_49 - 7.3996000289917) + 5.79603808066921e-7*std::sin(1.74439990520477*x_51 - 9.60255908966064) - 3.61784180034915e-7*std::sin(1.6166398525238*x_66 - 6.19975996017456) - 1.06607791411989e-6*std::sin(1.43927991390228*x_70 - 8.60223960876465) + 1.17860991153162e-6*std::sin(1.52583992481232*x_72 + 0.823119878768921) - 4.69596680108504e-7*std::sin(1.63103985786438*x_72 + 0.196399986743927) - 6.82762213160797e-8*std::sin(1.44383978843689*x_75 + 7.18752002716064) - 1.63787717584637e-7*std::sin(1.9651198387146*x_75 + 6.40167999267578) - 9.20442772631182e-8*std::sin(1.62847983837128*x_78 - 6.5827202796936) - 3.57283020571229e-8*std::sin(1.61631989479065*x_80 - 0.393119841814041) - 1.00631102348055e-6*std::sin(1.33839976787567*x_87 + 4.78111982345581) + 4.73475879822337e-7*std::sin(1.35327982902527*x_87 + 4.78735971450806) - 1.89999644910954e-8*std::sin(1.04919981956482*x_89 - 1.59895980358124) - 0.000109541325555218*std::sin(0.238479986786842*x_91 - 8.02320003509521) - 2.39721963482431e-7*std::sin(0.456079840660095*x_92 - 1.59135985374451) - 0.000110838494820262*std::sin(0.401999861001968*x_95 - 1.40631985664368) - 2.55413168821648e-7*std::sin(1.0402398109436*x_96 + 0.18376000225544) + 0.0645706609785588);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
