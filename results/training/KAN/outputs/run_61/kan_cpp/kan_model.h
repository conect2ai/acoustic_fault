
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.53469347091463e-5*x_1 + 5.76655992298492e-5*x_10 + 0.000984097346353717*x_100 - 5.43715783506299e-7*x_101 - 1.22074262606776e-5*x_102 + 7.51998291380359e-5*x_103 + 8.8174548226479e-6*x_104 + 2.91559752188449e-6*x_105 + 3.34384535699857e-5*x_106 + 0.000511641922876479*x_107 + 1.19188414707583e-5*x_108 - 1.44863351895983e-5*x_109 + 2.41028649793282e-5*x_11 + 1.767902206782e-5*x_110 - 5.59708279013381e-6*x_111 - 0.000477478985962921*x_112 - 0.000993318260275265*x_113 + 0.000394701741417451*x_114 + 0.000255609719347709*x_115 - 0.00264314952706608*x_116 - 3.89895340232008e-5*x_117 + 1.87854189247924e-6*x_118 + 4.72349129327216e-5*x_119 - 4.32843424400017e-5*x_12 + 0.000841748236914464*x_120 - 1.54616945079811e-5*x_13 + 1.73145512447375e-5*x_14 - 0.00272018080426972*x_15 - 3.16944408312985e-5*x_16 + 0.00374034852137271*x_17 - 3.71277555819441e-5*x_18 - 0.00100692890426092*x_19 - 0.000810896624158017*x_2 - 0.00228132291854099*x_20 + 0.000374215051972493*x_21 - 3.65933683242302e-5*x_22 + 0.000656402151680578*x_23 - 0.00444275360131927*x_25 - 1.91586260597853e-5*x_26 + 8.26968205967916e-6*x_28 - 0.00759163729267237*x_29 - 0.00267144703995525*x_3 + 1.55634981886608e-5*x_30 - 0.0228323556280439*x_31 + 5.8461412837237e-5*x_32 - 0.000630389299124845*x_33 + 0.00186621751468339*x_34 - 2.09747975770664e-5*x_36 - 1.72704388436997e-5*x_37 - 6.59396321799639e-6*x_38 - 0.00162900772836448*x_39 + 2.25737030002824e-5*x_4 - 0.000898766651046198*x_40 - 9.80087542154128e-6*x_41 + 5.27487004584907e-5*x_42 - 4.43500136977886e-8*x_43 - 0.000210472514694447*x_44 - 0.00168463758604157*x_45 - 0.000280398936266496*x_46 + 0.000104771767566416*x_47 + 5.89015271503393e-5*x_48 - 5.41488692589601e-6*x_49 + 3.84472752782819e-5*x_5 - 1.26682953119348e-5*x_50 - 0.000336740766785789*x_51 - 0.00239424831721415*x_52 + 0.00011781342757286*x_53 + 3.26946190828913e-5*x_54 - 0.000336847699073284*x_55 + 0.00167533163451756*x_56 + 0.00110551711159986*x_57 - 4.76173557563623e-5*x_58 - 4.49017515303581e-5*x_59 - 2.30827303964004e-5*x_6 + 5.08792764784746e-7*x_60 - 0.000167751826532112*x_61 - 0.000521931750183994*x_62 - 0.00344170708785005*x_63 + 0.0008561001377134*x_64 + 0.00361252748112211*x_65 - 0.00171183207885097*x_66 - 4.17035226061227e-5*x_67 + 4.73471737872056e-5*x_68 - 0.000507061389212638*x_69 - 6.34805256385626e-5*x_7 + 4.53051816413066e-5*x_70 - 0.00191362193378406*x_71 - 0.00135260362871923*x_72 - 0.000664971052140637*x_73 - 7.93004778557426e-6*x_74 + 8.50955680378504e-6*x_75 + 4.47808538526996e-6*x_76 - 0.00139675028786939*x_77 - 0.000706149861972309*x_78 + 0.00327494657611364*x_79 + 3.30703925679182e-5*x_8 - 5.88434346423182e-6*x_80 + 0.00129098402079603*x_81 + 4.28460023393594e-6*x_82 - 0.00370496643754288*x_83 + 9.77974063121117e-8*x_84 + 1.4944826591398e-5*x_86 - 4.45208345707207e-6*x_87 - 2.01775578881001e-6*x_88 - 0.0061252048475639*x_89 - 0.00213827805903785*x_9 + 1.145684538734e-5*x_90 - 2.68564934172046e-5*x_91 - 7.4750091179972e-5*x_92 + 5.25123740162517e-5*x_93 - 0.00124844701251041*x_94 - 1.82271787648184e-5*x_95 - 0.000232310607134114*x_96 - 0.000306443271973026*x_97 + 0.00117823248131856*x_98 + 3.434633413455e-5*x_99 - 1.54254913260092e-9*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) - 1.42244527644655e-6*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 3.36414375848184e-6*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) + 0.000251768921827803*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) + 8.63251080940237e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 4.11102762442545e-6*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) - 2.5500115674443e-7*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 1.36287495735279e-6*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 1.62547195326961e-6*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) - 1.8681236726848e-8*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 7.92683035794495e-7*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) - 7.2860510162118e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) - 7.92586866638121e-9*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) - 7.33984778934904e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) - 8.18628637799986e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) + 2.22698822936042e-6*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) - 0.000146459148405941*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 3.18624723888183e-5*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) - 1.88657060712821e-5*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) - 7.20769392529643e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) + 2.29849893446308e-6*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 3.55756369991816e-7*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) - 2.37014024896461e-7*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 1.04330409240119e-6*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) - 1.11892102055379e-8*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 7.37502481580189e-7*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) + 6.73281637845711e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) + 2.60862532224971e-9*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) - 1.97324780611886e-7*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 2.11829120335735e-6*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) - 6.63995415614568e-9*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) + 1.18591087748704e-6*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) + 0.00506151498471799*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 2.37586521783568e-7*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) - 6.18573492254808e-10*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 4.84165054130723e-7*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) - 1.70742110302934e-7*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 1.21185691253757e-6*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) - 4.20177715234068e-5*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 3.30678501850313e-7*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) + 0.000344147903380868*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 1.11869624606433e-7*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) - 1.40397001957804e-9*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) - 2.94024786318086e-9*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) - 0.318065377275489*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.00608526546320697*std::sin(0.281999945640564*x_1 + 1.99319982528687) + 8.56703577591231e-6*std::sin(0.311839938163757*x_1 + 1.97727978229523) - 0.00061749565949078*std::sin(0.257359951734543*x_10 + 5.08655977249146) + 0.138860242877151*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.000720089611702119*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 0.00035706460816614*std::sin(0.441439867019653*x_100 - 7.36719989776611) + 0.0236440268767608*std::sin(0.31199985742569*x_101 + 5.1398401260376) + 0.000100436756170772*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.000342991310100961*std::sin(0.34487983584404*x_101 - 1.207279920578) + 0.0375455154010386*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.000617787240530985*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.000231929317107523*std::sin(0.400079846382141*x_102 - 1.17423987388611) + 0.0437002037963197*std::sin(0.306879937648773*x_104 + 5.10343980789185) + 4.40340249279472e-7*std::sin(0.499839842319489*x_104 + 5.27536010742188) + 0.000301172167116406*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 0.000192975040515162*std::sin(0.360079854726791*x_105 + 5.16247987747192) - 0.0270544846116394*std::sin(0.407039850950241*x_105 - 7.39559984207153) - 2.02423908711754e-6*std::sin(0.41143986582756*x_106 - 7.37631988525391) + 0.0197227966588237*std::sin(0.451839864253998*x_106 + 5.22064018249512) + 9.71051143694165e-5*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.00035728439288154*std::sin(0.363279849290848*x_107 + 5.16000032424927) - 0.0520423111809086*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.000819879325720462*std::sin(0.377119839191437*x_108 + 5.17655992507935) + 0.0387955263718862*std::sin(0.20440000295639*x_109 + 8.20039939880371) + 9.16414575380951e-7*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 0.00012101153338688*std::sin(0.508639812469482*x_109 + 5.28111982345581) + 0.000225083274663088*std::sin(0.264079958200455*x_11 + 8.28791999816895) - 0.0615864012239241*std::sin(0.291839927434921*x_11 + 8.31551933288574) + 8.16890608476328e-7*std::sin(0.426799863576889*x_110 - 7.36663961410522) + 0.0145093528810059*std::sin(0.436079859733582*x_110 - 1.15799987316132) - 0.00708821762119075*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.000399139125936173*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.000308842884402144*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.000382471021480407*std::sin(0.380559861660004*x_114 + 5.17543983459473) - 3.39647800193022e-7*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 0.000124867538629259*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 0.00015771800502339*std::sin(0.485599845647812*x_117 + 2.05175971984863) + 4.40628314791015e-5*std::sin(0.557679891586304*x_117 - 4.2129602432251) - 0.00582673829342547*std::sin(0.677919805049896*x_117 + 2.03951978683472) + 1.63522032764491e-6*std::sin(0.355519831180573*x_118 - 7.42095994949341) + 0.0214227671553985*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.000266687837222544*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.00068521688661675*std::sin(0.422559857368469*x_118 + 5.20847988128662) - 0.0165252460580135*std::sin(0.397839844226837*x_119 + 1.99255979061127) + 1.17668986417335e-6*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 0.000292621119627337*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.00289431673571654*std::sin(0.362559854984283*x_12 - 4.22640037536621) + 0.0574516565862162*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.000484507874610515*std::sin(0.491039842367172*x_120 - 7.3458399772644) + 5.54530058760046e-7*std::sin(0.461919873952866*x_14 + 2.24759984016418) - 6.12898866378953e-6*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.00435119764817042*std::sin(0.344959855079651*x_16 - 4.25424003601074) - 0.199159656513442*std::sin(0.345839828252792*x_16 - 4.24904012680054) + 6.0261008662405e-7*std::sin(0.503919839859009*x_16 - 1.2526398897171) - 1.26647629433865e-5*std::sin(0.161200016736984*x_18 + 4.95375967025757) + 0.0141507499203052*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 7.09294809830752e-5*std::sin(0.377439826726913*x_21 - 7.40695953369141) + 0.00448059032517832*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 0.000171579732135346*std::sin(0.394479840993881*x_23 - 4.21127986907959) + 0.000430966658261965*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.00334516608828191*std::sin(0.186080008745193*x_24 + 4.97135972976685) + 3.49989433241004e-6*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 0.000186724705021165*std::sin(0.341279864311218*x_24 - 1.07183980941772) - 2.66271540392935e-6*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.00095247549998684*std::sin(0.326319843530655*x_26 - 4.26119995117188) + 0.107173804863373*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.00053071248689165*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.00208346943372121*std::sin(0.188480004668236*x_27 - 7.59960031509399) + 5.24313332612242e-6*std::sin(0.21807998418808*x_27 - 4.38279962539673) - 0.00174982648090378*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.00107627581857182*std::sin(0.420319855213165*x_27 + 5.22671985626221) + 0.0167469173946748*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.00124209752559201*std::sin(0.334159851074219*x_28 + 8.32832050323486) + 0.000197482622084818*std::sin(0.340159833431244*x_28 + 8.32423973083496) - 3.31273738289092e-7*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.00329774585323264*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.00127125485520964*std::sin(0.323519825935364*x_3 + 8.31744003295898) - 7.40719405655857e-6*std::sin(0.334479838609695*x_3 + 8.32800006866455) + 0.0317646648509518*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 0.000114060647674716*std::sin(0.304079920053482*x_30 - 4.29239988327026) - 0.0397023229715927*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.000552164656048314*std::sin(0.302559942007065*x_34 + 2.05271983146667) + 0.0223961738044883*std::sin(0.244959965348244*x_35 + 2.04167985916138) - 1.93066741733019e-6*std::sin(0.302159935235977*x_35 - 1.13207995891571) + 0.000143368197253918*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.000472718955855247*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.000361062773706493*std::sin(0.321359843015671*x_35 + 1.95679974555969) + 0.0264013706889795*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 0.00025711293671285*std::sin(0.376719832420349*x_36 - 4.20711994171143) - 8.52141169876047e-7*std::sin(0.37951985001564*x_36 - 4.2116003036499) + 9.44596811591757e-5*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 0.000177686034762619*std::sin(0.408959865570068*x_37 + 5.21288013458252) - 0.0118407473734964*std::sin(0.413519859313965*x_37 - 7.38855981826782) - 0.000135736913626015*std::sin(0.424719840288162*x_37 - 7.38560009002686) + 1.79574326016932e-6*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.000654461785327126*std::sin(0.321839839220047*x_38 - 4.2836799621582) - 0.0129725192153293*std::sin(0.463599860668182*x_38 + 5.25464010238647) - 2.03368454961742e-6*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 0.000297587359578203*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 0.000149245943979739*std::sin(0.347359836101532*x_41 - 4.24991989135742) + 1.39619362499534e-6*std::sin(0.370639860630035*x_41 - 4.23487997055054) - 0.0182639954386195*std::sin(0.384719848632813*x_41 - 7.41767978668213) - 0.000173202389786119*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.000271093272678272*std::sin(0.245119974017143*x_42 + 5.04055976867676) - 0.000345584826956681*std::sin(0.293919950723648*x_42 - 1.09335994720459) - 0.0709768283943808*std::sin(0.356479853391647*x_42 - 7.42711973190308) - 0.0166210540423074*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.000262734884514599*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 0.000283660515201103*std::sin(0.392479836940765*x_43 - 7.40231990814209) - 0.000109466409514864*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.000506399545997293*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.000507765871436819*std::sin(0.391119837760925*x_44 - 1.01895976066589) - 0.000353704165680611*std::sin(0.338559836149216*x_45 - 4.26592016220093) - 3.10649445934591e-6*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.00143351144329613*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 0.000123708633362868*std::sin(0.442719846963882*x_46 - 7.3452000617981) - 2.23368421315029e-6*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 0.000224319026721302*std::sin(0.514399826526642*x_47 - 4.26032018661499) - 0.0227864550779311*std::sin(0.278799951076508*x_48 + 5.11183977127075) + 1.19730152102322e-6*std::sin(0.338479846715927*x_48 + 5.15136003494263) + 2.92584684827918e-6*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.000251712204411423*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 0.000274185804317864*std::sin(0.45023986697197*x_49 + 5.23031997680664) + 9.45751656191295e-7*std::sin(0.409279853105545*x_50 + 5.19200038909912) - 0.0171603945708879*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.000425035007042941*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.000756124586053975*std::sin(0.331839829683304*x_52 - 4.27472019195557) - 8.75321965467069e-7*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.000387291469442426*std::sin(0.308639854192734*x_53 + 5.103600025177) + 0.000147526397770384*std::sin(0.376719832420349*x_53 - 4.21767997741699) - 0.00380634208540031*std::sin(0.690639853477478*x_54 - 4.15112018585205) - 5.53565005723309e-5*std::sin(0.751919865608215*x_54 - 4.21736001968384) + 0.000102803995911871*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.000689686566343886*std::sin(0.31879985332489*x_55 - 4.28104019165039) + 6.986446731602e-7*std::sin(0.404239863157272*x_55 + 5.19928026199341) - 2.907950979335e-6*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 7.59299685251673e-5*std::sin(0.333999842405319*x_56 + 5.12904024124146) - 0.00271859167588283*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 0.000146182801040735*std::sin(0.486399859189987*x_58 + 8.26839923858643) - 3.70903367054392e-5*std::sin(0.54423987865448*x_58 - 4.2469596862793) + 0.0572881686447259*std::sin(0.329679846763611*x_59 - 4.2771201133728) - 0.000181739195662856*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 0.000208075504998518*std::sin(0.374399840831757*x_59 - 4.21688032150269) - 0.00053313771463325*std::sin(0.197759985923767*x_6 - 4.38903999328613) - 3.09589416487474e-6*std::sin(0.356479853391647*x_60 + 5.16247987747192) - 0.000852360801524172*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.000468721167174614*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.000334902471021872*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.00132515319474288*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 0.000204766255039269*std::sin(0.303039938211441*x_65 - 7.46543979644775) + 0.000145501377579366*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.000431684594425151*std::sin(0.225519984960556*x_66 + 5.03727960586548) - 8.57330665847439e-7*std::sin(0.404399842023849*x_66 - 1.00423979759216) + 0.000655299477066629*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 7.27549769153105e-5*std::sin(0.440319865942001*x_67 + 5.22703981399536) - 0.00511196528211449*std::sin(0.465839862823486*x_67 + 2.03639984130859) - 0.000605342441735507*std::sin(0.213760003447533*x_69 + 5.00463962554932) + 3.81173729799227e-6*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.000982692265706612*std::sin(0.196319997310638*x_70 - 7.60400009155273) + 0.0371708849199153*std::sin(0.225439995527267*x_70 - 4.37183952331543) - 8.57730025104456e-7*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.000888560858198625*std::sin(0.235279992222786*x_71 + 5.05199956893921) + 1.97574854628466e-6*std::sin(0.302239835262299*x_71 - 4.30936002731323) + 1.14643012576921e-6*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 0.000390042671615336*std::sin(0.302159935235977*x_74 + 8.32800006866455) + 0.000189101177513651*std::sin(0.369439840316772*x_74 + 5.16767978668213) - 0.00935865618260122*std::sin(0.417439848184586*x_74 - 4.18495988845825) - 2.10829233221769e-6*std::sin(0.302319914102554*x_75 - 7.47096014022827) + 0.0569737845218666*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.000541491881797698*std::sin(0.358239859342575*x_75 + 5.16095972061157) + 0.0428311885046271*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.0004757544498297*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.000871267596784994*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 0.000337463224489945*std::sin(0.310159921646118*x_77 - 7.46808004379272) - 1.43128618218811e-6*std::sin(0.324559837579727*x_77 + 8.30447959899902) + 3.15053946081484e-6*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 0.000384941509694165*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.000479382115166061*std::sin(0.270399957895279*x_79 - 4.30095958709717) + 0.000460833011292214*std::sin(0.295919924974442*x_79 + 5.10743999481201) + 0.0453698687773605*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.00159662224816509*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 0.0004529150343503*std::sin(0.31743985414505*x_80 - 4.30200004577637) + 4.27450947379017e-7*std::sin(0.361999839544296*x_80 - 4.24368000030518) + 0.0103444360895126*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 0.000218091553319189*std::sin(0.45551985502243*x_81 + 5.25024032592773) + 0.219894301157006*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.000611800179924917*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 9.97120186949617e-5*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.00187114445549953*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.00078137720084158*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.000708995804325027*std::sin(0.251039981842041*x_84 - 7.54536008834839) - 0.000210312935552804*std::sin(0.369279831647873*x_84 - 7.42456007003784) + 0.00920539565565659*std::sin(0.417599856853485*x_84 - 4.17431974411011) - 3.32299114723849e-6*std::sin(0.242399975657463*x_85 - 7.54536008834839) - 0.0293170051017768*std::sin(0.301359921693802*x_86 + 1.90327990055084) + 3.21433808864285e-7*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 0.000372221820657863*std::sin(0.278639942407608*x_87 - 4.27216005325317) + 0.0409348206063786*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 5.11749083629765e-5*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.00134605227086595*std::sin(0.255679965019226*x_88 - 7.52096033096313) - 0.000214665809565485*std::sin(0.347679853439331*x_89 - 4.2655200958252) - 0.00248493861142001*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 0.0209154657261323*std::sin(0.202159985899925*x_9 - 4.39911985397339) + 0.0603703349620874*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.000468467473918535*std::sin(0.274079948663712*x_90 + 5.08575963973999) + 0.0635340794898287*std::sin(0.188960000872612*x_91 + 2.00175976753235) - 5.6914829069015e-6*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.000636590316144123*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.000834906004565955*std::sin(0.36575984954834*x_92 - 7.4017596244812) - 0.000295853549179496*std::sin(0.375679850578308*x_92 - 1.1775997877121) + 0.0202758937908207*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 0.000146250089705982*std::sin(0.424639850854874*x_93 + 1.99519979953766) - 7.49100522181871e-7*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.000683844672784527*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.000235500408612307*std::sin(0.401119858026505*x_94 - 7.40488004684448) - 0.0233755568682074*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.000473523195554763*std::sin(0.384479850530624*x_95 - 7.396559715271) + 1.18598304025359e-6*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 0.00041633545620315*std::sin(0.314559936523438*x_96 + 5.12815999984741) - 2.47772340196142e-6*std::sin(0.403039842844009*x_96 - 7.38471984863281) - 0.000283714428368807*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.000725055764141629*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 0.000131080568116321*std::sin(0.352559864521027*x_98 - 1.01783978939056) - 0.000114532926601293*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 0.000297341493667698*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 0.000210616165569179*std::sin(0.473919868469238*x_99 + 5.23375988006592) + 0.006070969992547*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 0.141332603975697);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000206812779224641*x_1 - 0.000910166020575065*x_10 - 0.00247028214518685*x_100 + 0.0005383017691093*x_101 + 0.00187449999925975*x_102 - 0.00258185636503311*x_103 + 0.000408806712771957*x_104 - 0.00134786194299403*x_105 + 0.000391783616925017*x_106 - 0.000279807013154771*x_107 - 0.000865827385889793*x_108 - 0.000251566491330015*x_109 + 0.0147584023266587*x_11 + 0.000249771444372637*x_110 + 3.82719848063011e-5*x_111 + 0.000804246071449679*x_112 + 0.00112842604245471*x_113 + 0.000820509096742465*x_114 - 0.000294777379194382*x_115 + 0.00323828457121523*x_116 - 0.00266075471771612*x_117 - 3.81618480767002e-6*x_118 + 0.000714258460538106*x_119 - 0.00686868657638572*x_12 + 0.00010952021064376*x_120 - 0.00076836521860708*x_13 + 0.000107004503646103*x_14 + 0.00022345244172987*x_15 - 8.40303535146624e-5*x_16 - 0.000121308442156129*x_17 + 0.000205418380646782*x_18 - 0.000152642669717046*x_19 - 0.01190268456897*x_2 - 0.00358487547405349*x_20 + 0.0006506439125942*x_21 + 0.000112583134973604*x_22 - 0.00496640160525618*x_23 + 0.006635848824116*x_25 + 3.89200038593187e-5*x_26 + 0.000898912289406936*x_28 - 0.000986988059293008*x_29 + 3.39767361141413e-5*x_3 + 0.00278207666470268*x_30 + 0.0233212675506379*x_31 + 0.00113780519058099*x_32 - 0.00291907710335108*x_33 - 0.000343283047358554*x_34 - 0.000348264594728346*x_36 + 0.000189176843910891*x_37 + 3.0574750165637e-5*x_38 + 0.000189056189084306*x_39 - 0.00599103770291507*x_4 - 0.003030698491355*x_40 + 3.96824214105384e-5*x_41 + 0.00243105675351144*x_42 + 0.00140750391050921*x_43 + 0.000906856440747575*x_44 - 0.0041722484513706*x_45 + 3.7329151937888e-5*x_46 - 0.000127640440506741*x_47 + 0.000317455251965489*x_48 + 1.1000132232656e-5*x_49 + 0.00498916989280236*x_5 + 4.3748500828597e-5*x_50 - 0.000392057048224857*x_51 + 0.000157587357158473*x_52 - 0.000558980041557737*x_53 - 0.000876224986802237*x_54 + 0.000122108095062194*x_55 - 0.000164124427804305*x_56 + 0.00155228837492749*x_57 - 0.000999259936595747*x_58 - 0.00256111496436561*x_59 + 9.34588590813614e-5*x_6 + 0.000135523323100719*x_60 + 0.00360542175956406*x_61 - 0.000560408347720411*x_62 + 0.00112453264743788*x_63 - 0.000837141120692825*x_64 - 0.00180503955149704*x_65 + 0.000219942046664024*x_66 + 0.000168851932830692*x_67 - 0.00221109808564959*x_68 - 9.62252046368932e-6*x_69 + 0.000257024078095646*x_7 - 0.000192858030536583*x_70 + 9.33166046940893e-5*x_71 + 0.00535718889600248*x_72 - 0.00029321813273546*x_73 + 0.000802515965134618*x_74 + 0.000109744134783522*x_75 + 0.000660177162507509*x_76 + 0.000423965722252519*x_77 - 0.000238581561607976*x_78 - 0.00293722009465714*x_79 + 0.0073668091217306*x_8 - 0.0002808770944131*x_80 - 3.77162192947651e-5*x_81 - 0.00109121450620362*x_82 - 0.00183677688239639*x_83 - 0.00310372467435831*x_84 - 0.000419655459557672*x_86 + 0.000599861869372145*x_87 - 0.00130376887575827*x_88 + 0.000158348825889706*x_89 + 0.00235271620545245*x_9 - 8.09243322886205e-5*x_90 - 0.000596760359041231*x_91 - 0.00103283165265751*x_92 - 0.00509845271053925*x_93 + 4.37065140456413e-5*x_94 + 7.14208684593345e-5*x_95 + 0.000130509296803295*x_96 + 0.00564061921738526*x_97 - 0.00126519284038721*x_98 + 0.000199712679655612*x_99 + 4.89547523273178e-5*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 2.889642267468e-6*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) + 1.36209639004589e-5*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) - 5.9215522750385e-6*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) - 2.03034845014243e-6*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) + 1.66449958402961e-5*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 5.18024934233471e-7*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 2.26291144381221e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) + 6.58131649126828e-6*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 0.000592872731119313*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 1.3161673441409e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) + 1.71366392872764e-6*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 0.000251537490340623*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) + 1.72631681702092e-6*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) + 1.92539739908472e-6*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 4.52403999174543e-6*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) + 3.44468847523828e-6*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) + 0.000129006849095925*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) + 4.43717452875359e-7*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) + 1.69523450516707e-6*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 4.66931120847533e-6*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 5.90696275194071e-6*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 4.81484775312029e-7*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) - 4.22419741842741e-6*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 0.000355103771266467*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 1.22454580033472e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) - 1.58354430141053e-6*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 8.27880317498729e-5*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 4.00857618859954e-7*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 3.51720117795316e-5*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 0.000210727363108863*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 2.40913183359667e-6*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) - 0.000119045771635776*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 3.94487591204895e-6*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 1.96312139883149e-5*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 8.03905476269428e-6*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 3.46855957791625e-7*std::pow(-6.0*x_85 - 9.9902400970459, 2) + 4.9066450316157e-6*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) + 9.88249180042368e-7*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 5.49057095827206e-6*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) - 8.09428656015184e-6*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 1.85747821083005e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 4.45567684884915e-5*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 9.33124935088751e-5*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) + 0.00748083101259347*std::sin(0.276799947023392*x_1 + 5.19144010543823) - 0.024638418316718*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.27188574141681*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.00125441842100252*std::sin(0.257359951734543*x_10 + 5.08655977249146) - 0.00326596380979849*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.0119563354957825*std::sin(0.309999853372574*x_10 + 8.29687976837158) + 0.00144570639280805*std::sin(0.441439867019653*x_100 - 7.36719989776611) - 0.000556102556767961*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.00020403336468835*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.00569501227216909*std::sin(0.34487983584404*x_101 - 1.207279920578) - 0.000883062653350733*std::sin(0.30991992354393*x_102 + 8.30463981628418) - 0.00250133713228536*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.00385094394028334*std::sin(0.400079846382141*x_102 - 1.17423987388611) - 0.00102781963449297*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.0139747560629584*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.000611819546449315*std::sin(0.332959830760956*x_105 + 5.14432001113892) + 0.000781329886369897*std::sin(0.360079854726791*x_105 + 5.16247987747192) + 0.000636315807920165*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.0642417937080728*std::sin(0.41143986582756*x_106 - 7.37631988525391) - 0.000463876043863179*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.000197265263919433*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.00593233397521331*std::sin(0.363279849290848*x_107 + 5.16000032424927) + 0.00122402425181907*std::sin(0.343119859695435*x_108 + 5.14359998703003) - 0.00331958070169114*std::sin(0.377119839191437*x_108 + 5.17655992507935) - 0.000912462649404687*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.0290835783566093*std::sin(0.30583992600441*x_109 + 5.09887981414795) - 0.00048995936147084*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.000457247920138884*std::sin(0.264079958200455*x_11 + 8.28791999816895) + 0.00144849924935687*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.0259250590929584*std::sin(0.426799863576889*x_110 - 7.36663961410522) - 0.000341256938855306*std::sin(0.436079859733582*x_110 - 1.15799987316132) + 0.00016671339288428*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.0066272880786404*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.00512801334915624*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.00635053162261986*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 0.0107791535358955*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 0.00207329499012631*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 0.00261874265527556*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 8.95119287712824e-5*std::sin(0.557679891586304*x_117 - 4.2129602432251) + 0.000137043663479188*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.051895790188203*std::sin(0.355519831180573*x_118 - 7.42095994949341) - 0.00050385899365861*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.0044280728435177*std::sin(0.376959830522537*x_118 - 7.41655969619751) + 0.00277435066591907*std::sin(0.422559857368469*x_118 + 5.20847988128662) + 0.000388670323882661*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.0373437446167717*std::sin(0.434239864349365*x_119 - 1.16887986660004) + 0.00118478340793454*std::sin(0.46375983953476*x_119 + 8.23847961425781) - 0.0117186977144758*std::sin(0.362559854984283*x_12 - 4.22640037536621) - 0.00135125092204796*std::sin(0.403199851512909*x_12 + 8.3887996673584) + 0.00196170697310988*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.0175987144337362*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.194511225419995*std::sin(0.336239844560623*x_15 - 1.06783974170685) - 0.0176174118421851*std::sin(0.344959855079651*x_16 - 4.25424003601074) + 0.00468419338082426*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.0191245950726265*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.401932308070009*std::sin(0.161200016736984*x_18 + 4.95375967025757) - 0.000332822672376517*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 0.00117770990914695*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.00910214501832186*std::sin(0.112320065498352*x_23 - 4.53903961181641) + 0.000694703171222573*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.000875492008166545*std::sin(0.179120019078255*x_24 - 4.42608022689819) - 0.0135441258759077*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.111073583715303*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 0.003100368596218*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.0845046490659946*std::sin(0.318239837884903*x_26 - 4.27447986602783) + 0.00385644471009378*std::sin(0.326319843530655*x_26 - 4.26119995117188) - 0.00252070542863624*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.00881192624078921*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.0345938326840958*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.166397483214452*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.00355470445413957*std::sin(0.234879985451698*x_27 + 5.03936004638672) - 0.00435769548633061*std::sin(0.420319855213165*x_27 + 5.22671985626221) - 0.00039388398726251*std::sin(0.277679949998856*x_28 - 4.29263973236084) + 0.0050290851912265*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.000401178267674568*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 0.0105133920649533*std::sin(0.647999823093414*x_29 - 0.774399816989899) - 0.0133521277461818*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.0211078583866816*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.235076694035534*std::sin(0.334479838609695*x_3 + 8.32800006866455) - 0.000747098259977602*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 0.00189385785922057*std::sin(0.304079920053482*x_30 - 4.29239988327026) + 0.000933790315381116*std::sin(0.253279983997345*x_32 + 5.17439985275269) + 0.00223564014711947*std::sin(0.302559942007065*x_34 + 2.05271983146667) - 0.000526753314036237*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.0612721781396084*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.000291246917864244*std::sin(0.309599906206131*x_35 + 8.26696014404297) - 0.0019139752326377*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.00599507004033607*std::sin(0.321359843015671*x_35 + 1.95679974555969) - 0.00062095470534043*std::sin(0.360319852828979*x_36 - 4.23935985565186) + 0.00104101556911086*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.0270437803487361*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.000191891169220217*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 0.00295029092214702*std::sin(0.408959865570068*x_37 + 5.21288013458252) + 0.000278491896611605*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.000275744261915811*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.0569901889587221*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.0108666540210788*std::sin(0.321839839220047*x_38 - 4.2836799621582) + 0.00030511093313198*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.0645415574352218*std::sin(0.297759920358658*x_39 - 4.29871988296509) - 0.0012048910430263*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 0.00247807293510114*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.0443099747476959*std::sin(0.370639860630035*x_41 - 4.23487997055054) + 0.000429565344903132*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.000351853919894009*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.00450122049550117*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.000702042137933285*std::sin(0.293919950723648*x_42 - 1.09335994720459) + 0.00166936012833713*std::sin(0.356479853391647*x_42 - 7.42711973190308) + 0.000390923707593581*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.00436243819470859*std::sin(0.310479938983917*x_43 + 5.12063980102539) + 0.00114850313034286*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.000222376754339764*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.00840823526469675*std::sin(0.379759848117828*x_44 + 8.3834400177002) + 0.002055875462304*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.000718536258831326*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.0985885400013439*std::sin(0.250719964504242*x_46 + 5.04783964157104) - 0.00580409430209454*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 0.00205405257925462*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.0708888003118811*std::sin(0.401119828224182*x_47 + 2.01015996932983) - 0.000908237454910599*std::sin(0.514399826526642*x_47 - 4.26032018661499) + 0.000535932647791499*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.0379978816778324*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.0928554590437331*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.00417941811049332*std::sin(0.409519851207733*x_49 - 4.18383979797363) - 0.00111014130511393*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.0300146278089242*std::sin(0.409279853105545*x_50 + 5.19200038909912) + 0.000403608883789476*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.00705726212275908*std::sin(0.34775984287262*x_51 - 4.25008010864258) + 0.0030614463680168*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.0277794522848353*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.0064305701235748*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.000299694140522259*std::sin(0.376719832420349*x_53 - 4.21767997741699) + 8.95243681060556e-5*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 0.000112454578381057*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.000208842320172527*std::sin(0.316559910774231*x_55 - 1.30199980735779) + 0.00279244779570327*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.022172374426537*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.0922875109548659*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 0.00126073777918442*std::sin(0.333999842405319*x_56 + 5.12904024124146) + 6.39407064476174e-5*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 0.00242721264763817*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 7.53475767633046e-5*std::sin(0.54423987865448*x_58 - 4.2469596862793) - 0.00134740571992831*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.000369196109079813*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 0.00345487631787387*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.00108304853627416*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.0982521262175198*std::sin(0.356479853391647*x_60 + 5.16247987747192) + 2.00473474119701e-5*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.00778262515892635*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.00556070555224241*std::sin(0.193680003285408*x_64 - 4.40383958816528) + 0.00536536638265307*std::sin(0.247039973735809*x_64 + 5.06735944747925) + 0.000829070922100163*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.000295580390746901*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.00716767157230286*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.0272084755824981*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.00133121540641044*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 0.0012080203614258*std::sin(0.440319865942001*x_67 + 5.22703981399536) + 0.000120232352057044*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.00122972963170927*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.120970315574569*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.016316578141054*std::sin(0.196319997310638*x_70 - 7.60400009155273) - 0.000874251422950691*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.027221149754817*std::sin(0.350559860467911*x_70 - 7.45039987564087) - 0.00359766295431622*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.0627028849196774*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.036383413455996*std::sin(0.320959836244583*x_73 - 4.27807998657227) - 0.0015792301194966*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.000384151688939821*std::sin(0.369439840316772*x_74 + 5.16767978668213) + 0.000220113632004542*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.0669093300018744*std::sin(0.302319914102554*x_75 - 7.47096014022827) - 0.00134001147124806*std::sin(0.316879838705063*x_75 + 5.1080002784729) + 0.00219242752506107*std::sin(0.358239859342575*x_75 + 5.16095972061157) - 0.00100738057696273*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.00789940546750781*std::sin(0.32399994134903*x_76 + 5.15583992004395) - 0.00352764487353641*std::sin(0.34607982635498*x_76 + 8.3244800567627) - 0.00136634303659613*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.0454236815396523*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.0999863639620836*std::sin(0.325119853019714*x_78 + 8.30047988891602) - 0.00155857620356228*std::sin(0.38487982749939*x_78 + 5.18024015426636) + 0.00194095346512458*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.000936164342997539*std::sin(0.295919924974442*x_79 + 5.10743999481201) - 0.00106708980491455*std::sin(0.221119999885559*x_8 + 8.23999977111816) - 0.00646450793016659*std::sin(0.226959988474846*x_8 + 8.22976016998291) + 0.00183379182810087*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.0135656977264211*std::sin(0.361999839544296*x_80 - 4.24368000030518) - 0.000243298968812914*std::sin(0.478479862213135*x_80 + 5.2771201133728) + 0.000883023255848096*std::sin(0.45551985502243*x_81 + 5.25024032592773) - 0.00517186787722294*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.0101583026455162*std::sin(0.324479848146439*x_82 - 7.46504020690918) - 0.000403720502033144*std::sin(0.453759849071503*x_82 + 5.2655200958252) + 0.0075760112856784*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.0129739518668157*std::sin(0.162400022149086*x_84 - 4.45423984527588) + 0.00287062829343717*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.000427242550579406*std::sin(0.369279831647873*x_84 - 7.42456007003784) - 0.000216508976531523*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.105459336860563*std::sin(0.242399975657463*x_85 - 7.54536008834839) + 0.000689529815663573*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 0.0102011094298469*std::sin(0.411919862031937*x_86 - 3.99207997322083) - 0.00150707589988123*std::sin(0.278639942407608*x_87 - 4.27216005325317) - 0.000962778401441388*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 0.00084970587467214*std::sin(0.3503198325634*x_87 + 5.3318395614624) + 0.00544998392038685*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.000436085244875125*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.00504805616252632*std::sin(0.189520001411438*x_9 - 4.41287994384766) - 0.0846838970239182*std::sin(0.202159985899925*x_9 - 4.39911985397339) - 0.00141989762574464*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.00777841284752315*std::sin(0.274079948663712*x_90 + 5.08575963973999) - 0.00149430823397173*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.180626425566576*std::sin(0.193920001387596*x_91 - 7.38560009002686) - 0.00257746824692588*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.0138627417141011*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.000601014980924377*std::sin(0.375679850578308*x_92 - 1.1775997877121) - 0.000476884772488288*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 0.00242832990560675*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.023773654761871*std::sin(0.355199843645096*x_94 - 7.41871976852417) - 0.00276879475736871*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.00391023818286576*std::sin(0.401119858026505*x_94 - 7.40488004684448) + 0.000549788198433391*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.00786235782197313*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.0376386753413284*std::sin(0.397999823093414*x_95 - 7.40655994415283) - 0.00168568605462429*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.0786336933554271*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.000576354829025882*std::sin(0.368239849805832*x_97 + 5.17176008224487) + 0.002935652902553*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 0.00217645585203195*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.000232669186789865*std::sin(0.413679867982864*x_98 - 7.38263988494873) + 0.00120389556514789*std::sin(0.454479843378067*x_98 - 1.14039981365204) + 0.000852756420066152*std::sin(0.473919868469238*x_99 + 5.23375988006592) - 0.000142787941855845*std::sin(0.621439814567566*x_99 - 7.38647985458374) + 1.07079201868136);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000286847287891748*x_1 + 0.0016359204605704*x_10 - 0.000688092042920106*x_100 + 2.36677481289747e-5*x_101 + 0.000140737868211262*x_102 + 0.00133157452173634*x_103 - 0.000540500227772915*x_104 - 0.000159952806027798*x_105 - 0.000286549233809339*x_106 + 0.000710543789944559*x_107 - 0.000330728477476398*x_108 + 0.00030564074841476*x_109 + 0.00116090150280736*x_11 - 0.00014774244535153*x_110 + 9.61568971169692e-9*x_111 - 0.000165996035787346*x_112 + 0.000877105197865701*x_113 + 0.00044391607873727*x_114 + 0.00184465864701331*x_115 + 0.000875992116223647*x_116 - 0.00134787177977051*x_117 - 9.19340224745919e-7*x_118 - 0.000883952262257579*x_119 - 0.000276270743845532*x_12 - 0.000395973353621805*x_120 + 0.000276768749811625*x_13 - 0.00015953511445303*x_14 + 0.000947939799409119*x_15 + 0.000173200277654157*x_16 - 0.00192057045659871*x_17 - 0.0012234183825189*x_18 - 0.00265651673922734*x_19 - 0.0139180455375469*x_2 + 0.00224767548264445*x_20 - 0.000269981054440488*x_21 - 0.000545596212268963*x_22 + 0.000141517358992651*x_23 + 0.00345024797799089*x_25 + 9.37604620804097e-6*x_26 - 0.000112804053763733*x_28 + 0.00960640444792409*x_29 + 0.00137235217619049*x_3 + 0.000844695591770281*x_30 + 0.0151431823795172*x_31 + 0.000274684526891645*x_32 - 0.000519797536557527*x_33 - 0.000370783889966681*x_34 + 0.000425560471740125*x_36 - 0.000496102227123222*x_37 - 0.000249894226622465*x_38 + 0.000688935130016098*x_39 - 0.000917555971716299*x_4 - 0.000268241692364638*x_40 - 0.000286529437522748*x_41 + 0.00173728209643115*x_42 + 0.00010256165264115*x_43 + 0.000174197633299775*x_44 + 0.00184576687399372*x_45 + 0.000143637305460206*x_46 + 7.66899278101285e-5*x_47 + 8.87950294202001e-5*x_48 + 2.6499932651792e-6*x_49 - 0.000467695210164788*x_5 - 0.000259209406212455*x_50 + 0.000720475451181064*x_51 + 0.00110919098690965*x_52 - 0.000164892057397624*x_53 - 2.85020266296242e-5*x_54 + 3.71943542366072e-5*x_55 + 3.86689741419404e-5*x_56 - 0.000653290965169391*x_57 - 0.00148006929060211*x_58 - 0.00151512928585317*x_59 - 0.000674825612254315*x_6 - 0.000571309267854873*x_60 - 5.74333687351076e-5*x_61 - 0.00151531501803006*x_62 + 0.00351755543693341*x_63 - 0.000498586605816154*x_64 - 0.00143138128055928*x_65 - 0.000216973088793512*x_66 - 0.00121920607712106*x_67 - 0.000275987410148953*x_68 - 0.000400023307911562*x_69 - 0.00185585863737113*x_7 + 0.00146334646800964*x_70 + 0.000913212821213877*x_71 + 0.0017553608559792*x_72 + 0.000753355650680586*x_73 + 0.000228333334013025*x_74 - 0.000139132265852964*x_75 + 4.65697800302164e-5*x_76 + 0.000258786305146793*x_77 + 0.000735529170082604*x_78 - 0.0020505292477528*x_79 - 0.000163686952145883*x_8 + 0.000314006512417008*x_80 - 0.000662936333293335*x_81 - 8.096530981302e-5*x_82 + 0.00229651833531383*x_83 - 0.00022616145473453*x_84 + 0.00116899367603266*x_86 + 4.52240069265959e-5*x_87 - 9.4299858965887e-5*x_88 + 0.00304021590935423*x_89 + 0.000836166825256873*x_9 + 0.000843812488373474*x_90 + 0.000952370180405678*x_91 - 3.69813188654251e-5*x_92 + 0.00106487890686585*x_93 + 0.000641005911152091*x_94 - 0.000497828007410802*x_95 - 1.99402530044654e-5*x_96 - 7.33841376327595e-5*x_97 - 0.000695270370377359*x_98 - 0.000743133155057253*x_99 + 3.56722298662134e-6*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 6.96130954211125e-7*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 9.83510326786585e-5*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) - 0.000129303744168714*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) - 4.43349386067617e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 0.000120186246860984*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 1.2479509862966e-7*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) - 2.76515521850855e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 4.75208126261544e-5*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 4.32013059824964e-5*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) - 1.6082852071094e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) + 3.74197764267667e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 1.832897267135e-5*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) + 3.76960664525706e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) + 4.20432145408596e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 1.08986649032601e-6*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) + 7.52186414397959e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 0.000931502125982182*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) + 9.68906890371341e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) + 3.70173492660207e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 1.12486313744047e-6*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) + 7.21798854468119e-6*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 1.15992370353091e-7*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 3.05010850463279e-5*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 2.58756152421754e-5*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) + 1.4963286430661e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) - 3.45784682324841e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 6.03257816321312e-6*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 9.65688382473349e-8*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) + 4.29782933766837e-5*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 1.53552302453906e-5*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 5.80373308150548e-7*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) - 0.0025994981189049*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) - 4.82042469863265e-6*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 1.43048252652116e-6*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) + 9.82328950155101e-6*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 8.35595366214208e-8*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 3.54287412677714e-5*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) + 2.15795307068043e-5*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) - 6.70918032580219e-6*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) - 0.000176747837389535*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) - 2.2697377672411e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 3.24675176985868e-6*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 6.79947208308246e-6*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) + 0.163352346562791*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.177903260204393*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.0198117040820042*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.000302196400649158*std::sin(0.257359951734543*x_10 + 5.08655977249146) - 0.0713159876518557*std::sin(0.267119973897934*x_10 + 5.08279991149902) + 0.0146099943861283*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 0.0104388145891804*std::sin(0.441439867019653*x_100 - 7.36719989776611) - 0.0121431238621338*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 4.91527766085255e-5*std::sin(0.339919835329056*x_101 + 1.93815982341766) - 0.00695899653825138*std::sin(0.34487983584404*x_101 - 1.207279920578) - 0.0192826647659826*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.0180610632137019*std::sin(0.369759827852249*x_102 - 7.41752004623413) - 0.0047056449167624*std::sin(0.400079846382141*x_102 - 1.17423987388611) - 0.0224435960196259*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.00101830912608648*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.000147390744338736*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 0.00564164193876097*std::sin(0.360079854726791*x_105 + 5.16247987747192) + 0.0138946702851294*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.00468115540009268*std::sin(0.41143986582756*x_106 - 7.37631988525391) - 0.0101292543771877*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 4.75223033490823e-5*std::sin(0.505039870738983*x_106 + 5.25744009017944) - 0.00724899080534145*std::sin(0.363279849290848*x_107 + 5.16000032424927) + 0.0267279441879935*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.0239692427391625*std::sin(0.377119839191437*x_108 + 5.17655992507935) - 0.0199246466977046*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.00211925511446222*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 0.00353778260653122*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.000110153576635022*std::sin(0.264079958200455*x_11 + 8.28791999816895) + 0.031629607857544*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.00188910090092135*std::sin(0.426799863576889*x_110 - 7.36663961410522) - 0.00745172851104454*std::sin(0.436079859733582*x_110 - 1.15799987316132) + 0.00364037416234193*std::sin(0.605519831180573*x_111 + 8.21232032775879) + 0.00809818707900476*std::sin(0.326959848403931*x_112 + 8.33672046661377) + 0.00626615456463157*std::sin(0.345279842615128*x_113 - 4.24360036849976) - 0.00776000567967792*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 0.000785452738326084*std::sin(0.455279856920242*x_115 + 2.23247981071472) - 0.00253345418228004*std::sin(0.514239847660065*x_115 - 1.04975974559784) + 0.003199961686069*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 2.15639233583855e-5*std::sin(0.557679891586304*x_117 - 4.2129602432251) + 0.00299250229997186*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.00378152981819771*std::sin(0.355519831180573*x_118 - 7.42095994949341) - 0.0110023269891196*std::sin(0.374719828367233*x_118 - 7.42935991287231) - 0.00541086517754385*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.0200323747276558*std::sin(0.422559857368469*x_118 + 5.20847988128662) + 0.00848705302107094*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.00272115490060663*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 0.00855480364843903*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.0846155991815599*std::sin(0.362559854984283*x_12 - 4.22640037536621) - 0.0295060814152979*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.0141646294658913*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.00128237884328906*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.0141735966680991*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.127207638201416*std::sin(0.344959855079651*x_16 - 4.25424003601074) + 0.102284623088453*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.00139356634258426*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.0292879056731133*std::sin(0.161200016736984*x_18 + 4.95375967025757) - 0.0072675568303146*std::sin(0.418559849262238*x_18 + 5.21335983276367) - 0.00143909772080201*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.00219275754937116*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 0.00501614825457227*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.000210910912368131*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.0977962188549947*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.00809368288468568*std::sin(0.278879940509796*x_24 - 7.48816013336182) - 0.00378848249964645*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.00615766421631698*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.0278457033200928*std::sin(0.326319843530655*x_26 - 4.26119995117188) - 0.0550424339312196*std::sin(0.33111983537674*x_26 - 4.26255989074707) - 0.010767696586828*std::sin(0.343999862670898*x_26 + 5.15895986557007) - 0.0422717898379136*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.0121250113384253*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.000856348147816577*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.0314650163022093*std::sin(0.420319855213165*x_27 + 5.22671985626221) - 0.00860089921621329*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.0363128281963518*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 9.66460843368586e-5*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 0.000766087296095585*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.0964098841969701*std::sin(0.315759837627411*x_3 + 8.31560039520264) - 0.0257926596858536*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.0171295113695135*std::sin(0.334479838609695*x_3 + 8.32800006866455) - 0.0163137295408589*std::sin(0.280559957027435*x_30 + 8.27775955200195) - 0.00231419172714731*std::sin(0.304079920053482*x_30 - 4.29239988327026) + 0.0203903602364935*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.0161425813014349*std::sin(0.302559942007065*x_34 + 2.05271983146667) - 0.0115022501862016*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.00446476617507062*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 7.01630084548627e-5*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.0138199794101907*std::sin(0.313279837369919*x_35 + 5.1625599861145) - 0.0073256508789547*std::sin(0.321359843015671*x_35 + 1.95679974555969) - 0.0135592433589006*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 0.00751671886107595*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.00197061960931047*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 4.62276539341346e-5*std::sin(0.440559864044189*x_36 + 5.23559999465942) + 0.00360509571057268*std::sin(0.408959865570068*x_37 + 5.21288013458252) + 0.00608118332490663*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 6.6428332090357e-5*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.00415274722883243*std::sin(0.292959928512573*x_38 - 7.50207996368408) - 0.0132784626443413*std::sin(0.321839839220047*x_38 - 4.2836799621582) + 0.00666243988203563*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.00470299851045899*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 0.00869999210136*std::sin(0.312559843063354*x_39 - 1.05167984962463) - 0.00302807090709484*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.00322876846357547*std::sin(0.370639860630035*x_41 - 4.23487997055054) + 0.00938004173250992*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 8.476357359396e-5*std::sin(0.407439857721329*x_41 - 7.40343999862671) + 0.00550024764637922*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.000169125870312017*std::sin(0.293919950723648*x_42 - 1.09335994720459) + 0.036452353189528*std::sin(0.356479853391647*x_42 - 7.42711973190308) + 0.00853625818507817*std::sin(0.309359908103943*x_43 - 7.46832036972046) + 0.00533066319166158*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 0.00829283960587304*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 5.35718015810161e-5*std::sin(0.4336798787117*x_43 - 1.18711996078491) + 0.0102744080791141*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.0148445790073271*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.000173099396117926*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.00718392575574286*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.041908830575205*std::sin(0.287759929895401*x_46 + 5.09239959716797) + 0.00250994099841947*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.00516550786072391*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 0.00655798607651287*std::sin(0.514399826526642*x_47 - 4.26032018661499) + 0.0117026912476667*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.0027688204008836*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.00676616900682886*std::sin(0.202960014343262*x_49 + 5.00367975234985) - 0.00510702256164772*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 0.00801584561673424*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.00218709859951904*std::sin(0.409279853105545*x_50 + 5.19200038909912) + 0.00881325325349686*std::sin(0.41407984495163*x_50 - 1.16055989265442) - 0.00862359207227971*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.022105367431055*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.00202422637303218*std::sin(0.375039845705032*x_52 - 4.20832014083862) - 0.0078578083927281*std::sin(0.308639854192734*x_53 + 5.103600025177) - 7.21979915514071e-5*std::sin(0.376719832420349*x_53 - 4.21767997741699) + 0.00195486511860202*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 2.70909357310895e-5*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 5.03112808315734e-5*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.0201630461996457*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.00161565118731449*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.00672478390361623*std::sin(0.234799981117249*x_56 + 5.04367971420288) - 0.00154055328095817*std::sin(0.333999842405319*x_56 + 5.12904024124146) + 0.00139621713436885*std::sin(0.440479874610901*x_58 + 5.2324800491333) - 0.00296592239055539*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 1.81516518844719e-5*std::sin(0.54423987865448*x_58 - 4.2469596862793) - 0.0294221171086326*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 8.8941403784893e-5*std::sin(0.3572798371315*x_59 + 5.15119981765747) + 0.0042216717343462*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.000260912438713088*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.00715941203796016*std::sin(0.356479853391647*x_60 + 5.16247987747192) + 0.000437756345062724*std::sin(1.10423994064331*x_60 - 3.81703996658325) - 0.00950994641471575*std::sin(0.319679856300354*x_62 + 8.32096004486084) + 0.00679488100094146*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.0387409678411606*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 0.00598635911146137*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 7.12069662647321e-5*std::sin(0.312959939241409*x_65 + 5.13624000549316) + 0.00875850643952703*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.00198262058154979*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.000320697223167716*std::sin(0.23463998734951*x_67 - 4.35623979568481) + 0.00147613545178498*std::sin(0.440319865942001*x_67 + 5.22703981399536) + 0.00262540843500124*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.000296248733478546*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.00881483553488715*std::sin(0.237919986248016*x_69 + 5.03039979934692) + 0.0199379747352951*std::sin(0.196319997310638*x_70 - 7.60400009155273) - 0.01909026165468*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.00198354412005592*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.0259771532596773*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.00456901856876784*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.0026511777231391*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 0.0114029311159469*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 9.25442864655406e-5*std::sin(0.369439840316772*x_74 + 5.16767978668213) + 0.00480642835506789*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.00487553278599533*std::sin(0.302319914102554*x_75 - 7.47096014022827) - 0.0292606553845335*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.0158305618265097*std::sin(0.358239859342575*x_75 + 5.16095972061157) - 0.0219972862442178*std::sin(0.285439938306808*x_76 + 5.11615991592407) - 0.00965264562664295*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.0254715832720321*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 0.00986576644829051*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.0033099217792344*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.00728578205215841*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 0.0112537982075974*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.0140147774468289*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.000225527216543778*std::sin(0.295919924974442*x_79 + 5.10743999481201) - 0.0233011042934375*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.0466773890113489*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 0.0132410100584239*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.000988501962704088*std::sin(0.361999839544296*x_80 - 4.24368000030518) - 0.00531270622274335*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 0.00637592535496005*std::sin(0.45551985502243*x_81 + 5.25024032592773) - 0.112933543403782*std::sin(0.15504002571106*x_82 - 7.66024017333984) - 0.0124128956297635*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 0.00291508945906305*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.0547030693992617*std::sin(0.168000012636185*x_83 - 7.6276798248291) + 0.0158534664744845*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.0207275534359656*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.000102925115597456*std::sin(0.369279831647873*x_84 - 7.42456007003784) - 0.00472771665457944*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.0076845853102788*std::sin(0.242399975657463*x_85 - 7.54536008834839) + 0.0150566579065932*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 0.000743331960988873*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 0.0108819370025233*std::sin(0.278639942407608*x_87 - 4.27216005325317) - 0.0210233476509049*std::sin(0.310479938983917*x_87 + 5.13271999359131) - 0.00103829455632115*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.0393519541325611*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.000105055370019319*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.00121610491128716*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 0.61146544285863*std::sin(0.202159985899925*x_9 - 4.39911985397339) - 0.0310050592847052*std::sin(0.185840010643005*x_90 - 4.4215202331543) - 0.00950479919833201*std::sin(0.274079948663712*x_90 + 5.08575963973999) - 0.0326298984827298*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.0131618424492117*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.0186107727495754*std::sin(0.340719848871231*x_92 + 5.18991994857788) - 0.0169395195284381*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.000144787864185234*std::sin(0.375679850578308*x_92 - 1.1775997877121) - 0.0104133145762663*std::sin(0.332239836454391*x_93 - 4.21600008010864) - 0.00296728761927906*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.00173233289335268*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.0199922579380225*std::sin(0.380479842424393*x_94 + 5.18048000335693) + 0.0047780992696504*std::sin(0.401119858026505*x_94 - 7.40488004684448) + 0.0120052427565114*std::sin(0.381519854068756*x_95 + 5.17264032363892) + 0.00960737541040723*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.00274264584091546*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 0.0121716029391082*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.00572986084343615*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.000138847095922894*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.021197067745144*std::sin(0.371759831905365*x_97 + 5.18296003341675) - 0.00265951116803803*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 5.60513060177091e-5*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 0.00869280419027928*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 0.00615738174990951*std::sin(0.473919868469238*x_99 + 5.23375988006592) - 0.00311793506948065*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 0.661251926230097);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00080157333338321*x_1 + 0.000442486037652596*x_10 + 0.00161507949806421*x_100 - 0.000325189276747778*x_101 - 0.00108060457255488*x_102 - 0.000530062513043221*x_103 + 0.00140143718031106*x_104 + 0.00101959202597415*x_105 + 0.00155073581482114*x_106 + 0.000163634930724238*x_107 + 0.00140728002910524*x_108 - 0.000915399204659575*x_109 - 0.00807989430917404*x_11 + 0.000985261293338785*x_110 + 0.000120924074684618*x_111 - 0.00057284988423307*x_112 - 0.000846249084554356*x_113 - 0.000506429823110432*x_114 + 3.50992201097773e-5*x_115 - 0.00225928071681939*x_116 + 0.00168620845073118*x_117 - 6.23127574621953e-6*x_118 + 0.00262131223848214*x_119 + 0.00361583902388452*x_12 - 6.12429197103797e-5*x_120 - 0.000627753860540211*x_13 + 0.000430055272829021*x_14 - 8.22851808756171e-5*x_15 - 0.00040374446370534*x_16 + 0.000637130412600278*x_17 + 0.000136934918028407*x_18 - 0.000917708987627006*x_19 + 0.0192293032782855*x_2 + 0.00147234454865952*x_20 - 0.000315648036292244*x_21 + 4.78458897750241e-5*x_22 + 0.000303852051781582*x_23 - 0.00329089221722714*x_25 + 6.35507157839703e-5*x_26 + 4.11630913782627e-5*x_28 - 0.00367662801404826*x_29 - 0.000546930458305726*x_3 - 0.00169943338804069*x_30 - 0.0210519011340679*x_31 + 0.00150955680547989*x_32 + 0.00220912763188161*x_33 - 0.00151677547137516*x_34 - 0.00127062080586163*x_36 - 8.19730277551089e-5*x_37 - 1.11595774759162e-5*x_38 + 0.00019404843120313*x_39 + 0.00521072627471857*x_4 + 0.00115897580586424*x_40 - 5.50769032632881e-6*x_41 - 0.00157303680729436*x_42 - 0.000852881657387135*x_43 - 0.000596640667139506*x_44 + 0.000280582204783867*x_45 + 1.49472460969067e-6*x_46 - 0.000405712058602412*x_47 + 0.00153118054341303*x_48 + 1.79616189050359e-5*x_49 - 0.000295177990516932*x_5 + 7.38590539338553e-6*x_50 + 0.000179748472288712*x_51 - 7.72220705329603e-5*x_52 + 0.000363319677897158*x_53 + 0.00178975143036998*x_54 + 0.000352116515671614*x_55 + 0.000317436367900492*x_56 + 9.25053978108667e-8*x_57 + 0.000695642444708356*x_58 + 0.00163700964712241*x_59 - 1.29715485037272e-5*x_6 + 0.000299787514725678*x_60 - 0.000725053989238503*x_61 + 0.000360979668416995*x_62 - 0.00328148802474797*x_63 + 0.000637302717692727*x_64 - 0.000130436775340974*x_65 - 0.000277263580894371*x_66 - 2.34356706061932e-5*x_67 + 0.00195338230200101*x_68 - 0.000584708001503906*x_69 - 3.56734538428401e-5*x_7 + 4.35789842521388e-5*x_70 - 0.0001608070141771*x_71 - 0.00335830142321206*x_72 - 0.00119580726236742*x_73 - 0.00104438495226871*x_74 + 0.000407326125863415*x_75 - 0.000420499020634915*x_76 + 0.00115033378886628*x_77 - 0.00116934259118951*x_78 + 0.00287983890625267*x_79 - 0.00216638330780604*x_8 - 0.000984514952382492*x_80 + 0.000227152008679505*x_81 + 0.000641893603855484*x_82 - 0.00123308454602365*x_83 + 0.00188071224852397*x_84 - 0.0010858148586614*x_86 - 0.00034332465556394*x_87 + 0.00079938736652802*x_88 - 0.00113993911676103*x_89 - 0.000349661358008656*x_9 + 7.28458241557204e-5*x_90 - 0.00204733157413533*x_91 + 0.000613012322134482*x_92 + 0.00298063010678244*x_93 - 0.000207049094886249*x_94 - 5.66954225932965e-6*x_95 + 0.000395810205452552*x_96 - 0.0013176509940582*x_97 + 0.000968868800857627*x_98 + 0.00237375797250584*x_99 - 2.96642943512633e-5*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 4.71836629618517e-6*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 1.89051092254941e-6*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) + 4.68009210149584e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) + 1.60468358691203e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 2.31022904633124e-6*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 8.45859509250765e-7*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 8.25608576310487e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 9.13448622463354e-7*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) - 0.000359253195505325*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 4.80195126571953e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) - 1.35439233581779e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) - 0.000152419975571575*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) - 1.36439253168064e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) - 1.52173564314916e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 7.38710049335956e-6*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) - 2.72250561614296e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 1.79054036910936e-5*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) - 3.50691583903026e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) - 1.33982666188048e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 7.62430729938568e-6*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 2.15511708214842e-5*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 7.86194734737603e-7*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 5.86294143123967e-7*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) - 0.00021517630659555*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 4.46767600033945e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) + 1.25155243645164e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) + 5.01656821010929e-5*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 6.54542293934241e-7*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 0.000128322805784903*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) - 0.000127690943778683*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 3.93376251956254e-6*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) + 0.000940876901311239*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 1.43926241319523e-5*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) - 1.1895599150995e-5*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 2.93299703603464e-5*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 5.66365421526404e-7*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 6.81013920390007e-7*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) - 7.81061614759781e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 2.00319923450212e-5*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) + 6.39731017103354e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 6.77688888517731e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) - 2.69993214743759e-5*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) - 5.65430145696598e-5*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) - 0.059124662771699*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.00341966980328959*std::sin(0.281999945640564*x_1 + 1.99319982528687) + 0.164750065721384*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.00204828316141651*std::sin(0.257359951734543*x_10 + 5.08655977249146) + 0.0258125078021199*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.0436219152700643*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 0.000200655676527492*std::sin(0.441439867019653*x_100 - 7.36719989776611) + 0.00439515022863571*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.000333156862384326*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.0207778832307079*std::sin(0.34487983584404*x_101 - 1.207279920578) + 0.00697927563097609*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.00034717111095233*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.0140499194198811*std::sin(0.400079846382141*x_102 - 1.17423987388611) + 0.00812336078401273*std::sin(0.306879937648773*x_104 + 5.10343980789185) + 0.00846804973227025*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.000999012493627195*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 0.000108444064244735*std::sin(0.360079854726791*x_105 + 5.16247987747192) - 0.00502911474624236*std::sin(0.407039850950241*x_105 - 7.39559984207153) - 0.0389275277192239*std::sin(0.41143986582756*x_106 - 7.37631988525391) + 0.00366623903348567*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.000322105536441054*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.0216437360855056*std::sin(0.363279849290848*x_107 + 5.16000032424927) - 0.00967406174412357*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.000460738580668281*std::sin(0.377119839191437*x_108 + 5.17655992507935) + 0.00721163816519897*std::sin(0.20440000295639*x_109 + 8.20039939880371) + 0.0176232906539915*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 6.8003522455173e-5*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.000746619469016322*std::sin(0.264079958200455*x_11 + 8.28791999816895) - 0.0114481973325038*std::sin(0.291839927434921*x_11 + 8.31551933288574) + 0.0157093754425608*std::sin(0.426799863576889*x_110 - 7.36663961410522) + 0.00269712033253474*std::sin(0.436079859733582*x_110 - 1.15799987316132) - 0.00131761740336273*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.0241792310979176*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.018709224402373*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.0231695031023097*std::sin(0.380559861660004*x_114 + 5.17543983459473) - 0.00653166379452467*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 0.00756428241922796*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 0.00955431287979744*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 0.000146159984083782*std::sin(0.557679891586304*x_117 - 4.2129602432251) - 0.00108312303466887*std::sin(0.677919805049896*x_117 + 2.03951978683472) + 0.0314464259862103*std::sin(0.355519831180573*x_118 - 7.42095994949341) + 0.00398224382216396*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.0161555368246181*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.0003850638086432*std::sin(0.422559857368469*x_118 + 5.20847988128662) - 0.00307185148150575*std::sin(0.397839844226837*x_119 + 1.99255979061127) + 0.0226285657638218*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 0.000164441076998971*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.00162648739025913*std::sin(0.362559854984283*x_12 - 4.22640037536621) + 0.0106795962843619*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.00027227356937497*std::sin(0.491039842367172*x_120 - 7.3458399772644) + 0.0106639993125828*std::sin(0.461919873952866*x_14 + 2.24759984016418) - 0.117864721424887*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.00244519475700102*std::sin(0.344959855079651*x_16 - 4.25424003601074) - 0.0370214690764209*std::sin(0.345839828252792*x_16 - 4.24904012680054) + 0.0115886117406938*std::sin(0.503919839859009*x_16 - 1.2526398897171) - 0.243552213606402*std::sin(0.161200016736984*x_18 + 4.95375967025757) + 0.00263046020340663*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 0.00429679828636838*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.0148624813392806*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 9.64207777602098e-5*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.00142955134288374*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.00187984624964206*std::sin(0.186080008745193*x_24 + 4.97135972976685) + 0.0673054060196277*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 0.0113114939153302*std::sin(0.341279864311218*x_24 - 1.07183980941772) - 0.0512058720506495*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.000535252196534678*std::sin(0.326319843530655*x_26 - 4.26119995117188) + 0.0199223666680904*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.0321497418650853*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.126213356821973*std::sin(0.188480004668236*x_27 - 7.59960031509399) + 0.100829106199532*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.00580431629137539*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.000604822901980874*std::sin(0.420319855213165*x_27 + 5.22671985626221) + 0.00311305761069377*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.000698007905602398*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.000655065866895788*std::sin(0.340159833431244*x_28 + 8.32423973083496) - 0.00637062475078605*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.00185319802092577*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.077010653506765*std::sin(0.323519825935364*x_3 + 8.31744003295898) - 0.14244550151877*std::sin(0.334479838609695*x_3 + 8.32800006866455) + 0.00590468259530772*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 0.00690961767488094*std::sin(0.304079920053482*x_30 - 4.29239988327026) - 0.00738020113052208*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.000310293907825197*std::sin(0.302559942007065*x_34 + 2.05271983146667) + 0.00416318882271747*std::sin(0.244959965348244*x_35 + 2.04167985916138) - 0.0371280793276964*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.000475563932805631*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.000265648680169303*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.0218726245537263*std::sin(0.321359843015671*x_35 + 1.95679974555969) + 0.00490770844682196*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 0.00014448693340137*std::sin(0.376719832420349*x_36 - 4.20711994171143) - 0.016387268293627*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.000313330420023788*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 0.0107639452467133*std::sin(0.408959865570068*x_37 + 5.21288013458252) - 0.00220105753546539*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.000450250346362097*std::sin(0.424719840288162*x_37 - 7.38560009002686) + 0.0345333937980577*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.0396462830224036*std::sin(0.321839839220047*x_38 - 4.2836799621582) - 0.00241144078766361*std::sin(0.463599860668182*x_38 + 5.25464010238647) - 0.0391091705427546*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 0.000167231900324354*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 0.00904108852132433*std::sin(0.347359836101532*x_41 - 4.24991989135742) + 0.0268497759895563*std::sin(0.370639860630035*x_41 - 4.23487997055054) - 0.00339506481473123*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.000574526368021059*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.0164224112928155*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.00114633288674473*std::sin(0.293919950723648*x_42 - 1.09335994720459) - 0.0131937687759953*std::sin(0.356479853391647*x_42 - 7.42711973190308) - 0.00308966107402014*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.0159160730616498*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 0.000159405584535924*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.000363108954538925*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.0306769014985193*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.000285343610429515*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.00117326539150724*std::sin(0.338559836149216*x_45 - 4.26592016220093) - 0.0597400524203898*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.000805574682805441*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 0.0074940777300962*std::sin(0.442719846963882*x_46 - 7.3452000617981) - 0.042955303391171*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 0.000126058099949822*std::sin(0.514399826526642*x_47 - 4.26032018661499) - 0.00423573758258588*std::sin(0.278799951076508*x_48 + 5.11183977127075) + 0.0230249422830132*std::sin(0.338479846715927*x_48 + 5.15136003494263) + 0.0562660730214318*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.015248336144333*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 0.00015408118531321*std::sin(0.45023986697197*x_49 + 5.23031997680664) + 0.0181874631540256*std::sin(0.409279853105545*x_50 + 5.19200038909912) - 0.00318991821971951*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.0257479635349998*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.000424911029779617*std::sin(0.331839829683304*x_52 - 4.27472019195557) - 0.0168330511404587*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.0234615183864435*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.000489357021014045*std::sin(0.376719832420349*x_53 - 4.21767997741699) - 0.00070755482448533*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 0.000183622000016572*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.000341009188511975*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.000387575585472934*std::sin(0.31879985332489*x_55 - 4.28104019165039) + 0.0134354237369554*std::sin(0.404239863157272*x_55 + 5.19928026199341) - 0.0559219229954702*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 0.00459972008988468*std::sin(0.333999842405319*x_56 + 5.12904024124146) - 0.000505354645725243*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 0.00885552805832935*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 0.000123031653676189*std::sin(0.54423987865448*x_58 - 4.2469596862793) + 0.01064920577317*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.000602843645172485*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 0.0126048923652241*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.00176846101962871*std::sin(0.197759985923767*x_6 - 4.38903999328613) - 0.0595362013736015*std::sin(0.356479853391647*x_60 + 5.16247987747192) - 0.000158443982119695*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.0283944035679754*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.0202878738663079*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.000744681787868428*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 0.000115070243578405*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.000482639864876931*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.0261507852569824*std::sin(0.225519984960556*x_66 + 5.03727960586548) - 0.0164870659161316*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.00217368148898002*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 0.00440738400735051*std::sin(0.440319865942001*x_67 + 5.22703981399536) - 0.000950255026166735*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.00200796995289019*std::sin(0.213760003447533*x_69 + 5.00463962554932) + 0.0733023634758902*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.0595299780118674*std::sin(0.196319997310638*x_70 - 7.60400009155273) + 0.00690963617178644*std::sin(0.225439995527267*x_70 - 4.37183952331543) - 0.0164947458728355*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.00049933478720673*std::sin(0.235279992222786*x_71 + 5.05199956893921) + 0.0379950208407603*std::sin(0.302239835262299*x_71 - 4.30936002731323) + 0.0220466499155408*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 0.00021918799667524*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.000627263935789703*std::sin(0.369439840316772*x_74 + 5.16767978668213) - 0.00173966558552305*std::sin(0.417439848184586*x_74 - 4.18495988845825) - 0.0405439301735338*std::sin(0.302319914102554*x_75 - 7.47096014022827) + 0.0105907654128766*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.000304296246089184*std::sin(0.358239859342575*x_75 + 5.16095972061157) + 0.00796182092543117*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.0288204689563169*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.000489616683006651*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 0.000189640502207578*std::sin(0.310159921646118*x_77 - 7.46808004379272) - 0.027524630309658*std::sin(0.324559837579727*x_77 + 8.30447959899902) + 0.0605870684801461*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 0.000216321352731932*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.000269393102631637*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.00152862045707837*std::sin(0.295919924974442*x_79 + 5.10743999481201) + 0.00843373212902162*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.000897236270516471*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 0.000254519687890058*std::sin(0.31743985414505*x_80 - 4.30200004577637) + 0.0082201794781068*std::sin(0.361999839544296*x_80 - 4.24368000030518) + 0.00192291063112501*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 0.000122558515112849*std::sin(0.45551985502243*x_81 + 5.25024032592773) + 0.0408757989086802*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.0370619089307663*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 5.60340680974183e-5*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.00105150650053849*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.0473346226568971*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.000398426585884976*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.0006976250567917*std::sin(0.369279831647873*x_84 - 7.42456007003784) + 0.00171117623201518*std::sin(0.417599856853485*x_84 - 4.17431974411011) - 0.0639034345389809*std::sin(0.242399975657463*x_85 - 7.54536008834839) - 0.00544969105083513*std::sin(0.301359921693802*x_86 + 1.90327990055084) + 0.00618139605350563*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 0.000209173408773256*std::sin(0.278639942407608*x_87 - 4.27216005325317) + 0.00760930813879767*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 0.00310009682168075*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.000756426212161304*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.000712063892768774*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.00824274282206728*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 0.0117536345781207*std::sin(0.202159985899925*x_9 - 4.39911985397339) + 0.0112221447257881*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.0283790352227841*std::sin(0.274079948663712*x_90 + 5.08575963973999) + 0.0118102481210737*std::sin(0.188960000872612*x_91 + 2.00175976753235) - 0.109451180955796*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.000357737668857157*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.0505773148199644*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.000981370206762923*std::sin(0.375679850578308*x_92 - 1.1775997877121) + 0.0037690533721271*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 0.0088596043016279*std::sin(0.424639850854874*x_93 + 1.99519979953766) - 0.0144057248609125*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.000384292680705712*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.0142662506215979*std::sin(0.401119858026505*x_94 - 7.40488004684448) - 0.00434524476939961*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.0286853030223199*std::sin(0.384479850530624*x_95 - 7.396559715271) + 0.0228072800134208*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 0.00023396346407974*std::sin(0.314559936523438*x_96 + 5.12815999984741) - 0.0476483469883825*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.000941103758944585*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.000407451625130829*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 0.0079406581389309*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.000379915002444942*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 0.000167093733758754*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 0.000118357653554524*std::sin(0.473919868469238*x_99 + 5.23375988006592) + 0.00112852287344545*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 0.184904762345881);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000478658553863624*x_1 + 0.00082695475710537*x_10 + 0.000511850792664103*x_100 - 6.534893891414e-5*x_101 - 0.000185441988094375*x_102 + 0.00160707273127576*x_103 - 0.000779299264961824*x_104 + 5.61956200541235e-5*x_105 - 0.000749754006261378*x_106 + 0.000574665168249659*x_107 - 0.000298522110059677*x_108 + 0.000503181592173333*x_109 - 0.00185390926998934*x_11 - 0.000450357480932815*x_110 - 2.85746865875637e-5*x_111 - 0.000431902013704262*x_112 - 0.000279223375997187*x_113 + 0.000249579266392596*x_114 + 0.000905118992737958*x_115 - 0.00135270844395988*x_116 - 0.000203191184895547*x_117 - 2.51553102148079e-6*x_118 - 0.00145818091848238*x_119 + 0.00111427882394416*x_12 + 0.000245669074773102*x_120 + 0.000573081182999748*x_13 - 0.00026797119510689*x_14 - 0.00115900182371846*x_15 + 0.000297967016316355*x_16 + 0.00105607998543622*x_17 - 0.000611438079803979*x_18 - 0.00137077545079537*x_19 - 0.00785272197459396*x_2 + 0.000338069694545315*x_20 - 1.28760474100843e-5*x_21 - 0.000224076597009659*x_22 + 0.00200566232789397*x_23 - 0.00219110381138089*x_25 + 2.56550670364531e-5*x_26 - 0.000360206101017289*x_28 + 0.00159827004515339*x_29 - 0.000796994692468769*x_3 - 2.04135182990439e-5*x_30 - 0.0073850979951371*x_31 - 0.000749759320551937*x_32 - 0.00029137038462303*x_33 + 0.00150015693953625*x_34 + 0.000701046885460545*x_36 - 0.000238604807938497*x_37 - 0.000113834439104596*x_38 - 0.000701190052052892*x_39 - 5.39953769569956e-5*x_4 + 6.03564170001947e-5*x_40 - 0.000128054342060267*x_41 + 0.000401866125475776*x_42 - 0.000153479114616536*x_43 - 0.000163596166612481*x_44 + 0.00113082241999539*x_45 - 5.62682356826031e-5*x_46 + 0.000239828641916404*x_47 - 0.000600755187376989*x_48 + 7.25100467252566e-6*x_49 - 0.00176528266897242*x_5 - 0.000111655181856527*x_50 + 0.000199038435084505*x_51 - 0.000898658967791363*x_52 + 6.85351558437943e-5*x_53 - 0.000297578668267939*x_54 - 0.000329059099414564*x_55 + 0.000868759719682961*x_56 - 0.000117226884253463*x_57 - 0.000492637733115032*x_58 - 0.000288662558956215*x_59 - 0.000301589779150641*x_6 - 0.000404616526325239*x_60 - 0.0011114431841976*x_61 - 0.000807440174675238*x_62 + 0.000215270013446523*x_63 + 0.000330373248768185*x_64 + 0.00206851502472868*x_65 - 0.00094082032682578*x_66 - 0.000544881647733739*x_67 + 1.5335469795399e-5*x_68 - 0.000229973657038959*x_69 - 0.000829411312220076*x_7 + 0.000659225032593209*x_70 - 0.000681341933805302*x_71 - 0.000818860003890426*x_72 + 0.000418791786442464*x_73 + 0.00016225137846678*x_74 - 0.000230101623783218*x_75 - 7.90094442099281e-5*x_76 - 0.00118153902659778*x_77 + 0.000480160584761454*x_78 + 0.0010166928579091*x_79 - 0.00183407778460193*x_8 + 0.000512040558067634*x_80 + 0.000367875710818641*x_81 + 0.000112356487754913*x_82 - 9.73099439664789e-6*x_83 + 0.000338440917625353*x_84 + 0.000952511261771885*x_86 - 5.84921345636961e-5*x_87 + 0.000145380722500101*x_88 - 0.0018190592496804*x_89 - 0.00152345285987151*x_9 + 0.000396292856238783*x_90 + 0.0012553045759053*x_91 + 9.11599872400809e-5*x_92 + 0.00116481155605114*x_93 - 0.000349887683946861*x_94 - 0.000221165954210978*x_95 - 0.000297973277374601*x_96 - 0.00167754929256656*x_97 + 0.000476117218667519*x_98 - 0.00113492129861204*x_99 - 5.33819621200928e-6*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 1.90477797358978e-6*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 4.39545649811759e-5*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) + 7.29065212064453e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) + 2.49977768432045e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 5.3713052660616e-5*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 3.41468733208561e-7*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) - 4.55517742478246e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 2.12377703583364e-5*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) - 6.46489016286709e-5*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) - 2.64940804009831e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) - 2.10987372495482e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) - 2.74285215281408e-5*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) - 2.12545203999504e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) - 2.37056129520181e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 2.98213098033992e-6*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) - 4.2411219508811e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 0.000416302397762946*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) - 5.46307697461252e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) - 2.08718330363903e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 3.07789003568699e-6*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) + 1.18905507549787e-5*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 3.17382398838176e-7*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 1.36313965207211e-5*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) - 3.87217484825692e-5*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) + 2.46497643579895e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) + 1.94966962765488e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) + 9.0274945021071e-6*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 2.64235047897168e-7*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) + 7.08002756715922e-5*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) - 2.29784435225652e-5*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 1.58803783560718e-6*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) + 0.00146569897067149*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) - 7.94092484143394e-6*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) - 2.14065575184389e-6*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) + 1.6182392321073e-5*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 2.28638539741733e-7*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 1.58336406628645e-5*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) - 1.21673855866691e-5*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) - 1.10523657241103e-5*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) + 9.96573613368832e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) - 3.739051669978e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) - 4.858624780171e-6*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) - 1.01751183634169e-5*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) - 0.0921044583462591*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.0795076594321705*std::sin(0.281999945640564*x_1 + 1.99319982528687) + 0.0296473654942924*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.000826880408309*std::sin(0.257359951734543*x_10 + 5.08655977249146) + 0.0402107502727413*std::sin(0.267119973897934*x_10 + 5.08279991149902) + 0.0240677688393153*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 0.00466526422438004*std::sin(0.441439867019653*x_100 - 7.36719989776611) + 0.00684676938830168*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.000134493554206043*std::sin(0.339919835329056*x_101 + 1.93815982341766) - 0.0114639003691373*std::sin(0.34487983584404*x_101 - 1.207279920578) + 0.0108723225047805*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.00807176249231238*std::sin(0.369759827852249*x_102 - 7.41752004623413) - 0.0077518424102933*std::sin(0.400079846382141*x_102 - 1.17423987388611) + 0.0126545794916715*std::sin(0.306879937648773*x_104 + 5.10343980789185) + 0.0015238559349714*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.000403295732834602*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 0.0025213351649088*std::sin(0.360079854726791*x_105 + 5.16247987747192) - 0.00783435994303136*std::sin(0.407039850950241*x_105 - 7.39559984207153) - 0.00700514829555681*std::sin(0.41143986582756*x_106 - 7.37631988525391) + 0.00571127080506148*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.000130032195991289*std::sin(0.505039870738983*x_106 + 5.25744009017944) - 0.0119416223175918*std::sin(0.363279849290848*x_107 + 5.16000032424927) - 0.0150702629863839*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.0107122173385853*std::sin(0.377119839191437*x_108 + 5.17655992507935) + 0.0112342970912098*std::sin(0.20440000295639*x_109 + 8.20039939880371) + 0.00317137439031209*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 0.0015810885888318*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.000301406086336579*std::sin(0.264079958200455*x_11 + 8.28791999816895) - 0.0178340131667705*std::sin(0.291839927434921*x_11 + 8.31551933288574) + 0.00282695848037048*std::sin(0.426799863576889*x_110 - 7.36663961410522) + 0.00420157673088163*std::sin(0.436079859733582*x_110 - 1.15799987316132) - 0.00205258569867766*std::sin(0.605519831180573*x_111 + 8.21232032775879) + 0.013340545484403*std::sin(0.326959848403931*x_112 + 8.33672046661377) + 0.010322547400577*std::sin(0.345279842615128*x_113 - 4.24360036849976) - 0.0127834424815105*std::sin(0.380559861660004*x_114 + 5.17543983459473) - 0.00117539633719839*std::sin(0.455279856920242*x_115 + 2.23247981071472) - 0.00417348480859142*std::sin(0.514239847660065*x_115 - 1.04975974559784) + 0.00527145569803219*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 5.90039646833082e-5*std::sin(0.557679891586304*x_117 - 4.2129602432251) - 0.00168729013839356*std::sin(0.677919805049896*x_117 + 2.03951978683472) + 0.0056588971944876*std::sin(0.355519831180573*x_118 - 7.42095994949341) + 0.00620354337849542*std::sin(0.374719828367233*x_118 - 7.42935991287231) - 0.00891358674562344*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.00895277144237935*std::sin(0.422559857368469*x_118 + 5.20847988128662) - 0.00478533328666477*std::sin(0.397839844226837*x_119 + 1.99255979061127) + 0.0040720916066049*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 0.00382327122171752*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.0378159918747255*std::sin(0.362559854984283*x_12 - 4.22640037536621) + 0.016636685691148*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.00633038728049774*std::sin(0.491039842367172*x_120 - 7.3458399772644) + 0.00191902494160878*std::sin(0.461919873952866*x_14 + 2.24759984016418) - 0.0212101795508601*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.0568510187147161*std::sin(0.344959855079651*x_16 - 4.25424003601074) - 0.0576720812706047*std::sin(0.345839828252792*x_16 - 4.24904012680054) + 0.00208541226580647*std::sin(0.503919839859009*x_16 - 1.2526398897171) - 0.0438280947695896*std::sin(0.161200016736984*x_18 + 4.95375967025757) + 0.00409773351556651*std::sin(0.418559849262238*x_18 + 5.21335983276367) - 0.00237069709720997*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.00599990024319211*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 0.00224179257101641*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.000577101848205849*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.0437066102866445*std::sin(0.186080008745193*x_24 + 4.97135972976685) + 0.0121118493232057*std::sin(0.278879940509796*x_24 - 7.48816013336182) - 0.00624095524224531*std::sin(0.341279864311218*x_24 - 1.07183980941772) - 0.00921468041601227*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.0124446662398406*std::sin(0.326319843530655*x_26 - 4.26119995117188) + 0.031035082568257*std::sin(0.33111983537674*x_26 - 4.26255989074707) - 0.0177381609831225*std::sin(0.343999862670898*x_26 + 5.15895986557007) - 0.0696364173287429*std::sin(0.188480004668236*x_27 - 7.59960031509399) + 0.0181445594626693*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.00234316988753056*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.0140621919874292*std::sin(0.420319855213165*x_27 + 5.22671985626221) + 0.00484952423561044*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.0162287524913114*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.000264446411361155*std::sin(0.340159833431244*x_28 + 8.32423973083496) - 0.00114641678342605*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.0430870363467257*std::sin(0.315759837627411*x_3 + 8.31560039520264) - 0.0424895283778927*std::sin(0.323519825935364*x_3 + 8.31744003295898) - 0.0256335791312318*std::sin(0.334479838609695*x_3 + 8.32800006866455) + 0.00919832040729579*std::sin(0.280559957027435*x_30 + 8.27775955200195) - 0.00381228288436031*std::sin(0.304079920053482*x_30 - 4.29239988327026) - 0.0114968846458869*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.00721436389077999*std::sin(0.302559942007065*x_34 + 2.05271983146667) + 0.00648541967994338*std::sin(0.244959965348244*x_35 + 2.04167985916138) - 0.00668133110059463*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.000191982488721632*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.00617635795455714*std::sin(0.313279837369919*x_35 + 5.1625599861145) - 0.0120679082614577*std::sin(0.321359843015671*x_35 + 1.95679974555969) + 0.0076452330893*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 0.00335933541952617*std::sin(0.376719832420349*x_36 - 4.20711994171143) - 0.00294894773138246*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.000126489730778105*std::sin(0.440559864044189*x_36 + 5.23559999465942) + 0.00593885308320531*std::sin(0.408959865570068*x_37 + 5.21288013458252) - 0.00342880961327073*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.000181763536045324*std::sin(0.424719840288162*x_37 - 7.38560009002686) + 0.00621440812910374*std::sin(0.292959928512573*x_38 - 7.50207996368408) - 0.0218742705177849*std::sin(0.321839839220047*x_38 - 4.2836799621582) - 0.00375654485234793*std::sin(0.463599860668182*x_38 + 5.25464010238647) - 0.00703783557343466*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 0.003888158138658*std::sin(0.312559843063354*x_39 - 1.05167984962463) - 0.00498829148697075*std::sin(0.347359836101532*x_41 - 4.24991989135742) + 0.00483171353356813*std::sin(0.370639860630035*x_41 - 4.23487997055054) - 0.00528883533794871*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.000231933068006576*std::sin(0.407439857721329*x_41 - 7.40343999862671) + 0.0090608309225452*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.00046276814812753*std::sin(0.293919950723648*x_42 - 1.09335994720459) - 0.0205532660939*std::sin(0.356479853391647*x_42 - 7.42711973190308) - 0.00481307708755949*std::sin(0.309359908103943*x_43 - 7.46832036972046) + 0.0087814660338933*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 0.00370619552644424*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.000146585045586256*std::sin(0.4336798787117*x_43 - 1.18711996078491) + 0.0169255423426923*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.00663426702114684*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.000473640649036733*std::sin(0.338559836149216*x_45 - 4.26592016220093) - 0.010750436796491*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.0187296906461732*std::sin(0.287759929895401*x_46 + 5.09239959716797) + 0.00413475037386983*std::sin(0.442719846963882*x_46 - 7.3452000617981) - 0.00772996098047055*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 0.00293086322832562*std::sin(0.514399826526642*x_47 - 4.26032018661499) - 0.00659843621007015*std::sin(0.278799951076508*x_48 + 5.11183977127075) + 0.00414342098353938*std::sin(0.338479846715927*x_48 + 5.15136003494263) + 0.0101252817380722*std::sin(0.202960014343262*x_49 + 5.00367975234985) - 0.00841305172489377*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 0.00358240272057939*std::sin(0.45023986697197*x_49 + 5.23031997680664) + 0.00327289925609652*std::sin(0.409279853105545*x_50 + 5.19200038909912) - 0.00496925776863396*std::sin(0.41407984495163*x_50 - 1.16055989265442) - 0.0142060712054238*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.00987922325488622*std::sin(0.331839829683304*x_52 - 4.27472019195557) - 0.00302916795425907*std::sin(0.375039845705032*x_52 - 4.20832014083862) - 0.01294455774462*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.000197550680964021*std::sin(0.376719832420349*x_53 - 4.21767997741699) - 0.00110222960782278*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 7.41271701141243e-5*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.000137663494162058*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.00901117050083698*std::sin(0.31879985332489*x_55 - 4.28104019165039) + 0.00241775271139394*std::sin(0.404239863157272*x_55 + 5.19928026199341) - 0.0100633507059972*std::sin(0.234799981117249*x_56 + 5.04367971420288) - 0.00253782987664622*std::sin(0.333999842405319*x_56 + 5.12904024124146) - 0.000787241968669102*std::sin(0.440479874610901*x_58 + 5.2324800491333) - 0.00488591115127412*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 4.96671875954616e-5*std::sin(0.54423987865448*x_58 - 4.2469596862793) + 0.016589343322651*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.000243364593751765*std::sin(0.3572798371315*x_59 + 5.15119981765747) + 0.00695456936754112*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.00071391778125924*std::sin(0.197759985923767*x_6 - 4.38903999328613) - 0.0107137530691488*std::sin(0.356479853391647*x_60 + 5.16247987747192) - 0.00024682419259978*std::sin(1.10423994064331*x_60 - 3.81703996658325) - 0.0156662067030615*std::sin(0.319679856300354*x_62 + 8.32096004486084) + 0.0111935446995509*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.0173139248468455*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 0.00267539448645241*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.000194839002757629*std::sin(0.312959939241409*x_65 + 5.13624000549316) + 0.0144283223383259*std::sin(0.225519984960556*x_66 + 5.03727960586548) - 0.00296690667165299*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.000877503008860613*std::sin(0.23463998734951*x_67 - 4.35623979568481) + 0.00243171118962313*std::sin(0.440319865942001*x_67 + 5.22703981399536) - 0.00148030822287906*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.00081060619244158*std::sin(0.213760003447533*x_69 + 5.00463962554932) + 0.0131910233361631*std::sin(0.237919986248016*x_69 + 5.03039979934692) + 0.0328448152936187*std::sin(0.196319997310638*x_70 - 7.60400009155273) + 0.0107638380861385*std::sin(0.225439995527267*x_70 - 4.37183952331543) - 0.00296828870741961*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.0116095829385859*std::sin(0.235279992222786*x_71 + 5.05199956893921) + 0.00683734033669076*std::sin(0.302239835262299*x_71 - 4.30936002731323) + 0.00396737376163551*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 0.00509614249145063*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.000253222927920087*std::sin(0.369439840316772*x_74 + 5.16767978668213) - 0.00271005277572467*std::sin(0.417439848184586*x_74 - 4.18495988845825) - 0.00729602571729841*std::sin(0.302319914102554*x_75 - 7.47096014022827) + 0.0164983048713847*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.00707491766522991*std::sin(0.358239859342575*x_75 + 5.16095972061157) + 0.0124029325396468*std::sin(0.285439938306808*x_76 + 5.11615991592407) - 0.0159012821969629*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.0113836360596436*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 0.00440916033751609*std::sin(0.310159921646118*x_77 - 7.46808004379272) - 0.00495315599002998*std::sin(0.324559837579727*x_77 + 8.30447959899902) + 0.0109028603757665*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 0.00502949273768243*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.00626341614526872*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.000617095493195547*std::sin(0.295919924974442*x_79 + 5.10743999481201) + 0.0131380762809661*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.0208608315802277*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 0.00591760778893874*std::sin(0.31743985414505*x_80 - 4.30200004577637) + 0.00147925079330928*std::sin(0.361999839544296*x_80 - 4.24368000030518) + 0.00299551208963188*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 0.00284949753649644*std::sin(0.45551985502243*x_81 + 5.25024032592773) + 0.0636763601086737*std::sin(0.15504002571106*x_82 - 7.66024017333984) - 0.0204483790169932*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 0.00130279759718407*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.0244476296088894*std::sin(0.168000012636185*x_83 - 7.6276798248291) + 0.0261162021233906*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.00926345732818769*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.000281627317293173*std::sin(0.369279831647873*x_84 - 7.42456007003784) + 0.00266567203255478*std::sin(0.417599856853485*x_84 - 4.17431974411011) - 0.0114996523480709*std::sin(0.242399975657463*x_85 - 7.54536008834839) - 0.00848953412774283*std::sin(0.301359921693802*x_86 + 1.90327990055084) + 0.00111236440034676*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 0.00486330233726424*std::sin(0.278639942407608*x_87 - 4.27216005325317) + 0.0118537877707645*std::sin(0.310479938983917*x_87 + 5.13271999359131) - 0.00171043415269094*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.0175869838673412*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.000287456194282999*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.00332754898281913*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 0.273273160533933*std::sin(0.202159985899925*x_9 - 4.39911985397339) + 0.0174818681916744*std::sin(0.185840010643005*x_90 - 4.4215202331543) - 0.0156577274380587*std::sin(0.274079948663712*x_90 + 5.08575963973999) + 0.0183980162445357*std::sin(0.188960000872612*x_91 + 2.00175976753235) - 0.0196961327533919*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.00831743600338035*std::sin(0.340719848871231*x_92 + 5.18991994857788) - 0.0279053112194628*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.00039617364071344*std::sin(0.375679850578308*x_92 - 1.1775997877121) + 0.00587143508383908*std::sin(0.332239836454391*x_93 - 4.21600008010864) - 0.00488816016030627*std::sin(0.424639850854874*x_93 + 1.99519979953766) - 0.0025923618803525*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.00893484264195148*std::sin(0.380479842424393*x_94 + 5.18048000335693) + 0.00787120006168065*std::sin(0.401119858026505*x_94 - 7.40488004684448) - 0.00676902661437312*std::sin(0.381519854068756*x_95 + 5.17264032363892) + 0.0158267063230186*std::sin(0.384479850530624*x_95 - 7.396559715271) + 0.00410425187709524*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 0.00543967356255524*std::sin(0.314559936523438*x_96 + 5.12815999984741) - 0.00857449101569664*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.000379918301881208*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.00947329037874449*std::sin(0.371759831905365*x_97 + 5.18296003341675) - 0.00438114473737858*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.000153369552736614*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 0.00388494575241181*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 0.0027518270918881*std::sin(0.473919868469238*x_99 + 5.23375988006592) + 0.0017580140522985*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 0.561622760832126);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000821240025467218*x_1 - 0.00148655609404033*x_10 + 0.0005138083139939*x_100 + 0.00010736583481529*x_101 - 0.00026776623327751*x_102 - 0.00147800360284604*x_103 - 3.43495489888851e-5*x_104 - 0.000193357620333606*x_105 + 0.000288653758859099*x_106 - 0.000459431007537734*x_107 + 1.4375655116307e-5*x_108 - 0.000252344031425283*x_109 + 0.00253212348645339*x_11 - 5.18892804838759e-5*x_110 - 0.000389145656552699*x_111 + 0.000796325228087869*x_112 - 0.000482196947422662*x_113 + 0.000145838844258745*x_114 - 0.00102184378993008*x_115 - 0.000570847179137557*x_116 + 0.000427771530587462*x_117 + 9.20147929775603e-5*x_118 + 0.000995306664409252*x_119 - 0.00302892463668918*x_12 + 0.000726798330860739*x_120 - 0.000379288175712739*x_13 + 0.000616753740671571*x_14 - 7.83054518882965e-5*x_15 - 0.00131095956995559*x_16 + 0.00143923195575402*x_17 + 0.00100954526499877*x_18 + 0.00443910892080049*x_19 + 0.00241007113181351*x_2 - 0.00175445474809787*x_20 + 0.00021655340778945*x_21 - 0.000414332680385435*x_22 - 0.00138757144597299*x_23 - 0.000737600445967792*x_25 - 0.000938428372389956*x_26 + 0.000289446308399594*x_28 - 0.0118651135312358*x_29 + 0.000252366661204966*x_3 - 0.000302868846382932*x_30 - 0.00138347894057825*x_31 - 0.000119008099088333*x_32 - 0.000148853794501003*x_33 - 0.000206997355916461*x_34 - 0.000391370180038627*x_36 + 0.000430513923229044*x_37 + 0.000296037639354039*x_38 - 0.000788386810270198*x_39 - 0.000708376767601175*x_4 - 0.00040778560305711*x_40 + 0.000232388339991557*x_41 - 0.000784675869248917*x_42 + 0.000249056054471758*x_43 + 0.000238893846553446*x_44 - 0.00200409563248531*x_45 - 0.000794301883265571*x_46 + 0.000275248308698366*x_47 + 0.000570547238761912*x_48 - 0.000265232147059359*x_49 + 0.00149071680934197*x_5 + 2.85553307997859e-5*x_50 - 0.000986573518398759*x_51 - 0.000289887175726267*x_52 - 2.93680553171856e-5*x_53 - 0.000201139163172737*x_54 + 7.03528979979075e-5*x_55 - 0.00036540736098124*x_56 - 0.000310255670082746*x_57 + 0.000918985034213787*x_58 + 0.000581296503063839*x_59 + 0.000547314109054207*x_6 + 0.00097611628114089*x_60 + 0.00106117073568309*x_61 + 0.0012442607121418*x_62 - 0.00165791478163684*x_63 + 0.000175407791855721*x_64 - 0.000103977662400555*x_65 - 0.000171841698483154*x_66 + 0.000988831300613873*x_67 - 0.000318701809920042*x_68 + 0.000424079959784275*x_69 + 0.0015051853370683*x_7 - 0.00141378542551157*x_70 - 6.00238351068747e-6*x_71 + 0.00113224028825501*x_72 - 0.000273889491981692*x_73 + 1.77982819827493e-5*x_74 + 0.000210114576264576*x_75 + 0.000338813552827491*x_76 + 5.74806090900569e-5*x_77 - 0.0019002552721962*x_78 + 0.000163143735302607*x_79 + 0.0018508508741667*x_8 + 0.000188258125870446*x_80 + 0.000395779132697857*x_81 + 1.66364081150779e-5*x_82 - 0.00233877473435834*x_83 - 0.00054920019460739*x_84 - 0.000735452360115759*x_86 - 0.000112609015410455*x_87 - 0.00033229287200116*x_88 - 0.00094500446708015*x_89 + 0.000366332971215173*x_9 - 0.00151612692711707*x_90 - 0.000936667267927327*x_91 - 0.000195641695738925*x_92 - 0.00184034588852793*x_93 - 0.00055857623811326*x_94 + 0.000346479234133537*x_95 - 0.000104485581116553*x_96 + 0.00142036463612456*x_97 - 2.0897223344989e-5*x_98 + 0.000544063398268152*x_99 + 8.66248212260583e-6*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) - 6.96742554201967e-5*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) + 7.97671381281171e-5*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) + 4.23264879720587e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) + 1.45126675004288e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) + 9.74764849270398e-5*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) - 1.24904739898615e-5*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 2.54299768791332e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) + 3.85415294732677e-5*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 0.000104908087369399*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 1.4790726885091e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) - 1.22490475974004e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 4.45092439375879e-5*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) - 1.23394888025578e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) - 1.37624909936749e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) + 0.000109082401467035*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) - 2.46221866400249e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) + 0.000755490376930011*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) - 3.17163482813285e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) - 1.21173164670418e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) + 0.000112585140880004*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 6.638082396839e-6*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) - 1.16094277806302e-5*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) - 2.47377602215642e-5*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 6.28351676605085e-5*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 1.37611091565701e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) + 1.1318969370483e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 1.4649238549999e-5*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) - 9.66536807618509e-6*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 3.95253401891548e-5*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 3.72879430268463e-5*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) + 5.80883206909973e-5*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) + 0.000850923742159039*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 4.43314313110962e-6*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 3.47371873279671e-6*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 9.03406880125207e-6*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) - 8.36329495497258e-6*std::pow(-6.0*x_85 - 9.9902400970459, 2) + 2.87343124056986e-5*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) - 7.06387701900144e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 6.17015274300261e-6*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) + 5.78569109614819e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 2.08738296339722e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 7.88426438953229e-6*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 1.65115288794004e-5*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) - 0.0534720102379714*std::sin(0.276799947023392*x_1 + 5.19144010543823) - 0.14428759458512*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.0481098414852013*std::sin(0.311839938163757*x_1 + 1.97727978229523) - 0.0302461901435686*std::sin(0.257359951734543*x_10 + 5.08655977249146) + 0.023344685901927*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.0134362012286566*std::sin(0.309999853372574*x_10 + 8.29687976837158) + 0.00846635101381749*std::sin(0.441439867019653*x_100 - 7.36719989776611) + 0.00397494898077501*std::sin(0.31199985742569*x_101 + 5.1398401260376) + 0.00491959607788914*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.00639989827280481*std::sin(0.34487983584404*x_101 - 1.207279920578) + 0.00631201736294408*std::sin(0.30991992354393*x_102 + 8.30463981628418) - 0.0146483395737707*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.0043275849628153*std::sin(0.400079846382141*x_102 - 1.17423987388611) + 0.00734672149736781*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.00247281558598761*std::sin(0.499839842319489*x_104 + 5.27536010742188) + 0.0147520237471231*std::sin(0.332959830760956*x_105 + 5.14432001113892) + 0.00457562691048567*std::sin(0.360079854726791*x_105 + 5.16247987747192) - 0.00454830290089579*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.0113675049523185*std::sin(0.41143986582756*x_106 - 7.37631988525391) + 0.00331572582308637*std::sin(0.451839864253998*x_106 + 5.22064018249512) + 0.00475640550340451*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.00666659388026367*std::sin(0.363279849290848*x_107 + 5.16000032424927) - 0.00874916666538947*std::sin(0.343119859695435*x_108 + 5.14359998703003) - 0.0194401405285501*std::sin(0.377119839191437*x_108 + 5.17655992507935) + 0.00652216472322356*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.00514630277140526*std::sin(0.30583992600441*x_109 + 5.09887981414795) - 0.00286930178724663*std::sin(0.508639812469482*x_109 + 5.28111982345581) + 0.0110250354297405*std::sin(0.264079958200455*x_11 + 8.28791999816895) - 0.0103536848460974*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.00458740674283697*std::sin(0.426799863576889*x_110 - 7.36663961410522) + 0.00243926035724252*std::sin(0.436079859733582*x_110 - 1.15799987316132) - 0.00119164571905289*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.00744756420194969*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.00576272046621686*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.00713655290289961*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 0.00190735772039466*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 0.00232991192857789*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 0.00294287102388192*std::sin(0.485599845647812*x_117 + 2.05175971984863) + 0.00215828687812958*std::sin(0.557679891586304*x_117 - 4.2129602432251) - 0.000979570339748627*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.00918289508928749*std::sin(0.355519831180573*x_118 - 7.42095994949341) + 0.00360151876470027*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.00497614656276923*std::sin(0.376959830522537*x_118 - 7.41655969619751) + 0.0162471624182738*std::sin(0.422559857368469*x_118 + 5.20847988128662) - 0.00277816508658765*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.00660792884766426*std::sin(0.434239864349365*x_119 - 1.16887986660004) + 0.00693833288475507*std::sin(0.46375983953476*x_119 + 8.23847961425781) - 0.0686270799998777*std::sin(0.362559854984283*x_12 - 4.22640037536621) + 0.00965856641009291*std::sin(0.403199851512909*x_12 + 8.3887996673584) + 0.0114881554811017*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.00311407048173371*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.0344185177688381*std::sin(0.336239844560623*x_15 - 1.06783974170685) - 0.10317115103933*std::sin(0.344959855079651*x_16 - 4.25424003601074) - 0.0334820070115764*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.00338407315005979*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.0711214186086542*std::sin(0.161200016736984*x_18 + 4.95375967025757) + 0.00237897331389876*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 0.00132347802835269*std::sin(0.377439826726913*x_21 - 7.40695953369141) + 0.219468404105925*std::sin(0.112320065498352*x_23 - 4.53903961181641) + 0.00406832322748355*std::sin(0.394479840993881*x_23 - 4.21127986907959) + 0.0211096212434581*std::sin(0.179120019078255*x_24 - 4.42608022689819) - 0.0793171590104379*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.0196543315507831*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 0.00348410901956432*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.0149529918345185*std::sin(0.318239837884903*x_26 - 4.27447986602783) + 0.0225841254790443*std::sin(0.326319843530655*x_26 - 4.26119995117188) + 0.0180176756111777*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.00990260052715051*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.0388755984120679*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.0294438262899239*std::sin(0.21807998418808*x_27 - 4.38279962539673) - 0.0857100509877471*std::sin(0.234879985451698*x_27 + 5.03936004638672) - 0.0255195520903403*std::sin(0.420319855213165*x_27 + 5.22671985626221) + 0.00281543167650998*std::sin(0.277679949998856*x_28 - 4.29263973236084) + 0.0294513469118817*std::sin(0.334159851074219*x_28 + 8.32832050323486) + 0.00967309947174957*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 0.00186033156090107*std::sin(0.647999823093414*x_29 - 0.774399816989899) - 0.0781927788677326*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.0237204311379087*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.0415965266438039*std::sin(0.334479838609695*x_3 + 8.32800006866455) + 0.00534016150599336*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 0.00212826541241976*std::sin(0.304079920053482*x_30 - 4.29239988327026) - 0.00667461211463285*std::sin(0.253279983997345*x_32 + 5.17439985275269) + 0.013092363926905*std::sin(0.302559942007065*x_34 + 2.05271983146667) + 0.003765164398663*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.0108420351960661*std::sin(0.302159935235977*x_35 - 1.13207995891571) + 0.00702246515912135*std::sin(0.309599906206131*x_35 + 8.26696014404297) - 0.0112086286896673*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.00673709494604431*std::sin(0.321359843015671*x_35 + 1.95679974555969) + 0.00443850373112075*std::sin(0.360319852828979*x_36 - 4.23935985565186) + 0.00609639914631801*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.00478536306817101*std::sin(0.37951985001564*x_36 - 4.2116003036499) + 0.00462682681785547*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 0.00331545585409755*std::sin(0.408959865570068*x_37 + 5.21288013458252) - 0.00199062397235534*std::sin(0.413519859313965*x_37 - 7.38855981826782) - 0.00664866940509225*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.0100843425724652*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.0122116471356051*std::sin(0.321839839220047*x_38 - 4.2836799621582) - 0.00218089339442172*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.0114205477684699*std::sin(0.297759920358658*x_39 - 4.29871988296509) - 0.00705608729020797*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 0.00278479025844095*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.0078405945461365*std::sin(0.370639860630035*x_41 - 4.23487997055054) - 0.00307047739507416*std::sin(0.384719848632813*x_41 - 7.41767978668213) - 0.00848380443534058*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.00505834788371747*std::sin(0.245119974017143*x_42 + 5.04055976867676) - 0.0169274459280958*std::sin(0.293919950723648*x_42 - 1.09335994720459) - 0.0119323697759025*std::sin(0.356479853391647*x_42 - 7.42711973190308) - 0.00279427198121707*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.004902388148305*std::sin(0.310479938983917*x_43 + 5.12063980102539) + 0.00672586819171788*std::sin(0.392479836940765*x_43 - 7.40231990814209) - 0.00536188681755385*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.0094489437030438*std::sin(0.379759848117828*x_44 + 8.3834400177002) + 0.0120396253285925*std::sin(0.391119837760925*x_44 - 1.01895976066589) - 0.017325147610868*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.0174451186995157*std::sin(0.250719964504242*x_46 + 5.04783964157104) - 0.03398995807398*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 0.00230828783608837*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.0125436844474031*std::sin(0.401119828224182*x_47 + 2.01015996932983) - 0.00531882347302473*std::sin(0.514399826526642*x_47 - 4.26032018661499) - 0.00383077708630597*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.00672367758150089*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.0164306572030974*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.00469671520768958*std::sin(0.409519851207733*x_49 - 4.18383979797363) - 0.00650121353186816*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.00531105080612138*std::sin(0.409279853105545*x_50 + 5.19200038909912) - 0.00288494397611651*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.00793075721555454*std::sin(0.34775984287262*x_51 - 4.25008010864258) + 0.0179284533087406*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.00491553929604677*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.00722649797053759*std::sin(0.308639854192734*x_53 + 5.103600025177) + 0.00722614225634955*std::sin(0.376719832420349*x_53 - 4.21767997741699) - 0.000639908576982457*std::sin(0.690639853477478*x_54 - 4.15112018585205) - 0.00271147370229942*std::sin(0.751919865608215*x_54 - 4.21736001968384) + 0.0050355482829358*std::sin(0.316559910774231*x_55 - 1.30199980735779) + 0.0163531428952627*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.00392337389026931*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.0163301594999636*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 0.0014167824668074*std::sin(0.333999842405319*x_56 + 5.12904024124146) - 0.000457039880199727*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 0.00272763486520689*std::sin(0.486399859189987*x_58 + 8.26839923858643) - 0.00181675993869629*std::sin(0.54423987865448*x_58 - 4.2469596862793) + 0.00963108140384659*std::sin(0.329679846763611*x_59 - 4.2771201133728) - 0.00890195450619203*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 0.00388249505406136*std::sin(0.374399840831757*x_59 - 4.21688032150269) - 0.0261141668636226*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.0173855907017293*std::sin(0.356479853391647*x_60 + 5.16247987747192) - 0.000143295840295341*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.00874590026011119*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.00624896807216498*std::sin(0.193680003285408*x_64 - 4.40383958816528) + 0.0314206780431027*std::sin(0.247039973735809*x_64 + 5.06735944747925) + 0.00485520813684419*std::sin(0.303039938211441*x_65 - 7.46543979644775) + 0.00712695265914234*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.00805483232051782*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.00481450568355191*std::sin(0.404399842023849*x_66 - 1.00423979759216) + 0.0320978978227688*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 0.00135754008158747*std::sin(0.440319865942001*x_67 + 5.22703981399536) - 0.000859405265177993*std::sin(0.465839862823486*x_67 + 2.03639984130859) - 0.0296509008821262*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.0214055458604769*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.0183361220788456*std::sin(0.196319997310638*x_70 - 7.60400009155273) + 0.00624903583036208*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.00481674836247298*std::sin(0.350559860467911*x_70 - 7.45039987564087) - 0.021068646823569*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.0110951969692515*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.00643799945130291*std::sin(0.320959836244583*x_73 - 4.27807998657227) - 0.00924829314566529*std::sin(0.302159935235977*x_74 + 8.32800006866455) + 0.00926255931283351*std::sin(0.369439840316772*x_74 + 5.16767978668213) - 0.00157334370529826*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.0118395221591866*std::sin(0.302319914102554*x_75 - 7.47096014022827) + 0.00957822827289537*std::sin(0.316879838705063*x_75 + 5.1080002784729) + 0.0128393020130932*std::sin(0.358239859342575*x_75 + 5.16095972061157) + 0.00720062576392968*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.00887713476136774*std::sin(0.32399994134903*x_76 + 5.15583992004395) - 0.0206586066853054*std::sin(0.34607982635498*x_76 + 8.3244800567627) - 0.00800158303972032*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.00803766356837654*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.0176924618989971*std::sin(0.325119853019714*x_78 + 8.30047988891602) - 0.00912733960836356*std::sin(0.38487982749939*x_78 + 5.18024015426636) + 0.0113666187124704*std::sin(0.270399957895279*x_79 - 4.30095958709717) + 0.0225725358061172*std::sin(0.295919924974442*x_79 + 5.10743999481201) + 0.00762741958442451*std::sin(0.221119999885559*x_8 + 8.23999977111816) - 0.0378574747546709*std::sin(0.226959988474846*x_8 + 8.22976016998291) + 0.0107390583455996*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.00240043322556496*std::sin(0.361999839544296*x_80 - 4.24368000030518) + 0.0017390694869796*std::sin(0.478479862213135*x_80 + 5.2771201133728) + 0.0051711639891507*std::sin(0.45551985502243*x_81 + 5.25024032592773) + 0.0369678410880752*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.0114156213276967*std::sin(0.324479848146439*x_82 - 7.46504020690918) - 0.00236426946625603*std::sin(0.453759849071503*x_82 + 5.2655200958252) + 0.0443666647310124*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.014579770538802*std::sin(0.162400022149086*x_84 - 4.45423984527588) + 0.0168109838092566*std::sin(0.251039981842041*x_84 - 7.54536008834839) - 0.0103015542548557*std::sin(0.369279831647873*x_84 - 7.42456007003784) + 0.00154757809529676*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.0186608976000624*std::sin(0.242399975657463*x_85 - 7.54536008834839) - 0.00492866972940306*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 0.00180507353966296*std::sin(0.411919862031937*x_86 - 3.99207997322083) - 0.00882574334341582*std::sin(0.278639942407608*x_87 - 4.27216005325317) + 0.00688181519567889*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 0.000954876109096622*std::sin(0.3503198325634*x_87 + 5.3318395614624) + 0.0319162155740585*std::sin(0.255679965019226*x_88 - 7.52096033096313) - 0.0105147668548716*std::sin(0.347679853439331*x_89 - 4.2655200958252) - 0.121717334496061*std::sin(0.189520001411438*x_9 - 4.41287994384766) - 0.495926144471064*std::sin(0.202159985899925*x_9 - 4.39911985397339) + 0.0101492441485276*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.00874116658032518*std::sin(0.274079948663712*x_90 + 5.08575963973999) + 0.0106811215292939*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.0319616198214843*std::sin(0.193920001387596*x_91 - 7.38560009002686) - 0.0150941788830705*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.0155785681421585*std::sin(0.36575984954834*x_92 - 7.4017596244812) - 0.0144915070504496*std::sin(0.375679850578308*x_92 - 1.1775997877121) + 0.0034087105288034*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 0.00272889040900586*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.00420671844046472*std::sin(0.355199843645096*x_94 - 7.41871976852417) - 0.016214625886498*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.00439421820301829*std::sin(0.401119858026505*x_94 - 7.40488004684448) - 0.00392981476601411*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.00883550163551346*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.00666011647005887*std::sin(0.397999823093414*x_95 - 7.40655994415283) - 0.00987172077853658*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.0139141335732129*std::sin(0.403039842844009*x_96 - 7.38471984863281) - 0.013896908285952*std::sin(0.368239849805832*x_97 + 5.17176008224487) + 0.0171917811606757*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 0.00244584126996972*std::sin(0.352559864521027*x_98 - 1.01783978939056) - 0.00561005510312223*std::sin(0.413679867982864*x_98 - 7.38263988494873) + 0.00705025756905088*std::sin(0.454479843378067*x_98 - 1.14039981365204) + 0.00499391523581996*std::sin(0.473919868469238*x_99 + 5.23375988006592) + 0.00102062969687744*std::sin(0.621439814567566*x_99 - 7.38647985458374) + 0.676957152236637);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00241854427249671*x_1 + 6.42866207790854e-6*x_10 + 0.0032613145269463*x_100 + 4.48380045741858e-6*x_101 - 0.00253551094960213*x_102 + 0.000609694329699583*x_103 - 0.00224844440065976*x_104 - 1.06276036841752e-5*x_105 + 1.3534316717102e-5*x_106 + 0.00112946510816552*x_107 - 0.000123732120698061*x_108 + 0.000117362473176213*x_109 + 0.000133503591035808*x_11 - 0.000885704853148851*x_110 - 0.00169580631515515*x_111 + 0.00161477923007123*x_112 - 0.00118892483954821*x_113 + 0.00163809749689226*x_114 + 0.0022496187980965*x_115 - 0.00516548093044229*x_116 - 3.24523552443959e-5*x_117 + 0.000394501030826274*x_118 + 0.000809342967178409*x_119 - 0.00711903925864996*x_12 + 0.00245340019824774*x_120 - 1.15718684307921e-5*x_13 + 0.00203744802031307*x_14 + 9.3792960222943e-5*x_15 - 0.00498713879491834*x_16 + 0.00335945302526733*x_17 + 4.23180652081078e-5*x_18 + 0.00934597367336362*x_19 - 0.0241016845065764*x_2 + 0.00135889116676271*x_20 - 0.00026430003290549*x_21 - 0.00370760173700606*x_22 - 7.90702927666981e-5*x_23 - 0.00232457635668973*x_25 - 0.00402338524366124*x_26 + 1.03764591722152e-5*x_28 - 0.0250503096426002*x_29 + 0.00310951463556005*x_3 - 0.00123439285938853*x_30 - 9.13769501324111e-5*x_31 - 0.000566036034360326*x_32 - 2.56841182314091e-5*x_33 - 0.000145672982740677*x_34 - 9.74197018776244e-6*x_36 - 2.64091713722628e-6*x_37 + 0.000401740965976122*x_38 - 0.00274751744251046*x_39 - 4.41424546682434e-5*x_4 - 0.000487286210503345*x_40 - 2.07927690642417e-6*x_41 + 3.38787583639369e-5*x_42 + 1.20638852076105e-5*x_43 + 0.000504841668488614*x_44 + 1.84631705213193e-5*x_45 - 0.00320534364577165*x_46 + 0.0016259784102613*x_47 + 0.00254866498609441*x_48 - 0.00113714710469109*x_49 + 5.51950926822877e-5*x_5 - 0.000787165684180952*x_50 - 0.00175252886261124*x_51 + 8.47395778649883e-5*x_52 - 9.38396061475034e-6*x_53 + 1.92272278214241e-6*x_54 + 1.49187194817931e-5*x_55 + 0.000271285122902544*x_56 - 0.00395789477221724*x_57 - 2.03286551788988e-5*x_58 - 3.30572052628122e-5*x_59 - 4.89705114963118e-6*x_6 + 0.00216182098548913*x_60 + 0.000694765365591313*x_61 + 0.0003812553905297*x_62 + 0.000167144250287294*x_63 + 0.000715910163766618*x_64 - 0.000147336459275979*x_65 - 0.00323635960138203*x_66 - 8.84749246795475e-6*x_67 - 1.66088791702449e-5*x_68 + 6.57055148780767e-6*x_69 - 1.34675307348385e-5*x_7 - 0.000970343420818237*x_70 + 0.00114502990382918*x_71 + 0.0040984007938687*x_72 + 0.000936314501349085*x_73 + 4.33330332230356e-6*x_74 + 0.000358684594715776*x_75 + 0.000950580946710746*x_76 - 0.000527726798501463*x_77 - 0.0061479774173795*x_78 - 0.00013354998404993*x_79 + 0.000223688652719911*x_8 + 0.00205689950500382*x_80 + 0.000725048736133438*x_81 + 0.000883340025542198*x_82 - 0.00407478124812436*x_83 - 2.66023972707406e-5*x_84 + 0.00108719583797002*x_86 - 0.00092598059276365*x_87 - 0.000443602015786706*x_88 + 0.000208146201662469*x_89 + 9.99913674578608e-5*x_9 - 0.00358911568343708*x_90 - 0.000400177215510116*x_91 - 6.3156699565737e-6*x_92 + 0.000739960372349429*x_93 - 0.00145775885983178*x_94 - 0.000251211183213883*x_95 - 0.000829959916789599*x_96 + 6.96147034754162e-5*x_97 - 5.08119945044657e-5*x_98 - 0.000180849776239612*x_99 + 4.19597066860085e-7*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) - 0.000298718985239948*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 7.13710370354068e-7*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) - 8.59151507654269e-6*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) - 2.94581023856964e-6*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 8.72163396991268e-7*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) - 5.35512248091543e-5*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 6.33001923160198e-7*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 3.44847388534828e-7*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 5.08158344537623e-6*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 3.68170156335548e-7*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) + 2.48633614902862e-6*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 2.15595806606454e-6*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) + 2.50469408550952e-6*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) + 2.79353791273673e-6*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) + 0.000467676103278796*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) + 4.99786062748388e-6*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 6.75969239176689e-6*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) + 6.43784772816006e-7*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) + 2.45959710105296e-6*std::pow(-6.40000009536743*x_5 - 10.0, 2) + 0.000482693626705373*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 1.65234869983026e-7*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) - 4.97738578608629e-5*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 2.21339218427335e-7*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 3.04363710918457e-6*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 3.42540954808104e-7*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) - 2.29754701267978e-6*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 7.09586171759303e-7*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) - 4.14389637359751e-5*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 9.83863118405981e-7*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 1.80616955993256e-6*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) + 0.000249045850672664*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) - 0.000172722200919991*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 1.10349613803206e-7*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 1.68261494886638e-7*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 2.24875663565645e-7*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) - 3.58565006133901e-5*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 2.57098063566001e-7*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) + 1.43383986754719e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 1.53587184568685e-7*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) - 1.17439113572546e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 5.19590496083576e-8*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 3.81901418712769e-7*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 7.99792598600813e-7*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) + 0.0108538554494728*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.0012910022220359*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.0023303653720236*std::sin(0.311839938163757*x_1 + 1.97727978229523) - 0.129676466186423*std::sin(0.257359951734543*x_10 + 5.08655977249146) - 0.00473855097583245*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.000334453360226451*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 7.57520284595655e-5*std::sin(0.441439867019653*x_100 - 7.36719989776611) - 0.00080684308415479*std::sin(0.31199985742569*x_101 + 5.1398401260376) + 0.0210921055318731*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.000159306000708136*std::sin(0.34487983584404*x_101 - 1.207279920578) - 0.00128122589270653*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.000131064898498382*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.000107722064283474*std::sin(0.400079846382141*x_102 - 1.17423987388611) - 0.00149125220475328*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.000119779314067338*std::sin(0.499839842319489*x_104 + 5.27536010742188) + 0.0632473147707128*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 4.09400719835234e-5*std::sin(0.360079854726791*x_105 + 5.16247987747192) + 0.000923223608146395*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.000550624136131032*std::sin(0.41143986582756*x_106 - 7.37631988525391) - 0.000673032650796208*std::sin(0.451839864253998*x_106 + 5.22064018249512) + 0.0203924479249596*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.000165944576638512*std::sin(0.363279849290848*x_107 + 5.16000032424927) + 0.00177592332636953*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.000173939171217125*std::sin(0.377119839191437*x_108 + 5.17655992507935) - 0.00132388202366946*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.000249278846119684*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 2.56728583886794e-5*std::sin(0.508639812469482*x_109 + 5.28111982345581) + 0.0472683543719921*std::sin(0.264079958200455*x_11 + 8.28791999816895) + 0.00210161163174556*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.00022220679783747*std::sin(0.426799863576889*x_110 - 7.36663961410522) - 0.000495125939782589*std::sin(0.436079859733582*x_110 - 1.15799987316132) + 0.000241882628388611*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.000185384457292274*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.000143445397339042*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.000177642777016316*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 9.23894206767824e-5*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 5.79960704877353e-5*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 7.32538227063134e-5*std::sin(0.485599845647812*x_117 + 2.05175971984863) + 0.00925336427642219*std::sin(0.557679891586304*x_117 - 4.2129602432251) + 0.00019883514427278*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.000444805055896591*std::sin(0.355519831180573*x_118 - 7.42095994949341) - 0.000731043472961898*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.000123866032561934*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.000145370243672582*std::sin(0.422559857368469*x_118 + 5.20847988128662) + 0.000563917498713782*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.000320077724058378*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 6.20802030638834e-5*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.000614035551888078*std::sin(0.362559854984283*x_12 - 4.22640037536621) - 0.00196051510309292*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.000102789392919339*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.000150840696885383*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.00166717909452167*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.000923115986684498*std::sin(0.344959855079651*x_16 - 4.25424003601074) + 0.00679624466416308*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.00016391920326156*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.00344501012720618*std::sin(0.161200016736984*x_18 + 4.95375967025757) - 0.000482888755300144*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 3.29439598466545e-5*std::sin(0.377439826726913*x_21 - 7.40695953369141) + 0.940941220991489*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 3.64010110622716e-5*std::sin(0.394479840993881*x_23 - 4.21127986907959) + 0.0905046576905011*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.000709684216598688*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.000952025037752506*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 8.67262963063763e-5*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.000724299505123753*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.000202069736209952*std::sin(0.326319843530655*x_26 - 4.26119995117188) - 0.00365726378621059*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.000246495119038705*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.000967689773207582*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.00142621283063306*std::sin(0.21807998418808*x_27 - 4.38279962539673) - 0.367470298771249*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.000228334241406695*std::sin(0.420319855213165*x_27 + 5.22671985626221) - 0.000571481945576947*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.000263513674994138*std::sin(0.334159851074219*x_28 + 8.32832050323486) + 0.0414721110530663*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 9.01115471631723e-5*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.000699623911228573*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.000590447981917199*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.00201487060224455*std::sin(0.334479838609695*x_3 + 8.32800006866455) - 0.0010839566495619*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 5.29766938232056e-5*std::sin(0.304079920053482*x_30 - 4.29239988327026) + 0.00135482609969432*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.000117142925349454*std::sin(0.302559942007065*x_34 + 2.05271983146667) - 0.000764260590628955*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.000525171204127649*std::sin(0.302159935235977*x_35 - 1.13207995891571) + 0.0301078734686778*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.000100288348322276*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.000167699486225575*std::sin(0.321359843015671*x_35 + 1.95679974555969) - 0.000900936353339504*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 5.45470653034642e-5*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.000231795492197924*std::sin(0.37951985001564*x_36 - 4.2116003036499) + 0.0198368967644557*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 8.25281887502848e-5*std::sin(0.408959865570068*x_37 + 5.21288013458252) + 0.000404060830218377*std::sin(0.413519859313965*x_37 - 7.38855981826782) - 0.0285052745222352*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.000488469760136809*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.000303971810848741*std::sin(0.321839839220047*x_38 - 4.2836799621582) + 0.000442682097576243*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.000553193447069872*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 6.3133801604571e-5*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 6.93188828904271e-5*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.000379786119894283*std::sin(0.370639860630035*x_41 - 4.23487997055054) + 0.000623251634989835*std::sin(0.384719848632813*x_41 - 7.41767978668213) - 0.03637316877827*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.000125912184412321*std::sin(0.245119974017143*x_42 + 5.04055976867676) - 0.0725741443500106*std::sin(0.293919950723648*x_42 - 1.09335994720459) + 0.00242205625225093*std::sin(0.356479853391647*x_42 - 7.42711973190308) + 0.000567186908359494*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.000122030041187383*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 6.01791914654582e-5*std::sin(0.392479836940765*x_43 - 7.40231990814209) - 0.0229883675031976*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.000235202712306321*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.000107723627220933*std::sin(0.391119837760925*x_44 - 1.01895976066589) - 0.0742792367458957*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.000845014227301037*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.00030412255139875*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 5.74578044799636e-5*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.000607596428743393*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 4.75897664108661e-5*std::sin(0.514399826526642*x_47 - 4.26032018661499) + 0.000777578785029331*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.000325684411440032*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.000795875301261724*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.000116910438933305*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 5.81691110708778e-5*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.000257258982893352*std::sin(0.409279853105545*x_50 + 5.19200038909912) + 0.000585591691003236*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.000197412077620959*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.000160413465383516*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.000238101024794526*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.000179881685886121*std::sin(0.308639854192734*x_53 + 5.103600025177) + 0.0309811115884638*std::sin(0.376719832420349*x_53 - 4.21767997741699) + 0.000129889921185595*std::sin(0.690639853477478*x_54 - 4.15112018585205) - 0.0116250782727546*std::sin(0.751919865608215*x_54 - 4.21736001968384) + 0.0215892349926615*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.000146318495888432*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.00019004208646577*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.000791007349921187*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 3.52664900346265e-5*std::sin(0.333999842405319*x_56 + 5.12904024124146) + 9.27708678288961e-5*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 6.78961732274143e-5*std::sin(0.486399859189987*x_58 + 8.26839923858643) - 0.00778911352606476*std::sin(0.54423987865448*x_58 - 4.2469596862793) - 0.00195493614162321*std::sin(0.329679846763611*x_59 - 4.2771201133728) - 0.0381659308837198*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 9.66429048505122e-5*std::sin(0.374399840831757*x_59 - 4.21688032150269) - 0.111960972942479*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.000842130784320872*std::sin(0.356479853391647*x_60 + 5.16247987747192) + 2.90864758993468e-5*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.000217702584266225*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.000155549052452852*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.000281134114739088*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 4.34416036329088e-5*std::sin(0.303039938211441*x_65 - 7.46543979644775) + 0.0305558495509235*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.000200500549955454*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.000233207114843879*std::sin(0.404399842023849*x_66 - 1.00423979759216) + 0.137615413442562*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 3.37918310542014e-5*std::sin(0.440319865942001*x_67 + 5.22703981399536) + 0.000174443797404384*std::sin(0.465839862823486*x_67 + 2.03639984130859) - 0.127124243661332*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.00103685111616638*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.000456421985532101*std::sin(0.196319997310638*x_70 - 7.60400009155273) - 0.00126844177541622*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.000233315746698338*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.000188510106795572*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.000537433963919384*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.000311846610241652*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 8.27483959062725e-5*std::sin(0.302159935235977*x_74 + 8.32800006866455) + 0.0397119754200115*std::sin(0.369439840316772*x_74 + 5.16767978668213) + 0.000319360448085768*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.000573487910359492*std::sin(0.302319914102554*x_75 - 7.47096014022827) - 0.00194420790752759*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.000114878673221729*std::sin(0.358239859342575*x_75 + 5.16095972061157) - 0.00146159740095097*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.000220969267994457*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.000184841304005253*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 7.1593552541966e-5*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.000389331834682555*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.000856995144495583*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 8.1666173377935e-5*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.000101701951973267*std::sin(0.270399957895279*x_79 - 4.30095958709717) + 0.096776706828519*std::sin(0.295919924974442*x_79 + 5.10743999481201) - 0.00154822886316388*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.000338726861234876*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 9.60869035664972e-5*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.000116273225893546*std::sin(0.361999839544296*x_80 - 4.24368000030518) - 0.000352999798291885*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 4.62685944671923e-5*std::sin(0.45551985502243*x_81 + 5.25024032592773) - 0.00750380622803146*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.000284157169660268*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 2.11541203053844e-5*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.000396967340932895*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.000362919039767944*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.000150414992465319*std::sin(0.251039981842041*x_84 - 7.54536008834839) - 0.0441665262850121*std::sin(0.369279831647873*x_84 - 7.42456007003784) - 0.000314130493100361*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.00090390465309349*std::sin(0.242399975657463*x_85 - 7.54536008834839) + 0.00100043122678686*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 8.74349351593799e-5*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 7.89676638537808e-5*std::sin(0.278639942407608*x_87 - 4.27216005325317) - 0.00139688459497718*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 2.37687362560626e-5*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.000285567898914405*std::sin(0.255679965019226*x_88 - 7.52096033096313) - 0.0450806465886021*std::sin(0.347679853439331*x_89 - 4.2655200958252) - 0.52184667676025*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 0.00443726126503647*std::sin(0.202159985899925*x_9 - 4.39911985397339) - 0.00206011385057863*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.000217584753706551*std::sin(0.274079948663712*x_90 + 5.08575963973999) - 0.00216807538376186*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.00154817080593959*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.000135054011634767*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.000387781068026068*std::sin(0.36575984954834*x_92 - 7.4017596244812) - 0.0621303845243968*std::sin(0.375679850578308*x_92 - 1.1775997877121) - 0.000691906872101389*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 6.79274261712583e-5*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.000203766852703673*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.000145079125541875*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.000109380696117681*std::sin(0.401119858026505*x_94 - 7.40488004684448) + 0.00079768165108616*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.000219932937963242*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.000322605610751043*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 8.83264669915217e-5*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.000673978838003454*std::sin(0.403039842844009*x_96 - 7.38471984863281) - 0.0595811224119499*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.000153822147655902*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 6.08817788153721e-5*std::sin(0.352559864521027*x_98 - 1.01783978939056) - 0.0240523556001875*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 6.30816406201892e-5*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 4.46826747970984e-5*std::sin(0.473919868469238*x_99 + 5.23375988006592) - 0.000207169454599642*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 1.20519732002157);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000825281834062876*x_1 - 0.000468566587831852*x_10 - 0.000452313189437284*x_100 - 1.15910372625891e-5*x_101 + 0.000510500065203558*x_102 + 0.000266849709851198*x_103 + 5.36426727719156e-5*x_104 - 1.83383739569824e-5*x_105 - 0.000601641394170515*x_106 - 0.000422721023651086*x_107 - 0.000202037512516665*x_108 + 0.000288180568776559*x_109 - 0.000801795198626541*x_11 - 0.000186735058159938*x_110 + 0.00033603553817215*x_111 - 0.000348988648395537*x_112 - 6.52339965457671e-5*x_113 - 0.000473624816254388*x_114 - 0.00102027190752222*x_115 + 0.000700327973423165*x_116 + 0.000415823433611946*x_117 - 8.75019334522888e-5*x_118 - 0.0010855074133281*x_119 + 0.00197522738332635*x_12 - 0.000343809013423226*x_120 + 0.000339442513916146*x_13 - 0.000610899864153405*x_14 - 0.000670587117829155*x_15 + 0.00127212872776056*x_16 + 6.35178182185823e-5*x_17 + 0.000272903370041258*x_18 - 0.00104770460551463*x_19 + 0.00531952936600888*x_2 - 0.00101498151260812*x_20 + 0.000158373770572092*x_21 + 0.000982233742780578*x_22 + 0.00112233817610436*x_23 - 0.00140558904298167*x_25 + 0.000892403214020499*x_26 - 0.000196479370819407*x_28 + 0.00349336274791955*x_29 - 0.00127296192344687*x_3 + 1.08923179351641e-5*x_30 - 0.00496439979595735*x_31 - 0.000805551149784979*x_32 - 6.05337374040503e-5*x_33 + 0.00104405687573811*x_34 + 0.000439241109396306*x_36 + 0.00014285321305739*x_37 - 1.72944411311907e-5*x_38 + 0.000101645646489476*x_39 - 0.000277964410823701*x_4 + 0.000367172876502854*x_40 + 8.31136174359623e-5*x_41 - 0.000527246001120133*x_42 - 4.2155649843715e-5*x_43 - 0.000183612414967192*x_44 + 9.6279805292279e-5*x_45 + 0.000653390081030474*x_46 - 0.000200839373893284*x_47 - 0.00127965894254222*x_48 + 0.000252223853691172*x_49 - 0.000938647974827847*x_5 + 0.000249896105157428*x_50 + 0.00016047353128635*x_51 - 0.000666982204830025*x_52 + 6.18929370724124e-5*x_53 - 0.000470293259923044*x_54 - 0.000221053850584237*x_55 + 4.18889011976585e-5*x_56 + 0.000885254422057141*x_57 + 0.000439831811617432*x_58 + 0.000463672518127221*x_59 + 0.000195746720678364*x_6 - 0.000467114720187558*x_60 - 0.00074462784142277*x_61 + 0.000325779763647045*x_62 - 0.000569353045180878*x_63 + 4.90529514860062e-5*x_64 + 0.00140426837895656*x_65 + 0.000668114416202094*x_66 + 0.000353655206758276*x_67 - 0.000129490097816565*x_68 + 0.000293574904873311*x_69 + 0.0005383290671118*x_7 - 0.000206232122432217*x_70 - 0.000744877111970788*x_71 - 0.0016516113538162*x_72 - 3.31332972834577e-6*x_73 + 0.0001374851551424*x_74 - 0.000221605325025686*x_75 - 0.000229616753666369*x_76 - 0.000673829216341799*x_77 + 0.00161442200594695*x_78 + 0.000663851797427448*x_79 - 0.000919849097917102*x_8 - 0.000128781480783785*x_80 + 0.000118739402800033*x_81 - 0.000165562550314557*x_82 + 0.000685698371852476*x_83 + 9.29585556435232e-5*x_84 - 0.00010141007590318*x_86 + 0.000188813041186742*x_87 + 0.000135080166360357*x_88 - 0.00134563403521142*x_89 - 0.000972703484782629*x_9 + 0.000555090652717786*x_90 + 0.000721264908898331*x_91 + 1.41806268973977e-5*x_92 - 0.000437416143698211*x_93 + 5.37721905942058e-5*x_94 + 0.00019948981829466*x_95 - 1.36510806685826e-5*x_96 - 0.000868987103617308*x_97 + 0.000301840577968388*x_98 - 0.000683722850263094*x_99 - 1.46622640398177e-6*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 6.62570861035639e-5*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) + 2.85286921133081e-5*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) + 5.65804084614574e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) + 1.93999713744651e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) + 3.4862434481535e-5*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 1.18778795069934e-5*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) - 2.85404760659344e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) + 1.37843660148974e-5*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) - 1.77569206510486e-5*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) - 1.65998730029558e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) - 1.63740520305455e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) - 7.53371005664196e-6*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) - 1.64949503279174e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) - 1.83971644985829e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 0.000103732462195639*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) - 3.29139846950332e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) + 0.00027020089806138*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) - 4.239718499319e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) - 1.6197958961645e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 0.000107063409982361*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) + 7.45002768469452e-6*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 1.10400441516789e-5*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) - 8.84745224029897e-6*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) - 1.06355869620824e-5*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) + 1.54443163039631e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) + 1.51307595085004e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) + 2.47955494236274e-6*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 9.19133072875005e-6*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) + 4.43599312350196e-5*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) - 6.31142042688376e-6*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 5.52393827881394e-5*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) + 0.0011374818750068*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) - 4.97538853580775e-6*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) - 5.87967519464325e-7*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) + 1.01390821401694e-5*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 7.95311769891542e-6*std::pow(-6.0*x_85 - 9.9902400970459, 2) + 1.02768178844921e-5*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) - 9.44271698895606e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) - 6.92486263443382e-6*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) + 7.73408759233655e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) - 2.34270380151868e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) - 1.33450395167199e-6*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) - 2.79476935945487e-6*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) - 0.0714793106037258*std::sin(0.276799947023392*x_1 + 5.19144010543823) - 0.0516044132745156*std::sin(0.281999945640564*x_1 + 1.99319982528687) + 0.00814315329931783*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.0287627677190258*std::sin(0.257359951734543*x_10 + 5.08655977249146) + 0.0312062712268355*std::sin(0.267119973897934*x_10 + 5.08279991149902) + 0.0150796668595565*std::sin(0.309999853372574*x_10 + 8.29687976837158) + 0.00302798780380532*std::sin(0.441439867019653*x_100 - 7.36719989776611) + 0.00531355772050285*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.00467831480884357*std::sin(0.339919835329056*x_101 + 1.93815982341766) - 0.00718270977388425*std::sin(0.34487983584404*x_101 - 1.207279920578) + 0.00843766014432726*std::sin(0.30991992354393*x_102 + 8.30463981628418) - 0.00523897408730009*std::sin(0.369759827852249*x_102 - 7.41752004623413) - 0.00485691888913497*std::sin(0.400079846382141*x_102 - 1.17423987388611) + 0.00982081252401679*std::sin(0.306879937648773*x_104 + 5.10343980789185) + 0.000418552956650951*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.0140285117037882*std::sin(0.332959830760956*x_105 + 5.14432001113892) + 0.00163647153975805*std::sin(0.360079854726791*x_105 + 5.16247987747192) - 0.00607999501657208*std::sin(0.407039850950241*x_105 - 7.39559984207153) - 0.00192408315221655*std::sin(0.41143986582756*x_106 - 7.37631988525391) + 0.00443233375611683*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.00452312790544993*std::sin(0.505039870738983*x_106 + 5.25744009017944) - 0.00748202658560401*std::sin(0.363279849290848*x_107 + 5.16000032424927) - 0.0116955468630398*std::sin(0.343119859695435*x_108 + 5.14359998703003) - 0.00695276020668662*std::sin(0.377119839191437*x_108 + 5.17655992507935) + 0.00871857698981557*std::sin(0.20440000295639*x_109 + 8.20039939880371) + 0.000871071928290349*std::sin(0.30583992600441*x_109 + 5.09887981414795) - 0.001026204890754*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.0104843132855555*std::sin(0.264079958200455*x_11 + 8.28791999816895) - 0.0138404045726664*std::sin(0.291839927434921*x_11 + 8.31551933288574) + 0.000776472239359521*std::sin(0.426799863576889*x_110 - 7.36663961410522) + 0.00326070869493662*std::sin(0.436079859733582*x_110 - 1.15799987316132) - 0.00159294580665112*std::sin(0.605519831180573*x_111 + 8.21232032775879) + 0.00835852226156251*std::sin(0.326959848403931*x_112 + 8.33672046661377) + 0.00646759477298977*std::sin(0.345279842615128*x_113 - 4.24360036849976) - 0.00800946922942792*std::sin(0.380559861660004*x_114 + 5.17543983459473) - 0.000322842600065286*std::sin(0.455279856920242*x_115 + 2.23247981071472) - 0.00261489799811327*std::sin(0.514239847660065*x_115 - 1.04975974559784) + 0.00330283194599179*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 0.00205243383884044*std::sin(0.557679891586304*x_117 - 4.2129602432251) - 0.00130945166006435*std::sin(0.677919805049896*x_117 + 2.03951978683472) + 0.00155431238464219*std::sin(0.355519831180573*x_118 - 7.42095994949341) + 0.00481437068255851*std::sin(0.374719828367233*x_118 - 7.42935991287231) - 0.00558481010621107*std::sin(0.376959830522537*x_118 - 7.41655969619751) + 0.00581079257978871*std::sin(0.422559857368469*x_118 + 5.20847988128662) - 0.00371374340049796*std::sin(0.397839844226837*x_119 + 1.99255979061127) + 0.00111846923490834*std::sin(0.434239864349365*x_119 - 1.16887986660004) + 0.00248149259574659*std::sin(0.46375983953476*x_119 + 8.23847961425781) - 0.0245444537925795*std::sin(0.362559854984283*x_12 - 4.22640037536621) + 0.0129111971916008*std::sin(0.403199851512909*x_12 + 8.3887996673584) + 0.00410873523058788*std::sin(0.491039842367172*x_120 - 7.3458399772644) + 0.000527092847010074*std::sin(0.461919873952866*x_14 + 2.24759984016418) - 0.00582573664503046*std::sin(0.336239844560623*x_15 - 1.06783974170685) - 0.0368991300433674*std::sin(0.344959855079651*x_16 - 4.25424003601074) - 0.0447574491433107*std::sin(0.345839828252792*x_16 - 4.24904012680054) + 0.000572793956212033*std::sin(0.503919839859009*x_16 - 1.2526398897171) - 0.0120381318398934*std::sin(0.161200016736984*x_18 + 4.95375967025757) + 0.00318011931224144*std::sin(0.418559849262238*x_18 + 5.21335983276367) - 0.00148536088615105*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.208704590528612*std::sin(0.112320065498352*x_23 - 4.53903961181641) + 0.00145503453549861*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.0200743012452199*std::sin(0.179120019078255*x_24 - 4.42608022689819) - 0.0283677572219865*std::sin(0.186080008745193*x_24 + 4.97135972976685) + 0.00332672546557605*std::sin(0.278879940509796*x_24 - 7.48816013336182) - 0.00391027213892501*std::sin(0.341279864311218*x_24 - 1.07183980941772) - 0.0025309687380572*std::sin(0.318239837884903*x_26 - 4.27447986602783) + 0.00807720544524419*std::sin(0.326319843530655*x_26 - 4.26119995117188) + 0.0240853303557679*std::sin(0.33111983537674*x_26 - 4.26255989074707) - 0.0111138494021817*std::sin(0.343999862670898*x_26 + 5.15895986557007) - 0.0436307154859796*std::sin(0.188480004668236*x_27 - 7.59960031509399) + 0.0049837119349289*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.0815064071225058*std::sin(0.234879985451698*x_27 + 5.03936004638672) - 0.00912705985872922*std::sin(0.420319855213165*x_27 + 5.22671985626221) + 0.00376355993337834*std::sin(0.277679949998856*x_28 - 4.29263973236084) + 0.0105332650523554*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.0091986829385229*std::sin(0.340159833431244*x_28 + 8.32423973083496) - 0.000314882872616334*std::sin(0.647999823093414*x_29 - 0.774399816989899) - 0.0279656230140619*std::sin(0.315759837627411*x_3 + 8.31560039520264) - 0.026621825115407*std::sin(0.323519825935364*x_3 + 8.31744003295898) - 0.00704069859144822*std::sin(0.334479838609695*x_3 + 8.32800006866455) + 0.00713852090583832*std::sin(0.280559957027435*x_30 + 8.27775955200195) - 0.00238858683803854*std::sin(0.304079920053482*x_30 - 4.29239988327026) - 0.00892236275348478*std::sin(0.253279983997345*x_32 + 5.17439985275269) + 0.00468247988170451*std::sin(0.302559942007065*x_34 + 2.05271983146667) + 0.00503312582280679*std::sin(0.244959965348244*x_35 + 2.04167985916138) - 0.00183514125078386*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.00667804881302408*std::sin(0.309599906206131*x_35 + 8.26696014404297) - 0.00400876256067154*std::sin(0.313279837369919*x_35 + 5.1625599861145) - 0.0075611510767547*std::sin(0.321359843015671*x_35 + 1.95679974555969) + 0.00593321974245292*std::sin(0.360319852828979*x_36 - 4.23935985565186) + 0.0021803752563593*std::sin(0.376719832420349*x_36 - 4.20711994171143) - 0.000809978662453027*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.00439990439808941*std::sin(0.440559864044189*x_36 + 5.23559999465942) + 0.00372098995218428*std::sin(0.408959865570068*x_37 + 5.21288013458252) - 0.00266098896566579*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.00632258584739225*std::sin(0.424719840288162*x_37 - 7.38560009002686) + 0.00170689291328638*std::sin(0.292959928512573*x_38 - 7.50207996368408) - 0.0137053299126418*std::sin(0.321839839220047*x_38 - 4.2836799621582) - 0.0029153337538596*std::sin(0.463599860668182*x_38 + 5.25464010238647) - 0.00193306126916755*std::sin(0.297759920358658*x_39 - 4.29871988296509) - 0.00252360742218998*std::sin(0.312559843063354*x_39 - 1.05167984962463) - 0.00312541533550896*std::sin(0.347359836101532*x_41 - 4.24991989135742) + 0.00132711231997354*std::sin(0.370639860630035*x_41 - 4.23487997055054) - 0.0041044951638712*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.00806771679967199*std::sin(0.407439857721329*x_41 - 7.40343999862671) + 0.00567706598376307*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.0160972404456604*std::sin(0.293919950723648*x_42 - 1.09335994720459) - 0.0159507293938348*std::sin(0.356479853391647*x_42 - 7.42711973190308) - 0.00373527447290302*std::sin(0.309359908103943*x_43 - 7.46832036972046) + 0.00550202983972939*std::sin(0.310479938983917*x_43 + 5.12063980102539) + 0.00240550466443995*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.00509891342800412*std::sin(0.4336798787117*x_43 - 1.18711996078491) + 0.0106047029805351*std::sin(0.379759848117828*x_44 + 8.3834400177002) + 0.00430596824982406*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.0164754368753181*std::sin(0.338559836149216*x_45 - 4.26592016220093) - 0.00295279035451925*std::sin(0.250719964504242*x_46 + 5.04783964157104) - 0.0121564979212288*std::sin(0.287759929895401*x_46 + 5.09239959716797) + 0.00259062892791011*std::sin(0.442719846963882*x_46 - 7.3452000617981) - 0.00212316528677178*std::sin(0.401119828224182*x_47 + 2.01015996932983) - 0.0019022755589306*std::sin(0.514399826526642*x_47 - 4.26032018661499) - 0.00512083432036851*std::sin(0.278799951076508*x_48 + 5.11183977127075) + 0.00113806106175158*std::sin(0.338479846715927*x_48 + 5.15136003494263) + 0.00278108088247432*std::sin(0.202960014343262*x_49 + 5.00367975234985) - 0.0052711997580921*std::sin(0.409519851207733*x_49 - 4.18383979797363) - 0.00232515699529857*std::sin(0.45023986697197*x_49 + 5.23031997680664) + 0.000898957459837305*std::sin(0.409279853105545*x_50 + 5.19200038909912) - 0.00385648128105615*std::sin(0.41407984495163*x_50 - 1.16055989265442) - 0.00890081762838732*std::sin(0.34775984287262*x_51 - 4.25008010864258) + 0.00641210574323702*std::sin(0.331839829683304*x_52 - 4.27472019195557) - 0.000832012511386936*std::sin(0.375039845705032*x_52 - 4.20832014083862) - 0.0081104160396579*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.00687173658029171*std::sin(0.376719832420349*x_53 - 4.21767997741699) - 0.000855404981569897*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 0.0025784896512683*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.00478858014554996*std::sin(0.316559910774231*x_55 - 1.30199980735779) + 0.00584869646438314*std::sin(0.31879985332489*x_55 - 4.28104019165039) + 0.000664076913428025*std::sin(0.404239863157272*x_55 + 5.19928026199341) - 0.00276407047093307*std::sin(0.234799981117249*x_56 + 5.04367971420288) - 0.00159007797280901*std::sin(0.333999842405319*x_56 + 5.12904024124146) - 0.000610953196068308*std::sin(0.440479874610901*x_58 + 5.2324800491333) - 0.00306126890940764*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 0.00172765706589543*std::sin(0.54423987865448*x_58 - 4.2469596862793) + 0.0128744563006247*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.00846535872754805*std::sin(0.3572798371315*x_59 + 5.15119981765747) + 0.0043573872557262*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.0248333992515738*std::sin(0.197759985923767*x_6 - 4.38903999328613) - 0.00294271454473457*std::sin(0.356479853391647*x_60 + 5.16247987747192) - 0.000191552324872557*std::sin(1.10423994064331*x_60 - 3.81703996658325) - 0.00981566590623109*std::sin(0.319679856300354*x_62 + 8.32096004486084) + 0.00701331835841181*std::sin(0.193680003285408*x_64 - 4.40383958816528) + 0.0112375957182183*std::sin(0.247039973735809*x_64 + 5.06735944747925) + 0.00173646367830805*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.00677741173041566*std::sin(0.312959939241409*x_65 + 5.13624000549316) + 0.00904006913382178*std::sin(0.225519984960556*x_66 + 5.03727960586548) - 0.000814911390919046*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.0305236585157696*std::sin(0.23463998734951*x_67 - 4.35623979568481) + 0.00152358928170659*std::sin(0.440319865942001*x_67 + 5.22703981399536) - 0.00114881964621769*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.0281966743806177*std::sin(0.213760003447533*x_69 + 5.00463962554932) + 0.00362313896733707*std::sin(0.237919986248016*x_69 + 5.03039979934692) + 0.0205789276105382*std::sin(0.196319997310638*x_70 - 7.60400009155273) + 0.00835346887286219*std::sin(0.225439995527267*x_70 - 4.37183952331543) - 0.000815290990553791*std::sin(0.350559860467911*x_70 - 7.45039987564087) - 0.00753519497600929*std::sin(0.235279992222786*x_71 + 5.05199956893921) + 0.00187799184153483*std::sin(0.302239835262299*x_71 - 4.30936002731323) + 0.0010897066973087*std::sin(0.320959836244583*x_73 - 4.27807998657227) - 0.0033076491637764*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.00880827769494727*std::sin(0.369439840316772*x_74 + 5.16767978668213) - 0.00210318487928419*std::sin(0.417439848184586*x_74 - 4.18495988845825) - 0.00200397758455686*std::sin(0.302319914102554*x_75 - 7.47096014022827) + 0.0128038042838625*std::sin(0.316879838705063*x_75 + 5.1080002784729) + 0.00459197236702919*std::sin(0.358239859342575*x_75 + 5.16095972061157) + 0.00962551741052043*std::sin(0.285439938306808*x_76 + 5.11615991592407) - 0.009962952518403*std::sin(0.32399994134903*x_76 + 5.15583992004395) - 0.00738854424823925*std::sin(0.34607982635498*x_76 + 8.3244800567627) - 0.00286176368259079*std::sin(0.310159921646118*x_77 - 7.46808004379272) - 0.00136046855664169*std::sin(0.324559837579727*x_77 + 8.30447959899902) + 0.0029946560836246*std::sin(0.325119853019714*x_78 + 8.30047988891602) - 0.00326439016882343*std::sin(0.38487982749939*x_78 + 5.18024015426636) + 0.00406526764313148*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.021465467258487*std::sin(0.295919924974442*x_79 + 5.10743999481201) + 0.0101960388463732*std::sin(0.221119999885559*x_8 + 8.23999977111816) - 0.013539714057795*std::sin(0.226959988474846*x_8 + 8.22976016998291) + 0.00384082087333243*std::sin(0.31743985414505*x_80 - 4.30200004577637) + 0.000406301395662761*std::sin(0.361999839544296*x_80 - 4.24368000030518) + 0.00232472068037203*std::sin(0.478479862213135*x_80 + 5.2771201133728) + 0.00184946519050186*std::sin(0.45551985502243*x_81 + 5.25024032592773) + 0.0494171770188522*std::sin(0.15504002571106*x_82 - 7.66024017333984) - 0.012811937219976*std::sin(0.324479848146439*x_82 - 7.46504020690918) - 0.000845580238410712*std::sin(0.453759849071503*x_82 + 5.2655200958252) + 0.0158677238259757*std::sin(0.168000012636185*x_83 - 7.6276798248291) + 0.0163631132693219*std::sin(0.162400022149086*x_84 - 4.45423984527588) + 0.00601244312470873*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.00979631519774602*std::sin(0.369279831647873*x_84 - 7.42456007003784) + 0.00206874241056093*std::sin(0.417599856853485*x_84 - 4.17431974411011) - 0.0031585751515503*std::sin(0.242399975657463*x_85 - 7.54536008834839) - 0.00658845464913922*std::sin(0.301359921693802*x_86 + 1.90327990055084) + 0.000305529806298347*std::sin(0.411919862031937*x_86 - 3.99207997322083) - 0.00315652435857713*std::sin(0.278639942407608*x_87 - 4.27216005325317) + 0.00919934380062*std::sin(0.310479938983917*x_87 + 5.13271999359131) - 0.00107167296561591*std::sin(0.3503198325634*x_87 + 5.3318395614624) + 0.0114148245618622*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.00999907079968851*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.115747715757635*std::sin(0.189520001411438*x_9 - 4.41287994384766) - 0.177367831146594*std::sin(0.202159985899925*x_9 - 4.39911985397339) + 0.0135671161726868*std::sin(0.185840010643005*x_90 - 4.4215202331543) - 0.0098103532205264*std::sin(0.274079948663712*x_90 + 5.08575963973999) + 0.0142781092386607*std::sin(0.188960000872612*x_91 + 2.00175976753235) - 0.00540987793486955*std::sin(0.193920001387596*x_91 - 7.38560009002686) - 0.0053984283774439*std::sin(0.340719848871231*x_92 + 5.18991994857788) - 0.0174840800412854*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.013780772031526*std::sin(0.375679850578308*x_92 - 1.1775997877121) + 0.00455663210644561*std::sin(0.332239836454391*x_93 - 4.21600008010864) - 0.00306267802660481*std::sin(0.424639850854874*x_93 + 1.99519979953766) - 0.000712036292165059*std::sin(0.355199843645096*x_94 - 7.41871976852417) - 0.00579915589933046*std::sin(0.380479842424393*x_94 + 5.18048000335693) + 0.00493170245682156*std::sin(0.401119858026505*x_94 - 7.40488004684448) - 0.00525322405170319*std::sin(0.381519854068756*x_95 + 5.17264032363892) + 0.00991622698508295*std::sin(0.384479850530624*x_95 - 7.396559715271) + 0.00112730260031482*std::sin(0.397999823093414*x_95 - 7.40655994415283) - 0.0035306178625474*std::sin(0.314559936523438*x_96 + 5.12815999984741) - 0.00235512982824337*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.013215335324685*std::sin(0.368239849805832*x_97 + 5.17176008224487) + 0.00614863517886955*std::sin(0.371759831905365*x_97 + 5.18296003341675) - 0.00274500738079416*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.00533491031617914*std::sin(0.413679867982864*x_98 - 7.38263988494873) + 0.00252152242423343*std::sin(0.454479843378067*x_98 - 1.14039981365204) + 0.00178607222906555*std::sin(0.473919868469238*x_99 + 5.23375988006592) + 0.00136433821713108*std::sin(0.621439814567566*x_99 - 7.38647985458374) + 0.466285419938171);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00168509879345578*x_1 - 0.000108428920776143*x_10 - 0.000275171476083309*x_100 + 1.13992680149591e-5*x_101 + 0.000139842179506436*x_102 - 0.0038278755557045*x_103 + 0.00300022966447404*x_104 + 0.000341976656975337*x_105 + 0.0032703301921855*x_106 - 0.000169945475686989*x_107 + 0.00158628303167804*x_108 - 0.00194463326336491*x_109 + 0.00187978300876848*x_11 + 0.00208143849978956*x_110 + 0.000266036104742326*x_111 + 4.19766604970833e-5*x_112 + 0.000197226507440038*x_113 - 0.000132325826274834*x_114 - 0.000225749809945788*x_115 + 0.00065902326245714*x_116 + 9.13435335192601e-6*x_117 - 1.60056436549656e-5*x_118 + 0.00556054519335532*x_119 - 0.0011197239121467*x_12 - 0.000367154960379661*x_120 - 0.00200098868744979*x_13 + 0.000898876862184296*x_14 + 0.00131063764063157*x_15 - 0.000822267198201027*x_16 - 0.000666971547510665*x_17 + 0.000404190492568721*x_18 - 0.00164167718896251*x_19 + 0.0212172419241615*x_2 - 0.000210367551124156*x_20 - 2.37185030471128e-5*x_21 + 0.000181549336376203*x_22 - 0.00532676276030474*x_23 + 0.00356161359919917*x_25 + 0.000163236254064561*x_26 + 0.00108178269500508*x_28 - 0.00402315082773134*x_29 + 0.00025659788926326*x_3 + 7.16171325673175e-5*x_30 - 0.00173503634088882*x_31 + 0.00407227494018398*x_32 + 0.000994207752736359*x_33 - 0.00399708278810878*x_34 - 0.00269803628128818*x_36 + 3.08397113540812e-5*x_37 - 2.31830577867352e-6*x_38 + 0.00130149896694056*x_39 + 0.0027529656177621*x_4 - 0.000940126459080954*x_40 + 1.61756575952964e-5*x_41 - 3.52512382233798e-5*x_42 + 2.76418867290887e-5*x_43 + 2.79601872275142e-5*x_44 - 0.00335897692628966*x_45 + 0.000167825208371096*x_46 - 0.00092847566318534*x_47 + 0.00317349154950063*x_48 + 4.61361819583598e-5*x_49 + 0.00505296279924457*x_5 + 4.6596575993686e-5*x_50 + 8.22607297958281e-5*x_51 + 0.00112222737001568*x_52 - 2.45068744685407e-5*x_53 + 0.00229615870395134*x_54 + 0.000931860888460505*x_55 - 0.000294852300958638*x_56 + 0.0012388510517915*x_57 + 5.52373982369036e-5*x_58 + 2.03750128996353e-5*x_59 + 3.80964278390956e-5*x_6 + 0.000665281250283471*x_60 + 0.00281153902398031*x_61 + 0.000130075957361702*x_62 - 0.0030711594732601*x_63 - 0.000166720557375504*x_64 - 0.00390521889717747*x_65 + 0.000428255040190285*x_66 + 6.88287395952083e-5*x_67 + 0.00106061345867692*x_68 - 0.000910692226460841*x_69 + 0.000104770155984427*x_7 - 4.26835135876561e-5*x_70 + 0.000680999808241824*x_71 + 0.000577212797437896*x_72 - 0.00220144595521006*x_73 - 0.000997938958042185*x_74 + 0.000862416290167905*x_75 - 2.51894133767404e-5*x_76 + 0.00320610795128926*x_77 - 0.0020871131601216*x_78 + 0.000462195770777137*x_79 + 0.00431768552241035*x_8 - 0.00210503464842687*x_80 - 0.000212873286598417*x_81 - 5.74759391527333e-5*x_82 - 0.00263738505920863*x_83 - 6.09538668037175e-5*x_84 - 0.00239191746100832*x_86 + 4.93780056311554e-5*x_87 - 8.1438576435289e-6*x_88 + 0.000869780807840758*x_89 + 0.00297717537070789*x_9 + 9.86997056882074e-5*x_90 - 0.00437007614891416*x_91 - 9.76449435279364e-6*x_92 - 0.000207764477447265*x_93 + 0.000236042585013335*x_94 + 3.81821910837865e-5*x_95 + 0.000972484783439022*x_96 + 0.00407804075008446*x_97 - 0.000190576353886964*x_98 + 0.00453550266362316*x_99 + 9.61419509088782e-7*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 1.21195871673882e-5*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) + 5.55228336225481e-6*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) - 3.55310946337865e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) - 1.21827013544524e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) + 6.7849628076441e-6*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 2.17267321149213e-6*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 0.00017530972913023*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) + 2.68272747239062e-6*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 1.1643392786338e-5*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 0.000101964635523998*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) + 1.02824989789915e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 4.93993001667702e-6*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) + 1.03584201142712e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) + 1.1552963482718e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 1.89744930180415e-5*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) + 2.06691668861117e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) + 5.2586776316769e-5*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) + 2.6624381710241e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) + 1.01719168947402e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 1.95837819926291e-5*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 4.57617571759922e-5*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 2.01941837917454e-6*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) - 1.72190024264171e-6*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 6.97386213219736e-6*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 9.48666343754875e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) - 9.50174207992534e-6*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 1.62586929888264e-6*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 1.68125615692279e-6*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 0.000272480652077458*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 4.13846232204597e-6*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 1.01042553203614e-5*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) - 0.000714310434372616*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 3.05612987854535e-5*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 3.85536259876664e-7*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 6.22792604971232e-5*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 1.45476520132265e-6*std::pow(-6.0*x_85 - 9.9902400970459, 2) + 2.00008485248332e-6*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) + 5.92979230899705e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 4.25359335247968e-5*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) - 4.85681538224488e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 1.43900461901126e-5*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 8.75047762480123e-7*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 1.8325585859637e-6*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) + 0.0448872360323958*std::sin(0.276799947023392*x_1 + 5.19144010543823) - 0.0100433039168086*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.00533954812585833*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.00526121643806068*std::sin(0.257359951734543*x_10 + 5.08655977249146) - 0.0195967651397146*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.0926267770171619*std::sin(0.309999853372574*x_10 + 8.29687976837158) + 0.000589310096565421*std::sin(0.441439867019653*x_100 - 7.36719989776611) - 0.00333678259565556*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.000855746116477842*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.0441197582679312*std::sin(0.34487983584404*x_101 - 1.207279920578) - 0.00529864151263674*std::sin(0.30991992354393*x_102 + 8.30463981628418) - 0.00101961451806728*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.0298335995830864*std::sin(0.400079846382141*x_102 - 1.17423987388611) - 0.00616722693702747*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.000274449414509398*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.00256606169122854*std::sin(0.332959830760956*x_105 + 5.14432001113892) + 0.000318491771964674*std::sin(0.360079854726791*x_105 + 5.16247987747192) + 0.00381808622774317*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.00126164081797086*std::sin(0.41143986582756*x_106 - 7.37631988525391) - 0.00278339577990839*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.000827359700570924*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.0459583102621408*std::sin(0.363279849290848*x_107 + 5.16000032424927) + 0.00734451365206437*std::sin(0.343119859695435*x_108 + 5.14359998703003) - 0.00135315333293269*std::sin(0.377119839191437*x_108 + 5.17655992507935) - 0.00547505033139013*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.000571170689194832*std::sin(0.30583992600441*x_109 + 5.09887981414795) - 0.0001997210499019*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.00191776542294488*std::sin(0.264079958200455*x_11 + 8.28791999816895) + 0.00869143115105457*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.000509140714666451*std::sin(0.426799863576889*x_110 - 7.36663961410522) - 0.0020476442705769*std::sin(0.436079859733582*x_110 - 1.15799987316132) + 0.00100033049851822*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.0513421804954585*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.0397271680107066*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.0491981240202185*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 0.00021169116394631*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 0.016061997658812*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 0.0202876284360793*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 0.000375426271783871*std::sin(0.557679891586304*x_117 - 4.2129602432251) + 0.000822303198532208*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.00101917837910651*std::sin(0.355519831180573*x_118 - 7.42095994949341) - 0.00302330550407108*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.0343046676832501*std::sin(0.376959830522537*x_118 - 7.41655969619751) + 0.00113090242041711*std::sin(0.422559857368469*x_118 + 5.20847988128662) + 0.00233213884093078*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.00073339160980616*std::sin(0.434239864349365*x_119 - 1.16887986660004) + 0.000482950637842074*std::sin(0.46375983953476*x_119 + 8.23847961425781) - 0.00477686680787584*std::sin(0.362559854984283*x_12 - 4.22640037536621) - 0.00810791193850689*std::sin(0.403199851512909*x_12 + 8.3887996673584) + 0.000799646270852405*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.000345620120358258*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.00381999454527308*std::sin(0.336239844560623*x_15 - 1.06783974170685) - 0.00718134658987382*std::sin(0.344959855079651*x_16 - 4.25424003601074) + 0.0281065691167847*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.000375586800711606*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.0078935250193464*std::sin(0.161200016736984*x_18 + 4.95375967025757) - 0.00199703613498926*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 0.00912382169134825*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.0381757427906193*std::sin(0.112320065498352*x_23 - 4.53903961181641) + 0.000283180315833212*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.00367194300373505*std::sin(0.179120019078255*x_24 - 4.42608022689819) - 0.00552096204840198*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.00218136759459629*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 0.0240188267328393*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.00165958184565081*std::sin(0.318239837884903*x_26 - 4.27447986602783) + 0.0015719940202314*std::sin(0.326319843530655*x_26 - 4.26119995117188) - 0.0151249907066288*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.0682667634481466*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.26800144804644*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.00326787041135486*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.0149089563684979*std::sin(0.234879985451698*x_27 + 5.03936004638672) - 0.00177631776453876*std::sin(0.420319855213165*x_27 + 5.22671985626221) - 0.00236342238928667*std::sin(0.277679949998856*x_28 - 4.29263973236084) + 0.00204999486370184*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.0016826010054885*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 0.000206471890009031*std::sin(0.647999823093414*x_29 - 0.774399816989899) - 0.00544269827580473*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.163524425421372*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.00461665740369276*std::sin(0.334479838609695*x_3 + 8.32800006866455) - 0.00448281425934534*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 0.0146718825086585*std::sin(0.304079920053482*x_30 - 4.29239988327026) + 0.00560302274182053*std::sin(0.253279983997345*x_32 + 5.17439985275269) + 0.000911309044172866*std::sin(0.302559942007065*x_34 + 2.05271983146667) - 0.00316067831210027*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.00120332071203046*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.00122153266098983*std::sin(0.309599906206131*x_35 + 8.26696014404297) - 0.00078018948714665*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.0464443320467511*std::sin(0.321359843015671*x_35 + 1.95679974555969) - 0.00372591499221417*std::sin(0.360319852828979*x_36 - 4.23935985565186) + 0.000424346871958723*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.00053111121578033*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.000804819952351498*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 0.0228561618631282*std::sin(0.408959865570068*x_37 + 5.21288013458252) + 0.00167103513971517*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.00115651222845799*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.0011192269777044*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.0841849193081076*std::sin(0.321839839220047*x_38 - 4.2836799621582) + 0.00183075736485748*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.00126752786022309*std::sin(0.297759920358658*x_39 - 4.29871988296509) - 0.000491147068622607*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 0.0191978478082055*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.000870200994682473*std::sin(0.370639860630035*x_41 - 4.23487997055054) + 0.00257752126676094*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.0014757273937854*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.0348713489420682*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.00294446858756583*std::sin(0.293919950723648*x_42 - 1.09335994720459) + 0.0100166628517066*std::sin(0.356479853391647*x_42 - 7.42711973190308) + 0.00234565982093064*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.0337961903172557*std::sin(0.310479938983917*x_43 + 5.12063980102539) + 0.000468161788600394*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.000932681006422017*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.0651393341417721*std::sin(0.379759848117828*x_44 + 8.3834400177002) + 0.000838031963643469*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.00301364737077502*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.00193617455351684*std::sin(0.250719964504242*x_46 + 5.04783964157104) - 0.00236591011194088*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 0.0159129250184772*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.00139218099072498*std::sin(0.401119828224182*x_47 + 2.01015996932983) - 0.000370222823195858*std::sin(0.514399826526642*x_47 - 4.26032018661499) + 0.00321575707543538*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.000746238169174225*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.00182358291291412*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.0323783177143791*std::sin(0.409519851207733*x_49 - 4.18383979797363) - 0.000452524442703225*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.000589455514770029*std::sin(0.409279853105545*x_50 + 5.19200038909912) + 0.00242177469333708*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.0546732270290554*std::sin(0.34775984287262*x_51 - 4.25008010864258) + 0.00124793060592447*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.000545559033776137*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.0498181892888249*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.00125696156251121*std::sin(0.376719832420349*x_53 - 4.21767997741699) + 0.000537173134249756*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 0.000471651138414216*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.000875915587221932*std::sin(0.316559910774231*x_55 - 1.30199980735779) + 0.00113827931336974*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.000435441960649008*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.0018124290137148*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 0.00976704586374482*std::sin(0.333999842405319*x_56 + 5.12904024124146) + 0.000383663469681468*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 0.0188038287120098*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 0.000316018883968813*std::sin(0.54423987865448*x_58 - 4.2469596862793) - 0.00808483956929466*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.00154846310085784*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 0.0267652290645792*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.0045424657888149*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.00192956774295159*std::sin(0.356479853391647*x_60 + 5.16247987747192) + 0.000120290113971251*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.0602926779244621*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.0430792723596073*std::sin(0.193680003285408*x_64 - 4.40383958816528) + 0.00218707242134327*std::sin(0.247039973735809*x_64 + 5.06735944747925) + 0.000337952344675907*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.0012397078873596*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.0555285786932076*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.000534345655814549*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.00558331435631249*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 0.00935863941668831*std::sin(0.440319865942001*x_67 + 5.22703981399536) + 0.000721430273779657*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.00515766800327153*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.00237572893100141*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.126405958220864*std::sin(0.196319997310638*x_70 - 7.60400009155273) - 0.0052457714801448*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.000534594563141205*std::sin(0.350559860467911*x_70 - 7.45039987564087) - 0.00146650738598444*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.00123141827855366*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.000714531722476276*std::sin(0.320959836244583*x_73 - 4.27807998657227) - 0.00064373807769634*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.00161118901533964*std::sin(0.369439840316772*x_74 + 5.16767978668213) + 0.00132074799405347*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.00131402840675725*std::sin(0.302319914102554*x_75 - 7.47096014022827) - 0.00804047185329707*std::sin(0.316879838705063*x_75 + 5.1080002784729) + 0.000893694378702226*std::sin(0.358239859342575*x_75 + 5.16095972061157) - 0.0060445864445347*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.0611973851908972*std::sin(0.32399994134903*x_76 + 5.15583992004395) - 0.00143796607071397*std::sin(0.34607982635498*x_76 + 8.3244800567627) - 0.000556959387358028*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.000892073017035534*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.00196362633628026*std::sin(0.325119853019714*x_78 + 8.30047988891602) - 0.000635318967665244*std::sin(0.38487982749939*x_78 + 5.18024015426636) + 0.000791186564334035*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.0039264117519644*std::sin(0.295919924974442*x_79 + 5.10743999481201) - 0.00640285977056939*std::sin(0.221119999885559*x_8 + 8.23999977111816) - 0.0026351130572058*std::sin(0.226959988474846*x_8 + 8.22976016998291) + 0.0007475045034559*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.000266415941835021*std::sin(0.361999839544296*x_80 - 4.24368000030518) - 0.00145986698819409*std::sin(0.478479862213135*x_80 + 5.2771201133728) + 0.000359944815048241*std::sin(0.45551985502243*x_81 + 5.25024032592773) - 0.031032762769599*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.078697259235573*std::sin(0.324479848146439*x_82 - 7.46504020690918) - 0.000164567694534765*std::sin(0.453759849071503*x_82 + 5.2655200958252) + 0.00308819270949757*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.10051034006388*std::sin(0.162400022149086*x_84 - 4.45423984527588) + 0.00117014785659421*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.00179191846397704*std::sin(0.369279831647873*x_84 - 7.42456007003784) - 0.00129911897706853*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.0020711097299686*std::sin(0.242399975657463*x_85 - 7.54536008834839) + 0.00413738627900579*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 0.000200338989657835*std::sin(0.411919862031937*x_86 - 3.99207997322083) - 0.000614326012881057*std::sin(0.278639942407608*x_87 - 4.27216005325317) - 0.00577695997672456*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 0.00658274574272292*std::sin(0.3503198325634*x_87 + 5.3318395614624) + 0.00222156488093332*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.00182900603205357*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.0211722943619652*std::sin(0.189520001411438*x_9 - 4.41287994384766) - 0.0345195094805999*std::sin(0.202159985899925*x_9 - 4.39911985397339) - 0.00851981280707236*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.0602600447795317*std::sin(0.274079948663712*x_90 + 5.08575963973999) - 0.00896629883638929*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.00354731177548566*std::sin(0.193920001387596*x_91 - 7.38560009002686) - 0.00105064767579807*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.107395872761474*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.00252074574497475*std::sin(0.375679850578308*x_92 - 1.1775997877121) - 0.0028614520642027*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 0.0188124842072292*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.000466889411217588*std::sin(0.355199843645096*x_94 - 7.41871976852417) - 0.00112863767771374*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.0302929572673886*std::sin(0.401119858026505*x_94 - 7.40488004684448) + 0.00329889454652307*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.0609103738400395*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.000739183737003999*std::sin(0.397999823093414*x_95 - 7.40655994415283) - 0.000687132474872801*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.00154428249086302*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.00241731741965588*std::sin(0.368239849805832*x_97 + 5.17176008224487) + 0.00119665369406426*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 0.0168611938804305*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.000975848990794267*std::sin(0.413679867982864*x_98 - 7.38263988494873) + 0.000490741284178704*std::sin(0.454479843378067*x_98 - 1.14039981365204) + 0.000347607211779611*std::sin(0.473919868469238*x_99 + 5.23375988006592) - 0.000856770596458283*std::sin(0.621439814567566*x_99 - 7.38647985458374) + 0.6617719327279);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00207910483675262*x_1 - 0.000112927636889042*x_10 - 0.0011685647514993*x_100 + 0.000114799951657404*x_101 + 0.000764717725568654*x_102 + 0.00308916155296499*x_103 - 0.00249619349688671*x_104 - 0.000658301783887736*x_105 - 0.00318425493901911*x_106 - 0.000235360038538303*x_107 - 0.00176945219011772*x_108 + 0.00186572894365605*x_109 + 0.00157418593743229*x_11 - 0.00186350495014658*x_110 + 5.19971284305883e-5*x_111 - 1.61766434912925e-5*x_112 + 0.000559088643719755*x_113 - 7.58401567392492e-5*x_114 - 0.000309518407868328*x_115 + 0.00176269713372381*x_116 - 0.000627061316320973*x_117 - 5.68442013136748e-5*x_118 - 0.00554498028025651*x_119 + 0.000799226992419426*x_12 - 0.00028293996796494*x_120 + 0.00182375341544616*x_13 - 0.00124616040200065*x_14 - 0.000527585995961243*x_15 + 0.00171297970630691*x_16 - 0.000998626444371738*x_17 - 0.00035995693738276*x_18 + 0.000168015270216766*x_19 - 0.0194743624480936*x_2 - 0.000246511975653252*x_20 + 0.000121360180156427*x_21 + 0.000523014841915083*x_22 + 0.00398313398044034*x_23 - 0.00034368376232652*x_25 + 0.000579735166405341*x_26 - 0.000872663031446781*x_28 + 0.0104361709323846*x_29 - 7.69201324306794e-5*x_3 + 0.000807638021682282*x_30 + 0.0135300106521987*x_31 - 0.00370736211400239*x_32 - 0.00150635694783034*x_33 + 0.00342480164080209*x_34 + 0.00262022378752696*x_36 + 1.5911916185199e-5*x_37 - 6.29267265810203e-5*x_38 - 0.000310256278955853*x_39 - 0.00416071661294733*x_4 + 0.000555451080532698*x_40 - 5.50031152431483e-6*x_41 + 0.00059742620561554*x_42 + 0.000302139055426099*x_43 + 0.000152389769583907*x_44 + 0.00283508568659736*x_45 + 0.000498493689752858*x_46 + 0.000574130063858647*x_47 - 0.00356859545025181*x_48 + 0.000163853105293376*x_49 - 0.00389095743360891*x_5 + 0.000108139847494343*x_50 + 0.000238667271223703*x_51 - 0.000440998437951415*x_52 - 0.000138409030507134*x_53 - 0.0025067783780088*x_54 - 0.000812072061600685*x_55 - 0.000248320431370073*x_56 - 0.000458691667025767*x_57 - 0.000282667278230641*x_58 - 0.000614125459731241*x_59 - 1.2954170168608e-5*x_6 - 0.0010268055697891*x_60 - 0.00203736473936032*x_61 - 0.000198122984072685*x_62 + 0.00425501266777628*x_63 - 0.000395794478289449*x_64 + 0.0025086533649142*x_65 + 0.000673828672576553*x_66 - 2.34042732030674e-5*x_67 - 0.00159023115817427*x_68 + 0.00104054765401951*x_69 - 3.56256611498119e-5*x_7 + 0.000169392858781068*x_70 - 0.000339494047528316*x_71 + 0.000321169014545656*x_72 + 0.00214334896848098*x_73 + 0.00118739633446032*x_74 - 0.000902779058103706*x_75 + 7.53372373322436e-6*x_76 - 0.00262287503568833*x_77 + 0.00333539090019328*x_78 - 0.00203026324025951*x_79 - 0.00262487480951565*x_8 + 0.00166555840311212*x_80 - 0.000282359249852475*x_81 - 0.000361008565480999*x_82 + 0.00395705695925097*x_83 - 0.000666254945660528*x_84 + 0.0020941881142545*x_86 + 0.000260990373417455*x_87 - 0.000218464974799007*x_88 + 0.000813816199176687*x_89 - 0.00184919454745877*x_9 + 0.00053407149079116*x_90 + 0.00430558774277384*x_91 - 0.00021212235749849*x_92 - 0.0011343897086106*x_93 + 0.000381577489012236*x_94 + 2.61086741557362e-5*x_95 - 0.000726454799915385*x_96 - 0.00267138000713402*x_97 - 0.000422654614695935*x_98 - 0.0044597072585611*x_99 + 1.05087755112831e-5*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 4.30428333675861e-5*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 1.88797815382492e-6*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) - 3.35522049744119e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) - 1.150419082777e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 2.30713396986001e-6*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 7.71627034096635e-6*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) - 0.000170253723286708*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 9.12224850585172e-7*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 0.00012726785739691*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) - 9.90239328282623e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) + 9.70981943979409e-6*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 5.39958000601731e-5*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) + 9.78151217876118e-6*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) + 1.09095259470407e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 6.73880991101439e-5*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) + 1.95180061622335e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 1.78814153364496e-5*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) + 2.51415477532049e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) + 9.60539617911106e-6*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 6.95519949131667e-5*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) + 4.44419689769027e-5*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 7.17198429234799e-6*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 5.85508668969151e-7*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 7.62276518222103e-5*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) + 9.21306409988654e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) - 8.97254647416629e-6*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 1.77715298172372e-5*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 5.97099782452827e-6*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) + 0.000264622196212029*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 4.52353744574038e-5*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 3.58853624344686e-5*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) - 0.000674527209376806*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) - 2.96798981580526e-5*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 4.21409589487477e-6*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) + 6.04831006002029e-5*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 5.16661296170105e-6*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 6.80101547582245e-7*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) + 5.59953497233298e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) - 4.13091794277594e-5*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) - 4.58631705292302e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) - 1.39750312449254e-5*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 9.56469097061457e-6*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 2.00307426769603e-5*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) + 0.0423872599371491*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.00341508837896531*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.0583638173095943*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.0186852620742405*std::sin(0.257359951734543*x_10 + 5.08655977249146) - 0.018505331388746*std::sin(0.267119973897934*x_10 + 5.08279991149902) + 0.0899553820627068*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 0.000200386852678955*std::sin(0.441439867019653*x_100 - 7.36719989776611) - 0.00315094186538307*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.00303919077339764*std::sin(0.339919835329056*x_101 + 1.93815982341766) - 0.0428473260034803*std::sin(0.34487983584404*x_101 - 1.207279920578) - 0.00500353585923198*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.00034670599640505*std::sin(0.369759827852249*x_102 - 7.41752004623413) - 0.0289731861047601*std::sin(0.400079846382141*x_102 - 1.17423987388611) - 0.00582374577669487*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.00299986349248921*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.00911339340697184*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 0.000108298778792532*std::sin(0.360079854726791*x_105 + 5.16247987747192) + 0.00360543949021493*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.0137903381474892*std::sin(0.41143986582756*x_106 - 7.37631988525391) - 0.0026283757000719*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.00293837613731233*std::sin(0.505039870738983*x_106 + 5.25744009017944) - 0.0446328533899145*std::sin(0.363279849290848*x_107 + 5.16000032424927) + 0.00693546399375788*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.000460121316703621*std::sin(0.377119839191437*x_108 + 5.17655992507935) - 0.00517011966159193*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.00624316907929424*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 6.7912416292931e-5*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.00681096281563554*std::sin(0.264079958200455*x_11 + 8.28791999816895) + 0.00820736547823307*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.00556515176101953*std::sin(0.426799863576889*x_110 - 7.36663961410522) - 0.0019336015675618*std::sin(0.436079859733582*x_110 - 1.15799987316132) + 0.000944617504030502*std::sin(0.605519831180573*x_111 + 8.21232032775879) + 0.0498614505559845*std::sin(0.326959848403931*x_112 + 8.33672046661377) + 0.038581419884774*std::sin(0.345279842615128*x_113 - 4.24360036849976) - 0.0477792295654118*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 0.00231388576849501*std::sin(0.455279856920242*x_115 + 2.23247981071472) - 0.0155987629346213*std::sin(0.514239847660065*x_115 - 1.04975974559784) + 0.0197025247545384*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 0.00133333010729025*std::sin(0.557679891586304*x_117 - 4.2129602432251) + 0.000776505361082564*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.0111401076124769*std::sin(0.355519831180573*x_118 - 7.42095994949341) - 0.00285492375110792*std::sin(0.374719828367233*x_118 - 7.42935991287231) - 0.0333153067326222*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.000384547928221757*std::sin(0.422559857368469*x_118 + 5.20847988128662) + 0.00220225133017125*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.00801632140439512*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 0.000164220770831004*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.0016243083410171*std::sin(0.362559854984283*x_12 - 4.22640037536621) - 0.00765634512753185*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.00027190879709421*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.00377779338019671*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.0417543691917049*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.00244191886330902*std::sin(0.344959855079651*x_16 - 4.25424003601074) + 0.0265411853435301*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.00410534354292451*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.0862800074648243*std::sin(0.161200016736984*x_18 + 4.95375967025757) - 0.00188581203121032*std::sin(0.418559849262238*x_18 + 5.21335983276367) - 0.00886068686126451*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.135581527070659*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 9.62916002307969e-5*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.0130409417962956*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.00187732776866892*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.0238433921326669*std::sin(0.278879940509796*x_24 - 7.48816013336182) - 0.0233261137332912*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.0181400240932023*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.00053453510465918*std::sin(0.326319843530655*x_26 - 4.26119995117188) - 0.0142826105881445*std::sin(0.33111983537674*x_26 - 4.26255989074707) - 0.0662979214641643*std::sin(0.343999862670898*x_26 + 5.15895986557007) - 0.260272174296958*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.0357193880800699*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.0529493055985139*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.000604012604345603*std::sin(0.420319855213165*x_27 + 5.22671985626221) - 0.00223179255420564*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.000697072765492032*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.00597577406747444*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 0.00225683660564753*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.00185071524130693*std::sin(0.315759837627411*x_3 + 8.31560039520264) - 0.158808312661453*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.0504622756343818*std::sin(0.334479838609695*x_3 + 8.32800006866455) - 0.00423314576829131*std::sin(0.280559957027435*x_30 + 8.27775955200195) - 0.0142487392862755*std::sin(0.304079920053482*x_30 - 4.29239988327026) + 0.00529096470141087*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.000309878198666489*std::sin(0.302559942007065*x_34 + 2.05271983146667) - 0.00298464563725897*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.0131528714689704*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.0043382852941995*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.000265292783432176*std::sin(0.313279837369919*x_35 + 5.1625599861145) - 0.0451048581031663*std::sin(0.321359843015671*x_35 + 1.95679974555969) - 0.00351840169362892*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 0.00014429336034043*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.00580529985651114*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.00285832599918826*std::sin(0.440559864044189*x_36 + 5.23559999465942) + 0.0221969806042568*std::sin(0.408959865570068*x_37 + 5.21288013458252) + 0.00157796752689556*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.00410736458672795*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.0122336866931429*std::sin(0.292959928512573*x_38 - 7.50207996368408) - 0.0817569910575195*std::sin(0.321839839220047*x_38 - 4.2836799621582) + 0.00172879408859254*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.0138546863377113*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 0.000167007855214734*std::sin(0.312559843063354*x_39 - 1.05167984962463) - 0.0186441738553513*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.00951171347820953*std::sin(0.370639860630035*x_41 - 4.23487997055054) + 0.00243396728301282*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.00524106039499491*std::sin(0.407439857721329*x_41 - 7.40343999862671) + 0.033865644667141*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.0104573092317632*std::sin(0.293919950723648*x_42 - 1.09335994720459) + 0.00945878894596329*std::sin(0.356479853391647*x_42 - 7.42711973190308) + 0.0022150192647673*std::sin(0.309359908103943*x_43 - 7.46832036972046) + 0.0328214940663369*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 0.000159192024553696*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.00331242579388838*std::sin(0.4336798787117*x_43 - 1.18711996078491) + 0.0632606885258218*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.000284961327860496*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.0107029983626816*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.0211633148081752*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.0008044954325681*std::sin(0.287759929895401*x_46 + 5.09239959716797) + 0.0154539896115257*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.01521720473144*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 0.000125889216496564*std::sin(0.514399826526642*x_47 - 4.26032018661499) + 0.00303665681158962*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.008156740448543*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.0199326342734496*std::sin(0.202960014343262*x_49 + 5.00367975234985) - 0.0314445135018034*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 0.000153874758572935*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.00644303097664104*std::sin(0.409279853105545*x_50 + 5.19200038909912) + 0.00228689495075175*std::sin(0.41407984495163*x_50 - 1.16055989265442) - 0.0530964283156322*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.000424341764955974*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.0059632214240584*std::sin(0.375039845705032*x_52 - 4.20832014083862) - 0.0483814118925694*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.00446411138740876*std::sin(0.376719832420349*x_53 - 4.21767997741699) + 0.000507255498116759*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 0.0016750736702503*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.00311082284768861*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.000387056339955991*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.00475958909653332*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.0198107168153025*std::sin(0.234799981117249*x_56 + 5.04367971420288) - 0.00948536017974973*std::sin(0.333999842405319*x_56 + 5.12904024124146) + 0.000362295490995258*std::sin(0.440479874610901*x_58 + 5.2324800491333) - 0.0182615184345358*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 0.00112234418349511*std::sin(0.54423987865448*x_58 - 4.2469596862793) - 0.00763455776440575*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.00549938197609768*std::sin(0.3572798371315*x_59 + 5.15119981765747) + 0.0259933086741644*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.0161326120539843*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.0210910992057048*std::sin(0.356479853391647*x_60 + 5.16247987747192) + 0.000113590605692203*std::sin(1.10423994064331*x_60 - 3.81703996658325) - 0.0585538118990562*std::sin(0.319679856300354*x_62 + 8.32096004486084) + 0.0418368481435328*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.000743684117492912*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 0.000114916080854149*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.00440283478992466*std::sin(0.312959939241409*x_65 + 5.13624000549316) + 0.0539271112803707*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.00584065383456442*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.0198291960079527*std::sin(0.23463998734951*x_67 - 4.35623979568481) + 0.00908873234528418*std::sin(0.440319865942001*x_67 + 5.22703981399536) + 0.00068125051226494*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.0183175087867278*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.0259678545895295*std::sin(0.237919986248016*x_69 + 5.03039979934692) + 0.122760357565432*std::sin(0.196319997310638*x_70 - 7.60400009155273) - 0.00495361040139127*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.00584337451080846*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.000498665814858035*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.0134599913227017*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.00781017380676036*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 0.000218894344575089*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.00572215368008234*std::sin(0.369439840316772*x_74 + 5.16767978668213) + 0.00124718947932122*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.0143629595733383*std::sin(0.302319914102554*x_75 - 7.47096014022827) - 0.00759266109004937*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.000303888572160468*std::sin(0.358239859342575*x_75 + 5.16095972061157) - 0.00570793569584339*std::sin(0.285439938306808*x_76 + 5.11615991592407) - 0.0594324270298838*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.000488960730265559*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 0.000189386435686639*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.00975078515369896*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.0214633759362449*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 0.000216031541152372*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.000269032189390246*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.0139446900656069*std::sin(0.295919924974442*x_79 + 5.10743999481201) - 0.00604625513676908*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.000896034218765622*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 0.000254178700965535*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.00291205379015536*std::sin(0.361999839544296*x_80 - 4.24368000030518) - 0.00137856029846851*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 0.000122394320148252*std::sin(0.45551985502243*x_81 + 5.25024032592773) - 0.0293044058478792*std::sin(0.15504002571106*x_82 - 7.66024017333984) - 0.0764275973945656*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 5.59589977376067e-5*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.00105009776877905*std::sin(0.168000012636185*x_83 - 7.6276798248291) + 0.09761157985691*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.000397892802988669*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.00636401609955878*std::sin(0.369279831647873*x_84 - 7.42456007003784) - 0.00122676508151548*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.0226382208866372*std::sin(0.242399975657463*x_85 - 7.54536008834839) + 0.00390695625683085*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 0.0021898010686998*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 0.000208893173487959*std::sin(0.278639942407608*x_87 - 4.27216005325317) - 0.00545521457376445*std::sin(0.310479938983917*x_87 + 5.13271999359131) - 0.00639289660481852*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.000755412807462235*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.00649573296339904*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.0751936122612946*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 0.0117378879152987*std::sin(0.202159985899925*x_9 - 4.39911985397339) - 0.00804530534712794*std::sin(0.185840010643005*x_90 - 4.4215202331543) - 0.0585221199076617*std::sin(0.274079948663712*x_90 + 5.08575963973999) - 0.00846692452121349*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.0387738159718032*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.000357258398005849*std::sin(0.340719848871231*x_92 + 5.18991994857788) - 0.104298530914298*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.00895245337687372*std::sin(0.375679850578308*x_92 - 1.1775997877121) - 0.00270208467180994*std::sin(0.332239836454391*x_93 - 4.21600008010864) - 0.0182699243016563*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.00510332478662827*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.000383777833385268*std::sin(0.380479842424393*x_94 + 5.18048000335693) + 0.0294192957214985*std::sin(0.401119858026505*x_94 - 7.40488004684448) + 0.00311516397551854*std::sin(0.381519854068756*x_95 + 5.17264032363892) + 0.0591536932063162*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.00807963212763245*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 0.000233650016885424*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.0168797469461231*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.00858512665932942*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.000406905751144824*std::sin(0.371759831905365*x_97 + 5.18296003341675) - 0.0163749100032539*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.00346573731617762*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 0.000166869873754627*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 0.000118199086598019*std::sin(0.473919868469238*x_99 + 5.23375988006592) - 0.000809053111498635*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 0.0465610978492476);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000120050443876519*x_1 + 0.00344202719812564*x_10 + 2.75265826018508e-5*x_100 - 2.69645990060648e-5*x_101 + 2.37623157371999e-5*x_102 + 0.0016190545035389*x_103 + 3.55369264519367e-5*x_104 + 1.46241063867411e-5*x_105 + 0.000708435216109559*x_106 + 0.00199722680887222*x_107 + 0.000106043853064127*x_108 - 0.000139301601063182*x_109 + 0.000958428367794032*x_11 + 0.000506613148255709*x_110 + 7.5671423819285e-5*x_111 - 0.000961927442547151*x_112 + 0.000528697053099261*x_113 + 0.0011880681563537*x_114 + 0.00397531250352604*x_115 - 0.00152472156462222*x_116 - 0.00236121408571188*x_117 - 1.24955797209249e-6*x_118 + 0.000398023658417453*x_119 - 0.000126230370652151*x_12 + 3.02811449490083e-5*x_120 - 0.000146920749672889*x_13 + 6.38425027826705e-5*x_14 - 0.000712060149089719*x_15 - 5.75837548691237e-5*x_16 + 0.000202237170983657*x_17 - 0.0023687366050725*x_18 - 0.00701771318577627*x_19 - 0.0189604903137364*x_2 + 0.00236337905304939*x_20 - 0.000222128319275443*x_21 - 0.00112214281812608*x_22 - 0.000364875896215116*x_23 + 0.00228323116784541*x_25 + 1.27438275522026e-5*x_26 + 8.2856315789871e-5*x_28 + 0.00889781406954603*x_29 - 0.000163391224910523*x_3 + 0.00132433222154724*x_30 + 0.000250638113092539*x_31 + 0.00206899530124692*x_32 - 0.000942928391702959*x_33 - 0.000157217884558528*x_34 - 0.000193225599888329*x_36 - 0.00103172717806786*x_37 - 0.000510604125563887*x_38 - 1.5424494447223e-5*x_39 + 0.000152172830215346*x_4 - 0.00150345979992701*x_40 - 0.000586200591510631*x_41 + 0.00318236114721802*x_42 + 1.19314864645394e-5*x_43 - 6.05316409930476e-6*x_44 + 0.00105421072211743*x_45 - 5.00200498205719e-6*x_46 - 5.99421628990553e-5*x_47 + 0.00149130082495753*x_48 + 3.60184415014718e-6*x_49 + 0.000390599667901006*x_5 - 0.000531564097886619*x_50 + 0.00113376534027893*x_51 - 8.13709195866839e-5*x_52 - 0.000125068190843204*x_53 + 0.00102264260355456*x_54 + 4.35767132204154e-5*x_55 + 0.00190070273781558*x_56 + 0.000174666716927118*x_57 - 0.00286039704479134*x_58 - 0.00271404548751927*x_59 - 0.00138060220440211*x_6 - 0.000878489561958342*x_60 + 0.000294984530518405*x_61 - 0.00350280240079284*x_62 + 0.00174990204328079*x_63 + 3.95806790224294e-5*x_64 - 4.3582553607519e-5*x_65 - 0.00228770875270745*x_66 - 0.00249433122739781*x_67 + 0.000244356164045717*x_68 - 0.00174417992507543*x_69 - 0.00379683651492421*x_7 + 0.00299223981683766*x_70 - 8.1039515768155e-5*x_71 + 0.00147484136684951*x_72 - 7.02135958024897e-5*x_73 - 6.48677446467792e-5*x_74 + 6.16707004661141e-5*x_75 + 2.68110052960848e-6*x_76 + 0.000134274948106266*x_77 - 0.000192192333274453*x_78 + 0.000232134850210169*x_79 + 0.000357454915069954*x_8 - 0.000151296932227206*x_80 + 7.1296713807284e-5*x_81 - 1.20044034269168e-5*x_82 - 0.000445254614175079*x_83 - 2.6310441246565e-5*x_84 + 0.00148561599414578*x_86 + 7.9577414602761e-6*x_87 - 9.71800266594685e-6*x_88 - 0.00056288231417349*x_89 + 8.16299812752623e-5*x_9 + 0.00172057349201061*x_90 + 0.000224287592897987*x_91 - 1.30535175472562e-5*x_92 + 0.00286791468090753*x_93 - 6.6345123523359e-5*x_94 - 0.00101888517779806*x_95 + 5.40088415881901e-5*x_96 + 0.000305600512692968*x_97 + 5.69917651957805e-5*x_98 + 0.00032213003735009*x_99 + 4.1499207242483e-7*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 9.46174180179343e-7*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) - 0.000201212950509958*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) + 1.4420264692687e-5*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) + 4.9443390363805e-6*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) - 0.000245884854311899*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 1.69620240878568e-7*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) + 1.25551786728664e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) - 9.72211745898043e-5*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) + 5.02581407676898e-6*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) + 7.30241398277731e-6*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) - 4.1731435101452e-6*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) + 2.13229685467628e-6*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) - 4.20395603865824e-6*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) - 4.68876045398625e-6*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 1.48133555439686e-6*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) - 8.38856389162947e-6*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) - 0.00190572773940832*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) - 1.08054827890309e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) - 4.12826386482022e-6*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 1.52890264460055e-6*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) - 3.27732545466489e-6*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 1.57655661283249e-7*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) + 6.24011070222197e-5*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) + 3.01023379667905e-6*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) - 6.79407555180776e-6*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) + 3.85627398329225e-6*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) - 7.01798604518336e-7*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 1.31255392116686e-7*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) - 1.95142807458809e-5*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) + 1.78634720789646e-6*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 7.88837553789878e-7*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) + 0.000289902285380382*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) + 2.18871233576083e-6*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) + 1.66414858413654e-7*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) - 4.4602615441526e-6*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 1.13573280401722e-7*std::pow(-6.0*x_85 - 9.9902400970459, 2) - 7.24824271711901e-5*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) - 2.40660119114615e-6*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) + 3.04630124106959e-6*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) + 1.97113441331715e-5*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) + 1.03057372756222e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) + 3.77710126525842e-7*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) + 7.91015033749191e-7*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) - 0.0182174467626663*std::sin(0.276799947023392*x_1 + 5.19144010543823) + 0.363966080641209*std::sin(0.281999945640564*x_1 + 1.99319982528687) - 0.002304790075107*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.000410742303452645*std::sin(0.257359951734543*x_10 + 5.08655977249146) + 0.00795333055026091*std::sin(0.267119973897934*x_10 + 5.08279991149902) - 0.00663366340882497*std::sin(0.309999853372574*x_10 + 8.29687976837158) - 0.0213564070056904*std::sin(0.441439867019653*x_100 - 7.36719989776611) + 0.00135423039304704*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 6.68079588039769e-5*std::sin(0.339919835329056*x_101 + 1.93815982341766) + 0.00315973021466515*std::sin(0.34487983584404*x_101 - 1.207279920578) + 0.002150449174488*std::sin(0.30991992354393*x_102 + 8.30463981628418) + 0.0369504998534134*std::sin(0.369759827852249*x_102 - 7.41752004623413) + 0.00213659661148728*std::sin(0.400079846382141*x_102 - 1.17423987388611) + 0.00250296383402832*std::sin(0.306879937648773*x_104 + 5.10343980789185) - 0.000118464759895484*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.000200332014899069*std::sin(0.332959830760956*x_105 + 5.14432001113892) - 0.0115420386477054*std::sin(0.360079854726791*x_105 + 5.16247987747192) - 0.00154956706487744*std::sin(0.407039850950241*x_105 - 7.39559984207153) + 0.000544581145645482*std::sin(0.41143986582756*x_106 - 7.37631988525391) + 0.00112963882212119*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 6.45918359750384e-5*std::sin(0.505039870738983*x_106 + 5.25744009017944) + 0.00329140202147919*std::sin(0.363279849290848*x_107 + 5.16000032424927) - 0.00298076465117154*std::sin(0.343119859695435*x_108 + 5.14359998703003) + 0.0490378384616883*std::sin(0.377119839191437*x_108 + 5.17655992507935) + 0.00222204454431174*std::sin(0.20440000295639*x_109 + 8.20039939880371) - 0.000246543060314988*std::sin(0.30583992600441*x_109 + 5.09887981414795) + 0.00723782615327256*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.000149719631681332*std::sin(0.264079958200455*x_11 + 8.28791999816895) - 0.00352740997845007*std::sin(0.291839927434921*x_11 + 8.31551933288574) - 0.000219768122383481*std::sin(0.426799863576889*x_110 - 7.36663961410522) + 0.000831034694610987*std::sin(0.436079859733582*x_110 - 1.15799987316132) - 0.000405983286399613*std::sin(0.605519831180573*x_111 + 8.21232032775879) - 0.00367697932552383*std::sin(0.326959848403931*x_112 + 8.33672046661377) - 0.00284514553194524*std::sin(0.345279842615128*x_113 - 4.24360036849976) + 0.0035234281662989*std::sin(0.380559861660004*x_114 + 5.17543983459473) + 9.1375465142544e-5*std::sin(0.455279856920242*x_115 + 2.23247981071472) + 0.00115031408382213*std::sin(0.514239847660065*x_115 - 1.04975974559784) - 0.00145294160870264*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 2.9309467394956e-5*std::sin(0.557679891586304*x_117 - 4.2129602432251) - 0.000333731057337084*std::sin(0.677919805049896*x_117 + 2.03951978683472) - 0.000439923408790464*std::sin(0.355519831180573*x_118 - 7.42095994949341) + 0.00122700598067435*std::sin(0.374719828367233*x_118 - 7.42935991287231) + 0.00245680165164457*std::sin(0.376959830522537*x_118 - 7.41655969619751) - 0.0409835373853415*std::sin(0.422559857368469*x_118 + 5.20847988128662) - 0.000946496575265634*std::sin(0.397839844226837*x_119 + 1.99255979061127) - 0.000316564934635974*std::sin(0.434239864349365*x_119 - 1.16887986660004) - 0.0175019746743269*std::sin(0.46375983953476*x_119 + 8.23847961425781) + 0.173112105758135*std::sin(0.362559854984283*x_12 - 4.22640037536621) + 0.00329058919977908*std::sin(0.403199851512909*x_12 + 8.3887996673584) - 0.028978921828146*std::sin(0.491039842367172*x_120 - 7.3458399772644) - 0.000149185250208968*std::sin(0.461919873952866*x_14 + 2.24759984016418) + 0.00164888213522619*std::sin(0.336239844560623*x_15 - 1.06783974170685) + 0.260249674180233*std::sin(0.344959855079651*x_16 - 4.25424003601074) - 0.0114070272938322*std::sin(0.345839828252792*x_16 - 4.24904012680054) - 0.000162120222576353*std::sin(0.503919839859009*x_16 - 1.2526398897171) + 0.0034072018255803*std::sin(0.161200016736984*x_18 + 4.95375967025757) + 0.000810495425604535*std::sin(0.418559849262238*x_18 + 5.21335983276367) + 0.000653421872719662*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.00298037397138798*std::sin(0.112320065498352*x_23 - 4.53903961181641) - 0.0102623629158586*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.000286667987385993*std::sin(0.179120019078255*x_24 - 4.42608022689819) + 0.200077876241772*std::sin(0.186080008745193*x_24 + 4.97135972976685) - 0.000941576752129633*std::sin(0.278879940509796*x_24 - 7.48816013336182) + 0.0017201593011384*std::sin(0.341279864311218*x_24 - 1.07183980941772) + 0.000716350461972636*std::sin(0.318239837884903*x_26 - 4.27447986602783) - 0.056968554080842*std::sin(0.326319843530655*x_26 - 4.26119995117188) + 0.00613846468035973*std::sin(0.33111983537674*x_26 - 4.26255989074707) + 0.00488906928760972*std::sin(0.343999862670898*x_26 + 5.15895986557007) + 0.0191934930337518*std::sin(0.188480004668236*x_27 - 7.59960031509399) - 0.00141056042820398*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.0011639397757088*std::sin(0.234879985451698*x_27 + 5.03936004638672) + 0.0643731803884282*std::sin(0.420319855213165*x_27 + 5.22671985626221) + 0.000959192976895474*std::sin(0.277679949998856*x_28 - 4.29263973236084) - 0.0742911498105159*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.000131360384223393*std::sin(0.340159833431244*x_28 + 8.32423973083496) + 8.91225908381344e-5*std::sin(0.647999823093414*x_29 - 0.774399816989899) + 0.197241622474648*std::sin(0.315759837627411*x_3 + 8.31560039520264) + 0.0117111491115134*std::sin(0.323519825935364*x_3 + 8.31744003295898) + 0.00199275779773777*std::sin(0.334479838609695*x_3 + 8.32800006866455) + 0.00181934637404731*std::sin(0.280559957027435*x_30 + 8.27775955200195) + 0.00105075803423705*std::sin(0.304079920053482*x_30 - 4.29239988327026) - 0.00227398203880178*std::sin(0.253279983997345*x_32 + 5.17439985275269) - 0.0330255445626187*std::sin(0.302559942007065*x_34 + 2.05271983146667) + 0.00128275861857577*std::sin(0.244959965348244*x_35 + 2.04167985916138) + 0.000519407554513362*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 9.53648542736143e-5*std::sin(0.309599906206131*x_35 + 8.26696014404297) + 0.0282738142892399*std::sin(0.313279837369919*x_35 + 5.1625599861145) + 0.00332620950406993*std::sin(0.321359843015671*x_35 + 1.95679974555969) + 0.00151215944692817*std::sin(0.360319852828979*x_36 - 4.23935985565186) - 0.015378193182095*std::sin(0.376719832420349*x_36 - 4.20711994171143) + 0.000229251582728593*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 6.28321615324675e-5*std::sin(0.440559864044189*x_36 + 5.23559999465942) - 0.00163689258657377*std::sin(0.408959865570068*x_37 + 5.21288013458252) - 0.000678188197516446*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 9.02887197818996e-5*std::sin(0.424719840288162*x_37 - 7.38560009002686) - 0.00048310890157778*std::sin(0.292959928512573*x_38 - 7.50207996368408) + 0.00602908183543519*std::sin(0.321839839220047*x_38 - 4.2836799621582) - 0.000743011327442394*std::sin(0.463599860668182*x_38 + 5.25464010238647) + 0.000547122258907287*std::sin(0.297759920358658*x_39 - 4.29871988296509) + 0.0177990106707627*std::sin(0.312559843063354*x_39 - 1.05167984962463) + 0.00137489465394967*std::sin(0.347359836101532*x_41 - 4.24991989135742) - 0.00037561804269158*std::sin(0.370639860630035*x_41 - 4.23487997055054) - 0.00104608482515985*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.000115209795325396*std::sin(0.407439857721329*x_41 - 7.40343999862671) - 0.00249738573383057*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.000229874179163506*std::sin(0.293919950723648*x_42 - 1.09335994720459) - 0.00406525414282235*std::sin(0.356479853391647*x_42 - 7.42711973190308) - 0.000951984053557875*std::sin(0.309359908103943*x_43 - 7.46832036972046) - 0.00242038596488924*std::sin(0.310479938983917*x_43 + 5.12063980102539) - 0.0169660315683257*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 7.2814253029575e-5*std::sin(0.4336798787117*x_43 - 1.18711996078491) - 0.00466509179404391*std::sin(0.379759848117828*x_44 + 8.3834400177002) - 0.0303700069007066*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.000235274955409819*std::sin(0.338559836149216*x_45 - 4.26592016220093) + 0.000835740364059924*std::sin(0.250719964504242*x_46 + 5.04783964157104) + 0.0857398160730118*std::sin(0.287759929895401*x_46 + 5.09239959716797) - 0.00113963793000041*std::sin(0.442719846963882*x_46 - 7.3452000617981) + 0.000600928178666762*std::sin(0.401119828224182*x_47 + 2.01015996932983) + 0.0134167551872052*std::sin(0.514399826526642*x_47 - 4.26032018661499) - 0.00130511228807074*std::sin(0.278799951076508*x_48 + 5.11183977127075) - 0.000322110089737658*std::sin(0.338479846715927*x_48 + 5.15136003494263) - 0.000787140727970035*std::sin(0.202960014343262*x_49 + 5.00367975234985) + 0.00231884200636054*std::sin(0.409519851207733*x_49 - 4.18383979797363) + 0.0163993392183812*std::sin(0.45023986697197*x_49 + 5.23031997680664) - 0.00025443561667321*std::sin(0.409279853105545*x_50 + 5.19200038909912) - 0.000982875210119859*std::sin(0.41407984495163*x_50 - 1.16055989265442) + 0.00391553929937374*std::sin(0.34775984287262*x_51 - 4.25008010864258) - 0.0452246009194622*std::sin(0.331839829683304*x_52 - 4.27472019195557) + 0.000235487913357851*std::sin(0.375039845705032*x_52 - 4.20832014083862) + 0.00356783545775282*std::sin(0.308639854192734*x_53 + 5.103600025177) - 9.81307827981312e-5*std::sin(0.376719832420349*x_53 - 4.21767997741699) - 0.000218011262009246*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 3.68217269331208e-5*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 6.83825860732367e-5*std::sin(0.316559910774231*x_55 - 1.30199980735779) - 0.0412508735963652*std::sin(0.31879985332489*x_55 - 4.28104019165039) - 0.000187956412327988*std::sin(0.404239863157272*x_55 + 5.19928026199341) + 0.000782326201428203*std::sin(0.234799981117249*x_56 + 5.04367971420288) + 0.000699487738266384*std::sin(0.333999842405319*x_56 + 5.12904024124146) - 0.000155709494535543*std::sin(0.440479874610901*x_58 + 5.2324800491333) + 0.00134667613933669*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 2.46715423826453e-5*std::sin(0.54423987865448*x_58 - 4.2469596862793) + 0.00328122529825685*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.000120888260033684*std::sin(0.3572798371315*x_59 + 5.15119981765747) - 0.00191684873847679*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.000354629558281469*std::sin(0.197759985923767*x_6 - 4.38903999328613) + 0.000832888566293529*std::sin(0.356479853391647*x_60 + 5.16247987747192) - 4.88196409724311e-5*std::sin(1.10423994064331*x_60 - 3.81703996658325) + 0.00431798821299233*std::sin(0.319679856300354*x_62 + 8.32096004486084) - 0.00308521360597253*std::sin(0.193680003285408*x_64 - 4.40383958816528) - 0.0792587960962288*std::sin(0.247039973735809*x_64 + 5.06735944747925) - 0.0122472834989428*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 9.6783791212016e-5*std::sin(0.312959939241409*x_65 + 5.13624000549316) - 0.00397679712587797*std::sin(0.225519984960556*x_66 + 5.03727960586548) + 0.000230647713096498*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.000435888435043614*std::sin(0.23463998734951*x_67 - 4.35623979568481) - 0.00067023884295758*std::sin(0.440319865942001*x_67 + 5.22703981399536) - 0.000292791866179318*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.000402658294150816*std::sin(0.213760003447533*x_69 + 5.00463962554932) - 0.00102547188118777*std::sin(0.237919986248016*x_69 + 5.03039979934692) - 0.00905283122991354*std::sin(0.196319997310638*x_70 - 7.60400009155273) + 0.00212899191653683*std::sin(0.225439995527267*x_70 - 4.37183952331543) + 0.000230755152737938*std::sin(0.350559860467911*x_70 - 7.45039987564087) + 0.0531457526257706*std::sin(0.235279992222786*x_71 + 5.05199956893921) - 0.000531535732952982*std::sin(0.302239835262299*x_71 - 4.30936002731323) - 0.000308424155657872*std::sin(0.320959836244583*x_73 - 4.27807998657227) + 0.0233288594111464*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.000125785261877981*std::sin(0.369439840316772*x_74 + 5.16767978668213) - 0.000536024455843136*std::sin(0.417439848184586*x_74 - 4.18495988845825) + 0.000567193994494794*std::sin(0.302319914102554*x_75 - 7.47096014022827) + 0.00326321869826072*std::sin(0.316879838705063*x_75 + 5.1080002784729) - 0.0323871947918401*std::sin(0.358239859342575*x_75 + 5.16095972061157) + 0.00245319029392169*std::sin(0.285439938306808*x_76 + 5.11615991592407) + 0.00438278074580318*std::sin(0.32399994134903*x_76 + 5.15583992004395) + 0.0521114246056901*std::sin(0.34607982635498*x_76 + 8.3244800567627) + 0.020184027783304*std::sin(0.310159921646118*x_77 - 7.46808004379272) + 0.000385058995156776*std::sin(0.324559837579727*x_77 + 8.30447959899902) - 0.000847589793068857*std::sin(0.325119853019714*x_78 + 8.30047988891602) + 0.023023753590802*std::sin(0.38487982749939*x_78 + 5.18024015426636) - 0.0286723448042532*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.000306534320777698*std::sin(0.295919924974442*x_79 + 5.10743999481201) + 0.00259859522014192*std::sin(0.221119999885559*x_8 + 8.23999977111816) + 0.0954956436071326*std::sin(0.226959988474846*x_8 + 8.22976016998291) - 0.0270893210678574*std::sin(0.31743985414505*x_80 - 4.30200004577637) - 0.000114997150342743*std::sin(0.361999839544296*x_80 - 4.24368000030518) + 0.000592485781900357*std::sin(0.478479862213135*x_80 + 5.2771201133728) - 0.0130442835012667*std::sin(0.45551985502243*x_81 + 5.25024032592773) + 0.0125946205118446*std::sin(0.15504002571106*x_82 - 7.66024017333984) + 0.00563607140156791*std::sin(0.324479848146439*x_82 - 7.46504020690918) + 0.00596387994191172*std::sin(0.453759849071503*x_82 + 5.2655200958252) - 0.111915103441155*std::sin(0.168000012636185*x_83 - 7.6276798248291) - 0.00719826152395196*std::sin(0.162400022149086*x_84 - 4.45423984527588) - 0.0424057792797174*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.000139894780258186*std::sin(0.369279831647873*x_84 - 7.42456007003784) + 0.000527246337601069*std::sin(0.417599856853485*x_84 - 4.17431974411011) + 0.000893984479130776*std::sin(0.242399975657463*x_85 - 7.54536008834839) - 0.00167915472050844*std::sin(0.301359921693802*x_86 + 1.90327990055084) - 8.64753541192434e-5*std::sin(0.411919862031937*x_86 - 3.99207997322083) + 0.0222629757096218*std::sin(0.278639942407608*x_87 - 4.27216005325317) + 0.00234457431841157*std::sin(0.310479938983917*x_87 + 5.13271999359131) + 0.00047143732049544*std::sin(0.3503198325634*x_87 + 5.3318395614624) - 0.0805087916587108*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.000142790200608318*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.00165291754444844*std::sin(0.189520001411438*x_9 - 4.41287994384766) + 1.25097584175302*std::sin(0.202159985899925*x_9 - 4.39911985397339) + 0.00345775881875878*std::sin(0.185840010643005*x_90 - 4.4215202331543) + 0.00431565112099354*std::sin(0.274079948663712*x_90 + 5.08575963973999) + 0.00363896479596542*std::sin(0.188960000872612*x_91 + 2.00175976753235) + 0.00153117993896446*std::sin(0.193920001387596*x_91 - 7.38560009002686) + 0.0380751314370793*std::sin(0.340719848871231*x_92 + 5.18991994857788) + 0.00769138357544942*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.000196794206415699*std::sin(0.375679850578308*x_92 - 1.1775997877121) + 0.00116131789905515*std::sin(0.332239836454391*x_93 - 4.21600008010864) + 0.00134729602101423*std::sin(0.424639850854874*x_93 + 1.99519979953766) + 0.000201530551983529*std::sin(0.355199843645096*x_94 - 7.41871976852417) + 0.0409014638433842*std::sin(0.380479842424393*x_94 + 5.18048000335693) - 0.00216949448789027*std::sin(0.401119858026505*x_94 - 7.40488004684448) - 0.00133885356036538*std::sin(0.381519854068756*x_95 + 5.17264032363892) - 0.0043622258181957*std::sin(0.384479850530624*x_95 - 7.396559715271) - 0.000319065078274476*std::sin(0.397999823093414*x_95 - 7.40655994415283) + 0.0249014583081758*std::sin(0.314559936523438*x_96 + 5.12815999984741) + 0.000666582054175315*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.000188719574040495*std::sin(0.368239849805832*x_97 + 5.17176008224487) - 0.043366342243658*std::sin(0.371759831905365*x_97 + 5.18296003341675) + 0.00120755021901487*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 7.61843704815386e-5*std::sin(0.413679867982864*x_98 - 7.38263988494873) - 0.0177843051739605*std::sin(0.454479843378067*x_98 - 1.14039981365204) - 0.0125971727553025*std::sin(0.473919868469238*x_99 + 5.23375988006592) + 0.000347719621620988*std::sin(0.621439814567566*x_99 - 7.38647985458374) - 1.60197649999389);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00108717280746672*x_1 - 0.0007918960523847*x_10 + 0.000367145222685111*x_100 - 0.000263039263349379*x_101 - 0.000644330158881694*x_102 + 0.00193999899221035*x_103 - 0.000986226617843998*x_104 + 0.00054502163382518*x_105 - 0.00163754394910614*x_106 - 0.000946204384144082*x_107 - 0.000161310827787306*x_108 + 0.000860562195590931*x_109 - 0.00840993421380693*x_11 - 0.000939988858966719*x_110 + 9.06972520776725e-5*x_111 - 3.55037460936182e-5*x_112 - 0.000148004159723736*x_113 - 0.0012215781498815*x_114 - 0.00165743488460672*x_115 + 0.0007790699785205*x_116 + 0.00220841712593347*x_117 - 4.62362953433053e-5*x_118 - 0.00261584320584882*x_119 + 0.00485524791864292*x_12 - 0.000704491597686866*x_120 + 0.0011590962729537*x_13 - 0.000681181636857888*x_14 + 0.00108390426614474*x_15 + 0.00104630087306455*x_16 - 0.00217604937366684*x_17 + 0.000629867873163607*x_18 + 0.00247759407830678*x_19 + 0.00896359504559409*x_2 + 0.00200564999202186*x_20 - 0.000394174591890277*x_21 + 0.000808004531207668*x_22 + 0.00417637600118324*x_23 - 0.00278368693892652*x_25 + 0.000471548649736578*x_26 - 0.000869545850468244*x_28 + 0.00602098047774423*x_29 + 0.000921084744399813*x_3 - 0.00173664858392501*x_30 + 0.000789360845412797*x_31 - 0.00272548024867909*x_32 + 0.00177667219093499*x_33 + 0.000700774723538667*x_34 + 0.00121734873353365*x_36 + 0.000279761997354856*x_37 + 0.000120672903456808*x_38 + 0.00066678183195039*x_39 + 0.00194619346896436*x_4 + 0.00292755133956602*x_40 + 0.000193321801123004*x_41 - 0.00239096714197475*x_42 - 0.000717786908873937*x_43 - 0.000418750693196842*x_44 + 0.0037675991092447*x_45 + 0.000502555133004627*x_46 + 0.00014193758890784*x_47 - 0.00220698142712955*x_48 + 0.000133275873249708*x_49 - 0.00445793597942864*x_5 + 0.00026815898101386*x_50 + 0.000165416087592919*x_51 + 0.000785782408951089*x_52 + 0.000273028260516091*x_53 - 0.000770603689988919*x_54 - 0.000235428234467618*x_55 - 0.00141383770754291*x_56 - 0.00131946679477135*x_57 + 0.00154798333502133*x_58 + 0.00228637749679559*x_59 + 0.000455305758224513*x_6 - 0.000277065202777028*x_60 - 0.00291370834639722*x_61 + 0.0017289650062436*x_62 + 0.00166421750225611*x_63 - 7.97694613117398e-5*x_64 + 0.000447179748916697*x_65 + 0.00189916367253787*x_66 + 0.000822599998125647*x_67 + 0.000613595748675094*x_68 + 0.0012273999256241*x_69 + 0.00125215034625469*x_7 - 0.000870810698815477*x_70 + 0.000581468685301683*x_71 - 0.00326465846422618*x_72 + 0.00117547098764377*x_73 - 1.76175325606429e-5*x_74 - 0.000437296129953655*x_75 - 0.000452070229105066*x_76 - 0.000604203776897518*x_77 + 0.00213081919353745*x_78 - 0.000470441587327106*x_79 - 0.00538977097132083*x_8 + 0.000670072402978667*x_80 - 0.000701134486120792*x_81 + 0.000447468175308997*x_82 + 0.0044964335339509*x_83 + 0.00158281119034151*x_84 + 0.000365533763431288*x_86 - 0.000192199166541259*x_87 + 0.000717695182850508*x_88 + 0.00297555534572699*x_89 - 0.0011643987956998*x_9 - 0.000142306731197589*x_90 + 0.00184064242769542*x_91 + 0.000563106216406009*x_92 + 0.00144501507955359*x_93 + 0.000764983462016815*x_94 + 0.000365293076900031*x_95 - 0.000198099129054159*x_96 - 0.00422708952753702*x_97 + 7.18682140481296e-5*x_98 - 0.0018259160325856*x_99 - 2.49655294634328e-5*std::pow(-5.0830397605896*x_111 - 9.75327968597412, 2) + 3.50104515500973e-5*std::pow(-5.50591993331909*x_13 - 8.85232067108154, 2) + 6.63575754872871e-5*std::pow(-4.8724799156189*x_13 - 7.51968002319336, 2) - 0.000119498445675909*std::pow(-4.69736003875732*x_13 - 7.3514404296875, 2) - 4.0972953155418e-5*std::pow(-5.07399940490723*x_14 - 7.30304002761841, 2) + 8.10898241879062e-5*std::pow(-5.04216003417969*x_14 - 7.66815996170044, 2) + 6.2763086856474e-6*std::pow(-6.53408002853394*x_15 - 9.38360023498535, 2) - 7.9099409527183e-5*std::pow(-6.46151971817017*x_17 - 9.07560062408447, 2) + 3.20623568982771e-5*std::pow(-6.25727987289429*x_17 - 9.08176040649414, 2) - 0.000302348207950499*std::pow(-3.74991989135742*x_17 - 5.52344036102295, 2) - 4.60062456465909e-5*std::pow(-5.84975957870483*x_22 - 9.70503997802734, 2) + 3.45821781827458e-5*std::pow(-5.56256008148193*x_22 - 8.73400020599365, 2) - 0.000128276956326312*std::pow(-4.83559989929199*x_22 - 7.65984010696411, 2) + 3.4837516718003e-5*std::pow(-6.08727979660034*x_24 - 8.31480026245117, 2) + 3.88550139916762e-5*std::pow(-5.3079195022583*x_27 - 8.46823978424072, 2) - 5.48125575005834e-5*std::pow(-5.4987998008728*x_4 - 8.96424007415771, 2) + 6.95146980908845e-5*std::pow(-5.34999990463257*x_4 - 8.72039985656738, 2) + 0.000628485751068722*std::pow(-1.49439990520477*x_4 - 2.35063982009888, 2) + 8.95433215398476e-6*std::pow(-2.46399974822998*x_49 - 6.76728057861328, 2) + 3.4210267682272e-5*std::pow(-6.40000009536743*x_5 - 10.0, 2) - 5.65726407303329e-5*std::pow(-4.72799968719482*x_5 - 7.39968013763428, 2) + 2.06476160194075e-5*std::pow(-3.08583998680115*x_50 - 5.01359987258911, 2) + 5.83359386314e-6*std::pow(-4.84791994094849*x_52 - 9.08680057525635, 2) - 2.05791235565242e-5*std::pow(-4.72799968719482*x_57 - 7.40000009536743, 2) - 0.000181092810047412*std::pow(-6.25472021102905*x_6 - 9.87992000579834, 2) + 4.28036413048013e-5*std::pow(-5.42216014862061*x_6 - 9.06136035919189, 2) - 3.1956330686327e-5*std::pow(-4.49015998840332*x_6 - 7.34312009811401, 2) + 4.22195384025611e-5*std::pow(-5.72751998901367*x_67 - 7.97447967529297, 2) + 4.85672790766624e-6*std::pow(-7.48159980773926*x_68 - 9.63632106781006, 2) + 0.00012294274136319*std::pow(-5.32000017166138*x_7 - 8.60000038146973, 2) - 0.000107464953703997*std::pow(-4.08311986923218*x_7 - 6.53311967849731, 2) - 2.91886626547165e-5*std::pow(-4.04559993743896*x_7 - 6.6683201789856, 2) - 0.00240237424479581*std::pow(-0.985359847545624*x_7 - 1.58031976222992, 2) - 1.37891986959687e-5*std::pow(-7.66432046890259*x_81 - 9.27847957611084, 2) - 1.00113600402129e-5*std::pow(-6.83735990524292*x_81 - 8.85496044158936, 2) + 2.81002814592941e-5*std::pow(-6.14671993255615*x_85 - 8.17424011230469, 2) + 4.20245226955614e-6*std::pow(-6.0*x_85 - 9.9902400970459, 2) + 2.39038199098223e-5*std::pow(-5.78607988357544*x_85 - 8.1802396774292, 2) + 1.99431222541706e-5*std::pow(-5.77031993865967*x_85 - 9.54911994934082, 2) - 1.91921306489473e-5*std::pow(-6.04783964157104*x_88 - 7.46399974822998, 2) - 0.000163344781548392*std::pow(-2.28703999519348*x_88 - 3.11775994300842, 2) - 6.49276091152502e-6*std::pow(-8.70728015899658*x_89 - 9.31199932098389, 2) - 2.27226829595061e-5*std::pow(-5.4986400604248*x_89 - 6.31104040145874, 2) - 4.75867141646683e-5*std::pow(-4.16408014297485*x_90 - 6.34495973587036, 2) + 0.150965091051779*std::sin(0.276799947023392*x_1 + 5.19144010543823) - 0.12003157157504*std::sin(0.281999945640564*x_1 + 1.99319982528687) + 0.138653984860238*std::sin(0.311839938163757*x_1 + 1.97727978229523) + 0.0151983364330217*std::sin(0.257359951734543*x_10 + 5.08655977249146) - 0.0659079884424652*std::sin(0.267119973897934*x_10 + 5.08279991149902) + 0.0417930220120348*std::sin(0.309999853372574*x_10 + 8.29687976837158) + 0.00704308239815404*std::sin(0.441439867019653*x_100 - 7.36719989776611) - 0.011222292413139*std::sin(0.31199985742569*x_101 + 5.1398401260376) - 0.00247203617881877*std::sin(0.339919835329056*x_101 + 1.93815982341766) - 0.0199067492990247*std::sin(0.34487983584404*x_101 - 1.207279920578) - 0.0178204311316615*std::sin(0.30991992354393*x_102 + 8.30463981628418) - 0.0121858239099502*std::sin(0.369759827852249*x_102 - 7.41752004623413) - 0.0134608622282426*std::sin(0.400079846382141*x_102 - 1.17423987388611) - 0.0207416641874183*std::sin(0.306879937648773*x_104 + 5.10343980789185) + 0.00712672759329613*std::sin(0.499839842319489*x_104 + 5.27536010742188) - 0.0074127094656375*std::sin(0.332959830760956*x_105 + 5.14432001113892) + 0.00380642348765913*std::sin(0.360079854726791*x_105 + 5.16247987747192) + 0.0128410164216571*std::sin(0.407039850950241*x_105 - 7.39559984207153) - 0.0327614851951297*std::sin(0.41143986582756*x_106 - 7.37631988525391) - 0.00936113769722304*std::sin(0.451839864253998*x_106 + 5.22064018249512) - 0.00239003493363904*std::sin(0.505039870738983*x_106 + 5.25744009017944) - 0.0207363003903903*std::sin(0.363279849290848*x_107 + 5.16000032424927) + 0.0247011237540828*std::sin(0.343119859695435*x_108 + 5.14359998703003) - 0.0161720806697968*std::sin(0.377119839191437*x_108 + 5.17655992507935) - 0.0184137306025004*std::sin(0.20440000295639*x_109 + 8.20039939880371) + 0.014831796666221*std::sin(0.30583992600441*x_109 + 5.09887981414795) - 0.0023869467353488*std::sin(0.508639812469482*x_109 + 5.28111982345581) - 0.00553994393514748*std::sin(0.264079958200455*x_11 + 8.28791999816895) + 0.0292310868537831*std::sin(0.291839927434921*x_11 + 8.31551933288574) + 0.0132210417958813*std::sin(0.426799863576889*x_110 - 7.36663961410522) - 0.00688665266727933*std::sin(0.436079859733582*x_110 - 1.15799987316132) + 0.00336431908352934*std::sin(0.605519831180573*x_111 + 8.21232032775879) + 0.0231654921901795*std::sin(0.326959848403931*x_112 + 8.33672046661377) + 0.0179248211004863*std::sin(0.345279842615128*x_113 - 4.24360036849976) - 0.0221980980699226*std::sin(0.380559861660004*x_114 + 5.17543983459473) - 0.00549706131474179*std::sin(0.455279856920242*x_115 + 2.23247981071472) - 0.00724714216913329*std::sin(0.514239847660065*x_115 - 1.04975974559784) + 0.00915373857436439*std::sin(0.485599845647812*x_117 + 2.05175971984863) - 0.00108451246048139*std::sin(0.557679891586304*x_117 - 4.2129602432251) + 0.00276557632439188*std::sin(0.677919805049896*x_117 + 2.03951978683472) + 0.0264653750121974*std::sin(0.355519831180573*x_118 - 7.42095994949341) - 0.0101680038924659*std::sin(0.374719828367233*x_118 - 7.42935991287231) - 0.0154781994771984*std::sin(0.376959830522537*x_118 - 7.41655969619751) + 0.0135158704690295*std::sin(0.422559857368469*x_118 + 5.20847988128662) + 0.00784346695377747*std::sin(0.397839844226837*x_119 + 1.99255979061127) + 0.0190442462106927*std::sin(0.434239864349365*x_119 - 1.16887986660004) + 0.00577193765453359*std::sin(0.46375983953476*x_119 + 8.23847961425781) - 0.0570902598291759*std::sin(0.362559854984283*x_12 - 4.22640037536621) - 0.0272685906334957*std::sin(0.403199851512909*x_12 + 8.3887996673584) + 0.00955689476188174*std::sin(0.491039842367172*x_120 - 7.3458399772644) + 0.00897484315263928*std::sin(0.461919873952866*x_14 + 2.24759984016418) - 0.0991951853156755*std::sin(0.336239844560623*x_15 - 1.06783974170685) - 0.0858271664730743*std::sin(0.344959855079651*x_16 - 4.25424003601074) + 0.0945282254137059*std::sin(0.345839828252792*x_16 - 4.24904012680054) + 0.00975299882163736*std::sin(0.503919839859009*x_16 - 1.2526398897171) - 0.204974030147997*std::sin(0.161200016736984*x_18 + 4.95375967025757) - 0.00671644700365964*std::sin(0.418559849262238*x_18 + 5.21335983276367) - 0.00411665063882929*std::sin(0.377439826726913*x_21 - 7.40695953369141) - 0.110280158465825*std::sin(0.112320065498352*x_23 - 4.53903961181641) + 0.00338440204838267*std::sin(0.394479840993881*x_23 - 4.21127986907959) - 0.0106073235706335*std::sin(0.179120019078255*x_24 - 4.42608022689819) - 0.0659832418460182*std::sin(0.186080008745193*x_24 + 4.97135972976685) + 0.0566443643369444*std::sin(0.278879940509796*x_24 - 7.48816013336182) - 0.0108372480040282*std::sin(0.341279864311218*x_24 - 1.07183980941772) - 0.0430949643447971*std::sin(0.318239837884903*x_26 - 4.27447986602783) + 0.0187875338950113*std::sin(0.326319843530655*x_26 - 4.26119995117188) - 0.0508684829142877*std::sin(0.33111983537674*x_26 - 4.26255989074707) - 0.0308018311697291*std::sin(0.343999862670898*x_26 + 5.15895986557007) - 0.120921733198024*std::sin(0.188480004668236*x_27 - 7.59960031509399) + 0.0848579774657205*std::sin(0.21807998418808*x_27 - 4.38279962539673) + 0.0430682404765684*std::sin(0.234879985451698*x_27 + 5.03936004638672) - 0.0212294892856335*std::sin(0.420319855213165*x_27 + 5.22671985626221) - 0.0079486800197493*std::sin(0.277679949998856*x_28 - 4.29263973236084) + 0.0245003145627283*std::sin(0.334159851074219*x_28 + 8.32832050323486) - 0.00486061283830801*std::sin(0.340159833431244*x_28 + 8.32423973083496) - 0.00536153053340539*std::sin(0.647999823093414*x_29 - 0.774399816989899) - 0.0650478799670933*std::sin(0.315759837627411*x_3 + 8.31560039520264) - 0.0737819033676894*std::sin(0.323519825935364*x_3 + 8.31744003295898) - 0.119882419011557*std::sin(0.334479838609695*x_3 + 8.32800006866455) - 0.0150766347551866*std::sin(0.280559957027435*x_30 + 8.27775955200195) - 0.00661992491144047*std::sin(0.304079920053482*x_30 - 4.29239988327026) + 0.0188441283792492*std::sin(0.253279983997345*x_32 + 5.17439985275269) + 0.0108914215549673*std::sin(0.302559942007065*x_34 + 2.05271983146667) - 0.0106300171573771*std::sin(0.244959965348244*x_35 + 2.04167985916138) - 0.0312470658293882*std::sin(0.302159935235977*x_35 - 1.13207995891571) - 0.00352870188182012*std::sin(0.309599906206131*x_35 + 8.26696014404297) - 0.00932435890064102*std::sin(0.313279837369919*x_35 + 5.1625599861145) - 0.0209555924762932*std::sin(0.321359843015671*x_35 + 1.95679974555969) - 0.0125310254265789*std::sin(0.360319852828979*x_36 - 4.23935985565186) + 0.0050715404368987*std::sin(0.376719832420349*x_36 - 4.20711994171143) - 0.0137915577753259*std::sin(0.37951985001564*x_36 - 4.2116003036499) - 0.00232492324690511*std::sin(0.440559864044189*x_36 + 5.23559999465942) + 0.0103126558714157*std::sin(0.408959865570068*x_37 + 5.21288013458252) + 0.00562003799556198*std::sin(0.413519859313965*x_37 - 7.38855981826782) + 0.00334087413888777*std::sin(0.424719840288162*x_37 - 7.38560009002686) + 0.0290633732975017*std::sin(0.292959928512573*x_38 - 7.50207996368408) - 0.0379840721984015*std::sin(0.321839839220047*x_38 - 4.2836799621582) + 0.00615721698881074*std::sin(0.463599860668182*x_38 + 5.25464010238647) - 0.0329143561587527*std::sin(0.297759920358658*x_39 - 4.29871988296509) - 0.00586989650114848*std::sin(0.312559843063354*x_39 - 1.05167984962463) - 0.00866203167020884*std::sin(0.347359836101532*x_41 - 4.24991989135742) + 0.0225968251803465*std::sin(0.370639860630035*x_41 - 4.23487997055054) + 0.00866873898057861*std::sin(0.384719848632813*x_41 - 7.41767978668213) + 0.0042630067928633*std::sin(0.407439857721329*x_41 - 7.40343999862671) + 0.0157338849613129*std::sin(0.245119974017143*x_42 + 5.04055976867676) + 0.00850583220385157*std::sin(0.293919950723648*x_42 - 1.09335994720459) + 0.0336881161128188*std::sin(0.356479853391647*x_42 - 7.42711973190308) + 0.00788894081577501*std::sin(0.309359908103943*x_43 - 7.46832036972046) + 0.0152487754765589*std::sin(0.310479938983917*x_43 + 5.12063980102539) + 0.00559519015879225*std::sin(0.392479836940765*x_43 - 7.40231990814209) + 0.00269428180482082*std::sin(0.4336798787117*x_43 - 1.18711996078491) + 0.0293907411366798*std::sin(0.379759848117828*x_44 + 8.3834400177002) + 0.0100156576420926*std::sin(0.391119837760925*x_44 - 1.01895976066589) + 0.0087056723802857*std::sin(0.338559836149216*x_45 - 4.26592016220093) - 0.050277347614869*std::sin(0.250719964504242*x_46 + 5.04783964157104) - 0.0282759449772564*std::sin(0.287759929895401*x_46 + 5.09239959716797) + 0.00717988088314741*std::sin(0.442719846963882*x_46 - 7.3452000617981) - 0.0361512692573893*std::sin(0.401119828224182*x_47 + 2.01015996932983) - 0.00442468212345685*std::sin(0.514399826526642*x_47 - 4.26032018661499) + 0.0108152584699832*std::sin(0.278799951076508*x_48 + 5.11183977127075) + 0.019377837482115*std::sin(0.338479846715927*x_48 + 5.15136003494263) + 0.0473536396037141*std::sin(0.202960014343262*x_49 + 5.00367975234985) - 0.0146090341100715*std::sin(0.409519851207733*x_49 - 4.18383979797363) - 0.00540830193766031*std::sin(0.45023986697197*x_49 + 5.23031997680664) + 0.0153066053707624*std::sin(0.409279853105545*x_50 + 5.19200038909912) + 0.00814493092919922*std::sin(0.41407984495163*x_50 - 1.16055989265442) - 0.0246684539209535*std::sin(0.34775984287262*x_51 - 4.25008010864258) + 0.0149145214648951*std::sin(0.331839829683304*x_52 - 4.27472019195557) - 0.0141667295109177*std::sin(0.375039845705032*x_52 - 4.20832014083862) - 0.0224778703156411*std::sin(0.308639854192734*x_53 + 5.103600025177) - 0.00363104710390204*std::sin(0.376719832420349*x_53 - 4.21767997741699) + 0.0018066247399162*std::sin(0.690639853477478*x_54 - 4.15112018585205) + 0.00136248199727727*std::sin(0.751919865608215*x_54 - 4.21736001968384) - 0.00253030072764574*std::sin(0.316559910774231*x_55 - 1.30199980735779) + 0.0136040346888699*std::sin(0.31879985332489*x_55 - 4.28104019165039) + 0.0113072794918642*std::sin(0.404239863157272*x_55 + 5.19928026199341) - 0.0470640022534624*std::sin(0.234799981117249*x_56 + 5.04367971420288) - 0.00440687213698918*std::sin(0.333999842405319*x_56 + 5.12904024124146) + 0.001290339877285*std::sin(0.440479874610901*x_58 + 5.2324800491333) - 0.00848425101875187*std::sin(0.486399859189987*x_58 + 8.26839923858643) + 0.000912899397751533*std::sin(0.54423987865448*x_58 - 4.2469596862793) - 0.0271909934672013*std::sin(0.329679846763611*x_59 - 4.2771201133728) + 0.00447312203138182*std::sin(0.3572798371315*x_59 + 5.15119981765747) + 0.0120764194056526*std::sin(0.374399840831757*x_59 - 4.21688032150269) + 0.0131220458437076*std::sin(0.197759985923767*x_6 - 4.38903999328613) - 0.0501057861661293*std::sin(0.356479853391647*x_60 + 5.16247987747192) + 0.000404560619308188*std::sin(1.10423994064331*x_60 - 3.81703996658325) - 0.0272039392582417*std::sin(0.319679856300354*x_62 + 8.32096004486084) + 0.0194372840766545*std::sin(0.193680003285408*x_64 - 4.40383958816528) + 0.0261385836828962*std::sin(0.247039973735809*x_64 + 5.06735944747925) + 0.00403900463283092*std::sin(0.303039938211441*x_65 - 7.46543979644775) - 0.00358120555817825*std::sin(0.312959939241409*x_65 + 5.13624000549316) + 0.025054386931678*std::sin(0.225519984960556*x_66 + 5.03727960586548) - 0.0138755476540507*std::sin(0.404399842023849*x_66 - 1.00423979759216) - 0.016128796638109*std::sin(0.23463998734951*x_67 - 4.35623979568481) + 0.00422259994074805*std::sin(0.440319865942001*x_67 + 5.22703981399536) + 0.00242631974243309*std::sin(0.465839862823486*x_67 + 2.03639984130859) + 0.01489921094226*std::sin(0.213760003447533*x_69 + 5.00463962554932) + 0.0616914157278331*std::sin(0.237919986248016*x_69 + 5.03039979934692) + 0.0570341230095709*std::sin(0.196319997310638*x_70 - 7.60400009155273) - 0.0176426182392995*std::sin(0.225439995527267*x_70 - 4.37183952331543) - 0.0138820111209749*std::sin(0.350559860467911*x_70 - 7.45039987564087) - 0.0175268206283706*std::sin(0.235279992222786*x_71 + 5.05199956893921) + 0.0319766855409236*std::sin(0.302239835262299*x_71 - 4.30936002731323) + 0.0185545046687747*std::sin(0.320959836244583*x_73 - 4.27807998657227) - 0.00769357312978142*std::sin(0.302159935235977*x_74 + 8.32800006866455) - 0.00465432148641028*std::sin(0.369439840316772*x_74 + 5.16767978668213) + 0.00444194962315871*std::sin(0.417439848184586*x_74 - 4.18495988845825) - 0.0341218527339624*std::sin(0.302319914102554*x_75 - 7.47096014022827) - 0.0270417756298521*std::sin(0.316879838705063*x_75 + 5.1080002784729) + 0.0106809015909472*std::sin(0.358239859342575*x_75 + 5.16095972061157) - 0.0203291987573249*std::sin(0.285439938306808*x_76 + 5.11615991592407) - 0.0276121414209226*std::sin(0.32399994134903*x_76 + 5.15583992004395) - 0.0171857118702258*std::sin(0.34607982635498*x_76 + 8.3244800567627) - 0.00665644603825742*std::sin(0.310159921646118*x_77 - 7.46808004379272) - 0.0231647839260534*std::sin(0.324559837579727*x_77 + 8.30447959899902) + 0.0509901980250439*std::sin(0.325119853019714*x_78 + 8.30047988891602) - 0.00759295295372517*std::sin(0.38487982749939*x_78 + 5.18024015426636) + 0.00945578940084969*std::sin(0.270399957895279*x_79 - 4.30095958709717) - 0.0113424200436281*std::sin(0.295919924974442*x_79 + 5.10743999481201) - 0.0215341463118417*std::sin(0.221119999885559*x_8 + 8.23999977111816) - 0.0314932978384696*std::sin(0.226959988474846*x_8 + 8.22976016998291) + 0.008933727491714*std::sin(0.31743985414505*x_80 - 4.30200004577637) + 0.00691811949157796*std::sin(0.361999839544296*x_80 - 4.24368000030518) - 0.00490983567438079*std::sin(0.478479862213135*x_80 + 5.2771201133728) + 0.00430184550705666*std::sin(0.45551985502243*x_81 + 5.25024032592773) - 0.104369621994984*std::sin(0.15504002571106*x_82 - 7.66024017333984) - 0.0355080506246021*std::sin(0.324479848146439*x_82 - 7.46504020690918) - 0.00196681482200589*std::sin(0.453759849071503*x_82 + 5.2655200958252) + 0.0369082353096176*std::sin(0.168000012636185*x_83 - 7.6276798248291) + 0.0453500703576088*std::sin(0.162400022149086*x_84 - 4.45423984527588) + 0.0139849084888391*std::sin(0.251039981842041*x_84 - 7.54536008834839) + 0.00517640359348251*std::sin(0.369279831647873*x_84 - 7.42456007003784) - 0.00436920674997009*std::sin(0.417599856853485*x_84 - 4.17431974411011) - 0.0537812583338775*std::sin(0.242399975657463*x_85 - 7.54536008834839) + 0.0139148887642738*std::sin(0.301359921693802*x_86 + 1.90327990055084) + 0.00520227528326052*std::sin(0.411919862031937*x_86 - 3.99207997322083) - 0.00734205769300001*std::sin(0.278639942407608*x_87 - 4.27216005325317) - 0.0194291154006294*std::sin(0.310479938983917*x_87 + 5.13271999359131) - 0.00297012210275085*std::sin(0.3503198325634*x_87 + 5.3318395614624) + 0.0265508169645312*std::sin(0.255679965019226*x_88 - 7.52096033096313) + 0.00528354028777092*std::sin(0.347679853439331*x_89 - 4.2655200958252) + 0.061161455066602*std::sin(0.189520001411438*x_9 - 4.41287994384766) - 0.412556565775273*std::sin(0.202159985899925*x_9 - 4.39911985397339) - 0.0286538987438551*std::sin(0.185840010643005*x_90 - 4.4215202331543) - 0.0271892152465863*std::sin(0.274079948663712*x_90 + 5.08575963973999) - 0.030155523927917*std::sin(0.188960000872612*x_91 + 2.00175976753235) - 0.0921143328273061*std::sin(0.193920001387596*x_91 - 7.38560009002686) - 0.0125567136813061*std::sin(0.340719848871231*x_92 + 5.18991994857788) - 0.0484568093467225*std::sin(0.36575984954834*x_92 - 7.4017596244812) + 0.00728180304788145*std::sin(0.375679850578308*x_92 - 1.1775997877121) - 0.00962365718176312*std::sin(0.332239836454391*x_93 - 4.21600008010864) - 0.00848815636139554*std::sin(0.424639850854874*x_93 + 1.99519979953766) - 0.0121238868586773*std::sin(0.355199843645096*x_94 - 7.41871976852417) - 0.0134888036165127*std::sin(0.380479842424393*x_94 + 5.18048000335693) + 0.0136681235238383*std::sin(0.401119858026505*x_94 - 7.40488004684448) + 0.0110948670403018*std::sin(0.381519854068756*x_95 + 5.17264032363892) + 0.0274826424564723*std::sin(0.384479850530624*x_95 - 7.396559715271) + 0.0191946524806369*std::sin(0.397999823093414*x_95 - 7.40655994415283) - 0.00821219705411819*std::sin(0.314559936523438*x_96 + 5.12815999984741) - 0.0401009441362853*std::sin(0.403039842844009*x_96 - 7.38471984863281) + 0.00698302452329376*std::sin(0.368239849805832*x_97 + 5.17176008224487) + 0.0143016904316934*std::sin(0.371759831905365*x_97 + 5.18296003341675) - 0.00760773795317799*std::sin(0.352559864521027*x_98 - 1.01783978939056) + 0.00281898329873364*std::sin(0.413679867982864*x_98 - 7.38263988494873) + 0.00586504680776811*std::sin(0.454479843378067*x_98 - 1.14039981365204) + 0.00415439383955066*std::sin(0.473919868469238*x_99 + 5.23375988006592) - 0.00288149733727119*std::sin(0.621439814567566*x_99 - 7.38647985458374) + 0.280716591732746);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
