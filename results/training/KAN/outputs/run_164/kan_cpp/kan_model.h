
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.28512419124986e-5*x_1 + 0.000352326301237234*x_10 + 0.000143830502749311*x_100 + 0.000324406171127114*x_101 + 0.000201253018369116*x_102 + 0.000349808966410549*x_103 + 0.000332277226798742*x_104 + 0.000488819810804713*x_105 + 4.7240515349074e-5*x_106 + 0.000297457279982061*x_107 + 0.000333358209935445*x_108 + 0.000134685972843141*x_109 - 6.52431564950923e-5*x_11 + 0.000229215366810059*x_110 + 0.000266422836536781*x_111 + 0.000182071848316056*x_112 - 0.000259314688462558*x_113 + 6.80724229542564e-5*x_114 + 0.000415081517909901*x_115 - 6.23074185343916e-5*x_116 + 0.00020983192369237*x_117 + 0.000284784487043341*x_118 + 0.000167303154512354*x_119 - 0.000489512994947071*x_12 + 0.000144314109646342*x_120 + 0.00104103644222078*x_13 - 0.000296100134727015*x_14 + 3.06935103877792e-5*x_15 - 3.2932921630905e-5*x_16 - 4.548987559455e-5*x_17 + 0.000448328801575337*x_18 - 0.000354514945238192*x_19 + 0.000161230827865881*x_2 + 7.73722247064686e-5*x_20 - 8.66461447174871e-5*x_21 + 7.68844823650541e-5*x_22 + 1.2321842014612e-6*x_23 + 0.000198345688940683*x_24 - 0.000273798678424815*x_25 + 0.000290861720264129*x_26 - 0.000238124963037055*x_27 - 0.000191566578914744*x_28 + 5.34885325142889e-5*x_29 - 5.29879369402701e-6*x_3 + 0.000678858685141275*x_30 + 5.37776138278728e-6*x_31 + 0.000313256158474986*x_32 + 0.000468641146706079*x_33 + 0.000786789686101878*x_34 + 0.000314604969082889*x_35 + 0.000287460098740697*x_36 + 0.00111308558654763*x_37 + 0.000425327928451039*x_38 + 0.000209002991369281*x_39 + 0.000341881908950389*x_4 + 0.000136065197468673*x_40 + 0.000178272465807289*x_41 + 8.72179788353099e-5*x_42 + 0.000187848296814331*x_43 + 0.000244900488522208*x_44 + 0.00026388247725622*x_45 + 0.000141760255048527*x_46 + 1.54127229250797e-5*x_47 - 0.000111430967684075*x_48 + 8.09376615822671e-6*x_49 - 7.89328085698656e-6*x_5 + 0.000627204739180356*x_50 + 0.000564850179556319*x_51 + 0.000133513936820879*x_52 - 8.39591404529668e-5*x_53 - 0.000466049650681547*x_54 - 0.000834788231820968*x_55 - 0.000174852949113797*x_56 + 0.000269873801568146*x_57 + 0.00112679070239322*x_58 + 0.00115594296654069*x_59 - 0.000179077267202795*x_6 + 0.000520838560361262*x_60 - 0.000266910561924238*x_61 + 1.08425457919083e-5*x_62 + 8.24192587840367e-5*x_63 + 0.000117175271396698*x_64 + 0.000144825931294354*x_65 + 2.70388666551964e-5*x_66 + 5.74464883614369e-5*x_67 + 4.38832974153757e-5*x_68 - 7.53178902469349e-5*x_69 + 8.23608077411622e-6*x_7 + 3.02221875457671e-5*x_70 - 8.81782334468494e-6*x_71 - 3.24022450060943e-5*x_72 + 8.60388865747035e-5*x_73 + 3.57329484849148e-5*x_74 + 0.000127486170644263*x_75 + 0.000133843082268326*x_76 - 6.8331993549334e-5*x_77 - 0.000151711629358255*x_78 - 6.97240956709393e-5*x_79 + 0.000223824412549421*x_8 - 0.000106804011339845*x_80 - 3.98681097930067e-5*x_81 + 5.22642352298828e-5*x_82 - 0.000855404504407201*x_83 - 2.3086960505653e-5*x_84 + 0.000113790903788881*x_85 + 0.000229867511284615*x_86 + 0.000141892013732901*x_87 - 6.02566055096831e-5*x_88 - 3.38337051936683e-5*x_89 + 0.000147359302405767*x_9 + 2.77394794963551e-5*x_90 + 3.82275532399185e-5*x_91 + 0.000101083110231832*x_92 + 0.000215666466796141*x_93 + 0.000157926157135439*x_94 + 0.000140720495376731*x_95 + 0.000263595027482455*x_96 + 0.000351389048729216*x_97 - 7.33214724279623e-5*x_98 - 0.000186564500218883*x_99 + 0.00138171626617227*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 8.90681666584108e-7*std::sin(1.14423990249634*x_3 + 4.221360206604) + 0.00138029062694455*std::sin(0.641519844532013*x_45 - 5.00735950469971) + 0.000520850799257589*std::sin(0.837359845638275*x_5 + 1.17007982730865) + 6.34707316828007e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) + 0.000177298777738114*std::sin(1.67527985572815*x_62 + 0.974879801273346) - 0.000223126467045528*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.000522916469455732*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 0.000136032118746033*std::sin(0.977199852466583*x_70 + 2.19375991821289) - 0.000247272733905081*std::sin(0.962239801883698*x_91 + 4.00952005386353) + 0.00018707418331962*std::sin(1.77159988880157*x_91 + 7.99575996398926) + 0.000218881752936119*std::sin(1.7279999256134*x_95 - 6.17560005187988) + 0.000296595093589573*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0296040419344953);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.08943950324634e-5*x_1 - 5.09878191840607e-5*x_10 - 5.52075491560236e-5*x_100 + 2.78837962534944e-5*x_101 + 5.91485719596876e-5*x_102 - 0.000213413657443861*x_103 + 0.000132651054347972*x_104 - 0.00011176690591447*x_105 + 0.000127370240616869*x_106 + 2.59627619443507e-5*x_107 + 5.29785214516949e-6*x_108 - 0.000135609017611224*x_109 - 0.000136936684724298*x_11 + 1.4736992151396e-5*x_110 - 7.04582286252225e-5*x_111 + 8.56640918697178e-5*x_112 - 4.91879299660963e-5*x_113 - 5.36655317346323e-5*x_114 + 6.01747937402445e-7*x_115 + 0.000182284623886519*x_116 - 2.46803403826675e-5*x_117 - 2.83443941411272e-5*x_118 - 3.25736512249186e-5*x_119 - 0.000193132798524261*x_12 - 8.30965910817357e-5*x_120 + 0.00055431024818679*x_13 - 0.000408855313361697*x_14 - 3.31483710817598e-5*x_15 - 5.72453472366709e-5*x_16 - 7.80669407206358e-5*x_17 + 0.000761790279344996*x_18 - 0.000478427540436209*x_19 + 2.01410053140948e-5*x_2 + 1.06113314366694e-7*x_20 - 7.32938949203754e-5*x_21 + 0.000234605272521321*x_22 + 0.00056946933054733*x_23 - 0.000110887369376578*x_24 - 0.00016776758966432*x_25 - 0.000550962475093416*x_26 - 0.000116486521106678*x_27 - 0.000178713397185231*x_28 + 1.63116891404347e-5*x_29 + 8.27260567422122e-5*x_3 - 0.000573498576722126*x_30 + 6.15224223330625e-5*x_31 + 8.27616356462375e-5*x_32 + 0.00038151106812864*x_33 + 0.000877475953000683*x_34 + 0.000210620139085629*x_35 + 0.000313240185129099*x_36 + 1.77187887278486e-5*x_37 + 0.000206217573442384*x_38 + 0.000121322588609319*x_39 + 4.70609529534043e-5*x_4 - 9.2905010793309e-6*x_40 - 0.000206574479205302*x_41 + 6.76866753658989e-5*x_42 + 1.0794342998293e-5*x_43 + 9.0305644148146e-5*x_44 + 0.000258346127952919*x_45 - 0.000177572614801317*x_46 - 0.000155196418516394*x_47 - 0.000156837378743245*x_48 - 0.000178314811191462*x_49 + 4.68353367310631e-5*x_5 - 0.00018938111747181*x_50 - 0.000650209058872963*x_51 + 0.000235037268085075*x_52 - 0.000133060501135766*x_53 - 0.000491417663309814*x_54 - 0.000881774820026377*x_55 - 0.000841495672093136*x_56 - 0.000355969768062927*x_57 - 6.26391970037815e-5*x_58 + 6.19969343490094e-5*x_59 - 0.000137317149022546*x_6 - 8.93615861474078e-6*x_60 + 0.000116038121659794*x_61 + 1.45043927630652e-6*x_62 - 2.84401915631076e-5*x_63 - 8.68267081671444e-5*x_64 + 9.39009434813937e-5*x_65 - 0.000158759075707236*x_66 - 2.13576635322907e-5*x_67 - 1.4982553682055e-5*x_68 - 0.00010566222568347*x_69 + 8.40323622779779e-5*x_7 - 1.72322023411579e-5*x_70 - 6.37515111175319e-5*x_71 + 1.37126539747393e-5*x_72 - 1.04002878308282e-5*x_73 - 2.02465971549139e-5*x_74 + 3.05489402125494e-6*x_75 + 3.55001581696049e-5*x_76 - 4.11989622435963e-5*x_77 - 0.000246323639564455*x_78 + 8.28177814719435e-6*x_79 - 0.000115166980546591*x_8 - 1.47431465075647e-5*x_80 + 8.4355511144505e-6*x_81 - 1.72159093239235e-5*x_82 - 0.000279913933907733*x_83 - 6.38453773087195e-5*x_84 - 2.23003547254301e-5*x_85 + 0.00014849805721705*x_86 + 1.14094001349586e-5*x_87 + 5.82940781745579e-5*x_88 - 6.12490077224112e-5*x_89 + 9.83874511333659e-5*x_9 - 2.39280556324758e-6*x_90 + 3.42980724969527e-5*x_91 + 6.0785830233061e-5*x_92 - 1.6827340472107e-5*x_93 - 2.16438469673347e-5*x_94 + 9.42392006668326e-5*x_95 - 3.74160610399122e-5*x_96 + 1.66051580332405e-5*x_97 - 0.000142874590639967*x_98 - 0.000558151554472822*x_99 - 0.000231252179200623*std::sin(0.308079928159714*x_109 - 1.6509598493576) + 0.000117542872721773*std::sin(1.14423990249634*x_3 + 4.221360206604) + 0.00104698727026962*std::sin(0.641519844532013*x_45 - 5.00735950469971) + 0.000395079228886453*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 3.8856921292727e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 2.9673768577053e-5*std::sin(1.67527985572815*x_62 + 0.974879801273346) - 0.000169247378846605*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.000597214524471772*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 0.000155360104060898*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 0.000151380910609398*std::sin(0.962239801883698*x_91 + 4.00952005386353) + 0.000141900759672111*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 3.66333404280986e-5*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 0.000181576167500556*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0660219682452846);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.78015735790154e-6*x_1 + 1.49007044715085e-5*x_10 + 3.96063675481961e-5*x_100 - 6.27315284829456e-5*x_101 - 5.09052576230203e-5*x_102 + 0.000263616481794291*x_103 - 0.000188310710446253*x_104 + 0.000137839889978343*x_105 - 7.07793343614578e-5*x_106 + 3.31434173084997e-7*x_107 - 2.84720187546833e-5*x_108 + 0.000106032854339246*x_109 + 8.18578879921279e-5*x_11 + 8.24891922077503e-6*x_110 + 6.13284210906993e-5*x_111 - 1.60244569836692e-5*x_112 + 9.19020988687545e-5*x_113 + 0.000110253773452303*x_114 - 3.29970892609705e-5*x_115 - 0.000166511258993409*x_116 + 5.33136599252521e-5*x_117 + 2.17133846076786e-5*x_118 + 2.01323289038928e-5*x_119 + 0.000102755491758049*x_12 + 6.96577007471825e-5*x_120 - 0.000570565960209137*x_13 + 0.000384583644233671*x_14 + 3.1634802731568e-5*x_15 - 6.07227522907042e-7*x_16 + 6.03454562014703e-5*x_17 - 0.00073524559759821*x_18 + 0.000170203433584584*x_19 - 3.10297472410315e-5*x_2 - 7.15671318786804e-5*x_20 + 3.84058246070803e-5*x_21 - 0.000187477531652817*x_22 - 0.000558899117885756*x_23 + 2.58698514664249e-5*x_24 + 0.000115744406791417*x_25 + 0.000341446737132175*x_26 - 0.000128054777293595*x_27 + 0.000127499749169364*x_28 + 2.82853364317346e-5*x_29 - 3.92484254172934e-5*x_3 + 0.000199781835084105*x_30 - 4.72867531558059e-5*x_31 - 6.61318203917383e-5*x_32 - 0.000306393510132392*x_33 - 0.000538756596166756*x_34 - 0.000141763846719137*x_35 - 0.000418139919457608*x_36 - 0.000220248987957757*x_37 - 0.000207719653209641*x_38 - 9.49301134292787e-5*x_39 - 1.18270887022841e-5*x_4 + 2.06871980627495e-5*x_40 + 0.000189926968699733*x_41 - 1.44436799332395e-5*x_42 - 6.6774806516075e-5*x_43 - 9.92336042133402e-5*x_44 - 8.69068557687901e-5*x_45 + 8.6769668395625e-5*x_46 + 0.000255016323377106*x_47 + 0.000162123290820347*x_48 + 0.000188273312981584*x_49 - 1.17058651357263e-5*x_5 + 0.000143211026347259*x_50 + 0.000368129369650085*x_51 - 0.000181752270497823*x_52 + 0.00019418197208643*x_53 + 0.000356020116513877*x_54 + 0.000585551152474075*x_55 + 0.00076326304455022*x_56 + 0.000419569055226788*x_57 - 0.000337753354892022*x_58 - 8.63297351941931e-5*x_59 + 0.000107729606364725*x_6 + 1.09504928206035e-5*x_60 - 0.000120566268885779*x_61 - 2.15271812999685e-5*x_62 - 1.48941924973286e-5*x_63 + 8.11115518269199e-5*x_64 - 7.01431109859836e-5*x_65 + 0.000123692381113971*x_66 + 1.21978263929056e-5*x_67 + 1.68105795353569e-5*x_68 + 9.81188409852881e-5*x_69 - 0.000104440088219257*x_7 + 1.99818301264425e-5*x_70 + 3.2516319577067e-5*x_71 + 5.2800122876906e-5*x_72 + 4.90711168319224e-5*x_73 + 2.22600645982256e-7*x_74 - 6.07840299099242e-5*x_75 - 9.27854905002931e-5*x_76 + 2.23650611768386e-5*x_77 + 0.000241508195926151*x_78 - 8.69753128523519e-6*x_79 + 7.00642469995647e-5*x_8 + 2.72028147530217e-5*x_80 - 7.32685407150766e-6*x_81 - 6.08877976795391e-6*x_82 + 0.000388527263074642*x_83 + 5.76542395225301e-5*x_84 + 1.52497496852861e-5*x_85 - 0.000134118144303199*x_86 - 2.14051170267237e-5*x_87 - 4.52419922388935e-5*x_88 + 4.66376132384724e-5*x_89 - 7.74863016061507e-5*x_9 - 6.36211948586503e-5*x_90 - 1.35718192915452e-5*x_91 - 4.03564043005768e-6*x_92 + 1.08103856539026e-6*x_93 + 3.42974587773523e-5*x_94 - 2.13572309727614e-5*x_95 + 2.81615641952254e-5*x_96 + 1.27000118803226e-5*x_97 + 0.000188476376612628*x_98 + 0.000556517970459108*x_99 + 0.000346648270141853*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 0.000167547671766803*std::sin(1.14423990249634*x_3 + 4.221360206604) - 0.00118457729209388*std::sin(0.641519844532013*x_45 - 5.00735950469971) - 0.000446998637334276*std::sin(0.837359845638275*x_5 + 1.17007982730865) + 2.08849254534153e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) + 4.4481139945934e-5*std::sin(1.67527985572815*x_62 + 0.974879801273346) + 0.000191489053803366*std::sin(1.07031989097595*x_67 + 1.36583995819092) + 0.000177267492802586*std::sin(0.295199930667877*x_7 - 1.89423990249634) - 4.61145785976709e-5*std::sin(0.977199852466583*x_70 + 2.19375991821289) - 8.13646302374237e-5*std::sin(0.962239801883698*x_91 + 4.00952005386353) - 0.000160548673715171*std::sin(1.77159988880157*x_91 + 7.99575996398926) + 5.49135758755426e-5*std::sin(1.7279999256134*x_95 - 6.17560005187988) + 9.759406036823e-5*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0382679295188552);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.43729885419993e-5*x_1 - 0.000356245677115412*x_10 - 0.000259029044431752*x_100 - 0.000360756418419805*x_101 - 0.000156562729188536*x_102 - 0.000324878278675464*x_103 - 0.000339108676777488*x_104 - 0.000316898965607163*x_105 - 8.51532344972133e-5*x_106 - 0.000194896346723953*x_107 - 0.000309594287425138*x_108 - 0.000132852726265537*x_109 - 5.45592285100028e-5*x_11 - 0.000151080033597268*x_110 - 0.000161488490038787*x_111 - 0.000141096144141363*x_112 + 0.00016213987349379*x_113 - 9.54880121391666e-5*x_114 - 0.00031568311872693*x_115 + 0.000118227447648204*x_116 - 8.50989879282203e-5*x_117 - 0.000204431730621639*x_118 - 0.000140168876374873*x_119 + 0.000288375833407607*x_12 - 0.000111009897167569*x_120 - 0.000711083992161616*x_13 + 0.000305310942329041*x_14 - 0.000142159390793787*x_15 + 3.15032328233777e-5*x_16 - 1.78325917445236e-5*x_17 - 0.000211630117593141*x_18 - 0.000158902437149755*x_19 - 0.00011051140793573*x_2 - 0.000196054676616698*x_20 + 4.73658370046144e-5*x_21 + 9.08870992024884e-5*x_22 - 8.06078455984778e-5*x_23 - 0.00027442861724237*x_24 + 0.00035439290054746*x_25 - 8.75964521997883e-5*x_26 - 0.000131201823478595*x_27 - 7.42291703609769e-5*x_28 + 6.68037727980213e-5*x_29 + 1.74351020541732e-5*x_3 - 0.000491008939908395*x_30 + 2.33548662211833e-5*x_31 - 0.000269414838147887*x_32 - 0.000412883974373452*x_33 - 0.00040994027927605*x_34 - 0.000190677569282073*x_35 + 0.000287231790261028*x_36 - 0.00141590406177268*x_37 - 0.000374693746985056*x_38 - 0.000222487700058006*x_39 - 0.000256109529219793*x_4 - 0.000184185585506865*x_40 - 0.000307060505117065*x_41 - 8.45564002081055e-5*x_42 - 7.8842330045145e-5*x_43 - 0.000172445002659436*x_44 - 4.93951765752093e-5*x_45 + 0.000140269334745936*x_46 - 1.55325543817831e-5*x_47 + 7.55195490697046e-5*x_48 + 1.99387452482757e-5*x_49 + 7.25331412871695e-6*x_5 - 0.000308317526807921*x_50 - 0.000150859318286369*x_51 - 0.00013632602959528*x_52 + 3.16861038273125e-5*x_53 + 0.000301002955599438*x_54 + 0.000462660446640851*x_55 + 0.000172007509846441*x_56 + 5.19253319979883e-5*x_57 - 0.000563899642384397*x_58 - 0.00082295273507489*x_59 + 0.000177828608305978*x_6 - 0.000716499625219732*x_60 + 0.000193327106744879*x_61 - 2.83539065161589e-5*x_62 - 6.21416801985127e-5*x_63 - 7.82874319323799e-5*x_64 - 7.8263749634003e-5*x_65 - 3.18199999588528e-5*x_66 - 3.46977762995893e-5*x_67 - 5.15450424821816e-5*x_68 + 3.4231941238948e-5*x_69 - 4.88013900161852e-5*x_7 - 3.49700798147954e-5*x_70 - 7.74788134560404e-5*x_71 + 7.87497245296172e-6*x_72 - 2.35716457002243e-5*x_73 - 2.72798990719829e-5*x_74 - 0.000132493426808464*x_75 - 0.000214671690232613*x_76 + 3.50662532670955e-5*x_77 + 7.28844772585614e-5*x_78 + 3.28539533330603e-5*x_79 - 0.000236643187089682*x_8 + 0.000102825026431754*x_80 + 3.26304083373304e-5*x_81 - 3.01813585747622e-5*x_82 + 0.000566867800217487*x_83 - 2.9727498714386e-6*x_84 - 9.96492967511912e-5*x_85 - 0.000199450859556035*x_86 - 0.000125605171759095*x_87 + 5.49247426460553e-5*x_88 + 5.56001711799922e-5*x_89 - 0.00027308681130152*x_9 + 6.69748427097304e-5*x_90 - 4.16561289087533e-6*x_91 - 5.92158563118282e-5*x_92 - 0.000232480735968765*x_93 - 0.000134864528828599*x_94 - 9.4194682303925e-5*x_95 - 0.000166834545519733*x_96 - 0.000286092847728155*x_97 - 2.81301702420132e-5*x_98 - 2.98291816537572e-5*x_99 - 0.000690661768075924*std::sin(0.308079928159714*x_109 - 1.6509598493576) + 0.000175791603388436*std::sin(1.14423990249634*x_3 + 4.221360206604) - 0.00152102896451993*std::sin(0.641519844532013*x_45 - 5.00735950469971) - 0.000573958220391491*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 4.11606993313571e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 8.86241917449054e-5*std::sin(1.67527985572815*x_62 + 0.974879801273346) + 0.000245877072916532*std::sin(1.07031989097595*x_67 + 1.36583995819092) + 0.000116883430459672*std::sin(0.295199930667877*x_7 - 1.89423990249634) - 3.04061960570547e-5*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 0.000160356094585053*std::sin(0.962239801883698*x_91 + 4.00952005386353) - 0.000206148796339312*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 0.000109409769707068*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 0.000192341590316097*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.050105445479299);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.12008926671895e-5*x_1 + 3.93090029483869e-5*x_10 - 0.000239124370276028*x_100 - 0.000108785455367604*x_101 - 1.47635527293216e-5*x_102 - 0.000405046107604292*x_103 + 0.000239337731727915*x_104 - 4.41051480022832e-6*x_105 - 9.02746795696672e-5*x_106 - 6.21062365886336e-5*x_107 + 0.000110547816714172*x_108 + 1.53906906465873e-6*x_109 + 4.01516570636321e-5*x_11 - 1.29300848315804e-5*x_110 + 7.15484149216862e-5*x_111 - 4.30922868010069e-5*x_112 - 0.000174537814137864*x_113 - 7.5913291920835e-6*x_114 - 8.1395057023223e-5*x_115 - 6.61860409986663e-5*x_116 - 0.000193477893738417*x_117 - 0.000195235949526873*x_118 - 0.000201889010650549*x_119 + 1.36354776076985e-5*x_12 - 0.00011644305038308*x_120 + 0.000469481747421022*x_13 - 0.000162752618671349*x_14 - 0.000189685014373653*x_15 + 0.000250842673224056*x_16 + 2.48333605630169e-8*x_17 + 0.000604419600418907*x_18 - 0.000201066950794959*x_19 + 1.09063387796236e-5*x_2 + 0.000226754994114726*x_20 + 5.98591806073562e-5*x_21 + 4.04651253015989e-5*x_22 + 0.000553684846588137*x_23 + 6.2072383962643e-5*x_24 - 2.46488046496935e-5*x_25 - 5.12438631529565e-5*x_26 + 5.01924505624667e-5*x_27 - 9.87323162558357e-5*x_28 - 0.000190991569066306*x_29 + 8.79047682074413e-5*x_3 - 0.000388309124498854*x_30 + 2.02148542510988e-5*x_31 - 5.75500102237355e-5*x_32 + 3.60227592761098e-5*x_33 + 0.000627483924445904*x_34 - 2.97298272629105e-5*x_35 + 0.00039452032984546*x_36 + 0.000439466644364752*x_37 - 3.47627067995934e-5*x_38 - 4.33454867931564e-5*x_39 - 0.000208773672351136*x_4 - 0.000161319613510382*x_40 - 0.000557456243461838*x_41 - 0.000116138238899056*x_42 - 0.000122264057306109*x_43 + 3.07251534285394e-5*x_44 + 9.27054155690431e-5*x_45 + 0.000166266029826754*x_46 - 0.000287861412353269*x_47 - 2.68947963722783e-5*x_48 - 6.52967209867336e-5*x_49 - 1.563406100568e-5*x_5 - 8.45624640467321e-5*x_50 - 1.03592742622218e-5*x_51 - 9.46221517679246e-5*x_52 - 0.000220227305316043*x_53 + 0.000129435010510013*x_54 + 5.34759341991375e-5*x_55 - 0.000350105354283793*x_56 - 7.2831152715138e-5*x_57 + 0.000500856622473694*x_58 - 0.000136438919463792*x_59 - 6.51196875010336e-5*x_6 - 0.000695321418938178*x_60 + 4.21578855092017e-6*x_61 + 2.88218806811392e-6*x_62 - 6.96213865218293e-5*x_63 - 5.02115299445244e-5*x_64 + 3.15369906356167e-5*x_65 - 1.72164464828865e-5*x_66 + 5.35974189755221e-5*x_67 - 7.14843550464754e-5*x_68 - 0.000116999221263873*x_69 + 0.000161994388959559*x_7 - 3.56564948500143e-5*x_70 - 0.000142657747638598*x_71 - 0.000258028935940823*x_72 - 9.36637137008544e-5*x_73 + 4.0677817146912e-5*x_74 + 3.16575243460415e-5*x_75 + 3.09865592017592e-5*x_76 - 3.08492397360667e-5*x_77 - 0.000261068857521319*x_78 - 0.000116027812803258*x_79 + 8.95407286946132e-5*x_8 - 7.08381256788451e-5*x_80 - 9.99840547553265e-6*x_81 + 3.2995525435743e-5*x_82 - 0.000430239854657075*x_83 + 2.6448887190723e-5*x_84 - 2.08183567135061e-5*x_85 + 7.66459411365914e-5*x_86 + 2.37309814324794e-5*x_87 + 3.92872703201139e-5*x_88 - 6.92500325929962e-5*x_89 + 2.68431381972972e-5*x_9 + 0.00017802155401348*x_90 + 3.91258599021196e-6*x_91 - 4.43295894959832e-5*x_92 + 4.47037878149373e-6*x_93 + 0.000106010473302172*x_94 + 2.40938073751435e-5*x_95 - 3.86334896934184e-5*x_96 - 0.00013894924607895*x_97 - 0.000167204036717013*x_98 - 0.00128886137858268*x_99 - 0.00195717383689662*std::sin(0.308079928159714*x_109 - 1.6509598493576) + 0.000190314770347262*std::sin(1.14423990249634*x_3 + 4.221360206604) + 0.000426728477730711*std::sin(0.641519844532013*x_45 - 5.00735950469971) + 0.000161025413310253*std::sin(0.837359845638275*x_5 + 1.17007982730865) + 2.54215129026431e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 0.000251140221475486*std::sin(1.67527985572815*x_62 + 0.974879801273346) - 6.89814273639886e-5*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.00021877184716828*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 5.69115712175973e-5*std::sin(0.977199852466583*x_70 + 2.19375991821289) - 9.90385147417994e-5*std::sin(0.962239801883698*x_91 + 4.00952005386353) + 5.78355600714399e-5*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 0.000310041685625805*std::sin(1.7279999256134*x_95 - 6.17560005187988) + 0.000118793273665555*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0381969454094917);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.74880032437472e-5*x_1 + 9.8311276248209e-5*x_10 + 0.00014977461468485*x_100 + 0.000159737409116679*x_101 - 7.34661280411722e-6*x_102 - 0.000166978890168597*x_103 + 0.000221430791332981*x_104 - 0.000216907699736749*x_105 + 1.54177850407225e-5*x_106 - 0.000106242383999736*x_107 + 7.01568774124106e-5*x_108 + 5.88514033665133e-6*x_109 + 0.000159404865953433*x_11 - 8.61283515759323e-5*x_110 - 9.5224101379647e-5*x_111 - 9.39791115646553e-5*x_112 - 2.52663853865469e-5*x_113 - 7.21693589628461e-5*x_114 - 1.32667688526836e-6*x_115 - 2.18233941109614e-5*x_116 - 0.00017880864772204*x_117 - 5.91726282993042e-5*x_118 - 8.09556986694301e-6*x_119 + 0.000217108395967786*x_12 - 3.6851955166275e-5*x_120 + 7.49427609533978e-5*x_13 - 0.00021171444881373*x_14 + 0.000116404725928485*x_15 + 7.38796096265278e-5*x_16 + 6.06961383955256e-5*x_17 + 0.000119922538284968*x_18 + 0.000820727519489241*x_19 - 6.79111093983908e-6*x_2 + 0.000277325260454155*x_20 + 5.78367119442581e-5*x_21 - 0.000153912661336562*x_22 + 0.000357906067708342*x_23 + 0.000211252940732832*x_24 - 0.00013302315467497*x_25 - 0.000107950991936019*x_26 + 0.000740997395526773*x_27 + 0.000280760584316914*x_28 - 0.000205900572880107*x_29 - 4.40450138630296e-5*x_3 + 0.000213089603392316*x_30 - 2.7321384145981e-5*x_31 + 7.23662720508997e-6*x_32 + 6.33989232301317e-5*x_33 - 0.000439806535305488*x_34 - 0.000112242575324481*x_35 - 0.0003063848250523*x_36 + 0.000890591240976521*x_37 + 0.000103370477012599*x_38 + 6.05085949549399e-5*x_39 - 9.00855214908295e-5*x_4 + 4.97529379446484e-5*x_40 + 9.13838699588598e-5*x_41 - 4.88168640750035e-5*x_42 - 8.6561575272375e-6*x_43 + 1.0490939493935e-5*x_44 - 0.000365909013582121*x_45 - 0.000238144195659903*x_46 - 0.000240116508664882*x_47 - 5.62059165635746e-5*x_48 - 0.000131317581644692*x_49 - 3.64654267202365e-5*x_5 - 0.000290616839272184*x_50 - 0.00023937975927778*x_51 + 4.17623155558075e-5*x_52 - 0.000119450469413506*x_53 + 0.000120358305115692*x_54 + 0.000384362532532298*x_55 - 0.000294680053346917*x_56 - 0.000603465575153161*x_57 + 0.00015306168920272*x_58 - 0.000145072531013943*x_59 - 4.48275619820422e-5*x_6 + 0.000279768324168574*x_60 + 0.000103802558464721*x_61 + 5.55414185008609e-5*x_62 + 4.3303421867808e-5*x_63 - 5.92226618768159e-5*x_64 - 4.96640417964675e-5*x_65 - 6.16137972021905e-6*x_66 - 1.03208792849097e-5*x_67 + 3.48814029602001e-6*x_68 - 4.15873697730959e-6*x_69 + 0.000126911885530277*x_7 - 3.18900819265334e-6*x_70 + 0.000116122954966514*x_71 - 8.76977793347809e-5*x_72 - 0.000130748407134675*x_73 + 2.05147720433708e-5*x_74 + 0.000122129405602846*x_75 + 0.000226807783537623*x_76 + 3.86411517481019e-5*x_77 - 4.59390965010519e-5*x_78 + 3.19312279169374e-5*x_79 + 7.55388357769445e-5*x_8 - 4.22506541953415e-5*x_80 + 3.72438304129076e-6*x_81 + 1.33998038453706e-5*x_82 - 0.000116534264819328*x_83 + 9.2324300673509e-6*x_84 + 2.0884296819764e-6*x_85 + 4.85518731066863e-5*x_86 + 2.59511094558404e-5*x_87 + 3.57466798666247e-6*x_88 - 3.83348877281712e-5*x_89 + 0.000184661405546188*x_9 + 4.91754273567779e-6*x_90 - 5.17458011753891e-5*x_91 - 9.8741697353474e-5*x_92 + 7.2730114760032e-5*x_93 - 2.745268275841e-5*x_94 - 0.000105793636096721*x_95 - 7.54157033326007e-5*x_96 - 6.56826988295236e-5*x_97 - 3.68318405366535e-5*x_98 - 7.77476823115126e-5*x_99 - 0.000965063273708789*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 6.55163750532734e-5*std::sin(1.14423990249634*x_3 + 4.221360206604) + 0.00110322753993318*std::sin(0.641519844532013*x_45 - 5.00735950469971) + 0.000416301418498485*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 3.74341610954333e-6*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 0.000123834786531476*std::sin(1.67527985572815*x_62 + 0.974879801273346) - 0.000178338719779272*std::sin(1.07031989097595*x_67 + 1.36583995819092) + 0.000791578624302919*std::sin(0.295199930667877*x_7 - 1.89423990249634) - 0.000205922214555745*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 1.45838043931347e-5*std::sin(0.962239801883698*x_91 + 4.00952005386353) + 0.000149523141735428*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 0.000152878522324144*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 1.74927690593424e-5*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.057797481680659);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.10020920979526e-5*x_1 + 5.17942493619969e-5*x_10 + 2.06698442190044e-6*x_100 + 1.84352427784469e-5*x_101 + 7.66991931510327e-5*x_102 + 0.000305200738106109*x_103 - 6.43801472812686e-5*x_104 + 0.000302358283304866*x_105 + 6.74082657683184e-5*x_106 + 0.000176902370627955*x_107 + 5.79289385170828e-5*x_108 + 3.03463685119423e-5*x_109 - 0.000129885422358447*x_11 + 0.00013984783474356*x_110 + 0.000124562176850889*x_111 + 0.000174436225673834*x_112 - 1.25347849075284e-5*x_113 + 0.00012893347252283*x_114 + 0.000114020099369113*x_115 - 1.8973890226271e-5*x_116 + 0.000190346181559846*x_117 + 0.000131465108708008*x_118 + 6.50111788748671e-5*x_119 - 0.000335809777315216*x_12 + 6.82906560600567e-5*x_120 + 0.000211226244106436*x_13 + 1.27786567871304e-5*x_14 - 1.55705587977495e-5*x_15 - 0.000116578176939889*x_16 - 4.78815091081276e-5*x_17 - 4.54770152375117e-6*x_18 - 0.000715420273850188*x_19 + 4.29121104348816e-5*x_2 - 0.000173982124257149*x_20 - 8.72987635596876e-5*x_21 + 0.000102177690463873*x_22 - 0.00023669560695983*x_23 - 9.6445069348916e-5*x_24 - 8.74644662251326e-5*x_25 - 2.83352227045406e-5*x_26 - 0.000637889644381393*x_27 - 0.000198635997061123*x_28 + 0.000157318212566873*x_29 + 4.94112810337069e-5*x_3 - 0.000182836145542857*x_30 + 1.8562641979352e-5*x_31 + 0.000120996830810339*x_32 + 0.000177046688484189*x_33 + 0.000683709002577945*x_34 + 0.000207364675278275*x_35 + 9.83656515219183e-6*x_36 - 0.000200430192825252*x_37 + 8.38826691066833e-5*x_38 + 6.986717251484e-5*x_39 + 0.00020397816746563*x_4 + 5.65204933887997e-5*x_40 + 7.71397958942268e-5*x_41 + 0.000111357051973022*x_42 + 7.05873524870236e-6*x_43 + 5.70734044082773e-5*x_44 + 0.000391815477395532*x_45 + 4.05776893014013e-5*x_46 + 0.00025670644453153*x_47 + 1.25784178570889e-5*x_48 + 9.37173659207847e-5*x_49 + 4.74252448489321e-5*x_5 + 0.000305844285636708*x_50 + 3.97464192996734e-5*x_51 + 6.84705457420866e-5*x_52 + 0.000122480843921067*x_53 - 0.000309750648733038*x_54 - 0.000670250413139475*x_55 + 9.74580948397818e-5*x_56 + 0.000450471821775809*x_57 - 0.000168093209316325*x_58 + 0.000434663135909322*x_59 - 5.94880743740441e-5*x_6 + 0.000133682749258769*x_60 - 0.000156445769238777*x_61 - 4.12143875391398e-5*x_62 - 3.08574435290849e-5*x_63 + 7.25747804262928e-5*x_64 + 8.2573383617609e-5*x_65 - 5.95375519558885e-6*x_66 + 1.28839459461369e-5*x_67 + 2.34917197240454e-5*x_68 - 1.12441800957823e-5*x_69 - 9.07109838537149e-5*x_7 + 2.02420139364932e-5*x_70 - 6.46023791386909e-5*x_71 + 0.000115992658077934*x_72 + 0.000132833118102307*x_73 - 1.87231529909283e-5*x_74 - 7.18692873872128e-5*x_75 - 0.00011142466611426*x_76 - 5.33138205727482e-5*x_77 + 1.03643056496423e-5*x_78 - 3.09492377280401e-5*x_79 + 9.52680807050979e-6*x_8 - 1.04487904832126e-6*x_80 - 1.49148873761689e-5*x_81 - 1.43070244787097e-5*x_82 - 6.03571960976208e-5*x_83 - 1.10335923787658e-5*x_84 + 3.60152608932858e-5*x_85 + 5.50894842434528e-5*x_86 + 2.59336047224141e-5*x_87 - 1.81417773293323e-5*x_88 - 2.73487642276739e-6*x_89 - 4.2216865911769e-6*x_9 - 8.42143646202533e-5*x_90 + 5.23002286346332e-5*x_91 + 0.000135100514382749*x_92 + 3.40682689746402e-5*x_93 + 7.87592094733799e-5*x_94 + 0.000162356234986662*x_95 + 0.000118082771685207*x_96 + 0.000191670158743478*x_97 + 7.57648012442742e-5*x_98 + 0.00012527023044408*x_99 + 0.00114012677801519*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 6.87350690177045e-5*std::sin(1.14423990249634*x_3 + 4.221360206604) - 0.000258277447147256*std::sin(0.641519844532013*x_45 - 5.00735950469971) - 9.74606449908625e-5*std::sin(0.837359845638275*x_5 + 1.17007982730865) + 6.2399470570769e-6*std::sin(1.65815985202789*x_62 - 8.60015964508057) + 0.000146298548520804*std::sin(1.67527985572815*x_62 + 0.974879801273346) + 4.17510147316392e-5*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.000884116697998701*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 0.000229995180248748*std::sin(0.977199852466583*x_70 + 2.19375991821289) - 2.43099256510459e-5*std::sin(0.962239801883698*x_91 + 4.00952005386353) - 3.50049776125083e-5*std::sin(1.77159988880157*x_91 + 7.99575996398926) + 0.00018061084887761*std::sin(1.7279999256134*x_95 - 6.17560005187988) + 2.91589151774221e-5*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0382144609527669);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.62112704274753e-6*x_1 - 0.000110189795940552*x_10 + 0.000234654693487228*x_100 + 0.000190568536914517*x_101 + 4.86888951868879e-5*x_102 - 5.95246938658276e-6*x_103 - 2.13801935958152e-5*x_104 - 0.000338662431354304*x_105 + 0.000211364635819261*x_106 - 1.25027890079151e-5*x_107 - 0.000133766300927225*x_108 - 0.000178930427165221*x_109 - 0.000110018513731548*x_11 - 6.10891461008674e-5*x_110 - 0.000248901011534659*x_111 + 2.55465611243146e-5*x_112 + 0.000125111467359588*x_113 - 0.00016353653872851*x_114 + 5.07837891658347e-5*x_115 + 0.000313374045165082*x_116 + 5.86237769240507e-5*x_117 + 0.000118532859623034*x_118 + 0.000165155190211134*x_119 - 1.9510105737304e-5*x_12 - 5.45050394065465e-6*x_120 + 7.16312438819405e-5*x_13 - 0.000360825778399178*x_14 + 0.000203718721390676*x_15 - 0.000271057332481457*x_16 - 5.98130681307104e-5*x_17 + 0.000281626985449476*x_18 + 0.000240957383558244*x_19 - 5.29261734883445e-6*x_2 - 0.000105815107442746*x_20 - 9.56451304855489e-5*x_21 + 0.000160638794608448*x_22 + 0.000252926904438494*x_23 - 9.93351860045016e-5*x_24 - 0.000135490693863534*x_25 - 0.000556024515364318*x_26 + 0.000333950756114087*x_27 + 4.91444335507513e-5*x_28 + 0.000115340545175097*x_29 - 4.7719009156672e-5*x_3 + 8.14491951504251e-6*x_30 + 3.60300087892685e-5*x_31 + 0.000104164387161271*x_32 + 0.000331792682090852*x_33 - 0.000173152442998489*x_34 + 0.000152082652073889*x_35 - 5.50890948225406e-5*x_36 - 0.000179584999294891*x_37 + 0.00027733372680243*x_38 + 0.000166763776539365*x_39 + 0.000170655237134377*x_4 + 0.000148777602957282*x_40 + 0.000365840268040915*x_41 + 0.000134577625665712*x_42 + 0.000178072492658242*x_43 + 5.60644520025114e-5*x_44 - 0.000106647626326367*x_45 - 0.000435664178404387*x_46 - 7.46969586193667e-5*x_47 - 0.000187563502882879*x_48 - 0.000224889964522881*x_49 + 3.32045210877567e-5*x_5 - 0.000323479012712137*x_50 - 0.000752228503191215*x_51 + 0.000360049854809533*x_52 - 2.14594574810526e-5*x_53 - 0.000546899783552476*x_54 - 0.000665148584051742*x_55 - 0.00073122813832458*x_56 - 0.000719381215094645*x_57 - 0.000378133751153877*x_58 + 3.50047656522286e-6*x_59 - 6.21423541480071e-5*x_6 + 0.00076932390155626*x_60 + 0.000243057936117938*x_61 + 3.65477380598416e-5*x_62 + 8.65213435681624e-5*x_63 - 9.66705872646441e-5*x_64 + 2.3650957161479e-5*x_65 - 0.000166789612248675*x_66 - 9.44740980982325e-5*x_67 + 5.17558244644962e-5*x_68 + 9.48928618401989e-6*x_69 - 7.90352405934699e-6*x_7 + 7.2294525071344e-6*x_70 + 0.000148285573541539*x_71 + 0.000217774890251771*x_72 - 8.07633422097018e-6*x_73 - 5.22790186409869e-5*x_74 + 4.67742532856784e-5*x_75 + 0.000123727322485584*x_76 + 2.46023607746141e-5*x_77 - 2.13739771103808e-5*x_78 + 0.000167508039681069*x_79 - 0.0002287034007399*x_8 + 5.34698176661206e-5*x_80 + 3.04791567656095e-5*x_81 - 4.110106378178e-5*x_82 + 0.000110213855286336*x_83 - 0.000103768138927947*x_84 - 1.99049591059419e-5*x_85 + 7.279544692136e-5*x_86 - 1.88487377014682e-5*x_87 + 3.33587624126495e-5*x_88 + 5.18745664853507e-6*x_89 + 0.000112372266557377*x_9 - 0.000136949586310493*x_90 - 3.94072771834407e-6*x_91 + 2.08055245997369e-5*x_92 - 2.83648047288698e-5*x_93 - 0.000203213721179214*x_94 - 3.88508810653109e-5*x_95 - 7.08342548585164e-5*x_96 + 6.16792740989067e-5*x_97 - 5.39845920827434e-5*x_98 + 0.000715421357038907*x_99 + 0.00121935008556*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 2.08600020832109e-5*std::sin(1.14423990249634*x_3 + 4.221360206604) + 0.00119479883549664*std::sin(0.641519844532013*x_45 - 5.00735950469971) + 0.000450855722898029*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 7.56731379723896e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) + 0.000156464308264645*std::sin(1.67527985572815*x_62 + 0.974879801273346) - 0.000193141384713022*std::sin(1.07031989097595*x_67 + 1.36583995819092) + 0.000244093682555698*std::sin(0.295199930667877*x_7 - 1.89423990249634) - 6.34988239041957e-5*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 0.000294811533024752*std::sin(0.962239801883698*x_91 + 4.00952005386353) + 0.000161934024631136*std::sin(1.77159988880157*x_91 + 7.99575996398926) + 0.000193160846915081*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 0.000353616239234556*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0292220601080102);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.28684857553376e-5*x_1 - 0.000185313884250118*x_10 - 0.000381930494667165*x_100 - 0.00042641522569448*x_101 - 0.000145347926470497*x_102 - 0.000294751274307511*x_103 - 0.000186333636824636*x_104 - 1.38404133639345e-5*x_105 - 0.000142684317523754*x_106 - 0.000145784768498849*x_107 - 0.000109257607146156*x_108 - 3.13442162748191e-6*x_109 + 3.00864089055774e-5*x_11 - 6.26970524896905e-5*x_110 + 3.52777777471494e-5*x_111 - 5.25840139875806e-5*x_112 + 4.99805233510437e-5*x_113 + 0.000125227352655317*x_114 - 0.000343794694852689*x_115 - 0.000157694523562107*x_116 - 0.00017414524184117*x_117 - 0.000318040062485968*x_118 - 0.000296799667777121*x_119 + 0.000168881952900247*x_12 - 0.000138076293089204*x_120 - 0.000487554770482286*x_13 + 0.000346157900162904*x_14 - 0.000252769538021301*x_15 + 0.000217741904237282*x_16 + 3.07426760509945e-5*x_17 - 0.000169783550838332*x_18 - 0.000517274339017278*x_19 - 9.67264652352036e-5*x_2 - 1.90433080604878e-5*x_20 + 8.71066539673974e-5*x_21 - 4.03667860804619e-5*x_22 + 1.74403948114121e-5*x_23 - 0.00016468365036134*x_24 + 0.000214463734075982*x_25 - 4.12369507530703e-5*x_26 - 0.0004497952087362*x_27 - 7.64421739962845e-5*x_28 - 9.17980227408671e-5*x_29 + 0.000122922119293411*x_3 - 0.000991874813164148*x_30 + 4.71102511808336e-6*x_31 - 0.000259246938411964*x_32 - 0.000402601025354685*x_33 + 0.000345589956351244*x_34 - 0.000196866962304649*x_35 + 9.70067265080833e-6*x_36 - 0.000772036062388431*x_37 - 0.000459348555663315*x_38 - 0.000231658258359958*x_39 - 0.000341078599884579*x_4 - 0.000241649109948416*x_40 - 0.000607918216806771*x_41 - 0.000119960450374104*x_42 - 0.000323244645873444*x_43 - 0.000176415605920566*x_44 + 0.000201360550021208*x_45 + 0.00021816043687856*x_46 + 6.22313984180163e-5*x_47 + 0.000184378541576881*x_48 + 0.000141213524631396*x_49 + 2.07587645687806e-5*x_5 - 0.000192261722756252*x_50 - 0.000107592449470869*x_51 - 0.000293702930190593*x_52 + 5.30782177156687e-5*x_53 + 0.000499231758281591*x_54 + 0.000536026946519663*x_55 + 0.000379141738140304*x_56 + 0.000441953470728611*x_57 - 0.000646695790278143*x_58 - 0.00073788153182427*x_59 + 9.69158164818618e-5*x_6 - 0.00113975368114276*x_60 - 1.32364249871288e-5*x_61 - 5.96771708816877e-5*x_62 - 0.000183388207326739*x_63 - 2.56424823265432e-5*x_64 - 5.12437721177429e-5*x_65 + 4.29989093732495e-5*x_66 + 3.93019101692835e-5*x_67 - 8.75126790182887e-5*x_68 - 1.88719907874389e-5*x_69 + 2.09972510585735e-5*x_7 - 3.46105639929773e-5*x_70 - 0.000204136322567583*x_71 - 0.000138767460284576*x_72 - 1.88119582425296e-5*x_73 + 3.50847346874528e-6*x_74 - 0.000174789430283114*x_75 - 0.000249514560254865*x_76 - 1.51422266450093e-5*x_77 - 6.11134414825392e-6*x_78 - 0.00011742809488148*x_79 - 1.95252857689925e-5*x_8 + 2.26865592077224e-5*x_80 + 1.35702217077099e-6*x_81 - 1.778313368652e-5*x_82 + 0.000385699368183049*x_83 + 7.87953657785234e-5*x_84 - 7.23478064616708e-5*x_85 - 0.000143883117712478*x_86 - 7.86011286254288e-5*x_87 + 4.51138005596275e-5*x_88 - 1.83658195504342e-5*x_89 - 0.000167114719811303*x_9 + 7.87621802750239e-5*x_90 + 1.38665968690338e-5*x_91 - 1.34259887505129e-5*x_92 - 0.000142232291871543*x_93 + 9.24431397008468e-5*x_94 + 4.59273847885714e-5*x_95 - 0.000122376370166958*x_96 - 0.000262810698171308*x_97 + 5.45064898942183e-5*x_98 - 0.000866517519383941*x_99 - 0.00206544012335041*std::sin(0.308079928159714*x_109 - 1.6509598493576) + 6.48580828397844e-5*std::sin(1.14423990249634*x_3 + 4.221360206604) - 0.00174112128697829*std::sin(0.641519844532013*x_45 - 5.00735950469971) - 0.000657009760281067*std::sin(0.837359845638275*x_5 + 1.17007982730865) + 2.01511260066543e-6*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 0.000265032712089119*std::sin(1.67527985572815*x_62 + 0.974879801273346) + 0.000281455393434933*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.000527369161669409*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 0.00013719044744924*std::sin(0.977199852466583*x_70 + 2.19375991821289) - 7.85058543807749e-6*std::sin(0.962239801883698*x_91 + 4.00952005386353) - 0.00023597845009126*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 0.000327192467695222*std::sin(1.7279999256134*x_95 - 6.17560005187988) + 9.41650575850932e-6*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0485835544439398);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.27425142652928e-5*x_1 - 1.08813227094319e-5*x_10 + 9.50013411121153e-5*x_100 + 0.000115423324031608*x_101 + 4.33857669735763e-5*x_102 - 0.000165503131740108*x_103 + 0.000160250359435148*x_104 - 0.000224458738108643*x_105 + 0.000177938418771967*x_106 - 3.08825006990744e-5*x_107 + 1.03676668251834e-5*x_108 - 0.000125206198181869*x_109 - 3.73189255047653e-5*x_11 - 3.27644986814231e-5*x_110 - 0.000148810087406429*x_111 + 6.91617044655558e-5*x_112 + 2.58445883334314e-5*x_113 - 2.79164536922749e-5*x_114 - 3.28469149186921e-5*x_115 + 0.000137054970985202*x_116 - 9.93201798522642e-5*x_117 - 4.94809856425609e-5*x_118 - 1.60441163905092e-5*x_119 - 6.08004197773581e-5*x_12 - 8.68028049866474e-5*x_120 + 0.000334890631403472*x_13 - 0.000447000276330075*x_14 + 9.47204867669491e-5*x_15 - 8.48369219691302e-5*x_16 - 2.56516892021397e-5*x_17 + 0.00055200739492621*x_18 - 4.66142463354179e-6*x_19 - 8.34527719051517e-6*x_2 + 0.000100829178237042*x_20 - 5.27564988889687e-5*x_21 + 8.73778894013291e-5*x_22 + 0.000603497150745225*x_23 - 2.07930427865462e-5*x_24 - 0.000272460528352973*x_25 - 0.000703852109540216*x_26 + 0.000216075588806593*x_27 + 5.66199280580987e-5*x_28 - 7.18553639611653e-5*x_29 + 5.97197297625804e-5*x_3 - 0.00061355935797523*x_30 + 3.41859911642597e-5*x_31 + 8.53731585781501e-5*x_32 + 0.000386422270410015*x_33 + 0.000544379596022539*x_34 + 0.000135579455644725*x_35 - 0.000211042116326947*x_36 + 0.000395958026149586*x_37 + 0.000219669715602056*x_38 + 0.000164724577703892*x_39 + 2.76743196167797e-5*x_4 + 6.77253348186696e-5*x_40 - 9.68908222349684e-6*x_41 + 8.56427271747617e-5*x_42 - 4.93843616926662e-5*x_43 + 5.14698020600022e-5*x_44 + 7.0406918461839e-5*x_45 - 0.000441871102520664*x_46 - 0.000137496752389191*x_47 - 0.000140087383839544*x_48 - 0.000204812740614962*x_49 + 4.66795062882791e-5*x_5 - 0.000410130327053167*x_50 - 0.000970254288071393*x_51 + 0.000268050959003015*x_52 - 8.06003959055838e-5*x_53 - 0.000411619872982688*x_54 - 0.000641433364362093*x_55 - 0.00084638346193339*x_56 - 0.000639515414753259*x_57 - 0.000479509546691316*x_58 - 9.82198696049893e-5*x_59 - 0.000151522084133027*x_6 + 0.000311042196382962*x_60 + 0.000159814173829244*x_61 + 2.08309037946033e-5*x_62 - 2.6789186362229e-5*x_63 - 0.000107364677708169*x_64 + 4.59912298076062e-5*x_65 - 0.000152493186613933*x_66 - 4.22667689075321e-5*x_67 + 4.44448675248103e-6*x_68 - 6.61167952310941e-5*x_69 + 0.000109925866627626*x_7 - 6.36400299062907e-6*x_70 + 3.26336573830337e-5*x_71 + 5.62212916219568e-5*x_72 - 5.27589813539719e-5*x_73 - 2.75794256001373e-5*x_74 + 2.45449274525955e-5*x_75 + 0.000129812316324066*x_76 - 1.40855664644193e-5*x_77 - 0.00016995703435136*x_78 + 4.86033143583278e-5*x_79 - 8.87424875126966e-5*x_8 - 1.67774884315661e-5*x_80 + 1.21243102688008e-5*x_81 - 3.40445645085408e-5*x_82 - 8.06848648781807e-5*x_83 - 4.72954965537675e-5*x_84 - 2.05916438186586e-5*x_85 + 0.000141953962324239*x_86 + 1.09081745317048e-5*x_87 + 5.31631485949078e-5*x_88 - 7.84725553319389e-5*x_89 + 0.000231030906232456*x_9 - 0.000101203331649477*x_90 + 5.6769011476708e-6*x_91 + 3.481956579511e-5*x_92 + 2.33684612617575e-5*x_93 - 3.99508234853092e-5*x_94 + 6.02435065992428e-5*x_95 - 9.43451994332331e-5*x_96 + 8.63916450330183e-6*x_97 - 4.82756419820026e-5*x_98 - 0.000253096678997495*x_99 - 0.000517995996658125*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 5.71080526421745e-5*std::sin(1.14423990249634*x_3 + 4.221360206604) + 0.00134329507524116*std::sin(0.641519844532013*x_45 - 5.00735950469971) + 0.000506890577911782*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 5.52738051975024e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 6.64681015409507e-5*std::sin(1.67527985572815*x_62 + 0.974879801273346) - 0.000217146069448935*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.000233716743340529*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 6.07993544669307e-5*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 0.000215338701195829*std::sin(0.962239801883698*x_91 + 4.00952005386353) + 0.000182060085211389*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 8.20572750992617e-5*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 0.000258291325638641*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0767709542158145);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.55426491998608e-5*x_1 - 0.000224331586164902*x_10 - 0.00040483925874231*x_100 - 0.000324351315273269*x_101 - 2.38349475641218e-5*x_102 - 0.000310988429510291*x_103 - 0.000118220467723195*x_104 + 3.16466710448251e-5*x_105 - 3.67480821679285e-5*x_106 + 1.18720572201791e-5*x_107 - 0.000110080612038933*x_108 - 0.000123962989822775*x_109 - 0.000223927051176154*x_11 + 2.86936709534125e-5*x_110 + 3.99017131198773e-5*x_111 + 5.22410011590542e-5*x_112 - 5.46346919900408e-5*x_113 - 1.23675059516151e-5*x_114 - 0.000146679601640278*x_115 + 0.000130323797299946*x_116 + 2.09216280239269e-5*x_117 - 0.000136019483453684*x_118 - 0.000169512030528994*x_119 - 0.000198576088351769*x_12 - 0.000112017948835552*x_120 + 0.000263352848864581*x_13 - 1.54482287922827e-6*x_14 - 0.000292958068471613*x_15 + 5.80946455028747e-5*x_16 - 0.000108876094764405*x_17 + 0.000580522092829173*x_18 - 0.00119585494641073*x_19 - 1.14295446092367e-5*x_2 - 0.000204701501642635*x_20 - 4.19811916839612e-5*x_21 + 0.000335808533216193*x_22 + 0.00024891110796576*x_23 - 0.000318724507097922*x_24 + 0.000162633279937182*x_25 - 0.000216504167362518*x_26 - 0.000770117882017126*x_27 - 0.000456731969522113*x_28 + 0.000123427847994436*x_29 + 0.000136308249737297*x_3 - 0.000840026788494776*x_30 + 7.94936232592515e-5*x_31 - 9.09034474801849e-5*x_32 + 1.29319689590787e-5*x_33 + 0.00107134091621812*x_34 + 0.00013437784161623*x_35 + 0.000845386250724579*x_36 - 0.00109442750910636*x_37 - 0.00013528432100144*x_38 - 0.000100313483334186*x_39 - 9.7805282674994e-5*x_4 - 0.000214131816484164*x_40 - 0.000628506564953678*x_41 - 2.00509780412292e-5*x_42 - 6.52573608108558e-5*x_43 + 8.54436912829079e-7*x_44 + 0.000509211438912947*x_45 + 0.000304164670424532*x_46 - 4.13671607511155e-5*x_47 - 2.50205576550857e-5*x_48 - 3.95418604095483e-6*x_49 + 4.86559783516548e-5*x_5 + 3.92074591118112e-5*x_50 - 0.000121381276193764*x_51 - 1.96970990408352e-5*x_52 - 8.54670274077092e-5*x_53 - 0.000194898704906085*x_54 - 0.000632381380084861*x_55 - 0.000308793350861567*x_56 + 0.000362040944570952*x_57 - 2.66843830664206e-6*x_58 - 0.00017792373151322*x_59 - 2.46908778998679e-7*x_6 - 0.000930224311253378*x_60 + 3.54657144355251e-5*x_61 - 5.83095470834659e-5*x_62 - 0.000109343471459169*x_63 - 4.52671002944581e-5*x_64 + 8.87443758424629e-5*x_65 - 9.8394575407365e-5*x_66 + 1.78795677982094e-5*x_67 - 7.09037752178045e-5*x_68 - 0.000108781691730178*x_69 - 7.33330848096804e-7*x_7 - 3.99220155085691e-5*x_70 - 0.000253322636007211*x_71 - 6.21478049085212e-5*x_72 + 5.51726850557348e-5*x_73 - 1.42315869596732e-5*x_74 - 0.000135370221531267*x_75 - 0.000252010951104762*x_76 - 6.28664377867562e-5*x_77 - 0.000216389443358244*x_78 - 8.01617664748663e-5*x_79 - 0.000166150504862441*x_8 + 2.78270654292793e-5*x_80 + 6.92398317464688e-6*x_81 - 9.62508871871495e-6*x_82 - 0.000114692753069761*x_83 - 3.15992254638664e-5*x_84 - 6.02632326483687e-5*x_85 + 6.01113119058675e-6*x_86 - 4.82314709832988e-5*x_87 + 6.84317387107777e-5*x_88 - 1.19025390046486e-5*x_89 - 0.000217061458746588*x_9 + 0.000134683096206692*x_90 + 6.75628954888414e-5*x_91 + 7.43988956802192e-5*x_92 - 0.000159335067575788*x_93 + 2.25417111703287e-5*x_94 + 0.000122358681796152*x_95 - 2.37964068872735e-5*x_96 - 0.0001106731965295*x_97 - 0.000162428627476188*x_98 - 0.000976350593271476*x_99 - 0.000523461721411102*std::sin(0.308079928159714*x_109 - 1.6509598493576) + 0.000317733846310606*std::sin(1.14423990249634*x_3 + 4.221360206604) - 0.00076607154591441*std::sin(0.641519844532013*x_45 - 5.00735950469971) - 0.000289076060641862*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 1.45954088095582e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) - 6.71694512622219e-5*std::sin(1.67527985572815*x_62 + 0.974879801273346) + 0.000123836845811498*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.00111708405328733*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 0.000290599588007327*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 5.68615886900156e-5*std::sin(0.962239801883698*x_91 + 4.00952005386353) - 0.000103827560673636*std::sin(1.77159988880157*x_91 + 7.99575996398926) - 8.29231166937247e-5*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 6.8203509351099e-5*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0382726422559529);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.15075129219818e-5*x_1 - 9.70369682620155e-5*x_10 + 8.50077202351244e-5*x_100 - 0.000144278946083044*x_101 - 5.68459417437663e-5*x_102 + 0.000484847087603241*x_103 - 0.000412873263786683*x_104 + 0.000144620510249275*x_105 + 0.000107035121452448*x_106 + 3.21208326836912e-5*x_107 - 0.000132927474647872*x_108 + 3.37560452102388e-5*x_109 - 1.37964149071887e-5*x_11 + 3.64306565719272e-5*x_110 - 1.86179219432109e-5*x_111 + 0.000161257240189701*x_112 + 0.00029980399215846*x_113 + 0.000295435846462348*x_114 - 0.000168638335367588*x_115 - 0.000157956506501249*x_116 + 0.000112087811117778*x_117 - 5.01957780832285e-6*x_118 + 3.79818606627191e-6*x_119 - 3.91957362858074e-5*x_12 + 4.20291297759471e-5*x_120 - 0.000936856926020557*x_13 + 0.000398992402638763*x_14 + 0.00010878966760038*x_15 - 0.000200313020307904*x_16 + 4.76308480518154e-5*x_17 - 0.000971079092534658*x_18 - 0.000407037053053096*x_19 - 9.33784622727006e-5*x_2 - 0.000267563469173247*x_20 - 4.41386956841742e-5*x_21 - 0.000162413383176781*x_22 - 0.000659478854320842*x_23 - 0.000190129581836187*x_24 - 3.80108775261547e-5*x_25 - 0.000284194135087198*x_26 - 0.000672963630794919*x_27 + 0.000136830618560808*x_28 + 0.000133580833902954*x_29 + 5.81521225783915e-5*x_3 - 0.000855531628629423*x_30 - 2.97414474371056e-5*x_31 - 4.64143816014657e-5*x_32 - 0.000180054023799293*x_33 + 5.43403560808301e-5*x_34 - 2.53902579855663e-5*x_35 - 0.00108695860465861*x_36 - 0.000782727419408071*x_37 - 0.000267760414379442*x_38 - 2.6825122725833e-5*x_39 + 7.23193784055358e-5*x_4 + 9.81018250540198e-5*x_40 + 0.000308062327659975*x_41 + 0.000147405738190861*x_42 - 0.000265408174574111*x_43 - 0.000180141198654631*x_44 + 0.000267314299352669*x_45 - 0.000306469895357375*x_46 + 0.000614623092893564*x_47 + 0.000221996543306761*x_48 + 0.000240337271448518*x_49 + 8.78973526695513e-5*x_5 - 0.000105837936804394*x_50 - 0.000560967774969838*x_51 - 4.52868968108172e-5*x_52 + 0.000451365148191144*x_53 + 8.92386775126484e-5*x_54 + 1.09339136187081e-5*x_55 + 0.000711016997890298*x_56 + 0.000522020989880905*x_57 - 0.00185437326833883*x_58 - 0.000317206173869934*x_59 + 5.50131241893646e-5*x_6 + 0.000198349259478131*x_60 - 0.000112471560363789*x_61 - 7.38834586280962e-5*x_62 - 0.00013818962840441*x_63 + 6.46288060649333e-5*x_64 - 5.0636909826132e-5*x_65 + 4.69145399843898e-5*x_66 - 3.1316017953307e-5*x_67 + 3.76617555322947e-5*x_68 + 0.000128535508908735*x_69 - 0.000184091372478455*x_7 + 3.73451065686373e-5*x_70 + 9.35661477315203e-6*x_71 + 0.000297965145136952*x_72 + 0.000149699517881744*x_73 - 6.66585840818276e-5*x_74 - 0.00023674817901713*x_75 - 0.000239277970433092*x_76 - 6.38768793002689e-6*x_77 + 0.000340221591227559*x_78 + 2.46315831200106e-5*x_79 - 6.0258389326336e-5*x_8 + 8.12410370117844e-5*x_80 + 4.07353192695566e-7*x_81 - 8.81278375582957e-5*x_82 + 0.000959376475196044*x_83 + 5.60788831712199e-5*x_84 - 7.98679060291013e-6*x_85 - 0.000143291202456733*x_86 - 6.65634594030183e-5*x_87 - 1.73851729309083e-5*x_88 + 1.44712818262152e-5*x_89 + 1.67304444351931e-5*x_9 - 0.000326636910216113*x_90 + 2.62942258986257e-5*x_91 + 0.000140619923081887*x_92 - 4.15251849058759e-5*x_93 + 4.4183162870093e-5*x_94 + 0.00015239107299716*x_95 - 3.59958306809051e-5*x_96 + 8.14093854906437e-5*x_97 + 0.000414139520408511*x_98 + 0.000928646148932206*x_99 + 0.000691056356659629*std::sin(0.308079928159714*x_109 - 1.6509598493576) - 0.000436135023644986*std::sin(1.14423990249634*x_3 + 4.221360206604) - 0.00177459634566584*std::sin(0.641519844532013*x_45 - 5.00735950469971) - 0.000669641528353852*std::sin(0.837359845638275*x_5 + 1.17007982730865) - 4.16467812358161e-5*std::sin(1.65815985202789*x_62 - 8.60015964508057) + 8.86748244799415e-5*std::sin(1.67527985572815*x_62 + 0.974879801273346) + 0.000286866696991799*std::sin(1.07031989097595*x_67 + 1.36583995819092) - 0.000751249301683451*std::sin(0.295199930667877*x_7 - 1.89423990249634) + 0.000195430896106302*std::sin(0.977199852466583*x_70 + 2.19375991821289) + 0.000162249798946585*std::sin(0.962239801883698*x_91 + 4.00952005386353) - 0.000240515407122846*std::sin(1.77159988880157*x_91 + 7.99575996398926) + 0.000109472277649548*std::sin(1.7279999256134*x_95 - 6.17560005187988) - 0.000194613023213163*std::sin(1.66831982135773*x_98 - 5.22143983840942) + 0.0506632124842466);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
