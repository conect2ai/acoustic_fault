
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00112995162303176*x_1 - 0.000253546183289874*x_10 - 1.19288088171616*x_100 + 0.27778705566689*x_101 + 0.854618398718624*x_102 - 0.463752478617593*x_103 + 2.52772132212088*x_104 - 0.685910131269503*x_105 - 0.941393092913163*x_106 - 0.720397646277805*x_107 + 1.61065043749652*x_108 + 1.97776351271796*x_109 - 0.155859271724487*x_110 - 1.30452745153771*x_111 - 0.0137278449306632*x_112 - 0.000191710976018621*x_113 + 2.03333195535489*x_114 - 1.07910027678981*x_115 - 2.51705446613922*x_116 + 0.0176802347648766*x_117 + 0.252066512352739*x_118 + 0.201066935205121*x_119 + 0.0282473881797705*x_12 + 0.000698782592474412*x_120 - 0.278187394441993*x_13 - 0.160252776421*x_14 + 0.0333423278059935*x_15 + 0.017966035612551*x_16 + 0.0465511507358171*x_17 - 0.388908658956865*x_18 - 0.00992850506160366*x_19 + 0.0397170508560458*x_2 + 0.00357138429354283*x_20 + 0.00116274774926141*x_21 - 0.000203040725589652*x_22 + 0.00335759503780236*x_24 + 0.0053035170743822*x_25 - 0.0135377159271552*x_26 + 0.79181232006083*x_27 + 0.0234254711433817*x_28 + 0.00135053167663135*x_29 - 0.00403582066053173*x_3 + 0.00465442777463775*x_30 + 0.00729317757195333*x_31 + 0.00184770301314284*x_32 + 0.0164421384165134*x_33 - 0.262854029027467*x_34 - 2.98059360021808*x_35 + 0.0155132489462777*x_36 - 18.7874610192118*x_37 + 102.031464897837*x_38 - 3.49240850529786*x_39 + 563.125518580865*x_40 + 0.280954724813274*x_41 - 1.49724157210353*x_42 - 0.730501158075347*x_43 - 1.58459662587907*x_44 - 2.00277610637479*x_45 + 0.0622833867552067*x_46 + 0.153919562451853*x_47 - 1.18632135235953*x_48 - 0.0793946293545333*x_49 + 0.00840407495043763*x_5 + 0.197255359903605*x_50 - 0.0219438214961308*x_52 - 0.0320383429798728*x_53 - 0.0285579386171834*x_55 - 0.00726146360626902*x_56 + 0.0677873207026821*x_58 + 0.484495667359394*x_59 + 0.488403025625567*x_6 - 1.50664002964722*x_60 + 0.604792457076715*x_61 + 0.0967221909130907*x_62 + 0.114246804844534*x_63 - 0.0288663811196326*x_64 + 1.66833546903911*x_65 + 0.0992760541401949*x_66 + 0.323010251634984*x_67 + 0.107818680994717*x_68 + 0.398645526476744*x_69 + 0.547823106529149*x_7 - 0.0751839914897393*x_70 + 0.658762142924311*x_71 - 0.00717762407102225*x_72 - 0.431361049543788*x_73 - 0.865719790399035*x_74 + 0.276737153321433*x_75 + 0.655006112234155*x_76 + 0.329366851430187*x_77 - 0.31161883451555*x_78 + 0.383829158272752*x_79 - 0.0147271043510578*x_8 - 0.0172805490552765*x_80 - 0.165196575128063*x_81 - 0.394450753580612*x_82 - 1.32150556455826*x_83 + 0.793440008677754*x_84 - 0.519021291787326*x_85 + 207.856295444892*x_86 + 1.58382912990541*x_87 + 0.899923262002039*x_88 + 0.6297844509589*x_89 - 0.0252166621155586*x_9 + 2.12486566236743*x_90 + 0.0309435743364322*x_91 + 0.00384330163182028*x_92 - 4.19828090002625*x_93 - 0.0230301181055991*x_94 + 0.00660526919819617*x_95 + 0.185234920701543*x_96 + 0.0298036825798776*x_97 - 1.23735408958903*x_98 - 9.62066341639869*x_99 + 0.00782669180245277*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 0.00236325704187552*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 8.83850991341053e-5*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.00445912872268834*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 0.000129958730250961*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 0.0218118561089136*std::exp(0.619999825954437*x_1) - 0.00341534019237647*std::exp(1.67199981212616*x_1) - 0.00104273054034572*std::exp(0.867839872837067*x_10) + 0.0641188218962329*std::exp(0.883439898490906*x_11) + 0.00749506178054409*std::exp(0.935519814491272*x_11) + 6.32530657441649e-5*std::exp(0.981679856777191*x_11) + 0.00213994669499229*std::exp(0.982479810714722*x_11) - 0.000542277727652906*std::exp(1.03247976303101*x_11) + 0.0114868608722424*std::exp(0.478879868984222*x_12) + 0.00224106020655286*std::exp(0.848559856414795*x_12) + 0.00261147071386965*std::exp(1.19295990467072*x_12) + 0.057166684897727*std::exp(0.269119828939438*x_13) + 0.000581001375794902*std::exp(0.856879889965057*x_14) - 0.00449481012895018*std::exp(0.778239846229553*x_15) + 0.00190169076396852*std::exp(0.980319857597351*x_15) - 0.00628352627091067*std::exp(0.480959862470627*x_16) - 0.0192710590779968*std::exp(0.682639837265015*x_16) + 0.170574231300458*std::exp(0.704719841480255*x_16) - 0.0110694844042428*std::exp(0.726879835128784*x_17) + 0.0247873100337231*std::exp(0.736799836158752*x_19) + 0.095644780065973*std::exp(0.765119850635529*x_19) - 0.198724535211632*std::exp(0.769039869308472*x_19) + 0.000919416808153642*std::exp(0.808799862861633*x_19) - 0.000505480272929835*std::exp(0.504639863967896*x_2) + 0.064670198722279*std::exp(0.695039868354797*x_20) + 0.0142633307659911*std::exp(0.969119846820831*x_20) + 8.43514886862605e-5*std::exp(1.11439990997314*x_20) - 0.00888622016269905*std::exp(0.497599840164185*x_22) + 0.002255632998929*std::exp(0.944959819316864*x_22) - 0.00711072332653478*std::exp(0.613439857959747*x_23) + 0.00584943543630882*std::exp(0.662079870700836*x_23) - 0.00209942780953224*std::exp(0.772399842739105*x_23) + 0.0447618662313063*std::exp(0.61983984708786*x_24) - 0.0636435966561774*std::exp(0.659039855003357*x_24) + 0.000166855963513209*std::exp(0.740079820156097*x_24) + 0.0421140983514729*std::exp(0.442479848861694*x_25) - 0.175558502461787*std::exp(0.453039854764938*x_25) + 0.00543990115373382*std::exp(0.923359870910645*x_25) + 1.9182875724405e-5*std::exp(1.03015983104706*x_25) + 0.321546818427738*std::exp(0.515279829502106*x_26) + 0.005787459071028*std::exp(0.741679847240448*x_26) - 0.00230851020423983*std::exp(0.549279868602753*x_27) + 0.00094939546451604*std::exp(0.836879849433899*x_27) + 0.00729129194481906*std::exp(0.928959846496582*x_27) + 3.50723541804076*std::exp(0.357039839029312*x_28) + 0.000283201649375676*std::exp(1.05983984470367*x_28) + 2.30808536367358*std::exp(0.310319840908051*x_29) + 0.0147943774404934*std::exp(0.593839824199677*x_29) + 1.97285619475995e-5*std::exp(1.26631987094879*x_29) + 0.00155868733042081*std::exp(1.27407991886139*x_29) - 0.031166811329721*std::exp(0.871119856834412*x_3) + 0.0204522220063446*std::exp(0.819999873638153*x_30) + 0.170950467752589*std::exp(0.877279877662659*x_30) - 0.274889895925617*std::exp(0.682399809360504*x_32) + 0.00672569712725682*std::exp(0.28167986869812*x_33) - 0.034442823626215*std::exp(0.442239850759506*x_33) - 1.82634543567386*std::exp(0.339919835329056*x_36) - 0.0312357385375396*std::exp(0.329519838094711*x_38) - 0.0010308408571355*std::exp(0.336719840764999*x_4) + 0.791493839953929*std::exp(0.454319834709167*x_4) - 0.0123712668007848*std::exp(0.461599856615067*x_4) - 0.00328017227159447*std::exp(1.0719997882843*x_4) - 0.00762623740677463*std::exp(0.618799805641174*x_41) - 0.002191557114253*std::exp(0.789759874343872*x_41) + 0.0299741744391957*std::exp(0.790239870548248*x_41) - 0.00184858147532569*std::exp(0.829279899597168*x_41) - 0.00446491100725113*std::exp(0.542079865932465*x_42) - 0.00856349593391673*std::exp(0.756079852581024*x_46) - 0.00235712299291999*std::exp(0.769599854946136*x_46) - 0.326499487139955*std::exp(0.50087982416153*x_47) - 0.0648209625325374*std::exp(0.568239867687225*x_47) - 0.0158358776641072*std::exp(0.499679833650589*x_48) - 0.00252724618996087*std::exp(0.530479848384857*x_48) - 0.0370882350605488*std::exp(0.66815984249115*x_49) - 0.00443960641560709*std::exp(0.675759792327881*x_49) - 9.9381101000985e-5*std::exp(0.769919812679291*x_49) + 0.00430586638621609*std::exp(0.279839843511581*x_50) - 0.0373551764945231*std::exp(0.558319866657257*x_50) - 9.12177128619737*std::exp(0.491999834775925*x_51) + 0.0140303493607365*std::exp(0.493039846420288*x_51) - 1.14796269643059*std::exp(0.495119869709015*x_51) + 0.218382935735996*std::exp(0.49551984667778*x_51) + 4.10428508229701*std::exp(0.501519858837128*x_51) - 0.0716601785543883*std::exp(0.348879843950272*x_54) + 0.0407842972235454*std::exp(0.47735983133316*x_54) - 0.131729686078934*std::exp(0.492399841547012*x_54) + 0.58823895271319*std::exp(0.494639873504639*x_54) - 0.0755507220223272*std::exp(0.498079836368561*x_55) + 0.493856998201389*std::exp(0.650959849357605*x_55) - 0.205241224245066*std::exp(0.653679847717285*x_55) - 1.42080153871031*std::exp(0.653839826583862*x_55) - 1.85426253236734*std::exp(0.344719856977463*x_56) - 0.13181391050542*std::exp(0.403919875621796*x_56) + 0.00305065134998919*std::exp(0.554959833621979*x_56) + 0.106266110713885*std::exp(0.215359851717949*x_57) + 0.00107260078118289*std::exp(0.423999845981598*x_57) - 0.0329521791902863*std::exp(0.600159823894501*x_57) - 0.310450346449493*std::exp(0.636399865150452*x_57) + 1.20361021925638*std::exp(0.640799820423126*x_57) + 0.0320461080656608*std::exp(0.514319837093353*x_58) - 0.0381104059561311*std::exp(0.575679838657379*x_58) - 0.0620949652513991*std::exp(0.581039845943451*x_58) - 0.000162817248190442*std::exp(0.943519830703735*x_59) - 0.00813971900295631*std::exp(0.851839900016785*x_60) - 4.56639430340375e-5*std::exp(0.903199791908264*x_60) - 0.000426758269032811*std::exp(0.91351979970932*x_60) + 0.00104780587814412*std::exp(0.918799817562103*x_60) + 0.0057556444609794*std::exp(0.99999988079071*x_66) + 0.00746795929397025*std::exp(1.11287987232208*x_66) - 0.00933551134469619*std::exp(0.403839856386185*x_8) + 0.842066298476614*std::log(7.69087982177734 - 0.987919807434082*x_21) - 0.00120741982621468*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.0756033277262702*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 5.24393473571428*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 0.0545641668819142*std::sin(0.553839862346649*x_10 - 1.13599991798401) + 0.00721591021409102*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 0.204457709065554*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 0.769231814682166*std::sin(0.307359933853149*x_103 + 1.91287982463837) - 0.00985957863421775*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 0.907759361521003*std::sin(0.270639955997467*x_107 - 7.45351982116699) - 0.00473196008026186*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 1.1738108945987*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 5.09955609099891*std::sin(0.273759961128235*x_112 - 7.4302396774292) + 0.00443612049121363*std::sin(0.286159932613373*x_112 - 7.44384002685547) + 0.00541853368045744*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 14.0409595892518*std::sin(0.288799941539764*x_113 - 7.43088006973267) - 0.0112866877978912*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 0.264343046997744*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 0.213869528696274*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 0.469514705519132*std::sin(0.246159970760345*x_117 + 5.15112018585205) - 0.00709469077396283*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 0.127878606168587*std::sin(0.262239962816238*x_117 - 7.46135997772217) + 0.00498562075609665*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 2.99305953604916*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 0.0184500719437142*std::sin(0.263999968767166*x_120 - 1.20231986045837) - 0.00280305666572433*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 0.387830908293025*std::sin(0.276079952716827*x_120 + 5.14111995697021) + 0.00195123994320902*std::sin(0.438399881124496*x_15 - 4.26543998718262) + 0.00249711078983913*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 1.6428139949353*std::sin(0.332959830760956*x_18 - 4.39271974563599) - 0.00526170690482152*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 0.493406651640082*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 2.45486456938502*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.0364094065160947*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 14.2663951720198*std::sin(0.181600019335747*x_23 + 4.97295999526978) + 0.00343602160883923*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 1.93884286251663*std::sin(0.253439962863922*x_24 - 4.38711977005005) - 0.00429609676087247*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.127933512473914*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 2.25982167316489*std::sin(0.41967985033989*x_3 - 4.21216011047363) + 0.00251709400272717*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.040556837348809*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 3.21127751938929*std::sin(0.383039832115173*x_31 + 5.17232036590576) - 0.00568369780856283*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.0893574870714213*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 0.15685657641327*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.126126821460775*std::sin(0.390079826116562*x_32 + 5.18871974945068) + 0.00328438530484818*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 41.0659247287869*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 2.67887619126935*std::sin(0.0688000917434692*x_4 - 7.74391984939575) + 0.00960044459470953*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.0762478399896533*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.246872967693777*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 8.74590811372691*std::sin(0.206719994544983*x_5 + 8.2021598815918) - 0.00128580006584006*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 1.27888515718313*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 18.7209335146226*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.136563822476063*std::sin(0.254079967737198*x_53 + 1.98175978660583) - 0.010307458070471*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 0.141219987483997*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.12160427358012*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.00667728152775279*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.228354321573736*std::sin(0.307599931955338*x_7 - 1.15295994281769) + 0.003747619766282*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 2.39053259428082*std::sin(0.377679854631424*x_8 + 2.00887989997864) + 0.00307928796647259*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 7.14760746151404*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.288480057199928*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 5.81198460091025*std::sin(0.36847984790802*x_91 + 2.00039982795715) - 0.00136683411682072*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 0.106246298971219*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 6.70314665804539*std::sin(0.298399955034256*x_92 + 1.9864798784256) - 0.0103311444100153*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 0.247882922269774*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.0644949982926506*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 10.9986539093782*std::sin(0.321039855480194*x_94 + 8.23744010925293) - 0.00352322873860181*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 0.125408306014166*std::sin(0.343759834766388*x_94 - 4.37103986740112) - 0.00740114478487458*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.134634609964734*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 20.5609904274675*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.177128339650675*std::sin(0.304719924926758*x_95 + 1.95855987071991) + 0.00598603238446187*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 5.42998362161704*std::sin(0.273839950561523*x_97 + 1.97855985164642) - 0.00709563621806411*std::sin(0.274719953536987*x_97 + 1.97439980506897) + 0.00832738022916842*std::sin(0.25655996799469*x_98 - 7.43255996704102) - 8889.910495897);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00121758626725882*x_1 - 0.0111311883745654*x_10 - 0.0969687935979507*x_100 - 0.21213171574282*x_101 + 1.51947063076508*x_102 - 0.441240364277449*x_103 - 36.5492728841156*x_104 + 0.0692662466789425*x_105 + 1.87544934409917*x_106 + 0.254819927672592*x_107 - 0.571103148202507*x_108 + 1.09035400645215*x_109 - 0.983350256722531*x_110 - 1.11050231269041*x_111 + 0.614722073474178*x_112 + 0.218977298598076*x_113 - 0.210474488154278*x_114 + 0.778674743361406*x_115 - 0.368881338864526*x_116 + 0.00325835891532147*x_117 + 1.56815606719905*x_118 + 0.399960462260644*x_119 + 0.0304381455210768*x_12 + 0.000752977447046372*x_120 + 0.731782119261646*x_13 + 0.271081529976339*x_14 + 0.018778650076356*x_15 + 0.954328161387399*x_16 + 2.0070851024111*x_17 + 1.08178481389685*x_18 - 0.00169044618523079*x_19 + 0.39170842014167*x_2 + 0.189706437188823*x_20 + 0.210019446548582*x_21 - 0.00891389700653847*x_22 + 0.00361799702369169*x_24 + 0.281714664694644*x_25 - 0.111474853668929*x_26 + 0.175490590854234*x_27 + 0.0667711643560829*x_28 + 0.0592910620989878*x_29 - 0.214376582219613*x_3 + 0.248744424634961*x_30 + 0.0630512518098122*x_31 + 0.00485883625554504*x_32 - 0.883744584028871*x_33 + 3.19621162568317*x_34 - 3.55445067007848*x_35 + 1.50897145212476*x_36 + 3.9861729449447*x_37 + 40.2608009299966*x_38 - 1.60164767911035*x_39 - 55.7817523585685*x_40 + 0.0478358866552719*x_41 + 0.170070829886075*x_42 + 0.655411719801234*x_43 - 0.799433729806184*x_44 - 2.46860803607623*x_45 - 0.390576255807902*x_46 + 4.95113784923871*x_47 - 0.470648960179544*x_48 - 0.193554576167623*x_49 - 0.882734257841385*x_5 - 1.12791247540226*x_50 + 0.767079630825588*x_52 - 0.50644432428102*x_53 - 0.00486232903079925*x_55 - 0.00782463442414503*x_56 - 0.0237088240495679*x_58 + 0.148934507935505*x_59 - 1.04973787620062*x_6 - 0.256523401542363*x_60 - 0.407056059486985*x_61 - 0.748054430451693*x_62 - 0.567552657078914*x_63 - 0.00708856640065008*x_64 - 0.282448381091275*x_65 - 0.00381197450382598*x_66 + 0.61563978990489*x_67 + 0.531109525836173*x_68 - 0.50712555741606*x_69 - 0.391789367431689*x_7 - 0.728831072334894*x_70 - 0.842703667090178*x_71 - 0.7600434679791*x_72 - 0.900425018970131*x_73 - 0.162633757346879*x_74 + 0.923504485560975*x_75 + 0.75522235497576*x_76 + 0.960274326900812*x_77 - 0.133799157520217*x_78 - 0.811964651280648*x_79 - 0.00737643352738617*x_8 - 0.459235424225792*x_80 - 0.488965598261003*x_81 + 0.529469847626058*x_82 + 0.470799027531294*x_83 + 0.133706914361045*x_84 - 0.694955159838451*x_85 + 54.2273587641957*x_86 + 0.783708576875725*x_87 + 3.73181398069404*x_88 - 0.296125514627801*x_89 - 0.143472140887721*x_9 + 0.731881786245913*x_90 + 1.20042815955029*x_91 + 0.00414137312824255*x_92 - 0.643792599515749*x_93 - 0.0605614495538623*x_94 + 0.350861734070019*x_95 + 0.382397555306036*x_96 + 1.73051502863468*x_97 + 1.17938132781267*x_98 + 5.44501307857354*x_99 + 0.00133258745584971*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 0.000402372645868704*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 9.52399029679266e-5*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.0117260058309303*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 0.000140037822893162*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 1.15861222730318*std::exp(0.619999825954437*x_1) - 0.00898119374904982*std::exp(1.67199981212616*x_1) - 0.00274202992480816*std::exp(0.867839872837067*x_10) + 0.0109169927600835*std::exp(0.883439898490906*x_11) + 0.0197094866749792*std::exp(0.935519814491272*x_11) + 0.00277693704922432*std::exp(0.981679856777191*x_11) + 0.00230591262084083*std::exp(0.982479810714722*x_11) - 0.0288049583087102*std::exp(1.03247976303101*x_11) + 0.610164370856625*std::exp(0.478879868984222*x_12) + 0.00589323311430705*std::exp(0.848559856414795*x_12) + 0.000444633978500469*std::exp(1.19295990467072*x_12) + 0.150329116321532*std::exp(0.269119828939438*x_13) + 0.00152783782304499*std::exp(0.856879889965057*x_14) - 0.000765294935005379*std::exp(0.778239846229553*x_15) + 0.00204917848833951*std::exp(0.980319857597351*x_15) - 0.0165235565675891*std::exp(0.480959862470627*x_16) - 0.0207656473167814*std::exp(0.682639837265015*x_16) + 0.0290422935589419*std::exp(0.704719841480255*x_16) - 0.0291090136082208*std::exp(0.726879835128784*x_17) + 1.31666376046238*std::exp(0.736799836158752*x_19) + 0.103062616460391*std::exp(0.765119850635529*x_19) - 0.522578558179777*std::exp(0.769039869308472*x_19) + 0.0403642506209582*std::exp(0.808799862861633*x_19) - 0.0221916025893238*std::exp(0.504639863967896*x_2) + 0.011010871228839*std::exp(0.695039868354797*x_20) + 0.0375077532253129*std::exp(0.969119846820831*x_20) + 9.08934614135615e-5*std::exp(1.11439990997314*x_20) - 0.472022338841846*std::exp(0.497599840164185*x_22) + 0.00593155464727966*std::exp(0.944959819316864*x_22) - 0.00766220331578067*std::exp(0.613439857959747*x_23) + 0.0153820439595777*std::exp(0.662079870700836*x_23) - 0.111518374150211*std::exp(0.772399842739105*x_23) + 2.37768144414392*std::exp(0.61983984708786*x_24) - 0.167361211551163*std::exp(0.659039855003357*x_24) + 0.00732531303443731*std::exp(0.740079820156097*x_24) + 0.110745886370381*std::exp(0.442479848861694*x_25) - 0.0298909250617255*std::exp(0.453039854764938*x_25) + 0.005861798686797*std::exp(0.923359870910645*x_25) + 0.00084216690026096*std::exp(1.03015983104706*x_25) + 0.0547471738405371*std::exp(0.515279829502106*x_26) + 0.307420918752968*std::exp(0.741679847240448*x_26) - 0.00248754925893873*std::exp(0.549279868602753*x_27) + 0.0504304259225767*std::exp(0.836879849433899*x_27) + 0.0191736406766966*std::exp(0.928959846496582*x_27) + 0.597148583431926*std::exp(0.357039839029312*x_28) + 0.0150432357576849*std::exp(1.05983984470367*x_28) + 0.392979010837994*std::exp(0.310319840908051*x_29) + 0.0389042270185064*std::exp(0.593839824199677*x_29) + 0.00104795084771607*std::exp(1.26631987094879*x_29) + 0.0016795730452412*std::exp(1.27407991886139*x_29) - 0.081958210698049*std::exp(0.871119856834412*x_3) + 0.0537824515541888*std::exp(0.819999873638153*x_30) + 0.0291063522939985*std::exp(0.877279877662659*x_30) - 0.0468032773355803*std::exp(0.682399809360504*x_32) + 0.295271657030537*std::exp(0.28167986869812*x_33) - 0.0905730190339089*std::exp(0.442239850759506*x_33) - 0.310957052999666*std::exp(0.339919835329056*x_36) - 0.0821394660264*std::exp(0.329519838094711*x_38) - 0.0452559909050384*std::exp(0.336719840764999*x_4) + 0.134761248957623*std::exp(0.454319834709167*x_4) - 0.657142652649432*std::exp(0.461599856615067*x_4) - 0.00862574766847808*std::exp(1.0719997882843*x_4) - 0.00821769865901888*std::exp(0.618799805641174*x_41) - 0.0962137735849069*std::exp(0.789759874343872*x_41) + 0.0788219775901492*std::exp(0.790239870548248*x_41) - 0.098193802938359*std::exp(0.829279899597168*x_41) - 0.00481119210429145*std::exp(0.542079865932465*x_42) - 0.0092276473048357*std::exp(0.756079852581024*x_46) - 0.125206745689952*std::exp(0.769599854946136*x_46) - 0.0555904246501335*std::exp(0.50087982416153*x_47) - 0.0698482237658573*std::exp(0.568239867687225*x_47) - 0.0170640466200433*std::exp(0.499679833650589*x_48) - 0.134243428091269*std::exp(0.530479848384857*x_48) - 0.00631471355315207*std::exp(0.66815984249115*x_49) - 0.00478392498713674*std::exp(0.675759792327881*x_49) - 0.00436303059963221*std::exp(0.769919812679291*x_49) + 0.189036211228958*std::exp(0.279839843511581*x_50) - 0.040252298402586*std::exp(0.558319866657257*x_50) - 23.9871844798141*std::exp(0.491999834775925*x_51) + 0.615960609893191*std::exp(0.493039846420288*x_51) - 1.23699420931758*std::exp(0.495119869709015*x_51) + 11.6001654473913*std::exp(0.49551984667778*x_51) + 0.698803396626156*std::exp(0.501519858837128*x_51) - 0.0772178627285229*std::exp(0.348879843950272*x_54) + 2.16639910006818*std::exp(0.47735983133316*x_54) - 0.346404681974944*std::exp(0.492399841547012*x_54) + 0.100154684662824*std::exp(0.494639873504639*x_54) - 0.198672938607321*std::exp(0.498079836368561*x_55) + 26.232923681426*std::exp(0.650959849357605*x_55) - 9.01050333179872*std::exp(0.653679847717285*x_55) - 1.5309933688951*std::exp(0.653839826583862*x_55) - 0.315710271063756*std::exp(0.344719856977463*x_56) - 0.346626163833285*std::exp(0.403919875621796*x_56) + 0.133929741719004*std::exp(0.554959833621979*x_56) + 5.64469225389519*std::exp(0.215359851717949*x_57) + 0.0470893357223318*std::exp(0.423999845981598*x_57) - 0.0355078217868241*std::exp(0.600159823894501*x_57) - 0.816379790553877*std::exp(0.636399865150452*x_57) + 0.204928968764419*std::exp(0.640799820423126*x_57) + 1.70223994037723*std::exp(0.514319837093353*x_58) - 0.0410661005179509*std::exp(0.575679838657379*x_58) - 0.163288832839601*std::exp(0.581039845943451*x_58) - 0.00864860164248987*std::exp(0.943519830703735*x_59) - 0.0214047179228449*std::exp(0.851839900016785*x_60) - 0.00200473911790727*std::exp(0.903199791908264*x_60) - 0.0226687424552602*std::exp(0.91351979970932*x_60) + 0.00112906961853666*std::exp(0.918799817562103*x_60) + 0.305730975630974*std::exp(0.99999988079071*x_66) + 0.0196382162687268*std::exp(1.11287987232208*x_66) - 0.495887994954837*std::exp(0.403839856386185*x_8) + 0.143371812084395*std::log(7.69087982177734 - 0.987919807434082*x_21) - 0.0530081634769274*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.0814668271829078*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 0.892842317608249*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 2.89836456862387*std::sin(0.553839862346649*x_10 - 1.13599991798401) + 0.31679299938492*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 10.8604788380637*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 2.02282044436298*std::sin(0.307359933853149*x_103 + 1.91287982463837) - 0.432855370360062*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 2.38710120928276*std::sin(0.270639955997467*x_107 - 7.45351982116699) - 0.207742583031113*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 3.08672708290323*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 0.868260134522927*std::sin(0.273759961128235*x_112 - 7.4302396774292) + 0.194754628917109*std::sin(0.286159932613373*x_112 - 7.44384002685547) + 0.237884547613728*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 2.39064052718493*std::sin(0.288799941539764*x_113 - 7.43088006973267) - 0.495508338453674*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 0.69513313098364*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 11.3604202117311*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 1.23466545081158*std::sin(0.246159970760345*x_117 + 5.15112018585205) - 0.311471221690544*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 6.79271475006963*std::sin(0.262239962816238*x_117 - 7.46135997772217) + 0.218878797859118*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 0.509604018277623*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 0.980039426350101*std::sin(0.263999968767166*x_120 - 1.20231986045837) - 0.123059836144672*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 1.01986459124177*std::sin(0.276079952716827*x_120 + 5.14111995697021) + 0.0856633655060957*std::sin(0.438399881124496*x_15 - 4.26543998718262) + 0.109628195673058*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 0.279708640278779*std::sin(0.332959830760956*x_18 - 4.39271974563599) - 0.230999536137206*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 1.29749321761299*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 0.417969918011489*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.039233178190492*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 2.42902361895361*std::sin(0.181600019335747*x_23 + 4.97295999526978) + 0.150848272653112*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 0.330111079197435*std::sin(0.253439962863922*x_24 - 4.38711977005005) - 0.188607304989323*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.137855537118021*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 0.384761542951404*std::sin(0.41967985033989*x_3 - 4.21216011047363) + 0.110505498987585*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.0437022675951955*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 0.546758227818459*std::sin(0.383039832115173*x_31 + 5.17232036590576) - 0.249525787177347*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.234980077858138*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 8.3319799313669*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.135908726190952*std::sin(0.390079826116562*x_32 + 5.18871974945068) + 0.144191133341267*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 6.99196257342089*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 2.88663938852937*std::sin(0.0688000917434692*x_4 - 7.74391984939575) + 0.421478863837262*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.0821613253056412*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.266019472953069*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 1.48909497608099*std::sin(0.206719994544983*x_5 + 8.2021598815918) - 0.0564492139427364*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 3.3630369838659*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 3.18746180289921*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.147155180329833*std::sin(0.254079967737198*x_53 + 1.98175978660583) - 0.452518180146195*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 7.50138839269608*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.319778259329293*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.354686918186597*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.246064592810953*std::sin(0.307599931955338*x_7 - 1.15295994281769) + 0.164528059675177*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 0.407016633380168*std::sin(0.377679854631424*x_8 + 2.00887989997864) + 0.135186946889087*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 1.21696526233044*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.31085344616988*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 0.989559569770911*std::sin(0.36847984790802*x_91 + 2.00039982795715) - 0.0600067720748129*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 5.64363988461571*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 1.14129051925015*std::sin(0.298399955034256*x_92 + 1.9864798784256) - 0.453558058183208*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 0.651848549949691*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.0694969790098749*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 1.87265176664763*std::sin(0.321039855480194*x_94 + 8.23744010925293) - 0.154676841383262*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 6.66149620774431*std::sin(0.343759834766388*x_94 - 4.37103986740112) - 0.324925170313781*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.35404365284609*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 3.50075339812187*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.190865723368191*std::sin(0.304719924926758*x_95 + 1.95855987071991) + 0.262798884302335*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 0.924519355338434*std::sin(0.273839950561523*x_97 + 1.97855985164642) - 0.311512728591782*std::sin(0.274719953536987*x_97 + 1.97439980506897) + 0.365588772801723*std::sin(0.25655996799469*x_98 - 7.43255996704102) + 2955.64937853555);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00281680751676889*x_1 - 0.079458388729406*x_10 + 0.141933028430114*x_100 - 0.206404778091889*x_101 + 0.187831509912633*x_102 + 0.611838728172977*x_103 + 239.13719632884*x_104 - 0.0517334912360236*x_105 - 0.0225627183568767*x_106 + 0.489320945135166*x_107 - 0.388821030949559*x_108 + 0.525318035940255*x_109 - 1.83537160954185*x_110 - 1.91349948991111*x_111 + 0.126611181433747*x_112 + 0.0734311215503842*x_113 + 0.0823043881523053*x_114 - 0.0143236393251599*x_115 + 0.117838942447203*x_116 + 0.00288947252412971*x_117 + 0.808657298848283*x_118 + 0.398957550779278*x_119 + 0.070416691946846*x_12 + 0.00174196489384913*x_120 + 0.0435231745534774*x_13 - 0.161007726603063*x_14 + 0.21826603808741*x_15 + 0.346268811344951*x_16 + 0.935269334990336*x_17 - 1.17284939170666*x_18 - 0.00125930494834544*x_19 + 0.134736590777378*x_2 + 0.0688331594599076*x_20 - 0.0840923950736616*x_21 - 0.0636305729097028*x_22 + 0.00837000341251049*x_24 + 0.102217461486665*x_25 - 0.394439053237754*x_26 + 0.391797295887148*x_27 + 0.180239742926633*x_28 + 0.423240727037346*x_29 - 0.0777844847389395*x_3 + 0.0415717396419127*x_30 + 0.035977732111536*x_31 + 0.0130201134722036*x_32 - 0.24968983287092*x_33 + 0.500940320166498*x_34 + 0.172568427135642*x_35 - 0.924033306956891*x_36 + 3.15510085889858*x_37 + 10.5695125994806*x_38 - 3.40297089408326*x_39 - 107.991087355381*x_40 + 0.0356355436214321*x_41 - 0.485647442583953*x_42 + 0.32324632228051*x_43 - 2.40250619888504*x_44 - 0.851187383631503*x_45 - 2.01369054439182*x_46 + 2.64590433227002*x_47 - 1.502205044725*x_48 - 0.555778624615651*x_49 - 0.187297866991191*x_5 - 0.394991718715204*x_50 + 0.481465104160495*x_52 + 0.247956504881798*x_53 - 0.00362221232622865*x_55 - 0.0181017884765739*x_56 - 0.243909552180187*x_58 + 0.498147408549413*x_59 - 0.621904013598728*x_6 - 0.191098179729749*x_60 - 0.357331453663644*x_61 - 0.595442827051788*x_62 - 0.022962569837656*x_63 - 0.0866589630165595*x_64 - 0.27137942919374*x_65 - 0.057662047197027*x_66 + 0.425753508139369*x_67 + 0.181188966130878*x_68 - 0.441069339439814*x_69 - 0.126741450124652*x_7 - 0.368109005874799*x_70 - 0.83487038399881*x_71 - 0.855563752998837*x_72 - 0.613085737567399*x_73 - 0.375125018403679*x_74 + 0.382661273746272*x_75 + 0.301082588603443*x_76 + 0.273992872542437*x_77 - 0.161214315758772*x_78 - 1.27623564646481*x_79 - 0.0117950387340544*x_8 - 0.640331710968231*x_80 - 0.204153097923507*x_81 + 0.134131943311734*x_82 - 0.521414356164128*x_83 + 0.401760952505391*x_84 - 1.55506256626421*x_85 + 27.164636045705*x_86 + 0.406884185735063*x_87 - 30.2017025304963*x_88 - 0.26244799689217*x_89 - 0.08049307155143*x_9 + 0.139059154336303*x_90 + 0.489050585467759*x_91 + 0.00958080036796161*x_92 + 0.189465345191495*x_93 - 0.162285144788023*x_94 + 0.127306811764025*x_95 + 0.192361045083743*x_96 + 0.564177551009151*x_97 + 0.632174576403329*x_98 + 2.16062657213698*x_99 + 0.000992716592764819*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 0.000299749183646521*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 0.000220331389890232*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.0314219122573224*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 0.000323968496331243*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 0.42039132343611*std::exp(0.619999825954437*x_1) - 0.0240667014853656*std::exp(1.67199981212616*x_1) - 0.00734775548865975*std::exp(0.867839872837067*x_10) + 0.00813265936764945*std::exp(0.883439898490906*x_11) + 0.0528150650671242*std::exp(0.935519814491272*x_11) + 0.0198227660973324*std::exp(0.981679856777191*x_11) + 0.00533458053696658*std::exp(0.982479810714722*x_11) - 0.010451602580707*std::exp(1.03247976303101*x_11) + 0.221392284090625*std::exp(0.478879868984222*x_12) + 0.0157919633078514*std::exp(0.848559856414795*x_12) + 0.000331231939957742*std::exp(1.19295990467072*x_12) + 0.402833528388349*std::exp(0.269119828939438*x_13) + 0.00409411241230207*std::exp(0.856879889965057*x_14) - 0.000570109659222543*std::exp(0.778239846229553*x_15) + 0.00474064263401294*std::exp(0.980319857597351*x_15) - 0.0442778003125466*std::exp(0.480959862470627*x_16) - 0.0480399894655251*std::exp(0.682639837265015*x_16) + 0.0216351779249827*std::exp(0.704719841480255*x_16) - 0.0780027645118572*std::exp(0.726879835128784*x_17) + 0.477738804871341*std::exp(0.736799836158752*x_19) + 0.238428734414913*std::exp(0.765119850635529*x_19) - 1.4003419271181*std::exp(0.769039869308472*x_19) + 0.288134402966339*std::exp(0.808799862861633*x_19) - 0.158411566288835*std::exp(0.504639863967896*x_2) + 0.00820259452517161*std::exp(0.695039868354797*x_20) + 0.1005086768511*std::exp(0.969119846820831*x_20) + 0.000210276176907997*std::exp(1.11439990997314*x_20) - 0.171268774004753*std::exp(0.497599840164185*x_22) + 0.0158946526518611*std::exp(0.944959819316864*x_22) - 0.0177260145545931*std::exp(0.613439857959747*x_23) + 0.0412189148295673*std::exp(0.662079870700836*x_23) - 0.0404633714297775*std::exp(0.772399842739105*x_23) + 0.86271888510942*std::exp(0.61983984708786*x_24) - 0.448474048236305*std::exp(0.659039855003357*x_24) + 0.0522906944944797*std::exp(0.740079820156097*x_24) + 0.296763243559928*std::exp(0.442479848861694*x_25) - 0.0222673695085505*std::exp(0.453039854764938*x_25) + 0.0135608942435994*std::exp(0.923359870910645*x_25) + 0.00601168740337545*std::exp(1.03015983104706*x_25) + 0.0407841358853453*std::exp(0.515279829502106*x_26) + 0.111544728979187*std::exp(0.741679847240448*x_26) - 0.00575478521672752*std::exp(0.549279868602753*x_27) + 0.0182981958893923*std::exp(0.836879849433899*x_27) + 0.0513791706812405*std::exp(0.928959846496582*x_27) + 0.444848332105068*std::exp(0.357039839029312*x_28) + 0.00545829367229673*std::exp(1.05983984470367*x_28) + 0.292751355983933*std::exp(0.310319840908051*x_29) + 0.10425077604771*std::exp(0.593839824199677*x_29) + 0.00038023890425599*std::exp(1.26631987094879*x_29) + 0.0038855842136335*std::exp(1.27407991886139*x_29) - 0.219621561037287*std::exp(0.871119856834412*x_3) + 0.14411961737745*std::exp(0.819999873638153*x_30) + 0.0216828987472995*std::exp(0.877279877662659*x_30) - 0.0348662969945022*std::exp(0.682399809360504*x_32) + 2.10775429501472*std::exp(0.28167986869812*x_33) - 0.242706467828738*std::exp(0.442239850759506*x_33) - 0.231648755805812*std::exp(0.339919835329056*x_36) - 0.220107266835641*std::exp(0.329519838094711*x_38) - 0.323053388071639*std::exp(0.336719840764999*x_4) + 0.100390955441375*std::exp(0.454319834709167*x_4) - 0.238437902624793*std::exp(0.461599856615067*x_4) - 0.0231142206733168*std::exp(1.0719997882843*x_4) - 0.0190111173029069*std::exp(0.618799805641174*x_41) - 0.686808197415943*std::exp(0.789759874343872*x_41) + 0.211217468206717*std::exp(0.790239870548248*x_41) - 0.0356286786879208*std::exp(0.829279899597168*x_41) - 0.0111303834877324*std::exp(0.542079865932465*x_42) - 0.0213475685372757*std::exp(0.756079852581024*x_46) - 0.0454300656279489*std::exp(0.769599854946136*x_46) - 0.0414123190990429*std::exp(0.50087982416153*x_47) - 0.161589373194532*std::exp(0.568239867687225*x_47) - 0.0394765743326304*std::exp(0.499679833650589*x_48) - 0.0487089390807208*std::exp(0.530479848384857*x_48) - 0.00470417224419523*std::exp(0.66815984249115*x_49) - 0.0110673027659574*std::exp(0.675759792327881*x_49) - 0.0311448669951562*std::exp(0.769919812679291*x_49) + 1.34940783053193*std::exp(0.279839843511581*x_50) - 0.0931211034129765*std::exp(0.558319866657257*x_50) - 64.2779149944467*std::exp(0.491999834775925*x_51) + 4.39694630401994*std::exp(0.493039846420288*x_51) - 2.86170654244467*std::exp(0.495119869709015*x_51) + 4.20900866535614*std::exp(0.49551984667778*x_51) + 0.520576509906332*std::exp(0.501519858837128*x_51) - 0.178638558935304*std::exp(0.348879843950272*x_54) + 0.786057114974794*std::exp(0.47735983133316*x_54) - 0.928252780996512*std::exp(0.492399841547012*x_54) + 0.0746106507842791*std::exp(0.494639873504639*x_54) - 0.532379374088063*std::exp(0.498079836368561*x_55) + 9.51836450898024*std::exp(0.650959849357605*x_55) - 64.320183280846*std::exp(0.653679847717285*x_55) - 3.54185468873256*std::exp(0.653839826583862*x_55) - 0.235189685461527*std::exp(0.344719856977463*x_56) - 0.92884628091624*std::exp(0.403919875621796*x_56) + 0.95603821639152*std::exp(0.554959833621979*x_56) + 2.04812239253505*std::exp(0.215359851717949*x_57) + 0.336140456609658*std::exp(0.423999845981598*x_57) - 0.0821450619169602*std::exp(0.600159823894501*x_57) - 2.18763443556978*std::exp(0.636399865150452*x_57) + 0.152662691471084*std::exp(0.640799820423126*x_57) + 0.617641420034601*std::exp(0.514319837093353*x_58) - 0.0950037822648684*std::exp(0.575679838657379*x_58) - 0.437561387233206*std::exp(0.581039845943451*x_58) - 0.00313806207519561*std::exp(0.943519830703735*x_59) - 0.0573577378488316*std::exp(0.851839900016785*x_60) - 0.014310542124658*std::exp(0.903199791908264*x_60) - 0.00822513556893911*std::exp(0.91351979970932*x_60) + 0.00261202994315096*std::exp(0.918799817562103*x_60) + 0.110931549341647*std::exp(0.99999988079071*x_66) + 0.0526240833736051*std::exp(1.11287987232208*x_66) - 0.179928198203446*std::exp(0.403839856386185*x_8) + 0.106805430417462*std::log(7.69087982177734 - 0.987919807434082*x_21) - 0.378391158037161*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.188468264916253*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 0.665126614783523*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 1.05164375801575*std::sin(0.553839862346649*x_10 - 1.13599991798401) + 2.26138130492866*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 3.94062048051281*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 5.42050613239793*std::sin(0.307359933853149*x_103 + 1.91287982463837) - 3.08987586269499*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 6.3966610480084*std::sin(0.270639955997467*x_107 - 7.45351982116699) - 1.48294057765252*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 8.27143265658698*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 0.646814014790136*std::sin(0.273759961128235*x_112 - 7.4302396774292) + 1.3902279334978*std::sin(0.286159932613373*x_112 - 7.44384002685547) + 1.69810466061297*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 1.7809176487852*std::sin(0.288799941539764*x_113 - 7.43088006973267) - 3.53711507259001*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 1.86273250788524*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 4.12201940826769*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 3.30850504612711*std::sin(0.246159970760345*x_117 + 5.15112018585205) - 2.22339255956366*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 2.46467133369767*std::sin(0.262239962816238*x_117 - 7.46135997772217) + 1.56243484699753*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 0.379631642533545*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 0.355597896996019*std::sin(0.263999968767166*x_120 - 1.20231986045837) - 0.878444957386868*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 2.73290804749725*std::sin(0.276079952716827*x_120 + 5.14111995697021) + 0.611495625373268*std::sin(0.438399881124496*x_15 - 4.26543998718262) + 0.782565121923318*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 0.208370120194007*std::sin(0.332959830760956*x_18 - 4.39271974563599) - 1.64895699552108*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 3.47686318991637*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 0.311368436694448*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.0907634343499208*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 1.80951129336224*std::sin(0.181600019335747*x_23 + 4.97295999526978) + 1.07680871837715*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 0.245917627647062*std::sin(0.253439962863922*x_24 - 4.38711977005005) - 1.34634614497145*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.318919918550389*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 0.286629718949366*std::sin(0.41967985033989*x_3 - 4.21216011047363) + 0.788827625571046*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.101102385245468*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 0.407309826160697*std::sin(0.383039832115173*x_31 + 5.17232036590576) - 1.78120397646426*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.629670792862928*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 3.02317892703705*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.314416096685312*std::sin(0.390079826116562*x_32 + 5.18871974945068) + 1.02928768598899*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 5.20869173138032*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 6.67805456291524*std::sin(0.0688000917434692*x_4 - 7.74391984939575) + 3.0086663056151*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.190074941654569*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.615418940875603*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 1.10930752384709*std::sin(0.206719994544983*x_5 + 8.2021598815918) - 0.402954602329822*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 9.011854040395*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 2.37451298723539*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.34043404498783*std::sin(0.254079967737198*x_53 + 1.98175978660583) - 3.23023600493002*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 2.72180676131306*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.856902559261919*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.128694743097097*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.569254609121863*std::sin(0.307599931955338*x_7 - 1.15295994281769) + 1.17445991233398*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 0.303208741545693*std::sin(0.377679854631424*x_8 + 2.00887989997864) + 0.965012594845606*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 0.906583356634917*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.719139454287802*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 0.737176535865267*std::sin(0.36847984790802*x_91 + 2.00039982795715) - 0.428349719856708*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 2.04774055044525*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 0.850209140609362*std::sin(0.298399955034256*x_92 + 1.9864798784256) - 3.23765902487324*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 1.74674379638758*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.160776791042875*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 1.39503975747399*std::sin(0.321039855480194*x_94 + 8.23744010925293) - 1.10413840611585*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 2.41705994537675*std::sin(0.343759834766388*x_94 - 4.37103986740112) - 2.31943163856203*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.948722758234308*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 2.60790087002391*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.441555574938796*std::sin(0.304719924926758*x_95 + 1.95855987071991) + 1.87595207302961*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 0.688724556386794*std::sin(0.273839950561523*x_97 + 1.97855985164642) - 2.22368885061386*std::sin(0.274719953536987*x_97 + 1.97439980506897) + 2.60970292181583*std::sin(0.25655996799469*x_98 - 7.43255996704102) + 32334.4908352299);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00373463853871915*x_1 + 0.0554855584970392*x_10 + 1.25818437813097*x_100 - 0.398798537744378*x_101 + 0.679237769559447*x_102 - 0.720972967618414*x_103 - 244.859176376054*x_104 - 0.0945858561802363*x_105 + 2.68644643318753*x_106 + 0.708433866287565*x_107 - 2.41982407454582*x_108 - 0.578562390155251*x_109 - 2.0482053124557*x_110 - 1.29163901687076*x_111 + 0.640699420593769*x_112 + 0.240738365133912*x_113 - 2.1973781245459*x_114 + 1.387379599751*x_115 + 1.63060094022244*x_116 - 0.0127190441867575*x_117 + 1.54358143513889*x_118 + 0.425777101369881*x_119 + 0.0933613283649095*x_12 + 0.00230956825659399*x_120 + 1.1181403934756*x_13 + 0.763358316236986*x_14 + 0.110956074397407*x_15 + 1.08707441206401*x_16 + 2.13430559330101*x_17 - 0.0378487778601242*x_18 + 0.00777018063710168*x_19 + 0.408975068254035*x_2 + 0.216094444254886*x_20 + 0.373145292290112*x_21 + 0.0444330413923286*x_22 + 0.0110972926362498*x_24 + 0.320900939408014*x_25 - 0.0690002620489452*x_26 - 0.822497342047682*x_27 + 0.138186300719411*x_28 - 0.295547751393921*x_29 - 0.244196185867426*x_3 + 0.327344651466135*x_30 + 0.0847710659796362*x_31 + 0.0103029030461094*x_32 - 0.936520995944212*x_33 + 0.821693690519098*x_34 - 2.57902902487223*x_35 + 2.47204352257129*x_36 + 26.2019218038408*x_37 - 43.3224540641882*x_38 + 4.96195033657882*x_39 - 459.763166881897*x_40 - 0.219878919243228*x_41 + 1.40199003599935*x_42 + 0.493003723287305*x_43 + 0.838235734044139*x_44 - 1.48403666996724*x_45 + 0.468208472147178*x_46 + 5.38635809621949*x_47 + 1.2709899978831*x_48 - 0.426142950044294*x_49 - 0.941403646874017*x_5 - 1.49885783203074*x_50 + 0.642559482726671*x_52 - 1.16142017001102*x_53 + 0.0223498240975802*x_55 - 0.0240000910470098*x_56 + 0.122714549432943*x_58 - 0.628682680768116*x_59 - 1.72311404355735*x_6 + 1.1791166054516*x_60 - 1.04066415901099*x_61 - 1.30482235599274*x_62 - 1.17462379096287*x_63 + 0.119538502237443*x_64 - 2.07513624376184*x_65 - 0.137199285969292*x_66 + 0.195359078937319*x_67 + 0.0881456266186053*x_68 - 1.25612827528582*x_69 - 0.840713508532435*x_7 - 0.807868877167013*x_70 - 1.80333253415049*x_71 - 1.07405398264334*x_72 - 0.710861101845085*x_73 + 0.524277403757887*x_74 + 0.600844402162582*x_75 + 0.245703681368027*x_76 + 0.424330101377935*x_77 + 0.0763916325832177*x_78 - 1.28388269712997*x_79 - 0.0362489038750105*x_8 - 0.766620154580106*x_80 - 0.590485166102695*x_81 + 0.780685647619738*x_82 + 1.90744678082222*x_83 - 1.12295244061949*x_84 - 2.12459021758645*x_85 - 57.7124266583156*x_86 - 0.157709601278456*x_87 + 32.0640750804166*x_88 - 1.03362307223006*x_89 - 0.208409067278954*x_9 - 1.58785205874356*x_90 + 1.39006221034648*x_91 + 0.0127026167293843*x_92 + 2.72425845601568*x_93 - 0.128417322640419*x_94 + 0.399666308416832*x_95 + 0.323851994078165*x_96 + 1.95729265040371*x_97 + 2.775611822462*x_98 + 14.8002901430754*x_99 - 0.00612527351485865*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) - 0.00184951651767697*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 0.000292124362447563*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.0248643697462154*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 0.000429530674185864*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 1.31977422103391*std::exp(0.619999825954437*x_1) - 0.0190441421707068*std::exp(1.67199981212616*x_1) - 0.00581432815987336*std::exp(0.867839872837067*x_10) - 0.0501802461982538*std::exp(0.883439898490906*x_11) + 0.0417929149329025*std::exp(0.935519814491272*x_11) - 0.0138421791009666*std::exp(0.981679856777191*x_11) + 0.00707280491927595*std::exp(0.982479810714722*x_11) - 0.0328117039661142*std::exp(1.03247976303101*x_11) + 0.695037725541993*std::exp(0.478879868984222*x_12) + 0.0124962863968784*std::exp(0.848559856414795*x_12) - 0.0020437718517908*std::exp(1.19295990467072*x_12) + 0.318764870641708*std::exp(0.269119828939438*x_13) + 0.00323969858894651*std::exp(0.856879889965057*x_14) + 0.00351769842637074*std::exp(0.778239846229553*x_15) + 0.00628533777117593*std::exp(0.980319857597351*x_15) - 0.0350373201192965*std::exp(0.480959862470627*x_16) - 0.0636933815993973*std::exp(0.682639837265015*x_16) - 0.133493671103114*std::exp(0.704719841480255*x_16) - 0.0617241103013333*std::exp(0.726879835128784*x_17) + 1.49981059053081*std::exp(0.736799836158752*x_19) + 0.316118561521513*std::exp(0.765119850635529*x_19) - 1.10809995145596*std::exp(0.769039869308472*x_19) - 0.201203403774556*std::exp(0.808799862861633*x_19) + 0.110618329524142*std::exp(0.504639863967896*x_2) - 0.0506117610648835*std::exp(0.695039868354797*x_20) + 0.0795331895609329*std::exp(0.969119846820831*x_20) + 0.000278792750083236*std::exp(1.11439990997314*x_20) - 0.53768025218034*std::exp(0.497599840164185*x_22) + 0.0125775451629758*std::exp(0.944959819316864*x_22) - 0.0235018746220249*std::exp(0.613439857959747*x_23) + 0.0326168035371969*std::exp(0.662079870700836*x_23) - 0.127030486910742*std::exp(0.772399842739105*x_23) + 2.70841494838693*std::exp(0.61983984708786*x_24) - 0.354880519861771*std::exp(0.659039855003357*x_24) - 0.0365144377405493*std::exp(0.740079820156097*x_24) + 0.234830743416664*std::exp(0.442479848861694*x_25) + 0.137394428269225*std::exp(0.453039854764938*x_25) + 0.0179795878703615*std::exp(0.923359870910645*x_25) - 0.00419794358304748*std::exp(1.03015983104706*x_25) - 0.251646833734434*std::exp(0.515279829502106*x_26) + 0.350182911948984*std::exp(0.741679847240448*x_26) - 0.00762992945896954*std::exp(0.549279868602753*x_27) + 0.0574452560744126*std::exp(0.836879849433899*x_27) + 0.0406566820825671*std::exp(0.928959846496582*x_27) - 2.74480927047197*std::exp(0.357039839029312*x_28) + 0.0171357372950741*std::exp(1.05983984470367*x_28) - 1.80633842560558*std::exp(0.310319840908051*x_29) + 0.082494337733252*std::exp(0.593839824199677*x_29) + 0.00119371993591467*std::exp(1.26631987094879*x_29) + 0.00515166636814432*std::exp(1.27407991886139*x_29) - 0.173788013064023*std::exp(0.871119856834412*x_3) + 0.114042819062386*std::exp(0.819999873638153*x_30) - 0.133788118774458*std::exp(0.877279877662659*x_30) + 0.215132503171744*std::exp(0.682399809360504*x_32) - 1.47183860764778*std::exp(0.28167986869812*x_33) - 0.192055254513842*std::exp(0.442239850759506*x_33) + 1.42932232525245*std::exp(0.339919835329056*x_36) - 0.174172355317265*std::exp(0.329519838094711*x_38) + 0.225587228084352*std::exp(0.336719840764999*x_4) - 0.619433648010038*std::exp(0.454319834709167*x_4) - 0.74855064711967*std::exp(0.461599856615067*x_4) - 0.0182904377209899*std::exp(1.0719997882843*x_4) - 0.0252057163724801*std::exp(0.618799805641174*x_41) + 0.479596138599591*std::exp(0.789759874343872*x_41) + 0.167137798086349*std::exp(0.790239870548248*x_41) - 0.111852478965266*std::exp(0.829279899597168*x_41) - 0.0147571173665748*std::exp(0.542079865932465*x_42) - 0.0283034789181158*std::exp(0.756079852581024*x_46) - 0.142622899506054*std::exp(0.769599854946136*x_46) + 0.255522858401881*std::exp(0.50087982416153*x_47) - 0.214241795716311*std::exp(0.568239867687225*x_47) - 0.0523396557988342*std::exp(0.499679833650589*x_48) - 0.152916576886526*std::exp(0.530479848384857*x_48) + 0.0290257479996897*std::exp(0.66815984249115*x_49) - 0.014673482367311*std::exp(0.675759792327881*x_49) + 0.0217483687647786*std::exp(0.769919812679291*x_49) - 0.942287508148696*std::exp(0.279839843511581*x_50) - 0.123463765097119*std::exp(0.558319866657257*x_50) - 50.8635448997946*std::exp(0.491999834775925*x_51) - 3.07037463584699*std::exp(0.493039846420288*x_51) - 3.79416750214369*std::exp(0.495119869709015*x_51) + 13.2137387785302*std::exp(0.49551984667778*x_51) - 3.2120683101569*std::exp(0.501519858837128*x_51) - 0.23684630303256*std::exp(0.348879843950272*x_54) + 2.46774340660644*std::exp(0.47735983133316*x_54) - 0.734532646378689*std::exp(0.492399841547012*x_54) - 0.460363659181409*std::exp(0.494639873504639*x_54) - 0.421275366507955*std::exp(0.498079836368561*x_55) + 29.8819014690376*std::exp(0.650959849357605*x_55) + 44.9145942805773*std::exp(0.653679847717285*x_55) - 4.69593571457691*std::exp(0.653839826583862*x_55) + 1.45117061790334*std::exp(0.344719856977463*x_56) - 0.735002286842567*std::exp(0.403919875621796*x_56) - 0.667598666789543*std::exp(0.554959833621979*x_56) + 6.42986423481894*std::exp(0.215359851717949*x_57) - 0.234725889445758*std::exp(0.423999845981598*x_57) - 0.10891128065167*std::exp(0.600159823894501*x_57) - 1.73108978951097*std::exp(0.636399865150452*x_57) - 0.941961429465502*std::exp(0.640799820423126*x_57) + 1.93902009523354*std::exp(0.514319837093353*x_58) - 0.125959897670768*std::exp(0.575679838657379*x_58) - 0.346245258077762*std::exp(0.581039845943451*x_58) - 0.00985161491202078*std::exp(0.943519830703735*x_59) - 0.0453875623482303*std::exp(0.851839900016785*x_60) + 0.00999300935847195*std::exp(0.903199791908264*x_60) - 0.0258219456093143*std::exp(0.91351979970932*x_60) + 0.00346313606162545*std::exp(0.918799817562103*x_60) + 0.348257899149306*std::exp(0.99999988079071*x_66) + 0.0416417898389385*std::exp(1.11287987232208*x_66) - 0.564865601138119*std::exp(0.403839856386185*x_8) - 0.659012329346795*std::log(7.69087982177734 - 0.987919807434082*x_21) + 0.264229429639358*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.249878928997305*std::sin(0.268559962511063*x_10 + 1.97279977798462) + 4.10397334672765*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 3.30152466087075*std::sin(0.553839862346649*x_10 - 1.13599991798401) - 1.57911589556679*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 12.3711623792574*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 4.28928282861468*std::sin(0.307359933853149*x_103 + 1.91287982463837) + 2.15765120171263*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 5.0617207551342*std::sin(0.270639955997467*x_107 - 7.45351982116699) + 1.03553303162466*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 6.54524009296641*std::sin(0.245599970221519*x_109 - 7.44384002685547) + 3.99098069147718*std::sin(0.273759961128235*x_112 - 7.4302396774292) - 0.970792065655909*std::sin(0.286159932613373*x_112 - 7.44384002685547) - 1.18578147615605*std::sin(0.287119954824448*x_113 - 7.42575979232788) - 10.9886424642775*std::sin(0.288799941539764*x_113 - 7.43088006973267) + 2.46995702290551*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 1.47399271677237*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 12.9406451807037*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 2.61804221526822*std::sin(0.246159970760345*x_117 + 5.15112018585205) + 1.55258846672152*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 7.73757570196329*std::sin(0.262239962816238*x_117 - 7.46135997772217) - 1.09104364544975*std::sin(0.244319975376129*x_12 + 1.96343982219696) + 2.34240835940565*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 1.11636209252197*std::sin(0.263999968767166*x_120 - 1.20231986045837) + 0.61341552287833*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 2.16256845283323*std::sin(0.276079952716827*x_120 + 5.14111995697021) - 0.427005591667321*std::sin(0.438399881124496*x_15 - 4.26543998718262) - 0.546462916559867*std::sin(0.319279909133911*x_16 + 1.9761598110199) + 1.28568816902473*std::sin(0.332959830760956*x_18 - 4.39271974563599) + 1.15146180657735*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 2.75126514271711*std::sin(0.0904800817370415*x_21 - 4.52415990829468) + 1.92120979194641*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.120337871086962*std::sin(0.530959844589233*x_22 + 2.06007981300354) - 11.1650713616058*std::sin(0.181600019335747*x_23 + 4.97295999526978) - 0.751932352128426*std::sin(0.339119851589203*x_23 + 1.99055981636047) + 1.51736431368411*std::sin(0.253439962863922*x_24 - 4.38711977005005) + 0.940149542151875*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.422837063410597*std::sin(0.247839972376823*x_3 - 7.5490403175354) + 1.76856661694569*std::sin(0.41967985033989*x_3 - 4.21216011047363) - 0.550836004386594*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.134045674774139*std::sin(0.687199831008911*x_30 - 4.14775991439819) + 2.51318866704473*std::sin(0.383039832115173*x_31 + 5.17232036590576) + 1.24380948332383*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.498262718192396*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 9.49095138516298*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.416865712294587*std::sin(0.390079826116562*x_32 + 5.18871974945068) - 0.718748555369194*std::sin(0.465439856052399*x_32 - 1.01639986038208) + 32.1387410483684*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 8.85403769546201*std::sin(0.0688000917434692*x_4 - 7.74391984939575) - 2.10094280752131*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.252009126687582*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.815947586183725*std::sin(0.246719971299171*x_45 - 7.42984008789063) + 6.84466447440929*std::sin(0.206719994544983*x_5 + 8.2021598815918) + 0.281382010342077*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 7.13114049597949*std::sin(0.333759844303131*x_50 - 7.44712018966675) - 14.6512525502297*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.451361371600569*std::sin(0.254079967737198*x_53 + 1.98175978660583) + 2.25566427506045*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 8.54482525675315*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.678072737759665*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.404023572451165*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.754741028243444*std::sin(0.307599931955338*x_7 - 1.15295994281769) - 0.820121892858345*std::sin(0.33943983912468*x_8 + 8.25103950500488) + 1.87086272920135*std::sin(0.377679854631424*x_8 + 2.00887989997864) - 0.67386544879521*std::sin(0.292879939079285*x_9 + 1.96663987636566) - 5.59381304178832*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.953464482293569*std::sin(0.362239837646484*x_91 + 2.00935983657837) - 4.54853675643205*std::sin(0.36847984790802*x_91 + 2.00039982795715) + 0.299115346011339*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 6.4286654818511*std::sin(0.298239946365356*x_92 + 1.99775981903076) - 5.24597208208346*std::sin(0.298399955034256*x_92 + 1.9864798784256) + 2.26084774799352*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 1.38221007205466*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.213164441086509*std::sin(0.311359941959381*x_94 - 7.43752002716064) - 8.60769341512821*std::sin(0.321039855480194*x_94 + 8.23744010925293) + 0.77101659247082*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 7.58810476992791*std::sin(0.343759834766388*x_94 - 4.37103986740112) + 1.61965227233068*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.750730676548497*std::sin(0.283039927482605*x_95 - 7.42447996139526) + 16.0913056606063*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.585432429207771*std::sin(0.304719924926758*x_95 + 1.95855987071991) - 1.3099717997076*std::sin(0.300079941749573*x_96 - 7.45623970031738) + 4.24957768915647*std::sin(0.273839950561523*x_97 + 1.97855985164642) + 1.552795365888*std::sin(0.274719953536987*x_97 + 1.97439980506897) - 1.8223478533075*std::sin(0.25655996799469*x_98 - 7.43255996704102) - 17479.0432495172);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000991033235492946*x_1 + 0.0153717329546493*x_10 - 0.0796176955135688*x_100 - 0.0411963649942776*x_101 + 0.425642012805852*x_102 - 0.426937848589115*x_103 - 67.1188588281982*x_104 - 0.266101922148524*x_105 + 0.428695527794204*x_106 - 0.0881427875425438*x_107 - 0.214243639093678*x_108 + 0.554533891368161*x_109 - 1.14528977037366*x_110 - 1.35305818624216*x_111 + 0.233923804433256*x_112 + 0.0949162039532394*x_113 + 0.049502899589633*x_114 - 0.0827468772765508*x_115 - 0.398265214883011*x_116 + 0.00219783092842724*x_117 + 0.637665761577299*x_118 + 0.267029354516867*x_119 - 0.024774600904517*x_12 - 0.000612872940230822*x_120 + 0.350987237643009*x_13 + 0.14776236254166*x_14 + 0.10098846372836*x_15 + 0.37493905714588*x_16 + 0.727723679687063*x_17 - 0.0657968365953521*x_18 - 0.00139039004388839*x_19 + 0.152128923313254*x_2 + 0.0745323836935455*x_20 + 0.12654681814797*x_21 + 0.0123097408613486*x_22 - 0.00294480595979887*x_24 + 0.110680827663326*x_25 - 0.198633828320413*x_26 + 0.0543658941948545*x_27 + 0.102731654234303*x_28 - 0.0818786227053453*x_29 - 0.0842248577205605*x_3 + 0.110472638772913*x_30 + 0.0166667804273969*x_31 + 0.00689252142563677*x_32 - 0.391115489176025*x_33 + 0.458359466939514*x_34 - 1.51731797032186*x_35 + 0.362238271223231*x_36 + 0.985254395693264*x_37 + 25.966489712825*x_38 - 0.266481448770495*x_39 + 73.0742209758028*x_40 + 0.039344961778232*x_41 - 0.239098519556754*x_42 - 0.236049138849847*x_43 - 0.561436857764041*x_44 - 1.36187161484514*x_45 + 0.00794106017746036*x_46 + 1.9957690716303*x_47 - 0.168023613895387*x_48 - 0.290998457958313*x_49 - 0.302562446581107*x_5 - 0.427104054255998*x_50 + 0.258853071898259*x_52 - 0.415142821367714*x_53 - 0.00399926003773364*x_55 + 0.00636872555023781*x_56 + 0.0584748027650945*x_58 - 0.0221629526885534*x_59 - 0.34570061816815*x_6 - 0.21099020285002*x_60 - 0.144668066342953*x_61 - 0.411960512538515*x_62 - 0.280147197226264*x_63 + 0.0975173550859376*x_64 + 0.0728233576531165*x_65 + 0.0380814379193282*x_66 + 0.221649490330078*x_67 + 0.0750427105472738*x_68 - 0.215300196472173*x_69 - 0.0463684099463098*x_7 - 0.245321976426556*x_70 - 0.403880357233853*x_71 - 0.390751095309072*x_72 - 0.446984281021248*x_73 - 0.170998283417697*x_74 + 0.338583558854123*x_75 + 0.41419365405658*x_76 + 0.284300135439075*x_77 - 0.018700317222799*x_78 - 0.130278914236659*x_79 + 0.038127258094529*x_8 - 0.28331011394362*x_80 - 0.263236511726597*x_81 + 0.157481701563753*x_82 + 0.136388217238894*x_83 + 0.127535912146131*x_84 + 0.340945161457103*x_85 + 74.1897440352534*x_86 + 0.582635033226432*x_87 + 9.96537815664801*x_88 - 0.00385664763258071*x_89 - 0.007075654967789*x_9 + 0.381190814193118*x_90 + 0.495306255948077*x_91 - 0.00337079886742294*x_92 - 0.733165084721746*x_93 - 0.0859096842667303*x_94 + 0.137847517325206*x_95 + 0.134907429049546*x_96 + 0.627149256180766*x_97 + 0.45741755793041*x_98 + 1.17993652959076*x_99 + 0.00109605165039373*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 0.000330951038629186*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) + 7.7518868046066e-5*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.0166339720410608*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) + 0.000113981358401522*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 0.455198739468403*std::exp(0.619999825954437*x_1) - 0.0127403079847516*std::exp(1.67199981212616*x_1) - 0.00388971741636874*std::exp(0.867839872837067*x_10) + 0.00897921399417364*std::exp(0.883439898490906*x_11) + 0.0279589704305353*std::exp(0.935519814491272*x_11) - 0.00383484074800905*std::exp(0.981679856777191*x_11) - 0.00187685760495698*std::exp(0.982479810714722*x_11) - 0.0113169707720802*std::exp(1.03247976303101*x_11) + 0.239723046190317*std::exp(0.478879868984222*x_12) + 0.0083598691888984*std::exp(0.848559856414795*x_12) + 0.00036571093613201*std::exp(1.19295990467072*x_12) + 0.213249963704935*std::exp(0.269119828939438*x_13) + 0.00216732039862795*std::exp(0.856879889965057*x_14) - 0.000629454204201373*std::exp(0.778239846229553*x_15) - 0.00166789330826935*std::exp(0.980319857597351*x_15) - 0.02343955665101*std::exp(0.480959862470627*x_16) + 0.0169018386629691*std::exp(0.682639837265015*x_16) + 0.0238872530630272*std::exp(0.704719841480255*x_16) - 0.0412927066115564*std::exp(0.726879835128784*x_17) + 0.517294457923382*std::exp(0.736799836158752*x_19) - 0.0838860300872617*std::exp(0.765119850635529*x_19) - 0.741305884659503*std::exp(0.769039869308472*x_19) - 0.055741441127496*std::exp(0.808799862861633*x_19) + 0.0306457295807023*std::exp(0.504639863967896*x_2) + 0.00905642892679528*std::exp(0.695039868354797*x_20) + 0.0532067719791817*std::exp(0.969119846820831*x_20) - 7.39811572880423e-5*std::exp(1.11439990997314*x_20) - 0.18544942697684*std::exp(0.497599840164185*x_22) + 0.00841423035136307*std::exp(0.944959819316864*x_22) + 0.00623651756531249*std::exp(0.613439857959747*x_23) + 0.021820259417156*std::exp(0.662079870700836*x_23) - 0.0438136437234908*std::exp(0.772399842739105*x_23) + 0.934149986273627*std::exp(0.61983984708786*x_24) - 0.237410909890299*std::exp(0.659039855003357*x_24) - 0.0101159689321113*std::exp(0.740079820156097*x_24) + 0.157099015991301*std::exp(0.442479848861694*x_25) - 0.0245852514984162*std::exp(0.453039854764938*x_25) - 0.00477110942739458*std::exp(0.923359870910645*x_25) - 0.00116299933649822*std::exp(1.03015983104706*x_25) + 0.0450294875423777*std::exp(0.515279829502106*x_26) + 0.120780371037765*std::exp(0.741679847240448*x_26) + 0.00202469759788289*std::exp(0.549279868602753*x_27) + 0.0198132436114923*std::exp(0.836879849433899*x_27) + 0.0271988439661397*std::exp(0.928959846496582*x_27) + 0.491154023345885*std::exp(0.357039839029312*x_28) + 0.00591022759216256*std::exp(1.05983984470367*x_28) + 0.323224784616056*std::exp(0.310319840908051*x_29) + 0.0551877454126744*std::exp(0.593839824199677*x_29) + 0.000411721794111858*std::exp(1.26631987094879*x_29) - 0.00136705936493476*std::exp(1.27407991886139*x_29) - 0.116262144582147*std::exp(0.871119856834412*x_3) + 0.0762933097894519*std::exp(0.819999873638153*x_30) + 0.0239399412989645*std::exp(0.877279877662659*x_30) - 0.038495641799951*std::exp(0.682399809360504*x_32) - 0.407758534688117*std::exp(0.28167986869812*x_33) - 0.12848271508705*std::exp(0.442239850759506*x_33) - 0.255761818592636*std::exp(0.339919835329056*x_36) - 0.116519265046485*std::exp(0.329519838094711*x_38) + 0.0624967418914467*std::exp(0.336719840764999*x_4) + 0.110840972335989*std::exp(0.454319834709167*x_4) - 0.258180001978064*std::exp(0.461599856615067*x_4) - 0.0122360885385409*std::exp(1.0719997882843*x_4) + 0.00668865337048218*std::exp(0.618799805641174*x_41) + 0.132867433767063*std::exp(0.789759874343872*x_41) + 0.111813228678195*std::exp(0.790239870548248*x_41) - 0.0385786497568642*std::exp(0.829279899597168*x_41) + 0.00391598641172957*std::exp(0.542079865932465*x_42) + 0.00751068356338087*std::exp(0.756079852581024*x_46) - 0.0491915685575561*std::exp(0.769599854946136*x_46) - 0.0457230603638063*std::exp(0.50087982416153*x_47) + 0.0568517509218905*std::exp(0.568239867687225*x_47) + 0.0138889849427558*std::exp(0.499679833650589*x_48) - 0.0527419250453608*std::exp(0.530479848384857*x_48) - 0.00519384463759847*std::exp(0.66815984249115*x_49) + 0.00389379281439438*std::exp(0.675759792327881*x_49) + 0.00602517350292602*std::exp(0.769919812679291*x_49) - 0.261051566103216*std::exp(0.279839843511581*x_50) + 0.0327626605150128*std::exp(0.558319866657257*x_50) - 34.0271156038935*std::exp(0.491999834775925*x_51) - 0.850617354342519*std::exp(0.493039846420288*x_51) + 1.00682999349684*std::exp(0.495119869709015*x_51) + 4.55750471541994*std::exp(0.49551984667778*x_51) + 0.57476499032813*std::exp(0.501519858837128*x_51) + 0.0628501408035603*std::exp(0.348879843950272*x_54) + 0.851140801294571*std::exp(0.47735983133316*x_54) - 0.491393734400577*std::exp(0.492399841547012*x_54) + 0.082377112989823*std::exp(0.494639873504639*x_54) - 0.281828284392673*std::exp(0.498079836368561*x_55) + 10.3064627758595*std::exp(0.650959849357605*x_55) + 12.4431503935262*std::exp(0.653679847717285*x_55) + 1.24612551298743*std::exp(0.653839826583862*x_55) - 0.259671334985693*std::exp(0.344719856977463*x_56) - 0.491707918368448*std::exp(0.403919875621796*x_56) - 0.184951701032555*std::exp(0.554959833621979*x_56) + 2.21770212510262*std::exp(0.215359851717949*x_57) - 0.0650285189126333*std::exp(0.423999845981598*x_57) + 0.0289009760186652*std::exp(0.600159823894501*x_57) - 1.15807878716387*std::exp(0.636399865150452*x_57) + 0.168553841206996*std::exp(0.640799820423126*x_57) + 0.668780681640194*std::exp(0.514319837093353*x_58) + 0.0334250406396316*std::exp(0.575679838657379*x_58) - 0.231634020930372*std::exp(0.581039845943451*x_58) - 0.00339788625827749*std::exp(0.943519830703735*x_59) - 0.0303637474353148*std::exp(0.851839900016785*x_60) + 0.00276846580322227*std::exp(0.903199791908264*x_60) - 0.008906157511376*std::exp(0.91351979970932*x_60) - 0.000918986643693247*std::exp(0.918799817562103*x_60) + 0.12011642156375*std::exp(0.99999988079071*x_66) + 0.0278578695133048*std::exp(1.11287987232208*x_66) - 0.194825831198386*std::exp(0.403839856386185*x_8) + 0.117923150608409*std::log(7.69087982177734 - 0.987919807434082*x_21) + 0.073202187041016*std::sin(0.536399841308594*x_1 - 4.00568008422852) - 0.0663085117658113*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 0.73436177975418*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 1.13871739574886*std::sin(0.553839862346649*x_10 - 1.13599991798401) - 0.437478661269847*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 4.26689461806986*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 2.86947995769081*std::sin(0.307359933853149*x_103 + 1.91287982463837) + 0.597756226672469*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 3.38623188039483*std::sin(0.270639955997467*x_107 - 7.45351982116699) + 0.286884329166517*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 4.37868893600269*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 0.714142962428027*std::sin(0.273759961128235*x_112 - 7.4302396774292) - 0.268948475819186*std::sin(0.286159932613373*x_112 - 7.44384002685547) - 0.328509195685815*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 1.96629908514966*std::sin(0.288799941539764*x_113 - 7.43088006973267) + 0.684277509211519*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 0.986083857735859*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 4.46331295177862*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 1.7514395681683*std::sin(0.246159970760345*x_117 + 5.15112018585205) + 0.430129495771141*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 2.66874034205321*std::sin(0.262239962816238*x_117 - 7.46135997772217) - 0.302263003455494*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 0.419148719154281*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 0.385040569218131*std::sin(0.263999968767166*x_120 - 1.20231986045837) + 0.169940789339363*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 1.44673295758013*std::sin(0.276079952716827*x_120 + 5.14111995697021) - 0.11829773553784*std::sin(0.438399881124496*x_15 - 4.26543998718262) - 0.151392222598342*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 0.230060035055229*std::sin(0.332959830760956*x_18 - 4.39271974563599) + 0.319001265872264*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 1.84056414574785*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 0.343779777034832*std::sin(0.383919835090637*x_22 + 2.00487995147705) + 0.031933165284731*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 1.99786913400131*std::sin(0.181600019335747*x_23 + 4.97295999526978) - 0.208315526237269*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 0.271515983119394*std::sin(0.253439962863922*x_24 - 4.38711977005005) + 0.260459263470613*std::sin(0.334079831838608*x_28 - 1.15431988239288) + 0.112205124724563*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 0.316465926726754*std::sin(0.41967985033989*x_3 - 4.21216011047363) - 0.15260374393976*std::sin(0.420319855213165*x_3 - 4.20503997802734) - 0.0355707031344488*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 0.449708013786348*std::sin(0.383039832115173*x_31 + 5.17232036590576) + 0.34458528925386*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.333331920660358*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 3.27349105477875*std::sin(0.345279842615128*x_32 + 1.98999989032745) + 0.110620551718257*std::sin(0.390079826116562*x_32 + 5.18871974945068) - 0.199122278912715*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 5.75088117815322*std::sin(0.151280030608177*x_33 + 4.98831987380981) + 2.34953009067368*std::sin(0.0688000917434692*x_4 - 7.74391984939575) - 0.582045719012309*std::sin(0.260479986667633*x_42 - 7.43607997894287) - 0.0668737864737512*std::sin(0.302719920873642*x_43 - 4.30320024490356) + 0.216521938587837*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 1.22477890585116*std::sin(0.206719994544983*x_5 + 8.2021598815918) + 0.077954142273824*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 4.77064944101607*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 2.62168366833904*std::sin(0.122960053384304*x_53 - 7.64232015609741) - 0.119774408108384*std::sin(0.254079967737198*x_53 + 1.98175978660583) + 0.624909792940483*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 2.94716598025738*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.453622717037362*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.139350366118847*std::sin(0.660319864749908*x_64 - 0.970399796962738) + 0.200280009812115*std::sin(0.307599931955338*x_7 - 1.15295994281769) - 0.22720677359592*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 0.334770713018288*std::sin(0.377679854631424*x_8 + 2.00887989997864) - 0.186687851881271*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 1.00095252915209*std::sin(0.307519912719727*x_9 - 1.20327985286713) + 0.25301377389499*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 0.81391160846455*std::sin(0.36847984790802*x_91 + 2.00039982795715) + 0.0828669900073039*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 2.21728866738296*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 0.938710139969925*std::sin(0.298399955034256*x_92 + 1.9864798784256) + 0.626345823573734*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 0.924682343775447*std::sin(0.303519934415817*x_92 - 1.17935991287231) - 0.0565658613415532*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 1.54025392512652*std::sin(0.321039855480194*x_94 + 8.23744010925293) + 0.213602628938078*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 2.61718684239751*std::sin(0.343759834766388*x_94 - 4.37103986740112) + 0.448708869191371*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.502230026802714*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 2.87936564522613*std::sin(0.290479928255081*x_95 - 7.44815969467163) + 0.155351846896341*std::sin(0.304719924926758*x_95 + 1.95855987071991) - 0.362914913874412*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 0.760416106868955*std::sin(0.273839950561523*x_97 + 1.97855985164642) + 0.430186815167788*std::sin(0.274719953536987*x_97 + 1.97439980506897) - 0.504863703462878*std::sin(0.25655996799469*x_98 - 7.43255996704102) - 6849.29293198558);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000464636824330219*x_1 + 0.0475351544209617*x_10 + 0.829462578544621*x_100 + 0.0573991897679042*x_101 - 1.80098583281899*x_102 + 0.016677119043129*x_103 - 83.3056083731793*x_104 - 0.685449868720981*x_105 - 1.50882561955111*x_106 - 0.0445809246318078*x_107 - 0.699877638513709*x_108 - 1.32725093004301*x_109 - 1.68068020876738*x_110 - 1.39020630812841*x_111 - 0.440572972831469*x_112 - 0.121173803316494*x_113 - 0.664967649330633*x_114 - 0.882573345406541*x_115 + 0.987800958117006*x_116 - 0.00835499712202751*x_117 - 0.879594177772094*x_118 + 0.0323009219390174*x_119 + 0.0116153439421208*x_12 + 0.000287339845393914*x_120 - 0.277738009863772*x_13 + 0.084870827686446*x_14 + 0.261904467967426*x_15 - 0.532524105813559*x_16 - 1.21428042573029*x_17 - 2.84809936677575*x_18 + 0.00482966337681265*x_19 - 0.244231956104555*x_2 - 0.105857979381209*x_20 - 0.0353297731907236*x_21 + 0.038066328269725*x_22 + 0.00138064520989456*x_24 - 0.157199437238637*x_25 - 0.232727496062557*x_26 - 0.559097261664539*x_27 + 0.169355286368989*x_28 - 0.253199361812817*x_29 + 0.11962415275255*x_3 - 0.112127479514196*x_30 - 0.0288727466055357*x_31 + 0.0117896368653198*x_32 + 0.527323740983109*x_33 - 5.11756368203103*x_34 + 2.93239550001647*x_35 - 1.19489486624785*x_36 + 9.67769432747312*x_37 - 56.1891153610971*x_38 + 4.35725330842462*x_39 - 65.2383864848843*x_40 - 0.136668787149107*x_41 - 0.118384277191417*x_42 - 1.25409048214848*x_43 + 0.213526290583654*x_44 + 1.49432496618817*x_45 + 0.300360530879445*x_46 - 2.51688091505113*x_47 + 0.795121844947343*x_48 - 0.517456634108162*x_49 + 0.652775954799318*x_5 + 0.543586116194395*x_50 - 0.568163539562645*x_52 - 0.222761656408246*x_53 + 0.0138918426692524*x_55 - 0.00298591844220172*x_56 + 0.117754306479962*x_58 - 0.474416857857547*x_59 + 0.285367297503072*x_6 + 0.732896254579918*x_60 - 0.137047873508693*x_61 - 0.165081828472388*x_62 - 0.0317231862208633*x_63 + 0.175695473412173*x_64 - 0.624998054452784*x_65 - 0.0500230790195072*x_66 - 0.586275660503171*x_67 - 0.815464589112593*x_68 - 0.252630067639521*x_69 + 0.180118686026416*x_7 + 0.416461852034302*x_70 - 0.313667517759338*x_71 - 0.0786165658445227*x_72 + 0.415151784730118*x_73 + 0.170065995135006*x_74 - 0.798585632782444*x_75 - 0.58500815762361*x_76 - 1.10019292440605*x_77 + 0.171820764371596*x_78 + 0.0887936330000782*x_79 + 0.0266082187186677*x_8 - 0.243476660805776*x_80 + 0.120907553146871*x_81 - 0.332787443685544*x_82 + 0.113869808906632*x_83 - 0.599611002540422*x_84 - 0.483134094541693*x_85 - 8.64519296878213*x_86 - 0.501798823244389*x_87 + 15.1517115088909*x_88 - 0.140743953245517*x_89 + 0.0904462810588519*x_9 - 1.67688923407623*x_90 - 0.6009510757677*x_91 + 0.00158036806952923*x_92 + 1.62236032222705*x_93 - 0.146948252776081*x_94 - 0.195784153459541*x_95 - 0.25457794021874*x_96 - 1.06636667023829*x_97 + 0.20362842672183*x_98 + 0.158056530182649*x_99 - 0.00380724857623232*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) - 0.0011495926037527*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 3.63440088431361e-5*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.0284523584159728*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 5.34391123363134e-5*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) - 0.646516539376043*std::exp(0.619999825954437*x_1) - 0.0217922579295688*std::exp(1.67199981212616*x_1) - 0.00665334977082944*std::exp(0.867839872837067*x_10) - 0.031190226922903*std::exp(0.883439898490906*x_11) + 0.0478237336017817*std::exp(0.935519814491272*x_11) - 0.0118587635938127*std::exp(0.981679856777191*x_11) + 0.000879947438749082*std::exp(0.982479810714722*x_11) + 0.0160734381389757*std::exp(1.03247976303101*x_11) - 0.340477467957499*std::exp(0.478879868984222*x_12) + 0.0142995307366175*std::exp(0.848559856414795*x_12) - 0.00127033469672803*std::exp(1.19295990467072*x_12) + 0.364763412163285*std::exp(0.269119828939438*x_13) + 0.00370719492805395*std::exp(0.856879889965057*x_14) + 0.00218647417016181*std::exp(0.778239846229553*x_15) + 0.000781976448741826*std::exp(0.980319857597351*x_15) - 0.0400932901233556*std::exp(0.480959862470627*x_16) - 0.00792427172010778*std::exp(0.682639837265015*x_16) - 0.0829748399006941*std::exp(0.704719841480255*x_16) - 0.0706310486501629*std::exp(0.726879835128784*x_17) - 0.734710784053578*std::exp(0.736799836158752*x_19) + 0.0393291942484929*std::exp(0.765119850635529*x_19) - 1.26800145353959*std::exp(0.769039869308472*x_19) - 0.172373409000776*std::exp(0.808799862861633*x_19) + 0.0947680715153925*std::exp(0.504639863967896*x_2) - 0.0314584409638946*std::exp(0.695039868354797*x_20) + 0.0910100211045007*std::exp(0.969119846820831*x_20) + 3.46853856677091e-5*std::exp(1.11439990997314*x_20) + 0.263392912507526*std::exp(0.497599840164185*x_22) + 0.0143925153391247*std::exp(0.944959819316864*x_22) - 0.00292393394353226*std::exp(0.613439857959747*x_23) + 0.037323487146299*std::exp(0.662079870700836*x_23) + 0.0622283035112235*std::exp(0.772399842739105*x_23) - 1.32676864854483*std::exp(0.61983984708786*x_24) - 0.406090636883759*std::exp(0.659039855003357*x_24) - 0.0312823639809668*std::exp(0.740079820156097*x_24) + 0.268717387449456*std::exp(0.442479848861694*x_25) + 0.0853994095351565*std::exp(0.453039854764938*x_25) + 0.00223689080596164*std::exp(0.923359870910645*x_25) - 0.00359642944715598*std::exp(1.03015983104706*x_25) - 0.156414574324671*std::exp(0.515279829502106*x_26) - 0.171543769209647*std::exp(0.741679847240448*x_26) - 0.000949260860703017*std::exp(0.549279868602753*x_27) - 0.0281406528244695*std::exp(0.836879849433899*x_27) + 0.0465235396040365*std::exp(0.928959846496582*x_27) - 1.70607421230802*std::exp(0.357039839029312*x_28) - 0.00839426729140794*std::exp(1.05983984470367*x_28) - 1.12275466269351*std::exp(0.310319840908051*x_29) + 0.0943984701173477*std::exp(0.593839824199677*x_29) - 0.000584766446905705*std::exp(1.26631987094879*x_29) + 0.000640933219235807*std::exp(1.27407991886139*x_29) - 0.198866043521975*std::exp(0.871119856834412*x_3) + 0.130499473578044*std::exp(0.819999873638153*x_30) - 0.083157857928343*std::exp(0.877279877662659*x_30) + 0.133718586511286*std::exp(0.682399809360504*x_32) - 1.26094207920794*std::exp(0.28167986869812*x_33) - 0.219769292078295*std::exp(0.442239850759506*x_33) + 0.88841508458256*std::exp(0.339919835329056*x_36) - 0.199305847291596*std::exp(0.329519838094711*x_38) + 0.19326332856429*std::exp(0.336719840764999*x_4) - 0.385017561866547*std::exp(0.454319834709167*x_4) + 0.366691791831168*std::exp(0.461599856615067*x_4) - 0.0209297921055025*std::exp(1.0719997882843*x_4) - 0.00313591366041384*std::exp(0.618799805641174*x_41) + 0.410875858972295*std::exp(0.789759874343872*x_41) + 0.191256186444586*std::exp(0.790239870548248*x_41) + 0.0547930672297909*std::exp(0.829279899597168*x_41) - 0.00183597423910943*std::exp(0.542079865932465*x_42) - 0.00352131496145297*std::exp(0.756079852581024*x_46) + 0.0698665438033756*std::exp(0.769599854946136*x_46) + 0.158823771132092*std::exp(0.50087982416153*x_47) - 0.0266544209214342*std::exp(0.568239867687225*x_47) - 0.0065117229431386*std::exp(0.499679833650589*x_48) + 0.0749090977276843*std::exp(0.530479848384857*x_48) + 0.0180413556191126*std::exp(0.66815984249115*x_49) - 0.00182556897496997*std::exp(0.675759792327881*x_49) + 0.0186320926677333*std::exp(0.769919812679291*x_49) - 0.807269196203219*std::exp(0.279839843511581*x_50) - 0.0153604722759199*std::exp(0.558319866657257*x_50) - 58.2032774032473*std::exp(0.491999834775925*x_51) - 2.63042738324386*std::exp(0.493039846420288*x_51) - 0.472042989139608*std::exp(0.495119869709015*x_51) - 6.47300161736899*std::exp(0.49551984667778*x_51) - 1.99650553904906*std::exp(0.501519858837128*x_51) - 0.0294667108890126*std::exp(0.348879843950272*x_54) - 1.20887110983073*std::exp(0.47735983133316*x_54) - 0.840527483154105*std::exp(0.492399841547012*x_54) - 0.286145407501524*std::exp(0.494639873504639*x_54) - 0.482066420425923*std::exp(0.498079836368561*x_55) - 14.6382185830267*std::exp(0.650959849357605*x_55) + 38.4788804999775*std::exp(0.653679847717285*x_55) - 0.584234494197715*std::exp(0.653839826583862*x_55) + 0.901995193435894*std::exp(0.344719856977463*x_56) - 0.841064893872385*std::exp(0.403919875621796*x_56) - 0.571939916920229*std::exp(0.554959833621979*x_56) - 3.14979146243389*std::exp(0.215359851717949*x_57) - 0.201092531167315*std::exp(0.423999845981598*x_57) - 0.0135499569907734*std::exp(0.600159823894501*x_57) - 1.98089023144831*std::exp(0.636399865150452*x_57) - 0.585489170809878*std::exp(0.640799820423126*x_57) - 0.949865925376935*std::exp(0.514319837093353*x_58) - 0.0156710231097164*std::exp(0.575679838657379*x_58) - 0.396209285946569*std::exp(0.581039845943451*x_58) + 0.00482600120435408*std::exp(0.943519830703735*x_59) - 0.0519370973300348*std::exp(0.851839900016785*x_60) + 0.00856113294796208*std::exp(0.903199791908264*x_60) + 0.0126493718768139*std::exp(0.91351979970932*x_60) + 0.000430858441912018*std::exp(0.918799817562103*x_60) - 0.17060076502479*std::exp(0.99999988079071*x_66) + 0.0476508007913787*std::exp(1.11287987232208*x_66) + 0.276710173482774*std::exp(0.403839856386185*x_8) - 0.409618239338824*std::log(7.69087982177734 - 0.987919807434082*x_21) + 0.226368573745901*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.0310881363303671*std::sin(0.268559962511063*x_10 + 1.97279977798462) + 2.55088146567196*std::sin(0.27551993727684*x_10 + 1.97495973110199) - 1.61731473792439*std::sin(0.553839862346649*x_10 - 1.13599991798401) - 1.35284783964764*std::sin(0.281599938869476*x_100 + 1.94175982475281) + 6.06024951997538*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 4.90823671111947*std::sin(0.307359933853149*x_103 + 1.91287982463837) + 1.84848608968145*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 5.79213929798353*std::sin(0.270639955997467*x_107 - 7.45351982116699) + 0.887153772975203*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 7.48973406301688*std::sin(0.245599970221519*x_109 - 7.44384002685547) + 2.48064931607349*std::sin(0.273759961128235*x_112 - 7.4302396774292) - 0.831689398135202*std::sin(0.286159932613373*x_112 - 7.44384002685547) - 1.01587344717097*std::sin(0.287119954824448*x_113 - 7.42575979232788) - 6.83014289490253*std::sin(0.288799941539764*x_113 - 7.43088006973267) + 2.11604229419836*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 1.68669342952176*std::sin(0.265599936246872*x_114 + 1.91943979263306) - 6.33922151697102*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 2.99583203665546*std::sin(0.246159970760345*x_117 + 5.15112018585205) + 1.33012146794467*std::sin(0.24967996776104*x_117 + 5.14487981796265) - 3.79039883206276*std::sin(0.262239962816238*x_117 - 7.46135997772217) - 0.934710392601171*std::sin(0.244319975376129*x_12 + 1.96343982219696) + 1.45595635356826*std::sin(0.263679951429367*x_120 + 5.15823984146118) - 0.546871233916426*std::sin(0.263999968767166*x_120 - 1.20231986045837) + 0.525520556953434*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 2.47463230908768*std::sin(0.276079952716827*x_120 + 5.14111995697021) - 0.365820896253633*std::sin(0.438399881124496*x_15 - 4.26543998718262) - 0.468161442862444*std::sin(0.319279909133911*x_16 + 1.9761598110199) + 0.799137285726756*std::sin(0.332959830760956*x_18 - 4.39271974563599) + 0.986471367831948*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 3.14827935463254*std::sin(0.0904800817370415*x_21 - 4.52415990829468) + 1.19415455118666*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.0149715710607114*std::sin(0.530959844589233*x_22 + 2.06007981300354) - 6.93980471923248*std::sin(0.181600019335747*x_23 + 4.97295999526978) - 0.644189613310805*std::sin(0.339119851589203*x_23 + 1.99055981636047) + 0.943138801701803*std::sin(0.253439962863922*x_24 - 4.38711977005005) + 0.805437574668562*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.0526063415014178*std::sin(0.247839972376823*x_3 - 7.5490403175354) + 1.09927707195519*std::sin(0.41967985033989*x_3 - 4.21216011047363) - 0.471907920518445*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.0166769972506143*std::sin(0.687199831008911*x_30 - 4.14775991439819) + 1.56210721875496*std::sin(0.383039832115173*x_31 + 5.17232036590576) + 1.06558674836462*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.5701632330932*std::sin(0.411279857158661*x_31 + 1.99031984806061) + 4.64932330631134*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.051863429010493*std::sin(0.390079826116562*x_32 + 5.18871974945068) - 0.615760650064304*std::sin(0.465439856052399*x_32 - 1.01639986038208) + 19.9762795573911*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 1.10155558956194*std::sin(0.0688000917434692*x_4 - 7.74391984939575) - 1.7999033170129*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.0313531601820049*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.101514320953358*std::sin(0.246719971299171*x_45 - 7.42984008789063) + 4.25439598930042*std::sin(0.206719994544983*x_5 + 8.2021598815918) + 0.241063398750957*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 8.16018131073481*std::sin(0.333759844303131*x_50 - 7.44712018966675) - 9.10668891382057*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.0561551304501203*std::sin(0.254079967737198*x_53 + 1.98175978660583) + 1.93245508455262*std::sin(0.415839850902557*x_54 + 1.96727979183197) - 4.18584540183038*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.775920273216437*std::sin(0.271519958972931*x_59 + 5.11528015136719) - 0.197918642237794*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.0938994419189573*std::sin(0.307599931955338*x_7 - 1.15295994281769) - 0.702608424192273*std::sin(0.33943983912468*x_8 + 8.25103950500488) + 1.16286063712901*std::sin(0.377679854631424*x_8 + 2.00887989997864) - 0.57730874546645*std::sin(0.292879939079285*x_9 + 1.96663987636566) - 3.47691195950616*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.118623182557442*std::sin(0.362239837646484*x_91 + 2.00935983657837) - 2.82720600930846*std::sin(0.36847984790802*x_91 + 2.00039982795715) + 0.256255763616169*std::sin(0.36999985575676*x_91 - 1.19487988948822) + 3.14920423046043*std::sin(0.298239946365356*x_92 + 1.99775981903076) - 3.26070659408385*std::sin(0.298399955034256*x_92 + 1.9864798784256) + 1.9368958290091*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 1.58166632726545*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.0265203842191727*std::sin(0.311359941959381*x_94 - 7.43752002716064) - 5.35023104191086*std::sin(0.321039855480194*x_94 + 8.23744010925293) + 0.66053931467915*std::sin(0.331599831581116*x_94 - 4.35911989212036) + 3.71717764909321*std::sin(0.343759834766388*x_94 - 4.37103986740112) + 1.3875758478237*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.859062928239909*std::sin(0.283039927482605*x_95 - 7.42447996139526) + 10.0017738664975*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.0728352856499777*std::sin(0.304719924926758*x_95 + 1.95855987071991) - 1.12226881143368*std::sin(0.300079941749573*x_96 - 7.45623970031738) + 2.64138386104428*std::sin(0.273839950561523*x_97 + 1.97855985164642) + 1.33029872098302*std::sin(0.274719953536987*x_97 + 1.97439980506897) - 1.56122762322565*std::sin(0.25655996799469*x_98 - 7.43255996704102) - 24453.0270090471);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00716706338268381*x_1 - 0.0249757940468788*x_10 - 0.420786293727106*x_100 + 0.00141918554470888*x_101 + 0.162705479602465*x_102 + 0.240948100449975*x_103 + 70.9826214284917*x_104 + 0.840748817679602*x_105 + 0.334090872074587*x_106 - 0.0808058047768868*x_107 + 0.488661483052988*x_108 - 0.194198997104452*x_109 + 1.70743779828863*x_110 + 1.85464351068311*x_111 + 0.0598602901209456*x_112 - 0.00675694985704165*x_113 + 0.0751970113119687*x_114 + 0.408709806010607*x_115 + 0.132084320994564*x_116 - 0.00116770061449566*x_117 - 0.325415610591889*x_118 - 0.312033039241866*x_119 - 0.179167689441867*x_12 - 0.00443224207912788*x_120 + 0.0598611403928279*x_13 - 0.237212263564606*x_14 - 0.199041474216693*x_15 - 0.149121547931127*x_16 - 0.30142515129577*x_17 + 2.43311323269636*x_18 - 0.00032321303450801*x_19 - 0.0502961206618587*x_2 - 0.0296431759123293*x_20 - 0.0705227930165112*x_21 - 0.0200007086663903*x_22 - 0.0212965723123155*x_24 - 0.0440202108393094*x_25 + 0.0282396273645254*x_26 + 0.117367232326329*x_27 - 0.14105031650424*x_28 + 0.133035333333206*x_29 + 0.0334980870042627*x_3 - 0.0561127732618478*x_30 - 0.04833513069441*x_31 - 0.0111994272624364*x_32 - 0.0703830827371222*x_33 + 3.19259152688206*x_34 + 1.28071061051321*x_35 - 0.533345136691367*x_36 - 6.81244360596491*x_37 - 4.64443668337267*x_38 - 2.27017943249367*x_39 - 40.1452296285299*x_40 + 0.00914621371523918*x_41 + 0.309676180430034*x_42 + 0.654106739232898*x_43 + 0.805643956286251*x_44 + 0.709755637461975*x_45 + 0.0252599510297642*x_46 - 0.969299047882335*x_47 - 0.0207908883517819*x_48 + 0.480557083198904*x_49 - 0.0131119069807924*x_5 + 0.189212650166383*x_50 + 0.0665728623500505*x_52 + 0.419703050315314*x_53 - 0.000929676516502922*x_55 + 0.0460580513859034*x_56 - 0.0771686827245619*x_58 + 0.0854326221875365*x_59 + 0.414999624330176*x_6 - 0.0490472324757882*x_60 + 0.188752517293586*x_61 + 0.645809606784983*x_62 + 0.457136239529588*x_63 + 0.00744255113230187*x_64 + 0.501238451764317*x_65 + 0.115725446605234*x_66 + 0.0371995019548692*x_67 + 0.350457698137959*x_68 + 0.583362615962057*x_69 - 0.0276143119982506*x_7 + 0.25506638312748*x_70 + 0.630006803907201*x_71 + 0.631052441286392*x_72 + 0.328071113210159*x_73 + 0.2595519113094*x_74 + 0.0681553541633153*x_75 - 0.0279322213020683*x_76 + 0.289573252106432*x_77 + 0.198922716233702*x_78 + 0.826486932203078*x_79 + 0.0949516687002182*x_8 + 0.577977940564037*x_80 + 0.2636396393487*x_81 + 0.173006150716851*x_82 + 0.151424058326274*x_83 + 0.506513184337749*x_84 + 3.70531104284188*x_85 - 66.6771286907641*x_86 - 0.526216105800185*x_87 - 11.6859098271251*x_88 + 0.347962543323978*x_89 + 0.165984974767777*x_9 + 0.562099209618664*x_90 - 0.23718186341729*x_91 - 0.0243773147739917*x_92 + 0.125450923124771*x_93 + 0.139591769204437*x_94 - 0.0548250036111861*x_95 - 0.177834038993982*x_96 - 0.257764629075242*x_97 - 0.603090791515049*x_98 - 0.924580180905483*x_99 + 0.00025479050390101*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 7.69335841687767e-5*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) + 0.00056060949395275*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) + 0.0270279841664839*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) + 0.000824302950548143*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) - 0.181042597062422*std::exp(0.619999825954437*x_1) + 0.0207012998241179*std::exp(1.67199981212616*x_1) + 0.00632027157928339*std::exp(0.867839872837067*x_10) + 0.00208732723260683*std::exp(0.883439898490906*x_11) - 0.0454295948221101*std::exp(0.935519814491272*x_11) + 0.00623079993696376*std::exp(0.981679856777191*x_11) - 0.0135732656920511*std::exp(0.982479810714722*x_11) + 0.0045010093434126*std::exp(1.03247976303101*x_11) - 0.0953431525506731*std::exp(0.478879868984222*x_12) - 0.0135836715075429*std::exp(0.848559856414795*x_12) + 8.50139440652382e-5*std::exp(1.19295990467072*x_12) - 0.346502725163454*std::exp(0.269119828939438*x_13) - 0.00352160634112009*std::exp(0.856879889965057*x_14) - 0.000146324266573992*std::exp(0.778239846229553*x_15) - 0.0120620546595238*std::exp(0.980319857597351*x_15) + 0.0380861507082646*std::exp(0.480959862470627*x_16) + 0.122232579739004*std::exp(0.682639837265015*x_16) + 0.00555288178486232*std::exp(0.704719841480255*x_16) + 0.0670951362508866*std::exp(0.726879835128784*x_17) - 0.205739436400499*std::exp(0.736799836158752*x_19) - 0.606656238181635*std::exp(0.765119850635529*x_19) + 1.20452310871028*std::exp(0.769039869308472*x_19) + 0.0905679767911583*std::exp(0.808799862861633*x_19) - 0.0497927873637996*std::exp(0.504639863967896*x_2) + 0.00210527678049929*std::exp(0.695039868354797*x_20) - 0.0864539021138894*std::exp(0.969119846820831*x_20) - 0.000535025087371526*std::exp(1.11439990997314*x_20) + 0.0737573349232785*std::exp(0.497599840164185*x_22) - 0.0136720011401009*std::exp(0.944959819316864*x_22) + 0.0451019351087481*std::exp(0.613439857959747*x_23) - 0.0354550088565529*std::exp(0.662079870700836*x_23) + 0.0174256542444118*std::exp(0.772399842739105*x_23) - 0.371532091143988*std::exp(0.61983984708786*x_24) + 0.385761037569733*std::exp(0.659039855003357*x_24) + 0.0164362962444399*std::exp(0.740079820156097*x_24) - 0.25526493048694*std::exp(0.442479848861694*x_25) - 0.00571513998958377*std::exp(0.453039854764938*x_25) - 0.0345042350217937*std::exp(0.923359870910645*x_25) + 0.00188962636748453*std::exp(1.03015983104706*x_25) + 0.0104676506962105*std::exp(0.515279829502106*x_26) - 0.0480370224055898*std::exp(0.741679847240448*x_26) + 0.0146424312476023*std::exp(0.549279868602753*x_27) - 0.00788016479097477*std::exp(0.836879849433899*x_27) - 0.0441944907836102*std::exp(0.928959846496582*x_27) + 0.114174711617242*std::exp(0.357039839029312*x_28) - 0.00235062810974539*std::exp(1.05983984470367*x_28) + 0.0751375226852093*std::exp(0.310319840908051*x_29) - 0.0896727195113517*std::exp(0.593839824199677*x_29) - 0.000163750855198457*std::exp(1.26631987094879*x_29) - 0.00988645059063573*std::exp(1.27407991886139*x_29) + 0.188910465592399*std::exp(0.871119856834412*x_3) - 0.123966444328979*std::exp(0.819999873638153*x_30) + 0.00556512980454213*std::exp(0.877279877662659*x_30) - 0.00894877898197484*std::exp(0.682399809360504*x_32) + 0.662520823987333*std::exp(0.28167986869812*x_33) + 0.208767261389373*std::exp(0.442239850759506*x_33) - 0.0594549377435333*std::exp(0.339919835329056*x_36) + 0.189328252024999*std::exp(0.329519838094711*x_38) - 0.101543902609211*std::exp(0.336719840764999*x_4) + 0.0257663287895415*std::exp(0.454319834709167*x_4) + 0.102683891704701*std::exp(0.461599856615067*x_4) + 0.0198820105301973*std::exp(1.0719997882843*x_4) + 0.048371740658327*std::exp(0.618799805641174*x_41) - 0.215881297905308*std::exp(0.789759874343872*x_41) - 0.18168157111589*std::exp(0.790239870548248*x_41) + 0.0153435814679559*std::exp(0.829279899597168*x_41) + 0.0283200621466889*std::exp(0.542079865932465*x_42) + 0.0543165892103074*std::exp(0.756079852581024*x_46) + 0.0195645737851441*std::exp(0.769599854946136*x_46) - 0.0106288801132734*std::exp(0.50087982416153*x_47) + 0.411146758434462*std::exp(0.568239867687225*x_47) + 0.100443892132799*std::exp(0.499679833650589*x_48) + 0.0209766290113959*std::exp(0.530479848384857*x_48) - 0.00120737219995234*std::exp(0.66815984249115*x_49) + 0.0281595600433341*std::exp(0.675759792327881*x_49) - 0.00978962443270111*std::exp(0.769919812679291*x_49) + 0.424153227866027*std::exp(0.279839843511581*x_50) + 0.236936619365396*std::exp(0.558319866657257*x_50) + 55.2895207171757*std::exp(0.491999834775925*x_51) + 1.38207213964994*std::exp(0.493039846420288*x_51) + 7.28130411831214*std::exp(0.495119869709015*x_51) - 1.8126203309953*std::exp(0.49551984667778*x_51) + 0.133611095296245*std::exp(0.501519858837128*x_51) + 0.454526575514555*std::exp(0.348879843950272*x_54) - 0.33851750405134*std::exp(0.47735983133316*x_54) + 0.798449224280481*std::exp(0.492399841547012*x_54) + 0.0191495593488205*std::exp(0.494639873504639*x_54) + 0.457933342044184*std::exp(0.498079836368561*x_55) - 4.09910798445502*std::exp(0.650959849357605*x_55) - 20.2174707588224*std::exp(0.653679847717285*x_55) + 9.01186783096931*std::exp(0.653839826583862*x_55) - 0.060363752261023*std::exp(0.344719856977463*x_56) + 0.798959731289152*std::exp(0.403919875621796*x_56) + 0.300507145631349*std::exp(0.554959833621979*x_56) - 0.882029138982932*std::exp(0.215359851717949*x_57) + 0.105657501358314*std::exp(0.423999845981598*x_57) + 0.209009263795444*std::exp(0.600159823894501*x_57) + 1.88172344198614*std::exp(0.636399865150452*x_57) + 0.039182385355794*std::exp(0.640799820423126*x_57) - 0.265988854913607*std::exp(0.514319837093353*x_58) + 0.241726892957191*std::exp(0.575679838657379*x_58) + 0.376374364142904*std::exp(0.581039845943451*x_58) + 0.00135141444688463*std::exp(0.943519830703735*x_59) + 0.0493370364511247*std::exp(0.851839900016785*x_60) - 0.00449816763868469*std::exp(0.903199791908264*x_60) + 0.0035421756386881*std::exp(0.91351979970932*x_60) - 0.00664602889923589*std::exp(0.918799817562103*x_60) - 0.0477729550287024*std::exp(0.99999988079071*x_66) - 0.0452653193271545*std::exp(1.11287987232208*x_66) + 0.077486538069487*std::exp(0.403839856386185*x_8) + 0.0274126670529786*std::log(7.69087982177734 - 0.987919807434082*x_21) - 0.118937972231982*std::sin(0.536399841308594*x_1 - 4.00568008422852) - 0.479537203815994*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 0.170711305294778*std::sin(0.27551993727684*x_10 + 1.97495973110199) - 0.452893070150608*std::sin(0.553839862346649*x_10 - 1.13599991798401) + 0.710809703500294*std::sin(0.281599938869476*x_100 + 1.94175982475281) + 1.69703827376407*std::sin(0.295759916305542*x_100 + 1.93311989307404) - 4.66252189621717*std::sin(0.307359933853149*x_103 + 1.91287982463837) - 0.971226630833153*std::sin(0.232399985194206*x_106 + 8.18399906158447) + 5.50217479153091*std::sin(0.270639955997467*x_107 - 7.45351982116699) - 0.466125969120011*std::sin(0.25231996178627*x_108 - 7.43975973129272) + 7.11478502789956*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 0.166011195903982*std::sin(0.273759961128235*x_112 - 7.4302396774292) + 0.436984025229914*std::sin(0.286159932613373*x_112 - 7.44384002685547) + 0.533757517006118*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 0.457090078323776*std::sin(0.288799941539764*x_113 - 7.43088006973267) - 1.1118052981664*std::sin(0.257279962301254*x_114 + 1.93927979469299) + 1.60225464055851*std::sin(0.265599936246872*x_114 + 1.91943979263306) - 1.77515818527093*std::sin(0.244879975914955*x_116 - 7.41983985900879) - 2.84585550583788*std::sin(0.246159970760345*x_117 + 5.15112018585205) - 0.698868873897435*std::sin(0.24967996776104*x_117 + 5.14487981796265) - 1.06141700430633*std::sin(0.262239962816238*x_117 - 7.46135997772217) + 0.49111304135765*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 0.0974362050587836*std::sin(0.263679951429367*x_120 + 5.15823984146118) - 0.153139142492029*std::sin(0.263999968767166*x_120 - 1.20231986045837) - 0.276117609330456*std::sin(0.275759935379028*x_120 + 5.14535999298096) - 2.3507479376593*std::sin(0.276079952716827*x_120 + 5.14111995697021) + 0.192208639567316*std::sin(0.438399881124496*x_15 - 4.26543998718262) + 0.245980136596881*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 0.0534802463352424*std::sin(0.332959830760956*x_18 - 4.39271974563599) - 0.518309154903027*std::sin(0.261759966611862*x_20 - 1.18231987953186) + 2.99067104753281*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 0.0799157800549052*std::sin(0.383919835090637*x_22 + 2.00487995147705) + 0.230937784333283*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 0.464428919200665*std::sin(0.181600019335747*x_23 + 4.97295999526978) + 0.338468388399602*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 0.0631171844240342*std::sin(0.253439962863922*x_24 - 4.38711977005005) - 0.423190862164713*std::sin(0.334079831838608*x_28 - 1.15431988239288) + 0.811457388069208*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 0.073566344167489*std::sin(0.41967985033989*x_3 - 4.21216011047363) + 0.247948600894039*std::sin(0.420319855213165*x_3 - 4.20503997802734) - 0.257244131479018*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 0.104540083854429*std::sin(0.383039832115173*x_31 + 5.17232036590576) - 0.559877747120602*std::sin(0.38647985458374*x_31 - 7.41648006439209) + 0.541619875971445*std::sin(0.411279857158661*x_31 + 1.99031984806061) + 1.30193972573355*std::sin(0.345279842615128*x_32 + 1.98999989032745) + 0.799997898352867*std::sin(0.390079826116562*x_32 + 5.18871974945068) + 0.323531318358282*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 1.33686210200963*std::sin(0.151280030608177*x_33 + 4.98831987380981) + 16.991590671533*std::sin(0.0688000917434692*x_4 - 7.74391984939575) + 0.945700400000904*std::sin(0.260479986667633*x_42 - 7.43607997894287) - 0.483625219752632*std::sin(0.302719920873642*x_43 - 4.30320024490356) + 1.56586722021357*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 0.284714716206159*std::sin(0.206719994544983*x_5 + 8.2021598815918) - 0.126658887991106*std::sin(0.434879869222641*x_5 - 7.41791963577271) + 7.75166852735703*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 0.609442176091971*std::sin(0.122960053384304*x_53 - 7.64232015609741) - 0.866197765919765*std::sin(0.254079967737198*x_53 + 1.98175978660583) - 1.01534539615057*std::sin(0.415839850902557*x_54 + 1.96727979183197) - 1.17215303289927*std::sin(0.428879857063293*x_56 - 1.06575977802277) + 0.737076362962395*std::sin(0.271519958972931*x_59 + 5.11528015136719) - 0.0554227197843694*std::sin(0.660319864749908*x_64 - 0.970399796962738) + 1.44840704953147*std::sin(0.307599931955338*x_7 - 1.15295994281769) + 0.369162644194335*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 0.0778215138224453*std::sin(0.377679854631424*x_8 + 2.00887989997864) + 0.303328021206001*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 0.232683559385213*std::sin(0.307519912719727*x_9 - 1.20327985286713) + 1.829772896865*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 0.189203628111019*std::sin(0.36847984790802*x_91 + 2.00039982795715) - 0.134641219816481*std::sin(0.36999985575676*x_91 - 1.19487988948822) + 0.881864697711784*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 0.218214560868556*std::sin(0.298399955034256*x_92 + 1.9864798784256) - 1.01767864025824*std::sin(0.300079941749573*x_92 + 1.9832798242569) + 1.50248537660739*std::sin(0.303519934415817*x_92 - 1.17935991287231) - 0.409079230657044*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 0.358050711914459*std::sin(0.321039855480194*x_94 + 8.23744010925293) - 0.347058804883528*std::sin(0.331599831581116*x_94 - 4.35911989212036) + 1.04091303833264*std::sin(0.343759834766388*x_94 - 4.37103986740112) - 0.729056400927259*std::sin(0.27991995215416*x_95 + 1.97951984405518) - 0.816056752942028*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 0.669343477927231*std::sin(0.290479928255081*x_95 - 7.44815969467163) + 1.12349060904022*std::sin(0.304719924926758*x_95 + 1.95855987071991) + 0.589659485512112*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 0.176767949734837*std::sin(0.273839950561523*x_97 + 1.97855985164642) - 0.698962005716065*std::sin(0.274719953536987*x_97 + 1.97439980506897) + 0.820296053583179*std::sin(0.25655996799469*x_98 - 7.43255996704102) + 8214.91536643695);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00266668561403534*x_1 + 0.00225032606369299*x_10 - 0.290511952397843*x_100 + 0.153207817543075*x_101 - 0.375821337977158*x_102 + 0.234156673618808*x_103 + 16.0949116273455*x_104 + 0.427623156308048*x_105 - 0.54886519357891*x_106 - 0.22881826639554*x_107 + 0.746703182590067*x_108 - 0.494556161862444*x_109 + 2.11950205503615*x_110 + 2.20970644186858*x_111 - 0.266274020630424*x_112 - 0.121439180229286*x_113 + 0.27626262720877*x_114 - 0.0218125035410656*x_115 + 0.0129625321384452*x_116 - 0.000830303092009892*x_117 - 0.98340813155777*x_118 - 0.450803825471046*x_119 - 0.0666638306965364*x_12 - 0.00164912678446363*x_120 - 0.383929778459158*x_13 - 0.210989945108072*x_14 - 0.210002652163025*x_15 - 0.548568131909521*x_16 - 1.15872938885883*x_17 + 1.10152095122102*x_18 + 0.000105514828691306*x_19 - 0.213156608404506*x_2 - 0.109047296381353*x_20 - 0.124422741906151*x_21 + 0.00180206947253928*x_22 - 0.00792392364643058*x_24 - 0.161935583162912*x_25 + 0.284287070696111*x_26 - 0.0166601332863105*x_27 - 0.186158094222486*x_28 - 0.011986520926217*x_29 + 0.123228220638898*x_3 - 0.145661168670851*x_30 - 0.0470916823971567*x_31 - 0.0133982522973112*x_32 + 0.44922509748213*x_33 + 0.286959872460512*x_34 + 1.59036969437565*x_35 - 0.392541734053943*x_36 - 7.26336517087498*x_37 - 15.0291677838829*x_38 + 0.00484542182732338*x_39 + 44.2440475292035*x_40 - 0.00298583618326698*x_41 + 0.204871824184334*x_42 + 0.156620524738476*x_43 + 1.27102491603244*x_44 + 1.55475204373209*x_45 + 0.617742066635173*x_46 - 3.18558925099166*x_47 + 0.428057732724494*x_48 + 0.568692880894338*x_49 + 0.383692485422207*x_5 + 0.667470977893558*x_50 - 0.400548516080618*x_52 + 0.460843146664417*x_53 + 0.000303498460470365*x_55 + 0.0171370527206495*x_56 + 0.0064251395566606*x_58 - 0.0391841469540392*x_59 + 0.78359204212391*x_6 + 0.0160117624598373*x_60 + 0.412930074835919*x_61 + 0.823199991258645*x_62 + 0.473768571490762*x_63 - 0.0514461916543231*x_64 + 0.472245613776661*x_65 + 0.0440792395725466*x_66 - 0.301418304545569*x_67 - 0.0243901793040144*x_68 + 0.619973113471677*x_69 + 0.182878718406721*x_7 + 0.460053821309148*x_70 + 0.967482835845487*x_71 + 0.86061184603535*x_72 + 0.680643523866706*x_73 + 0.230067386691052*x_74 - 0.410118409068076*x_75 - 0.408849623271922*x_76 - 0.252662663318334*x_77 + 0.10501568834359*x_78 + 0.91052752564627*x_79 + 0.00799164516801464*x_8 + 0.661978915942437*x_80 + 0.391008976807628*x_81 - 0.210934772354429*x_82 - 0.143374381888465*x_83 + 0.073884591264765*x_84 + 1.55488924563404*x_85 - 66.6271362360433*x_86 - 0.626316400338065*x_87 - 3.91720946153523*x_88 + 0.327885498833857*x_89 + 0.1026147515966*x_9 + 0.0896392666798224*x_90 - 0.740421261641431*x_91 - 0.00907019111532849*x_92 + 0.0447013940605551*x_93 + 0.166998338272363*x_94 - 0.201682789846116*x_95 - 0.241852432469101*x_96 - 0.93206936885089*x_97 - 1.0623736600595*x_98 - 3.83269132861358*x_99 - 8.31778842465597e-5*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) - 2.51154287961597e-5*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) + 0.000208588817035914*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) + 0.0323344884041421*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) + 0.000306702578512775*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) - 0.665994959443756*std::exp(0.619999825954437*x_1) + 0.0247656626920648*std::exp(1.67199981212616*x_1) + 0.00756115390746704*std::exp(0.867839872837067*x_10) - 0.000681420462223807*std::exp(0.883439898490906*x_11) - 0.054348955435676*std::exp(0.935519814491272*x_11) - 0.000561396825642004*std::exp(0.981679856777191*x_11) - 0.00505027379050723*std::exp(0.982479810714722*x_11) + 0.0165577029039661*std::exp(1.03247976303101*x_11) - 0.350735462518424*std::exp(0.478879868984222*x_12) - 0.0162506040458236*std::exp(0.848559856414795*x_12) - 2.77533106239673e-5*std::exp(1.19295990467072*x_12) - 0.414532888571647*std::exp(0.269119828939438*x_13) - 0.00421301635739836*std::exp(0.856879889965057*x_14) + 4.77684321872642e-5*std::exp(0.778239846229553*x_15) - 0.00448798983890319*std::exp(0.980319857597351*x_15) + 0.0455637457403096*std::exp(0.480959862470627*x_16) + 0.0454796957347923*std::exp(0.682639837265015*x_16) - 0.00181277147799651*std::exp(0.704719841480255*x_16) + 0.0802681728580002*std::exp(0.726879835128784*x_17) - 0.756846343483946*std::exp(0.736799836158752*x_19) - 0.225721662645317*std::exp(0.765119850635529*x_19) + 1.44101159195626*std::exp(0.769039869308472*x_19) - 0.00816020016526983*std::exp(0.808799862861633*x_19) + 0.00448634413698187*std::exp(0.504639863967896*x_2) - 0.000687280199513925*std::exp(0.695039868354797*x_20) - 0.103427716923887*std::exp(0.969119846820831*x_20) - 0.0001990694971512*std::exp(1.11439990997314*x_20) + 0.271328483340147*std::exp(0.497599840164185*x_22) - 0.0163562757622971*std::exp(0.944959819316864*x_22) + 0.0167813056893347*std::exp(0.613439857959747*x_23) - 0.0424160220636278*std::exp(0.662079870700836*x_23) + 0.0641031341799989*std::exp(0.772399842739105*x_23) - 1.36674188278563*std::exp(0.61983984708786*x_24) + 0.461498930857595*std::exp(0.659039855003357*x_24) - 0.00148091491145462*std::exp(0.740079820156097*x_24) - 0.305382039739734*std::exp(0.442479848861694*x_25) + 0.00186574163961453*std::exp(0.453039854764938*x_25) - 0.0128381656813891*std::exp(0.923359870910645*x_25) - 0.000170255866836928*std::exp(1.03015983104706*x_25) - 0.00341722719101451*std::exp(0.515279829502106*x_26) - 0.176712084934237*std::exp(0.741679847240448*x_26) + 0.00544808364006138*std::exp(0.549279868602753*x_27) - 0.0289884818022459*std::exp(0.836879849433899*x_27) - 0.0528713588467189*std::exp(0.928959846496582*x_27) - 0.0372730176414775*std::exp(0.357039839029312*x_28) - 0.00864717198062209*std::exp(1.05983984470367*x_28) - 0.0245290937801659*std::exp(0.310319840908051*x_29) - 0.107278496662849*std::exp(0.593839824199677*x_29) - 0.000602384443972457*std::exp(1.26631987094879*x_29) - 0.00367850180139569*std::exp(1.27407991886139*x_29) + 0.225999956988769*std::exp(0.871119856834412*x_3) - 0.148305235491025*std::exp(0.819999873638153*x_30) - 0.00181676991729302*std::exp(0.877279877662659*x_30) + 0.00292138243346753*std::exp(0.682399809360504*x_32) - 0.0596933124592437*std::exp(0.28167986869812*x_33) + 0.249755311050167*std::exp(0.442239850759506*x_33) + 0.0194094201071143*std::exp(0.339919835329056*x_36) + 0.22649976897908*std::exp(0.329519838094711*x_38) + 0.00914913416653385*std::exp(0.336719840764999*x_4) - 0.00841157217675562*std::exp(0.454319834709167*x_4) + 0.377739578425403*std::exp(0.461599856615067*x_4) + 0.0237855192965849*std::exp(1.0719997882843*x_4) + 0.0179979188200099*std::exp(0.618799805641174*x_41) + 0.0194509656200859*std::exp(0.789759874343872*x_41) - 0.217351786885307*std::exp(0.790239870548248*x_41) + 0.0564438871474535*std::exp(0.829279899597168*x_41) + 0.0105371891223435*std::exp(0.542079865932465*x_42) + 0.0202098487646351*std::exp(0.756079852581024*x_46) + 0.0719715013814057*std::exp(0.769599854946136*x_46) + 0.00346986149874683*std::exp(0.50087982416153*x_47) + 0.152977459167367*std::exp(0.568239867687225*x_47) + 0.037372668255649*std::exp(0.499679833650589*x_48) + 0.077165978694475*std::exp(0.530479848384857*x_48) + 0.000394153877607491*std::exp(0.66815984249115*x_49) + 0.0104774702909079*std::exp(0.675759792327881*x_49) + 0.000882047913004235*std::exp(0.769919812679291*x_49) - 0.038216325049562*std::exp(0.279839843511581*x_50) + 0.088158209375744*std::exp(0.558319866657257*x_50) + 66.144717100915*std::exp(0.491999834775925*x_51) - 0.12452508824827*std::exp(0.493039846420288*x_51) + 2.70919174380851*std::exp(0.495119869709015*x_51) - 6.66802190984872*std::exp(0.49551984667778*x_51) - 0.0436181413688984*std::exp(0.501519858837128*x_51) + 0.169118007669625*std::exp(0.348879843950272*x_54) - 1.24529229606632*std::exp(0.47735983133316*x_54) + 0.95521171777984*std::exp(0.492399841547012*x_54) - 0.00625148820894695*std::exp(0.494639873504639*x_54) + 0.547841091181309*std::exp(0.498079836368561*x_55) - 15.0792426763598*std::exp(0.650959849357605*x_55) + 1.82159979799379*std::exp(0.653679847717285*x_55) + 3.35309135935598*std::exp(0.653839826583862*x_55) + 0.0197061080432028*std::exp(0.344719856977463*x_56) + 0.955822454520339*std::exp(0.403919875621796*x_56) - 0.0270757782864052*std::exp(0.554959833621979*x_56) - 3.24468920672083*std::exp(0.215359851717949*x_57) - 0.00951977057005737*std::exp(0.423999845981598*x_57) + 0.0777671365806614*std::exp(0.600159823894501*x_57) + 2.25116917487888*std::exp(0.636399865150452*x_57) - 0.0127913241024656*std::exp(0.640799820423126*x_57) - 0.978483735402886*std::exp(0.514319837093353*x_58) + 0.0899405507605567*std::exp(0.575679838657379*x_58) + 0.450269337070514*std::exp(0.581039845943451*x_58) + 0.00497140023590309*std::exp(0.943519830703735*x_59) + 0.059023559552098*std::exp(0.851839900016785*x_60) + 0.000405286168567581*std::exp(0.903199791908264*x_60) + 0.0130304754743291*std::exp(0.91351979970932*x_60) - 0.00247282167182661*std::exp(0.918799817562103*x_60) - 0.175740669671673*std::exp(0.99999988079071*x_66) - 0.0541524271243522*std::exp(1.11287987232208*x_66) + 0.28504697025105*std::exp(0.403839856386185*x_8) - 0.00894902915183998*std::log(7.69087982177734 - 0.987919807434082*x_21) + 0.0107163447285821*std::sin(0.536399841308594*x_1 - 4.00568008422852) - 0.178423838960384*std::sin(0.268559962511063*x_10 + 1.97279977798462) + 0.0557297268696672*std::sin(0.27551993727684*x_10 + 1.97495973110199) - 1.66604162104079*std::sin(0.553839862346649*x_10 - 1.13599991798401) - 0.0640441540761542*std::sin(0.281599938869476*x_100 + 1.94175982475281) + 6.24283430887988*std::sin(0.295759916305542*x_100 + 1.93311989307404) - 5.57793208915087*std::sin(0.307359933853149*x_103 + 1.91287982463837) + 0.0875077924255108*std::sin(0.232399985194206*x_106 + 8.18399906158447) + 6.5824371473081*std::sin(0.270639955997467*x_107 - 7.45351982116699) + 0.0419980808340306*std::sin(0.25231996178627*x_108 - 7.43975973129272) + 8.51165712416907*std::sin(0.245599970221519*x_109 - 7.44384002685547) + 0.0541953480413037*std::sin(0.273759961128235*x_112 - 7.4302396774292) - 0.0393723834984634*std::sin(0.286159932613373*x_112 - 7.44384002685547) - 0.0480917023081005*std::sin(0.287119954824448*x_113 - 7.42575979232788) - 0.149219790545401*std::sin(0.288799941539764*x_113 - 7.43088006973267) + 0.100173969865373*std::sin(0.257279962301254*x_114 + 1.93927979469299) + 1.91683122857037*std::sin(0.265599936246872*x_114 + 1.91943979263306) - 6.53021124745651*std::sin(0.244879975914955*x_116 - 7.41983985900879) - 3.40459285777914*std::sin(0.246159970760345*x_117 + 5.15112018585205) + 0.0629682819726689*std::sin(0.24967996776104*x_117 + 5.14487981796265) - 3.90459696339958*std::sin(0.262239962816238*x_117 - 7.46135997772217) - 0.0442494230658811*std::sin(0.244319975376129*x_12 + 1.96343982219696) + 0.0318086320397259*std::sin(0.263679951429367*x_120 + 5.15823984146118) - 0.563347514055297*std::sin(0.263999968767166*x_120 - 1.20231986045837) + 0.0248782742104079*std::sin(0.275759935379028*x_120 + 5.14535999298096) - 2.81227898696056*std::sin(0.276079952716827*x_120 + 5.14111995697021) - 0.0173180524500424*std::sin(0.438399881124496*x_15 - 4.26543998718262) - 0.0221628794462252*std::sin(0.319279909133911*x_16 + 1.9761598110199) + 0.0174589463541332*std::sin(0.332959830760956*x_18 - 4.39271974563599) + 0.0466998005404649*std::sin(0.261759966611862*x_20 - 1.18231987953186) + 3.57784057114286*std::sin(0.0904800817370415*x_21 - 4.52415990829468) + 0.0260889844837506*std::sin(0.383919835090637*x_22 + 2.00487995147705) + 0.0859261924077126*std::sin(0.530959844589233*x_22 + 2.06007981300354) - 0.151615599053237*std::sin(0.181600019335747*x_23 + 4.97295999526978) - 0.030496096929778*std::sin(0.339119851589203*x_23 + 1.99055981636047) + 0.0206049824448354*std::sin(0.253439962863922*x_24 - 4.38711977005005) + 0.0381296156293767*std::sin(0.334079831838608*x_28 - 1.15431988239288) + 0.301923064946656*std::sin(0.247839972376823*x_3 - 7.5490403175354) + 0.0240161731537033*std::sin(0.41967985033989*x_3 - 4.21216011047363) - 0.022340238632685*std::sin(0.420319855213165*x_3 - 4.20503997802734) - 0.095714128378928*std::sin(0.687199831008911*x_30 - 4.14775991439819) + 0.0341277357705122*std::sin(0.383039832115173*x_31 + 5.17232036590576) + 0.050445142383157*std::sin(0.38647985458374*x_31 - 7.41648006439209) + 0.647958112272707*std::sin(0.411279857158661*x_31 + 1.99031984806061) + 4.7893993397541*std::sin(0.345279842615128*x_32 + 1.98999989032745) + 0.297659274501523*std::sin(0.390079826116562*x_32 + 5.18871974945068) - 0.0291502627206193*std::sin(0.465439856052399*x_32 - 1.01639986038208) + 0.43642663078908*std::sin(0.151280030608177*x_33 + 4.98831987380981) + 6.32214729854763*std::sin(0.0688000917434692*x_4 - 7.74391984939575) - 0.0852078718527419*std::sin(0.260479986667633*x_42 - 7.43607997894287) - 0.179944887778582*std::sin(0.302719920873642*x_43 - 4.30320024490356) + 0.582620156495587*std::sin(0.246719971299171*x_45 - 7.42984008789063) + 0.0929468223709343*std::sin(0.206719994544983*x_5 + 8.2021598815918) + 0.0114120014086349*std::sin(0.434879869222641*x_5 - 7.41791963577271) + 9.27358231996424*std::sin(0.333759844303131*x_50 - 7.44712018966675) - 0.198956044286659*std::sin(0.122960053384304*x_53 - 7.64232015609741) - 0.322290594899528*std::sin(0.254079967737198*x_53 + 1.98175978660583) + 0.0914829055812884*std::sin(0.415839850902557*x_54 + 1.96727979183197) - 4.31195765126185*std::sin(0.428879857063293*x_56 - 1.06575977802277) + 0.88178929528636*std::sin(0.271519958972931*x_59 + 5.11528015136719) - 0.203881587062778*std::sin(0.660319864749908*x_64 - 0.970399796962738) + 0.538916155197526*std::sin(0.307599931955338*x_7 - 1.15295994281769) - 0.0332616580042688*std::sin(0.33943983912468*x_8 + 8.25103950500488) + 0.0254052987435132*std::sin(0.377679854631424*x_8 + 2.00887989997864) - 0.0273299399685588*std::sin(0.292879939079285*x_9 + 1.96663987636566) - 0.0759609399577159*std::sin(0.307519912719727*x_9 - 1.20327985286713) + 0.68081287976478*std::sin(0.362239837646484*x_91 + 2.00935983657837) - 0.0617666562807291*std::sin(0.36847984790802*x_91 + 2.00039982795715) + 0.0121312117497345*std::sin(0.36999985575676*x_91 - 1.19487988948822) + 3.24408428246827*std::sin(0.298239946365356*x_92 + 1.99775981903076) - 0.0712374488332203*std::sin(0.298399955034256*x_92 + 1.9864798784256) + 0.0916931315312058*std::sin(0.300079941749573*x_92 + 1.9832798242569) + 1.79747389550231*std::sin(0.303519934415817*x_92 - 1.17935991287231) - 0.152208183623637*std::sin(0.311359941959381*x_94 - 7.43752002716064) - 0.116887796892108*std::sin(0.321039855480194*x_94 + 8.23744010925293) + 0.0312700958695303*std::sin(0.331599831581116*x_94 - 4.35911989212036) + 3.8291697534023*std::sin(0.343759834766388*x_94 - 4.37103986740112) + 0.0656881866430127*std::sin(0.27991995215416*x_95 + 1.97951984405518) - 0.976276197758276*std::sin(0.283039927482605*x_95 - 7.42447996139526) + 0.218511182621827*std::sin(0.290479928255081*x_95 - 7.44815969467163) + 0.418022847665881*std::sin(0.304719924926758*x_95 + 1.95855987071991) - 0.0531284853831316*std::sin(0.300079941749573*x_96 - 7.45623970031738) + 0.0577069546801416*std::sin(0.273839950561523*x_97 + 1.97855985164642) + 0.0629766731757044*std::sin(0.274719953536987*x_97 + 1.97439980506897) - 0.0739089049924888*std::sin(0.25655996799469*x_98 - 7.43255996704102) - 443.322745578634);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00204292132182182*x_1 + 0.0140535006046814*x_10 - 0.494318866521225*x_100 - 0.0504107467215485*x_101 + 1.96664284205716*x_102 - 0.611645936030446*x_103 - 124.838914133565*x_104 + 0.40757479294595*x_105 + 2.17978652973699*x_106 + 0.000921713075583586*x_107 + 0.178588082906864*x_108 + 1.10096202507714*x_109 + 1.63816280942131*x_110 + 1.49165290581216*x_111 + 0.541436109462161*x_112 + 0.15300868543933*x_113 + 0.1108771523517*x_114 + 1.15134038852543*x_115 - 0.790096594118926*x_116 + 0.00493547267776508*x_117 + 1.0341282373501*x_118 - 0.019827911776068*x_119 + 0.0510704975522733*x_12 + 0.00126337962474326*x_120 + 0.519792629942778*x_13 + 0.278256664953974*x_14 - 0.296389588679626*x_15 + 0.720373847850344*x_16 + 1.46772476968541*x_17 + 2.71114992933189*x_18 - 0.00253312149149454*x_19 + 0.314078636459271*x_2 + 0.143199752086344*x_20 + 0.201793272546077*x_21 + 0.0112540954978086*x_22 + 0.00607043908160019*x_24 + 0.212652088886193*x_25 + 0.446814464433585*x_26 + 0.150229074926716*x_27 - 0.192332664894453*x_28 - 0.0748569648649808*x_29 - 0.161821991292844*x_3 + 0.202259635733894*x_30 + 0.053793024901041*x_31 - 0.0128659008160769*x_32 - 0.633512574887738*x_33 + 4.18094906726236*x_34 - 4.45829988652529*x_35 + 2.6412785378096*x_36 - 2.97236526424717*x_37 + 46.5520097311586*x_38 - 0.762113657983621*x_39 + 30.4006443401014*x_40 + 0.0716817332665473*x_41 + 0.61365653532351*x_42 + 1.05893709798572*x_43 + 0.933518552183*x_44 - 1.8116333339254*x_45 + 0.852264473290853*x_46 + 3.03079509163519*x_47 + 0.25822875856837*x_48 + 0.567031978445307*x_49 - 0.834898599930767*x_5 - 0.823651031697987*x_50 + 0.488603665131581*x_52 - 0.339389404958021*x_53 - 0.00728616519960606*x_55 - 0.0131285256169442*x_56 + 0.0621787761010933*x_58 + 0.0647313680405463*x_59 - 0.573701072717542*x_6 - 0.384398478458235*x_60 + 0.0092027249353647*x_61 - 0.0845580557911327*x_62 - 0.42989977677376*x_63 - 0.12495605727544*x_64 + 0.101335581242534*x_65 + 0.000512062194279139*x_66 + 0.441924219318263*x_67 + 0.669687580626839*x_68 - 0.0395923192111665*x_69 - 0.32511493127374*x_7 - 0.562585543547825*x_70 + 0.0907190093468586*x_71 + 0.0220901015146028*x_72 - 0.429274099500832*x_73 + 0.0378523399717551*x_74 + 0.781486557778915*x_75 + 0.540161839143889*x_76 + 1.03515042048199*x_77 - 0.169530877943706*x_78 - 0.0842211591223281*x_79 - 0.0746203898744491*x_8 + 0.183353318769034*x_80 - 0.27355840440137*x_81 + 0.407321249802607*x_82 + 0.554998671848365*x_83 - 0.0560844293191154*x_84 - 0.776308131089786*x_85 + 6.52804526935076*x_86 + 0.500501009451997*x_87 + 12.057092787322*x_88 - 0.110379821831698*x_89 - 0.179751552089388*x_9 + 1.12363131434386*x_90 + 0.827585097686916*x_91 + 0.006948583186926*x_92 - 1.24126846891712*x_93 + 0.16036300921823*x_94 + 0.264847698791592*x_95 + 0.329401994383032*x_96 + 1.44474872773485*x_97 + 0.36618559846175*x_98 + 2.68446175405436*x_99 + 0.00199687275063895*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 0.000602952525637709*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 0.000159797817775535*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) + 0.0310497452589221*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 0.000234961794447651*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 0.874577511299113*std::exp(0.619999825954437*x_1) + 0.0237816509773044*std::exp(1.67199981212616*x_1) + 0.00726072730008869*std::exp(0.867839872837067*x_10) + 0.0163590353982681*std::exp(0.883439898490906*x_11) - 0.052189513570596*std::exp(0.935519814491272*x_11) - 0.00350597664752572*std::exp(0.981679856777191*x_11) + 0.00386896451286305*std::exp(0.982479810714722*x_11) - 0.0217433996958107*std::exp(1.03247976303101*x_11) + 0.460582086371799*std::exp(0.478879868984222*x_12) - 0.0156049203444888*std::exp(0.848559856414795*x_12) + 0.000666280829658288*std::exp(1.19295990467072*x_12) - 0.398062292828669*std::exp(0.269119828939438*x_13) - 0.00404562098010909*std::exp(0.856879889965057*x_14) - 0.00114678897449159*std::exp(0.778239846229553*x_15) + 0.00343820437090846*std::exp(0.980319857597351*x_15) + 0.0437533657745358*std::exp(0.480959862470627*x_16) - 0.0348415424891345*std::exp(0.682639837265015*x_16) + 0.043519668723678*std::exp(0.704719841480255*x_16) + 0.0770788851980342*std::exp(0.726879835128784*x_17) + 0.993882584446081*std::exp(0.736799836158752*x_19) + 0.172923120366404*std::exp(0.765119850635529*x_19) + 1.38375601574894*std::exp(0.769039869308472*x_19) - 0.0509612272671015*std::exp(0.808799862861633*x_19) + 0.0280176464464952*std::exp(0.504639863967896*x_2) + 0.0164997116107798*std::exp(0.695039868354797*x_20) - 0.0993182333074182*std::exp(0.969119846820831*x_20) + 0.000152505161506131*std::exp(1.11439990997314*x_20) - 0.356305684208754*std::exp(0.497599840164185*x_22) - 0.0157063934167256*std::exp(0.944959819316864*x_22) - 0.0128559913550789*std::exp(0.613439857959747*x_23) - 0.0407307103026178*std::exp(0.662079870700836*x_23) - 0.0841795553594593*std::exp(0.772399842739105*x_23) + 1.79479093270204*std::exp(0.61983984708786*x_24) + 0.443162237833881*std::exp(0.659039855003357*x_24) - 0.00924845467481043*std::exp(0.740079820156097*x_24) - 0.293248324267723*std::exp(0.442479848861694*x_25) - 0.0447913369476309*std::exp(0.453039854764938*x_25) + 0.00983519101972524*std::exp(0.923359870910645*x_25) - 0.00106326410476564*std::exp(1.03015983104706*x_25) + 0.0820382475737424*std::exp(0.515279829502106*x_26) + 0.232056434161818*std::exp(0.741679847240448*x_26) - 0.00417372268135786*std::exp(0.549279868602753*x_27) + 0.0380673665940693*std::exp(0.836879849433899*x_27) - 0.0507706261860443*std::exp(0.928959846496582*x_27) + 0.894822871927398*std::exp(0.357039839029312*x_28) + 0.0113553744564437*std::exp(1.05983984470367*x_28) + 0.588876230877519*std::exp(0.310319840908051*x_29) - 0.103016010382119*std::exp(0.593839824199677*x_29) + 0.00079104485759884*std::exp(1.26631987094879*x_29) + 0.0028180636378277*std::exp(1.27407991886139*x_29) + 0.217020322242975*std::exp(0.871119856834412*x_3) - 0.142412637707634*std::exp(0.819999873638153*x_30) + 0.043615660278989*std::exp(0.877279877662659*x_30) - 0.0701343756027059*std::exp(0.682399809360504*x_32) - 0.372790421919881*std::exp(0.28167986869812*x_33) + 0.239831807086119*std::exp(0.442239850759506*x_33) - 0.465966914988022*std::exp(0.339919835329056*x_36) + 0.217500275251123*std::exp(0.329519838094711*x_38) + 0.0571372142980414*std::exp(0.336719840764999*x_4) + 0.201938765597909*std::exp(0.454319834709167*x_4) - 0.496043604735967*std::exp(0.461599856615067*x_4) + 0.0228404515259172*std::exp(1.0719997882843*x_4) - 0.0137880265721226*std::exp(0.618799805641174*x_41) + 0.121473132944528*std::exp(0.789759874343872*x_41) - 0.208715769057778*std::exp(0.790239870548248*x_41) - 0.0741215134581462*std::exp(0.829279899597168*x_41) - 0.00807243576700793*std::exp(0.542079865932465*x_42) - 0.0154825640993315*std::exp(0.756079852581024*x_46) - 0.0945122116467403*std::exp(0.769599854946136*x_46) - 0.083301852867523*std::exp(0.50087982416153*x_47) - 0.117194509711335*std::exp(0.568239867687225*x_47) - 0.0286308293827347*std::exp(0.499679833650589*x_48) - 0.10133354411562*std::exp(0.530479848384857*x_48) - 0.00946255299569768*std::exp(0.66815984249115*x_49) - 0.00802668576430349*std::exp(0.675759792327881*x_49) + 0.00550847322917294*std::exp(0.769919812679291*x_49) - 0.238664589926729*std::exp(0.279839843511581*x_50) - 0.067537127241184*std::exp(0.558319866657257*x_50) + 63.5165953621147*std::exp(0.491999834775925*x_51) - 0.777671036757729*std::exp(0.493039846420288*x_51) - 2.07548484500756*std::exp(0.495119869709015*x_51) + 8.75637559190258*std::exp(0.49551984667778*x_51) + 1.04715188083993*std::exp(0.501519858837128*x_51) - 0.129559623359383*std::exp(0.348879843950272*x_54) + 1.63530462459246*std::exp(0.47735983133316*x_54) + 0.917258381660435*std::exp(0.492399841547012*x_54) + 0.150081077061096*std::exp(0.494639873504639*x_54) + 0.526073773332704*std::exp(0.498079836368561*x_55) + 19.8019014185646*std::exp(0.650959849357605*x_55) + 11.3760642404779*std::exp(0.653679847717285*x_55) - 2.56876993523019*std::exp(0.653839826583862*x_55) - 0.473089578186118*std::exp(0.344719856977463*x_56) + 0.917844852056248*std::exp(0.403919875621796*x_56) - 0.169090814286603*std::exp(0.554959833621979*x_56) + 4.26089142434815*std::exp(0.215359851717949*x_57) - 0.0594518739400698*std::exp(0.423999845981598*x_57) - 0.0595766297389855*std::exp(0.600159823894501*x_57) + 2.16172368466399*std::exp(0.636399865150452*x_57) + 0.307084590768022*std::exp(0.640799820423126*x_57) + 1.28493445486442*std::exp(0.514319837093353*x_58) - 0.0689025612460907*std::exp(0.575679838657379*x_58) + 0.432378828426191*std::exp(0.581039845943451*x_58) - 0.00652839001907661*std::exp(0.943519830703735*x_59) + 0.0566783820873039*std::exp(0.851839900016785*x_60) + 0.00253105072501642*std::exp(0.903199791908264*x_60) - 0.0171114820762323*std::exp(0.91351979970932*x_60) + 0.0018944040841744*std::exp(0.918799817562103*x_60) + 0.230780781950455*std::exp(0.99999988079071*x_66) - 0.0520007938999304*std::exp(1.11287987232208*x_66) - 0.37432065560035*std::exp(0.403839856386185*x_8) + 0.214841632723087*std::log(7.69087982177734 - 0.987919807434082*x_21) + 0.0669245935302152*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.136688728140655*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 1.33791781306571*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 2.18782817195427*std::sin(0.553839862346649*x_10 - 1.13599991798401) - 0.399961842222315*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 8.19802374761662*std::sin(0.295759916305542*x_100 + 1.93311989307404) - 5.35630464521331*std::sin(0.307359933853149*x_103 + 1.91287982463837) + 0.546494498556377*std::sin(0.232399985194206*x_106 + 8.18399906158447) + 6.3208977996572*std::sin(0.270639955997467*x_107 - 7.45351982116699) + 0.262282015001817*std::sin(0.25231996178627*x_108 - 7.43975973129272) + 8.17346426309577*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 1.3010815879168*std::sin(0.273759961128235*x_112 - 7.4302396774292) - 0.245884285051275*std::sin(0.286159932613373*x_112 - 7.44384002685547) - 0.300337261506852*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 3.58235769393819*std::sin(0.288799941539764*x_113 - 7.43088006973267) + 0.625595983084352*std::sin(0.257279962301254*x_114 + 1.93927979469299) + 1.84066995610275*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 8.57540409288985*std::sin(0.244879975914955*x_116 - 7.41983985900879) - 3.26931849433085*std::sin(0.246159970760345*x_117 + 5.15112018585205) + 0.393242918462406*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 5.12747528559105*std::sin(0.262239962816238*x_117 - 7.46135997772217) - 0.27634186167343*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 0.763637968560817*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 0.739781975603123*std::sin(0.263999968767166*x_120 - 1.20231986045837) + 0.15536719202622*std::sin(0.275759935379028*x_120 + 5.14535999298096) - 2.70053897407448*std::sin(0.276079952716827*x_120 + 5.14111995697021) - 0.108152887043919*std::sin(0.438399881124496*x_15 - 4.26543998718262) - 0.138409293090559*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 0.419141392513573*std::sin(0.332959830760956*x_18 - 4.39271974563599) + 0.291644702393431*std::sin(0.261759966611862*x_20 - 1.18231987953186) + 3.43568257281571*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 0.626324926142836*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.0658272012451611*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 3.63987448182456*std::sin(0.181600019335747*x_23 + 4.97295999526978) - 0.190451029989726*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 0.494669085949822*std::sin(0.253439962863922*x_24 - 4.38711977005005) + 0.238123081338856*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.231300256649281*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 0.576562414152058*std::sin(0.41967985033989*x_3 - 4.21216011047363) - 0.13951691810294*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.0733256416263517*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 0.819313285237362*std::sin(0.383039832115173*x_31 + 5.17232036590576) + 0.315034718933804*std::sin(0.38647985458374*x_31 - 7.41648006439209) + 0.622212854369528*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 6.28938837416757*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.228033809203696*std::sin(0.390079826116562*x_32 + 5.18871974945068) - 0.182046167166792*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 10.4774057980673*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 4.84333415529875*std::sin(0.0688000917434692*x_4 - 7.74391984939575) - 0.532131275518786*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.137853988509509*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.446339506225808*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 2.23139814786373*std::sin(0.206719994544983*x_5 + 8.2021598815918) + 0.0712690357563916*std::sin(0.434879869222641*x_5 - 7.41791963577271) + 8.90511595772297*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 4.77638866400208*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.246903618738372*std::sin(0.254079967737198*x_53 + 1.98175978660583) + 0.571319458832009*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 5.66241701681562*std::sin(0.428879857063293*x_56 - 1.06575977802277) + 0.846753245280313*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.267735135956591*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.412858305580777*std::sin(0.307599931955338*x_7 - 1.15295994281769) - 0.207722222311455*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 0.609911507635657*std::sin(0.377679854631424*x_8 + 2.00887989997864) - 0.170678078199803*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 1.82361372242716*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.52156397474155*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 1.48284792216474*std::sin(0.36847984790802*x_91 + 2.00039982795715) + 0.0757605728392216*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 4.26009704424087*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 1.71021566235592*std::sin(0.298399955034256*x_92 + 1.9864798784256) + 0.572632339912645*std::sin(0.300079941749573*x_92 + 1.9832798242569) + 1.72605503657079*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.116605175369719*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 2.80615524920286*std::sin(0.321039855480194*x_94 + 8.23744010925293) + 0.195284727089595*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 5.02842507407181*std::sin(0.343759834766388*x_94 - 4.37103986740112) + 0.410228982191598*std::sin(0.27991995215416*x_95 + 1.97951984405518) - 0.937485908664028*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 5.24585387377733*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.320243145277637*std::sin(0.304719924926758*x_95 + 1.95855987071991) - 0.33179245154915*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 1.38538562704422*std::sin(0.273839950561523*x_97 + 1.97855985164642) + 0.3932953223246*std::sin(0.274719953536987*x_97 + 1.97439980506897) - 0.461568151283247*std::sin(0.25655996799469*x_98 - 7.43255996704102) - 8459.55572814144);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00404247424226929*x_1 - 0.0425196255393335*x_10 - 0.398590392200087*x_100 - 0.117784736912995*x_101 + 0.877030643114242*x_102 + 0.132586420437324*x_103 + 94.5240422190042*x_104 + 0.662700417699064*x_105 + 1.02544717963296*x_106 + 0.128352357748331*x_107 + 0.154220489601482*x_108 + 0.512931323191823*x_109 + 0.643053737787698*x_110 + 0.641437647191774*x_111 + 0.327163904737281*x_112 + 0.0991398696057229*x_113 + 0.0895062861701624*x_114 + 0.630929927343802*x_115 - 0.144671345009719*x_116 + 0.00198908579767442*x_117 + 0.578704278543324*x_118 + 0.00259561391940474*x_119 - 0.101056838895212*x_12 - 0.00249993944293362*x_120 + 0.331037653457676*x_13 - 0.115027999171525*x_14 - 0.114065614003902*x_15 + 0.354434431583853*x_16 + 0.806191848290454*x_17 + 2.12360922587685*x_18 - 0.00169250659803589*x_19 + 0.154614915823525*x_2 + 0.0704563649626217*x_20 + 0.0103316220633014*x_21 - 0.0340498741069054*x_22 - 0.0120120111159004*x_24 + 0.104627926838836*x_25 - 0.0766783900660956*x_26 + 0.290799573337603*x_27 - 0.0552641190672597*x_28 + 0.226483792515708*x_29 - 0.0796187780453156*x_3 + 0.0676052895123177*x_30 - 0.00137485823008115*x_31 - 0.00463927059381945*x_32 - 0.462526435869269*x_33 + 3.96946638702276*x_34 - 0.645962272260993*x_35 + 0.0857568101130271*x_36 - 3.94876299587941*x_37 + 19.9924494236798*x_38 - 3.33395385952486*x_39 - 55.9524051876791*x_40 + 0.0478941917786581*x_41 + 0.169273980234217*x_42 + 0.871123764169134*x_43 - 0.250937182484394*x_44 - 0.717763712614153*x_45 - 0.562121144370853*x_46 + 1.85222081943379*x_47 - 0.583422065037676*x_48 + 0.206053374765216*x_49 - 0.422166361935887*x_5 - 0.395398118928257*x_50 + 0.470826821982744*x_52 + 0.189957704926442*x_53 - 0.00486825551641304*x_55 + 0.0259783507463427*x_56 - 0.123482987558285*x_58 + 0.268517509025057*x_59 - 0.226807035814289*x_6 - 0.25683606698298*x_60 - 0.0618658845188434*x_61 + 0.0862760352625934*x_62 + 0.121569496146617*x_63 - 0.0333174110868568*x_64 + 0.281033567668227*x_65 + 0.0741235701639763*x_66 + 0.392185379750576*x_67 + 0.552147790401859*x_68 + 0.171165339936446*x_69 - 0.193515352278742*x_7 - 0.194999558974335*x_70 + 0.0152499415869956*x_71 + 0.00821572051689134*x_72 - 0.258553643022864*x_73 + 0.0194174920335811*x_74 + 0.533492574026535*x_75 + 0.373835236729388*x_76 + 0.710249306954346*x_77 + 0.0378713440796339*x_78 + 0.0283036814635895*x_79 + 0.0585241261273005*x_8 + 0.136975805450885*x_80 - 0.042641388368844*x_81 + 0.362286081734517*x_82 + 0.134820278277769*x_83 + 0.554603841862072*x_84 + 2.07232058588796*x_85 - 18.6087032921262*x_86 + 0.0602935344438555*x_87 - 14.6057853511097*x_88 + 0.108413081000125*x_89 + 0.0399532828064991*x_9 + 0.874901438509011*x_90 + 0.415218204478382*x_91 - 0.0137496575386292*x_92 - 0.31649915614242*x_93 + 0.0578247418224216*x_94 + 0.130308927590318*x_95 + 0.0768904012153313*x_96 + 0.648676530972693*x_97 + 0.0833404629270366*x_98 + 1.55994202861155*x_99 + 0.00133421168990219*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) + 0.000402863080736854*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) + 0.000316203348326882*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) + 0.0111961200528845*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) + 0.00046493567413794*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) + 0.430304881303408*std::exp(0.619999825954437*x_1) + 0.00857534312044603*std::exp(1.67199981212616*x_1) + 0.0026181204980962*std::exp(0.867839872837067*x_10) + 0.0109302990172554*std::exp(0.883439898490906*x_11) - 0.0188188358572808*std::exp(0.935519814491272*x_11) + 0.0106075218122368*std::exp(0.981679856777191*x_11) - 0.0076557962465022*std::exp(0.982479810714722*x_11) - 0.0106980695299841*std::exp(1.03247976303101*x_11) + 0.22661309883477*std::exp(0.478879868984222*x_12) - 0.00562692415463192*std::exp(0.848559856414795*x_12) + 0.000445175923905704*std::exp(1.19295990467072*x_12) - 0.143535902851107*std::exp(0.269119828939438*x_13) - 0.00145879645079388*std::exp(0.856879889965057*x_14) - 0.000766227720383308*std::exp(0.778239846229553*x_15) - 0.00680342040615666*std::exp(0.980319857597351*x_15) + 0.0157768745554751*std::exp(0.480959862470627*x_16) + 0.0689434470964621*std::exp(0.682639837265015*x_16) + 0.0290776919727223*std::exp(0.704719841480255*x_16) + 0.0277936081286116*std::exp(0.726879835128784*x_17) + 0.489004715996325*std::exp(0.736799836158752*x_19) - 0.342175321441473*std::exp(0.765119850635529*x_19) + 0.498963786885642*std::exp(0.769039869308472*x_19) + 0.154185947072876*std::exp(0.808799862861633*x_19) - 0.0847689034148244*std::exp(0.504639863967896*x_2) + 0.0110242919104752*std::exp(0.695039868354797*x_20) - 0.0358128176021259*std::exp(0.969119846820831*x_20) - 0.000301772848820177*std::exp(1.11439990997314*x_20) - 0.175307589287807*std::exp(0.497599840164185*x_22) - 0.00566351397813688*std::exp(0.944959819316864*x_22) + 0.0254390677490201*std::exp(0.613439857959747*x_23) - 0.0146869456926166*std::exp(0.662079870700836*x_23) - 0.0414175680361592*std::exp(0.772399842739105*x_23) + 0.883063295457468*std::exp(0.61983984708786*x_24) + 0.159798335745359*std::exp(0.659039855003357*x_24) + 0.0279816994108532*std::exp(0.740079820156097*x_24) - 0.105741397117105*std::exp(0.442479848861694*x_25) - 0.0299273578362743*std::exp(0.453039854764938*x_25) - 0.0194615945021231*std::exp(0.923359870910645*x_25) + 0.0032169630084187*std::exp(1.03015983104706*x_25) + 0.054813902837301*std::exp(0.515279829502106*x_26) + 0.114175147505642*std::exp(0.741679847240448*x_26) + 0.00825884298800021*std::exp(0.549279868602753*x_27) + 0.018729699142918*std::exp(0.836879849433899*x_27) - 0.0183072041718518*std::exp(0.928959846496582*x_27) + 0.597876422388645*std::exp(0.357039839029312*x_28) + 0.005587009721274*std::exp(1.05983984470367*x_28) + 0.39345799620478*std::exp(0.310319840908051*x_29) - 0.0371461862243774*std::exp(0.593839824199677*x_29) + 0.000389205598311256*std::exp(1.26631987094879*x_29) - 0.00557630367225065*std::exp(1.27407991886139*x_29) + 0.0782546060035657*std::exp(0.871119856834412*x_3) - 0.0513520795589928*std::exp(0.819999873638153*x_30) + 0.0291418287862407*std::exp(0.877279877662659*x_30) - 0.0468603238554785*std::exp(0.682399809360504*x_32) + 1.12789756734371*std::exp(0.28167986869812*x_33) + 0.0864801202794037*std::exp(0.442239850759506*x_33) - 0.311336065297977*std::exp(0.339919835329056*x_36) + 0.0784276705956955*std::exp(0.329519838094711*x_38) - 0.172871729589146*std::exp(0.336719840764999*x_4) + 0.134925503700193*std::exp(0.454319834709167*x_4) - 0.244060682671983*std::exp(0.461599856615067*x_4) + 0.00823595927160713*std::exp(1.0719997882843*x_4) + 0.0272833523612279*std::exp(0.618799805641174*x_41) - 0.367523528206949*std::exp(0.789759874343872*x_41) - 0.0752600959465046*std::exp(0.790239870548248*x_41) - 0.0364688648388173*std::exp(0.829279899597168*x_41) + 0.0159735048589155*std::exp(0.542079865932465*x_42) + 0.0306364547216223*std::exp(0.756079852581024*x_46) - 0.046501385513518*std::exp(0.769599854946136*x_46) - 0.0556581814493683*std::exp(0.50087982416153*x_47) + 0.231901141655796*std::exp(0.568239867687225*x_47) + 0.0566538657549956*std::exp(0.499679833650589*x_48) - 0.0498575804995888*std::exp(0.530479848384857*x_48) - 0.00632241028835671*std::exp(0.66815984249115*x_49) + 0.0158829760629502*std::exp(0.675759792327881*x_49) - 0.0166661834361651*std::exp(0.769919812679291*x_49) + 0.722092614405462*std::exp(0.279839843511581*x_50) + 0.133640534441082*std::exp(0.558319866657257*x_50) + 22.9032290311748*std::exp(0.491999834775925*x_51) + 2.35288574753461*std::exp(0.493039846420288*x_51) + 4.10691000996616*std::exp(0.495119869709015*x_51) + 4.30826440314567*std::exp(0.49551984667778*x_51) + 0.699655138301953*std::exp(0.501519858837128*x_51) + 0.256368874647291*std::exp(0.348879843950272*x_54) + 0.804593707577634*std::exp(0.47735983133316*x_54) + 0.330751021463979*std::exp(0.492399841547012*x_54) + 0.100276758939173*std::exp(0.494639873504639*x_54) + 0.189695119035299*std::exp(0.498079836368561*x_55) + 9.74282408295656*std::exp(0.650959849357605*x_55) - 34.4188971291177*std::exp(0.653679847717285*x_55) + 5.0830084284516*std::exp(0.653839826583862*x_55) - 0.316095076856974*std::exp(0.344719856977463*x_56) + 0.330962494791834*std::exp(0.403919875621796*x_56) + 0.511593396396368*std::exp(0.554959833621979*x_56) + 2.0964206773135*std::exp(0.215359851717949*x_57) + 0.179874857421742*std::exp(0.423999845981598*x_57) + 0.117888529816847*std::exp(0.600159823894501*x_57) + 0.77948845289503*std::exp(0.636399865150452*x_57) + 0.205178747949977*std::exp(0.640799820423126*x_57) + 0.632206477916162*std::exp(0.514319837093353*x_58) + 0.13634241617064*std::exp(0.575679838657379*x_58) + 0.155909983512478*std::exp(0.581039845943451*x_58) - 0.00321206303154112*std::exp(0.943519830703735*x_59) + 0.0204374614014062*std::exp(0.851839900016785*x_60) - 0.00765783074808477*std::exp(0.903199791908264*x_60) - 0.00841909855742939*std::exp(0.91351979970932*x_60) - 0.0037485925830445*std::exp(0.918799817562103*x_60) + 0.113547508026804*std::exp(0.99999988079071*x_66) - 0.0187507860851654*std::exp(1.11287987232208*x_66) - 0.184171217755489*std::exp(0.403839856386185*x_8) + 0.143546561875361*std::log(7.69087982177734 - 0.987919807434082*x_21) - 0.202483974372118*std::sin(0.536399841308594*x_1 - 4.00568008422852) - 0.2704757431502*std::sin(0.268559962511063*x_10 + 1.97279977798462) - 0.893930565054517*std::sin(0.27551993727684*x_10 + 1.97495973110199) + 1.07644334513772*std::sin(0.553839862346649*x_10 - 1.13599991798401) + 1.21010616782909*std::sin(0.281599938869476*x_100 + 1.94175982475281) - 4.03354715855963*std::sin(0.295759916305542*x_100 + 1.93311989307404) - 1.93141133196251*std::sin(0.307359933853149*x_103 + 1.91287982463837) - 1.65344863828323*std::sin(0.232399985194206*x_106 + 8.18399906158447) + 2.27923063512543*std::sin(0.270639955997467*x_107 - 7.45351982116699) - 0.793548410270408*std::sin(0.25231996178627*x_108 - 7.43975973129272) + 2.94724115687506*std::sin(0.245599970221519*x_109 - 7.44384002685547) - 0.869318419793973*std::sin(0.273759961128235*x_112 - 7.4302396774292) + 0.743936192161569*std::sin(0.286159932613373*x_112 - 7.44384002685547) + 0.908686615100463*std::sin(0.287119954824448*x_113 - 7.42575979232788) + 2.3935543770298*std::sin(0.288799941539764*x_113 - 7.43088006973267) - 1.8927744544158*std::sin(0.257279962301254*x_114 + 1.93927979469299) + 0.663720801391833*std::sin(0.265599936246872*x_114 + 1.91943979263306) + 4.21922378822488*std::sin(0.244879975914955*x_116 - 7.41983985900879) - 1.1788722274018*std::sin(0.246159970760345*x_117 + 5.15112018585205) - 1.18977770089869*std::sin(0.24967996776104*x_117 + 5.14487981796265) + 2.52279256629298*std::sin(0.262239962816238*x_117 - 7.46135997772217) + 0.836087236178186*std::sin(0.244319975376129*x_12 + 1.96343982219696) - 0.510225152895194*std::sin(0.263679951429367*x_120 + 5.15823984146118) + 0.363983513284542*std::sin(0.263999968767166*x_120 - 1.20231986045837) - 0.470071835614538*std::sin(0.275759935379028*x_120 + 5.14535999298096) - 0.97377799106237*std::sin(0.276079952716827*x_120 + 5.14111995697021) + 0.327222404400325*std::sin(0.438399881124496*x_15 - 4.26543998718262) + 0.418764795969342*std::sin(0.319279909133911*x_16 + 1.9761598110199) - 0.280049565218692*std::sin(0.332959830760956*x_18 - 4.39271974563599) - 0.882386807751532*std::sin(0.261759966611862*x_20 - 1.18231987953186) + 1.23886087399685*std::sin(0.0904800817370415*x_21 - 4.52415990829468) - 0.418479363729868*std::sin(0.383919835090637*x_22 + 2.00487995147705) + 0.130256981819024*std::sin(0.530959844589233*x_22 + 2.06007981300354) + 2.43198425231308*std::sin(0.181600019335747*x_23 + 4.97295999526978) + 0.576219883325443*std::sin(0.339119851589203*x_23 + 1.99055981636047) - 0.330513437521897*std::sin(0.253439962863922*x_24 - 4.38711977005005) - 0.720454250909392*std::sin(0.334079831838608*x_28 - 1.15431988239288) + 0.457690327937428*std::sin(0.247839972376823*x_3 - 7.5490403175354) - 0.385230512396828*std::sin(0.41967985033989*x_3 - 4.21216011047363) + 0.422115975301041*std::sin(0.420319855213165*x_3 - 4.20503997802734) - 0.145094681036497*std::sin(0.687199831008911*x_30 - 4.14775991439819) - 0.547424648118455*std::sin(0.383039832115173*x_31 + 5.17232036590576) - 0.9531545668054*std::sin(0.38647985458374*x_31 - 7.41648006439209) + 0.224361577136206*std::sin(0.411279857158661*x_31 + 1.99031984806061) - 3.09447073913111*std::sin(0.345279842615128*x_32 + 1.98999989032745) + 0.45122677521934*std::sin(0.390079826116562*x_32 + 5.18871974945068) + 0.550790516650668*std::sin(0.465439856052399*x_32 - 1.01639986038208) - 7.00048477859068*std::sin(0.151280030608177*x_33 + 4.98831987380981) + 9.5838510080448*std::sin(0.0688000917434692*x_4 - 7.74391984939575) + 1.60999193078554*std::sin(0.260479986667633*x_42 - 7.43607997894287) - 0.272781527017798*std::sin(0.302719920873642*x_43 - 4.30320024490356) + 0.883203840476824*std::sin(0.246719971299171*x_45 - 7.42984008789063) - 1.49090997047923*std::sin(0.206719994544983*x_5 + 8.2021598815918) - 0.215628319103762*std::sin(0.434879869222641*x_5 - 7.41791963577271) + 3.21106490620482*std::sin(0.333759844303131*x_50 - 7.44712018966675) + 3.19134686423498*std::sin(0.122960053384304*x_53 - 7.64232015609741) - 0.488565814263893*std::sin(0.254079967737198*x_53 + 1.98175978660583) - 1.72855789715337*std::sin(0.415839850902557*x_54 + 1.96727979183197) + 2.78599169408316*std::sin(0.428879857063293*x_56 - 1.06575977802277) + 0.305327818643015*std::sin(0.271519958972931*x_59 + 5.11528015136719) + 0.131729588755857*std::sin(0.660319864749908*x_64 - 0.970399796962738) + 0.816952198887861*std::sin(0.307599931955338*x_7 - 1.15295994281769) + 0.628474809040753*std::sin(0.33943983912468*x_8 + 8.25103950500488) - 0.40751272860676*std::sin(0.377679854631424*x_8 + 2.00887989997864) + 0.516395749142477*std::sin(0.292879939079285*x_9 + 1.96663987636566) + 1.21844856941928*std::sin(0.307519912719727*x_9 - 1.20327985286713) + 1.03205586581674*std::sin(0.362239837646484*x_91 + 2.00935983657837) + 0.990765701753564*std::sin(0.36847984790802*x_91 + 2.00039982795715) - 0.229217707273307*std::sin(0.36999985575676*x_91 - 1.19487988948822) - 2.09602983072374*std::sin(0.298239946365356*x_92 + 1.99775981903076) + 1.14268158962006*std::sin(0.298399955034256*x_92 + 1.9864798784256) - 1.73253008981174*std::sin(0.300079941749573*x_92 + 1.9832798242569) + 0.622392204708331*std::sin(0.303519934415817*x_92 - 1.17935991287231) - 0.230734983727629*std::sin(0.311359941959381*x_94 - 7.43752002716064) + 1.87493426206996*std::sin(0.321039855480194*x_94 + 8.23744010925293) - 0.590844495117077*std::sin(0.331599831581116*x_94 - 4.35911989212036) - 2.47405841870719*std::sin(0.343759834766388*x_94 - 4.37103986740112) - 1.24116995464876*std::sin(0.27991995215416*x_95 + 1.97951984405518) - 0.338044795336088*std::sin(0.283039927482605*x_95 - 7.42447996139526) - 3.50502031722997*std::sin(0.290479928255081*x_95 - 7.44815969467163) + 0.633687970368669*std::sin(0.304719924926758*x_95 + 1.95855987071991) + 1.00385599243137*std::sin(0.300079941749573*x_96 - 7.45623970031738) - 0.925646212575856*std::sin(0.273839950561523*x_97 + 1.97855985164642) - 1.1899362516157*std::sin(0.274719953536987*x_97 + 1.97439980506897) + 1.39649938513601*std::sin(0.25655996799469*x_98 - 7.43255996704102) + 18678.1542845364);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00140616462021082*x_1 + 0.0154650999520726*x_10 + 0.250222529442228*x_100 + 0.19727601036399*x_101 - 1.9036968077985*x_102 + 0.358104989174279*x_103 + 38.6607049852289*x_104 - 0.521015659847751*x_105 - 2.4106918787505*x_106 - 0.292899533238538*x_107 + 0.318766356619091*x_108 - 0.996000735109702*x_109 - 0.679653823343065*x_110 - 0.692913828018929*x_111 - 0.647176910399668*x_112 - 0.203603957914138*x_113 + 0.24984034208954*x_114 - 1.31274074413195*x_115 + 0.302481771353923*x_116 - 0.00273721764583043*x_117 - 1.40460582821913*x_118 - 0.145995341053522*x_119 - 0.0351523702981027*x_12 - 0.000869597723237301*x_120 - 0.690421156458125*x_13 - 0.249155714128555*x_14 + 0.190366107179854*x_15 - 0.913012352669151*x_16 - 1.93411194661482*x_17 - 2.46633164344938*x_18 + 0.0013671682675135*x_19 - 0.383353088581594*x_2 - 0.181493460574868*x_20 - 0.190472874720287*x_21 + 0.0123845094997757*x_22 - 0.00417834821855942*x_24 - 0.26951836821029*x_25 - 0.199980627908683*x_26 - 0.165637458297294*x_27 + 0.0974389317682136*x_28 - 0.0823759486202378*x_29 + 0.20509555895841*x_3 - 0.234866936659878*x_30 - 0.0616524906339401*x_31 + 0.00644251642429492*x_32 + 0.838274477270953*x_33 - 4.74579878579739*x_34 + 3.84047265977905*x_35 - 2.15444673674503*x_36 - 1.66505936976288*x_37 - 35.2876260968715*x_38 + 1.72159527217694*x_39 + 107.183660580313*x_40 - 0.0386878368887746*x_41 - 0.64618139820872*x_42 - 1.26549840489982*x_43 - 0.177824688463013*x_44 + 1.99367136418674*x_45 - 0.0116566755480845*x_46 - 4.38459256930542*x_47 + 0.159919806822193*x_48 - 0.293208469563417*x_49 + 0.960570190626343*x_5 + 1.08460298215113*x_50 - 0.746115475023966*x_52 + 0.303355356551323*x_53 + 0.00393246588693435*x_55 + 0.00903650475467917*x_56 + 0.03972039860183*x_58 - 0.157698628105551*x_59 + 0.937999922904471*x_6 + 0.207466323108926*x_60 + 0.277062632597294*x_61 + 0.384429714310694*x_62 + 0.468339667389796*x_63 + 0.108058498130934*x_64 + 0.253185112109199*x_65 + 0.0122103933038632*x_66 - 0.59383531193995*x_67 - 0.746770869924702*x_68 + 0.283090319755193*x_69 + 0.48302181324954*x_7 + 0.702017659902587*x_70 + 0.426901366592577*x_71 + 0.358721728147194*x_72 + 0.661590104048596*x_73 - 0.0418012089910733*x_74 - 0.948673398470439*x_75 - 0.629370972016274*x_76 - 1.14376148893432*x_77 + 0.135581194820174*x_78 + 0.579082742560644*x_79 + 0.04421546051436*x_8 + 0.0928086052260616*x_80 + 0.356754574382209*x_81 - 0.591060510154715*x_82 - 0.65381635103449*x_83 - 0.0573283679227211*x_84 + 0.578776371316459*x_85 + 8.52740273210513*x_86 - 0.43522497475878*x_87 - 1.33353051272666*x_88 + 0.284604679281437*x_89 + 0.172608846653564*x_9 - 0.882061373315312*x_90 - 1.09576052792404*x_91 - 0.00478278420890616*x_92 + 0.473717233839188*x_93 - 0.0803007372361222*x_94 - 0.335671847741699*x_95 - 0.36637174164898*x_96 - 1.74349625263998*x_97 - 0.91445257013384*x_98 - 5.57563009198398*x_99 - 0.00107774580417982*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) - 0.000325423617713115*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) + 0.000109990548996018*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.015547958643581*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) + 0.000161726718951123*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) - 1.10845233147417*std::exp(0.619999825954437*x_1) - 0.0119085075509584*std::exp(1.67199981212616*x_1) - 0.003635762124382*std::exp(0.867839872837067*x_10) - 0.00882924650820697*std::exp(0.883439898490906*x_11) + 0.0261335605769928*std::exp(0.935519814491272*x_11) - 0.00385813334405495*std::exp(0.981679856777191*x_11) - 0.0026630497008018*std::exp(0.982479810714722*x_11) + 0.027557902845221*std::exp(1.03247976303101*x_11) - 0.58374847383819*std::exp(0.478879868984222*x_12) + 0.00781406269614305*std::exp(0.848559856414795*x_12) - 0.000359602968361354*std::exp(1.19295990467072*x_12) + 0.199327112504756*std::exp(0.269119828939438*x_13) + 0.00202581847811667*std::exp(0.856879889965057*x_14) + 0.000618941294653111*std::exp(0.778239846229553*x_15) - 0.00236655288276802*std::exp(0.980319857597351*x_15) - 0.0219092142594786*std::exp(0.480959862470627*x_16) + 0.0239818067580314*std::exp(0.682639837265015*x_16) - 0.0234882970641128*std::exp(0.704719841480255*x_16) - 0.0385967520621767*std::exp(0.726879835128784*x_17) - 1.25966132642079*std::exp(0.736799836158752*x_19) - 0.119024835307339*std::exp(0.765119850635529*x_19) - 0.69290685402608*std::exp(0.769039869308472*x_19) - 0.0560800113463176*std::exp(0.808799862861633*x_19) + 0.0308318699308657*std::exp(0.504639863967896*x_2) - 0.00890517182579861*std::exp(0.695039868354797*x_20) + 0.04973296145074*std::exp(0.969119846820831*x_20) - 0.00010497093560031*std::exp(1.11439990997314*x_20) + 0.451587036341731*std::exp(0.497599840164185*x_22) + 0.00786487467921789*std::exp(0.944959819316864*x_22) + 0.00884891650410059*std::exp(0.613439857959747*x_23) + 0.0203956391277255*std::exp(0.662079870700836*x_23) + 0.106690399873247*std::exp(0.772399842739105*x_23) - 2.27474428299343*std::exp(0.61983984708786*x_24) - 0.221910617584152*std::exp(0.659039855003357*x_24) - 0.0101774127295026*std::exp(0.740079820156097*x_24) + 0.146842197254544*std::exp(0.442479848861694*x_25) + 0.0241746377897477*std::exp(0.453039854764938*x_25) - 0.00676966728832205*std::exp(0.923359870910645*x_25) - 0.00117006332572926*std::exp(1.03015983104706*x_25) - 0.044277421821984*std::exp(0.515279829502106*x_26) - 0.294111719266787*std::exp(0.741679847240448*x_26) + 0.00287281801134814*std::exp(0.549279868602753*x_27) - 0.048247137285293*std::exp(0.836879849433899*x_27) + 0.0254230619177947*std::exp(0.928959846496582*x_27) - 0.482950951879787*std::exp(0.357039839029312*x_28) - 0.0143919676968489*std::exp(1.05983984470367*x_28) - 0.317826404715272*std::exp(0.310319840908051*x_29) + 0.0515845993482877*std::exp(0.593839824199677*x_29) - 0.0010025818242269*std::exp(1.26631987094879*x_29) - 0.00193970337608603*std::exp(1.27407991886139*x_29) - 0.108671519425133*std::exp(0.871119856834412*x_3) + 0.0713122050740604*std::exp(0.819999873638153*x_30) - 0.0235401053207681*std::exp(0.877279877662659*x_30) + 0.037852701936266*std::exp(0.682399809360504*x_32) - 0.410235235927325*std::exp(0.28167986869812*x_33) - 0.120094222573977*std::exp(0.442239850759506*x_33) + 0.25149018000985*std::exp(0.339919835329056*x_36) - 0.108911852782439*std::exp(0.329519838094711*x_38) + 0.0628763434078378*std::exp(0.336719840764999*x_4) - 0.108989747721661*std::exp(0.454319834709167*x_4) + 0.628692920957563*std::exp(0.461599856615067*x_4) - 0.0114372080274518*std::exp(1.0719997882843*x_4) + 0.00949044632367714*std::exp(0.618799805641174*x_41) + 0.133674462706661*std::exp(0.789759874343872*x_41) + 0.104513068255884*std::exp(0.790239870548248*x_41) + 0.0939426904346469*std::exp(0.829279899597168*x_41) + 0.00555634397332948*std::exp(0.542079865932465*x_42) + 0.010656814647767*std::exp(0.756079852581024*x_46) + 0.119786159601788*std::exp(0.769599854946136*x_46) + 0.0449594108486136*std::exp(0.50087982416153*x_47) + 0.0806662358842448*std::exp(0.568239867687225*x_47) + 0.0197069064262306*std::exp(0.499679833650589*x_48) + 0.128431616157901*std::exp(0.530479848384857*x_48) + 0.00510709897998216*std::exp(0.66815984249115*x_49) + 0.00552485375660387*std::exp(0.675759792327881*x_49) + 0.0060617700506661*std::exp(0.769919812679291*x_49) - 0.262637177886326*std::exp(0.279839843511581*x_50) + 0.046486527827973*std::exp(0.558319866657257*x_50) - 31.8055233508706*std::exp(0.491999834775925*x_51) - 0.855783953877225*std::exp(0.493039846420288*x_51) + 1.42857844189064*std::exp(0.495119869709015*x_51) - 11.0979585167819*std::exp(0.49551984667778*x_51) - 0.565165479649679*std::exp(0.501519858837128*x_51) + 0.0891772760065663*std::exp(0.348879843950272*x_54) - 2.07260900306876*std::exp(0.47735983133316*x_54) - 0.459311188050294*std::exp(0.492399841547012*x_54) - 0.0810012811470479*std::exp(0.494639873504639*x_54) - 0.263428031471504*std::exp(0.498079836368561*x_55) - 25.0972195276614*std::exp(0.650959849357605*x_55) + 12.5187293535665*std::exp(0.653679847717285*x_55) + 1.76811185129771*std::exp(0.653839826583862*x_55) + 0.255334401117018*std::exp(0.344719856977463*x_56) - 0.459604859298922*std::exp(0.403919875621796*x_56) - 0.186075086733093*std::exp(0.554959833621979*x_56) - 5.40031612116506*std::exp(0.215359851717949*x_57) - 0.0654234982930108*std::exp(0.423999845981598*x_57) + 0.041007232160881*std::exp(0.600159823894501*x_57) - 1.08246912068779*std::exp(0.636399865150452*x_57) - 0.165738717763871*std::exp(0.640799820423126*x_57) - 1.62854472460686*std::exp(0.514319837093353*x_58) + 0.0474263706738151*std::exp(0.575679838657379*x_58) - 0.21651089523186*std::exp(0.581039845943451*x_58) + 0.0082741770099589*std::exp(0.943519830703735*x_59) - 0.0283813323854972*std::exp(0.851839900016785*x_60) + 0.00278528130088142*std::exp(0.903199791908264*x_60) + 0.0216873426967084*std::exp(0.91351979970932*x_60) - 0.00130393861530281*std::exp(0.918799817562103*x_60) - 0.292494938993378*std::exp(0.99999988079071*x_66) + 0.0260390604253726*std::exp(1.11287987232208*x_66) + 0.474419474613319*std::exp(0.403839856386185*x_8) - 0.115953642091796*std::log(7.69087982177734 - 0.987919807434082*x_21) + 0.0736468127985024*std::sin(0.536399841308594*x_1 - 4.00568008422852) - 0.0940843151617798*std::sin(0.268559962511063*x_10 + 1.97279977798462) + 0.722096742973543*std::sin(0.27551993727684*x_10 + 1.97495973110199) - 2.77288542952048*std::sin(0.553839862346649*x_10 - 1.13599991798401) - 0.440135880801311*std::sin(0.281599938869476*x_100 + 1.94175982475281) + 10.39029522155*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 2.68213482628387*std::sin(0.307359933853149*x_103 + 1.91287982463837) + 0.601386962663014*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 3.16514859493517*std::sin(0.270639955997467*x_107 - 7.45351982116699) + 0.288626847625633*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 4.09280924135388*std::sin(0.245599970221519*x_109 - 7.44384002685547) + 0.702215612799695*std::sin(0.273759961128235*x_112 - 7.4302396774292) - 0.270582052965166*std::sin(0.286159932613373*x_112 - 7.44384002685547) - 0.33050454112394*std::sin(0.287119954824448*x_113 - 7.42575979232788) - 1.93345869058396*std::sin(0.288799941539764*x_113 - 7.43088006973267) + 0.688433770358383*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 0.921703547495097*std::sin(0.265599936246872*x_114 + 1.91943979263306) - 10.868592591613*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 1.63709004111537*std::sin(0.246159970760345*x_117 + 5.15112018585205) + 0.432742076905736*std::sin(0.24967996776104*x_117 + 5.14487981796265) - 6.49863718362383*std::sin(0.262239962816238*x_117 - 7.46135997772217) - 0.304098931073288*std::sin(0.244319975376129*x_12 + 1.96343982219696) + 0.412148253445533*std::sin(0.263679951429367*x_120 + 5.15823984146118) - 0.937610497692525*std::sin(0.263999968767166*x_120 - 1.20231986045837) + 0.170972999649494*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 1.35227738373227*std::sin(0.276079952716827*x_120 + 5.14111995697021) - 0.119016268991532*std::sin(0.438399881124496*x_15 - 4.26543998718262) - 0.152311770010397*std::sin(0.319279909133911*x_16 + 1.9761598110199) + 0.226217658083144*std::sin(0.332959830760956*x_18 - 4.39271974563599) + 0.320938860706665*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 1.72039577488196*std::sin(0.0904800817370415*x_21 - 4.52415990829468) + 0.338038095310624*std::sin(0.383919835090637*x_22 + 2.00487995147705) + 0.0453095674560278*std::sin(0.530959844589233*x_22 + 2.06007981300354) - 1.96450146824448*std::sin(0.181600019335747*x_23 + 4.97295999526978) - 0.209580822431186*std::sin(0.339119851589203*x_23 + 1.99055981636047) + 0.266981224351576*std::sin(0.253439962863922*x_24 - 4.38711977005005) + 0.26204127764254*std::sin(0.334079831838608*x_28 - 1.15431988239288) + 0.15920644327891*std::sin(0.247839972376823*x_3 - 7.5490403175354) + 0.311180430751703*std::sin(0.41967985033989*x_3 - 4.21216011047363) - 0.153530650060836*std::sin(0.420319855213165*x_3 - 4.20503997802734) - 0.0504708242592939*std::sin(0.687199831008911*x_30 - 4.14775991439819) + 0.44219715812678*std::sin(0.383039832115173*x_31 + 5.17232036590576) + 0.346678279934142*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.311569053033118*std::sin(0.411279857158661*x_31 + 1.99031984806061) + 7.97126282899388*std::sin(0.345279842615128*x_32 + 1.98999989032745) + 0.156958112526914*std::sin(0.390079826116562*x_32 + 5.18871974945068) - 0.200331735865748*std::sin(0.465439856052399*x_32 - 1.01639986038208) + 5.65483210381995*std::sin(0.151280030608177*x_33 + 4.98831987380981) + 3.33371875866777*std::sin(0.0688000917434692*x_4 - 7.74391984939575) - 0.585581030307893*std::sin(0.260479986667633*x_42 - 7.43607997894287) - 0.0948863763505852*std::sin(0.302719920873642*x_43 - 4.30320024490356) + 0.307220261276337*std::sin(0.246719971299171*x_45 - 7.42984008789063) + 1.20432310498767*std::sin(0.206719994544983*x_5 + 8.2021598815918) + 0.0784276311265311*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 4.45917908415641*std::sin(0.333759844303131*x_50 - 7.44712018966675) - 2.57789728469836*std::sin(0.122960053384304*x_53 - 7.64232015609741) - 0.169946404476462*std::sin(0.254079967737198*x_53 + 1.98175978660583) + 0.628705458087634*std::sin(0.415839850902557*x_54 + 1.96727979183197) - 7.17663015910969*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.424006198091216*std::sin(0.271519958972931*x_59 + 5.11528015136719) - 0.339331427843151*std::sin(0.660319864749908*x_64 - 0.970399796962738) + 0.284174792375342*std::sin(0.307599931955338*x_7 - 1.15295994281769) - 0.228586814109731*std::sin(0.33943983912468*x_8 + 8.25103950500488) + 0.329179497323997*std::sin(0.377679854631424*x_8 + 2.00887989997864) - 0.18782178285945*std::sin(0.292879939079285*x_9 + 1.96663987636566) - 0.984234993021832*std::sin(0.307519912719727*x_9 - 1.20327985286713) + 0.35899806841512*std::sin(0.362239837646484*x_91 + 2.00935983657837) - 0.800317960089568*std::sin(0.36847984790802*x_91 + 2.00039982795715) + 0.0833703192067712*std::sin(0.36999985575676*x_91 - 1.19487988948822) + 5.3993093121966*std::sin(0.298239946365356*x_92 + 1.99775981903076) - 0.923032153028745*std::sin(0.298399955034256*x_92 + 1.9864798784256) + 0.630150211086075*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 0.864310869585505*std::sin(0.303519934415817*x_92 - 1.17935991287231) - 0.0802605907466654*std::sin(0.311359941959381*x_94 - 7.43752002716064) - 1.51452917805496*std::sin(0.321039855480194*x_94 + 8.23744010925293) + 0.214900038681307*std::sin(0.331599831581116*x_94 - 4.35911989212036) + 6.37309949660003*std::sin(0.343759834766388*x_94 - 4.37103986740112) + 0.45143430034199*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.469439991062724*std::sin(0.283039927482605*x_95 - 7.42447996139526) + 2.83127555323439*std::sin(0.290479928255081*x_95 - 7.44815969467163) + 0.220426785869986*std::sin(0.304719924926758*x_95 + 1.95855987071991) - 0.365119237611271*std::sin(0.300079941749573*x_96 - 7.45623970031738) + 0.747715920426167*std::sin(0.273839950561523*x_97 + 1.97855985164642) + 0.432799744457011*std::sin(0.274719953536987*x_97 + 1.97439980506897) - 0.507930215757842*std::sin(0.25655996799469*x_98 - 7.43255996704102) + 15408.22315284);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00249788106037808*x_1 - 0.018914313685916*x_10 + 0.257697201602077*x_100 + 0.11688912317772*x_101 - 1.36287651748422*x_102 + 0.661312358527922*x_103 + 123.409358611753*x_104 - 0.250885549898023*x_105 - 1.83067779029481*x_106 + 0.0114873340744075*x_107 + 0.289942668889401*x_108 - 0.788882385257716*x_109 - 0.0115428254529832*x_110 + 0.0642013192473362*x_111 - 0.558135146088647*x_112 - 0.183444715084619*x_113 + 0.213575404834254*x_114 - 0.770854179459933*x_115 + 0.38905054624458*x_116 - 0.00159923324452827*x_117 - 1.10538635941601*x_118 - 0.172297448270267*x_119 + 0.0624439263603883*x_12 + 0.001544734984654*x_120 - 0.731501395135209*x_13 - 0.270397847127555*x_14 + 0.0938809452959044*x_15 - 0.741566002784003*x_16 - 1.46381459991946*x_17 - 2.04790211695238*x_18 + 0.00125694680241633*x_19 - 0.309110175175552*x_2 - 0.147412441569355*x_20 - 0.228065667911573*x_21 - 0.0151466526728507*x_22 + 0.00742232931250917*x_24 - 0.218907946213732*x_25 - 0.00218854594489851*x_26 - 0.0307405599099592*x_27 + 0.0215869280268655*x_28 + 0.100748429509456*x_29 + 0.166582514903446*x_3 - 0.211080519804229*x_30 - 0.0299977413970578*x_31 + 0.001999212270642*x_32 + 0.789629913679719*x_33 - 3.55904561283088*x_34 + 3.08726170796828*x_35 - 1.57553880302106*x_36 - 0.862973332111646*x_37 - 34.4017787334784*x_38 + 0.70278020835181*x_39 + 5.35469155656885*x_40 - 0.0355688133094192*x_41 - 0.373255896140625*x_42 - 0.55255465551042*x_43 - 0.340922310250846*x_44 + 1.92571621407488*x_45 - 0.4549025590167*x_46 - 3.47971429519608*x_47 - 0.148587276163604*x_48 - 0.0986793205872623*x_49 + 0.767073352794274*x_5 + 0.877700743994083*x_50 - 0.559417145252571*x_52 + 0.529718173979689*x_53 + 0.00361542945345213*x_55 - 0.0160522557276014*x_56 - 0.0688152575845754*x_58 + 0.0596701218932952*x_59 + 0.639607901951222*x_6 + 0.190740333605835*x_60 + 0.207885719401141*x_61 + 0.343826981747237*x_62 + 0.425219229478604*x_63 - 0.0618183200747339*x_64 - 0.00159754791887134*x_65 - 0.0628396206792421*x_66 - 0.426246150027304*x_67 - 0.497744521062892*x_68 + 0.162838152969414*x_69 + 0.313370103598783*x_7 + 0.470806058239908*x_70 + 0.345227157636509*x_71 + 0.249212029146219*x_72 + 0.556566702396996*x_73 - 0.0470319498053108*x_74 - 0.747685442278386*x_75 - 0.62690611147069*x_76 - 0.865708574066358*x_77 - 0.00882485352736775*x_78 - 0.00183462163528629*x_79 - 0.0387314174001891*x_8 + 0.0610652585417215*x_80 + 0.334905214181417*x_81 - 0.500521118071316*x_82 - 0.71005309810093*x_83 - 0.129112240819744*x_84 - 1.2174915738747*x_85 - 34.9975076022237*x_86 - 0.49950758311695*x_87 - 14.5132524812058*x_88 + 0.0601253075844521*x_89 + 0.0422639899903099*x_9 - 0.798541520298313*x_90 - 0.905361194961668*x_91 + 0.00849603660879403*x_92 + 0.72000700441774*x_93 - 0.0249185580061015*x_94 - 0.272639060850839*x_95 - 0.233334310545681*x_96 - 1.35573828177456*x_97 - 0.741745477822793*x_98 - 4.0390470299443*x_99 - 0.000990857654153433*std::pow(-4.96695995330811*x_1 - 6.95239973068237, 2) - 0.000299187880113093*std::pow(-7.93319988250732*x_17 - 9.54767990112305, 2) - 0.000195384882544229*std::pow(-8.34375953674316*x_2 - 9.96744060516357, 2) - 0.00482477151109217*std::pow(-1.39039993286133*x_52 - 3.17391991615295, 2) - 0.000287287919507271*std::pow(-4.87760019302368*x_61 - 8.3318395614624, 2) - 0.900306071790659*std::exp(0.619999825954437*x_1) - 0.00369539367119493*std::exp(1.67199981212616*x_1) - 0.00112823309612213*std::exp(0.867839872837067*x_10) - 0.00811743033388295*std::exp(0.883439898490906*x_11) + 0.00810964715341149*std::exp(0.935519814491272*x_11) + 0.00471862092955744*std::exp(0.981679856777191*x_11) + 0.00473058510708443*std::exp(0.982479810714722*x_11) + 0.0223830529765525*std::exp(1.03247976303101*x_11) - 0.474131616193274*std::exp(0.478879868984222*x_12) + 0.00242482424519466*std::exp(0.848559856414795*x_12) - 0.000330611682527777*std::exp(1.19295990467072*x_12) + 0.0618542791273922*std::exp(0.269119828939438*x_13) + 0.000628642737218538*std::exp(0.856879889965057*x_14) + 0.000569042084784907*std::exp(0.778239846229553*x_15) + 0.00420389443688543*std::exp(0.980319857597351*x_15) - 0.00679876729883044*std::exp(0.480959862470627*x_16) - 0.0426007737881733*std::exp(0.682639837265015*x_16) - 0.0215946643807324*std::exp(0.704719841480255*x_16) - 0.0119771678095606*std::exp(0.726879835128784*x_17) - 1.02312089421857*std::exp(0.736799836158752*x_19) + 0.211433197476018*std::exp(0.765119850635529*x_19) - 0.215019690094541*std::exp(0.769039869308472*x_19) + 0.0685876540986614*std::exp(0.808799862861633*x_19) - 0.0377083666580249*std::exp(0.504639863967896*x_2) - 0.00818723453241283*std::exp(0.695039868354797*x_20) + 0.0154329054424671*std::exp(0.969119846820831*x_20) + 0.000186468147582088*std::exp(1.11439990997314*x_20) + 0.366787582303789*std::exp(0.497599840164185*x_22) + 0.00244059198769909*std::exp(0.944959819316864*x_22) - 0.015719027930845*std::exp(0.613439857959747*x_23) + 0.00632908157718782*std::exp(0.662079870700836*x_23) + 0.0866559725486003*std::exp(0.772399842739105*x_23) - 1.84759058337349*std::exp(0.61983984708786*x_24) - 0.068862289273641*std::exp(0.659039855003357*x_24) + 0.012447302472885*std::exp(0.740079820156097*x_24) + 0.0455673999514012*std::exp(0.442479848861694*x_25) + 0.0222256721366569*std::exp(0.453039854764938*x_25) + 0.0120254936452785*std::exp(0.923359870910645*x_25) + 0.00143102500752111*std::exp(1.03015983104706*x_25) - 0.0407077644360497*std::exp(0.515279829502106*x_26) - 0.238883133827255*std::exp(0.741679847240448*x_26) - 0.00510321309277692*std::exp(0.549279868602753*x_27) - 0.0391872427988834*std::exp(0.836879849433899*x_27) + 0.00788916845468639*std::exp(0.928959846496582*x_27) - 0.444015319192029*std::exp(0.357039839029312*x_28) - 0.0116894299687708*std::exp(1.05983984470367*x_28) - 0.292203156424119*std::exp(0.310319840908051*x_29) + 0.016007497257492*std::exp(0.593839824199677*x_29) - 0.000814316031631231*std::exp(1.26631987094879*x_29) + 0.00344564801036617*std::exp(1.27407991886139*x_29) - 0.0337224495516616*std::exp(0.871119856834412*x_3) + 0.0221292777606233*std::exp(0.819999873638153*x_30) - 0.021642295842118*std::exp(0.877279877662659*x_30) + 0.0348010071563032*std::exp(0.682399809360504*x_32) + 0.501730862483389*std::exp(0.28167986869812*x_33) - 0.0372670906197003*std::exp(0.442239850759506*x_33) + 0.231214975591413*std::exp(0.339919835329056*x_36) - 0.0337970287013798*std::exp(0.329519838094711*x_38) - 0.0768997863786738*std::exp(0.336719840764999*x_4) - 0.100202965611584*std::exp(0.454319834709167*x_4) + 0.510636351206129*std::exp(0.461599856615067*x_4) - 0.00354914215571741*std::exp(1.0719997882843*x_4) - 0.0168586279200324*std::exp(0.618799805641174*x_41) - 0.163488158968622*std::exp(0.789759874343872*x_41) + 0.0324320179785145*std::exp(0.790239870548248*x_41) + 0.0763020404189871*std::exp(0.829279899597168*x_41) - 0.00987017179670243*std::exp(0.542079865932465*x_42) - 0.0189305399168882*std::exp(0.756079852581024*x_46) + 0.0972925977453159*std::exp(0.769599854946136*x_46) + 0.0413347713280866*std::exp(0.50087982416153*x_47) - 0.143293793579472*std::exp(0.568239867687225*x_47) - 0.0350069313458792*std::exp(0.499679833650589*x_48) + 0.104314602038924*std::exp(0.530479848384857*x_48) + 0.00469536331777748*std::exp(0.66815984249115*x_49) - 0.00981423324241402*std::exp(0.675759792327881*x_49) - 0.00741373936059328*std::exp(0.769919812679291*x_49) + 0.321213699460115*std::exp(0.279839843511581*x_50) - 0.0825776838325114*std::exp(0.558319866657257*x_50) - 9.86974473475402*std::exp(0.491999834775925*x_51) + 1.04665124707701*std::exp(0.493039846420288*x_51) - 2.5376964986703*std::exp(0.495119869709015*x_51) - 9.0139730446067*std::exp(0.49551984667778*x_51) - 0.51960169012242*std::exp(0.501519858837128*x_51) - 0.158412625059159*std::exp(0.348879843950272*x_54) - 1.68341246342019*std::exp(0.47735983133316*x_54) - 0.142531349975379*std::exp(0.492399841547012*x_54) - 0.0744709365691905*std::exp(0.494639873504639*x_54) - 0.0817457835206892*std::exp(0.498079836368561*x_55) - 20.3844391718374*std::exp(0.650959849357605*x_55) - 15.3108078626229*std::exp(0.653679847717285*x_55) - 3.14083645862489*std::exp(0.653839826583862*x_55) + 0.234749274582439*std::exp(0.344719856977463*x_56) - 0.142622480695912*std::exp(0.403919875621796*x_56) + 0.227575804263204*std::exp(0.554959833621979*x_56) - 4.38623949395082*std::exp(0.215359851717949*x_57) + 0.0800150385693537*std::exp(0.423999845981598*x_57) - 0.0728443790157619*std::exp(0.600159823894501*x_57) - 0.335906873362287*std::exp(0.636399865150452*x_57) - 0.152376818772107*std::exp(0.640799820423126*x_57) - 1.32273500818593*std::exp(0.514319837093353*x_58) - 0.0842472007657485*std::exp(0.575679838657379*x_58) - 0.0671866720964691*std::exp(0.581039845943451*x_58) + 0.00672044398267409*std::exp(0.943519830703735*x_59) - 0.00880716543434579*std::exp(0.851839900016785*x_60) - 0.00340648844117734*std::exp(0.903199791908264*x_60) + 0.017614872337256*std::exp(0.91351979970932*x_60) + 0.00231628894956281*std::exp(0.918799817562103*x_60) - 0.23756995413015*std::exp(0.99999988079071*x_66) + 0.00808032229798942*std::exp(1.11287987232208*x_66) + 0.385332523052262*std::exp(0.403839856386185*x_8) - 0.106605428987088*std::log(7.69087982177734 - 0.987919807434082*x_21) - 0.0900724161858473*std::sin(0.536399841308594*x_1 - 4.00568008422852) + 0.167129385523879*std::sin(0.268559962511063*x_10 + 1.97279977798462) + 0.663881113746578*std::sin(0.27551993727684*x_10 + 1.97495973110199) - 2.25219029965593*std::sin(0.553839862346649*x_10 - 1.13599991798401) + 0.538300311003632*std::sin(0.281599938869476*x_100 + 1.94175982475281) + 8.4391954530134*std::sin(0.295759916305542*x_100 + 1.93311989307404) + 0.832307828661811*std::sin(0.307359933853149*x_103 + 1.91287982463837) - 0.735515560434777*std::sin(0.232399985194206*x_106 + 8.18399906158447) - 0.982194455187937*std::sin(0.270639955997467*x_107 - 7.45351982116699) - 0.352999899844597*std::sin(0.25231996178627*x_108 - 7.43975973129272) - 1.27006186990158*std::sin(0.245599970221519*x_109 - 7.44384002685547) + 0.645602805513246*std::sin(0.273759961128235*x_112 - 7.4302396774292) + 0.330930536719642*std::sin(0.286159932613373*x_112 - 7.44384002685547) + 0.404217663307126*std::sin(0.287119954824448*x_113 - 7.42575979232788) - 1.77758274272525*std::sin(0.288799941539764*x_113 - 7.43088006973267) - 0.841976600532172*std::sin(0.257279962301254*x_114 + 1.93927979469299) - 0.286018834984674*std::sin(0.265599936246872*x_114 + 1.91943979263306) - 8.8276776765264*std::sin(0.244879975914955*x_116 - 7.41983985900879) + 0.508014304162501*std::sin(0.246159970760345*x_117 + 5.15112018585205) - 0.529257451491153*std::sin(0.24967996776104*x_117 + 5.14487981796265) - 5.27831675630104*std::sin(0.262239962816238*x_117 - 7.46135997772217) + 0.371922754569787*std::sin(0.244319975376129*x_12 + 1.96343982219696) + 0.378920752916555*std::sin(0.263679951429367*x_120 + 5.15823984146118) - 0.761545084148627*std::sin(0.263999968767166*x_120 - 1.20231986045837) - 0.209105466968492*std::sin(0.275759935379028*x_120 + 5.14535999298096) + 0.419632541203043*std::sin(0.276079952716827*x_120 + 5.14111995697021) + 0.145560717512952*std::sin(0.438399881124496*x_15 - 4.26543998718262) + 0.186282184076518*std::sin(0.319279909133911*x_16 + 1.9761598110199) + 0.207979931025506*std::sin(0.332959830760956*x_18 - 4.39271974563599) - 0.392518529089289*std::sin(0.261759966611862*x_20 - 1.18231987953186) - 0.533865358966636*std::sin(0.0904800817370415*x_21 - 4.52415990829468) + 0.310785375210882*std::sin(0.383919835090637*x_22 + 2.00487995147705) - 0.0804869563460975*std::sin(0.530959844589233*x_22 + 2.06007981300354) - 1.80612284349096*std::sin(0.181600019335747*x_23 + 4.97295999526978) + 0.256324073578617*std::sin(0.339119851589203*x_23 + 1.99055981636047) + 0.245457127866374*std::sin(0.253439962863922*x_24 - 4.38711977005005) - 0.320484894332997*std::sin(0.334079831838608*x_28 - 1.15431988239288) - 0.282810955161796*std::sin(0.247839972376823*x_3 - 7.5490403175354) + 0.286092982628437*std::sin(0.41967985033989*x_3 - 4.21216011047363) + 0.187772913505424*std::sin(0.420319855213165*x_3 - 4.20503997802734) + 0.0896553036585859*std::sin(0.687199831008911*x_30 - 4.14775991439819) + 0.406547107003825*std::sin(0.383039832115173*x_31 + 5.17232036590576) - 0.423998665064522*std::sin(0.38647985458374*x_31 - 7.41648006439209) - 0.0966846854479364*std::sin(0.411279857158661*x_31 + 1.99031984806061) + 6.4744113219898*std::sin(0.345279842615128*x_32 + 1.98999989032745) - 0.278817068015046*std::sin(0.390079826116562*x_32 + 5.18871974945068) + 0.245012143804543*std::sin(0.465439856052399*x_32 - 1.01639986038208) + 5.19893805319579*std::sin(0.151280030608177*x_33 + 4.98831987380981) - 5.92194742224058*std::sin(0.0688000917434692*x_4 - 7.74391984939575) + 0.716184397778885*std::sin(0.260479986667633*x_42 - 7.43607997894287) + 0.168554150038634*std::sin(0.302719920873642*x_43 - 4.30320024490356) - 0.54573956774102*std::sin(0.246719971299171*x_45 - 7.42984008789063) + 1.10723025969838*std::sin(0.206719994544983*x_5 + 8.2021598815918) - 0.0959195104698769*std::sin(0.434879869222641*x_5 - 7.41791963577271) - 1.38375208612857*std::sin(0.333759844303131*x_50 - 7.44712018966675) - 2.37006652798672*std::sin(0.122960053384304*x_53 - 7.64232015609741) + 0.301889194849366*std::sin(0.254079967737198*x_53 + 1.98175978660583) - 0.768926957288974*std::sin(0.415839850902557*x_54 + 1.96727979183197) - 5.82899554972244*std::sin(0.428879857063293*x_56 - 1.06575977802277) - 0.131575666746553*std::sin(0.271519958972931*x_59 + 5.11528015136719) - 0.275611441432293*std::sin(0.660319864749908*x_64 - 0.970399796962738) - 0.504802084698177*std::sin(0.307599931955338*x_7 - 1.15295994281769) + 0.279569011512026*std::sin(0.33943983912468*x_8 + 8.25103950500488) + 0.302640959722485*std::sin(0.377679854631424*x_8 + 2.00887989997864) + 0.229712069696358*std::sin(0.292879939079285*x_9 + 1.96663987636566) - 0.904885709171007*std::sin(0.307519912719727*x_9 - 1.20327985286713) - 0.637716568115618*std::sin(0.362239837646484*x_91 + 2.00935983657837) - 0.735796115777686*std::sin(0.36847984790802*x_91 + 2.00039982795715) - 0.101964576657035*std::sin(0.36999985575676*x_91 - 1.19487988948822) + 4.38542174455222*std::sin(0.298239946365356*x_92 + 1.99775981903076) - 0.848617058225778*std::sin(0.298399955034256*x_92 + 1.9864798784256) - 0.770693936584024*std::sin(0.300079941749573*x_92 + 1.9832798242569) - 0.268209001316393*std::sin(0.303519934415817*x_92 - 1.17935991287231) + 0.142573214145293*std::sin(0.311359941959381*x_94 - 7.43752002716064) - 1.39242743761504*std::sin(0.321039855480194*x_94 + 8.23744010925293) - 0.262829645804455*std::sin(0.331599831581116*x_94 - 4.35911989212036) + 5.17635265856147*std::sin(0.343759834766388*x_94 - 4.37103986740112) - 0.55211864079198*std::sin(0.27991995215416*x_95 + 1.97951984405518) + 0.145674473862965*std::sin(0.283039927482605*x_95 - 7.42447996139526) + 2.60301737391104*std::sin(0.290479928255081*x_95 - 7.44815969467163) - 0.391561475598856*std::sin(0.304719924926758*x_95 + 1.95855987071991) + 0.446552548276066*std::sin(0.300079941749573*x_96 - 7.45623970031738) + 0.687434866378781*std::sin(0.273839950561523*x_97 + 1.97855985164642) - 0.529327980757546*std::sin(0.274719953536987*x_97 + 1.97439980506897) + 0.621214958918601*std::sin(0.25655996799469*x_98 - 7.43255996704102) + 1582.29265604495);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
