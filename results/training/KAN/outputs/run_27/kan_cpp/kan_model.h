
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.02768738790498*x_1 - 3.65842365481681*x_10 + 4.73375364184369*x_100 - 60.6428790356656*x_101 + 0.137369007169059*x_102 + 7.24640012073664*x_103 - 3.40970055087618*x_104 + 3.01091849388204*x_105 + 6.4201155984813*x_106 - 11.6906720792895*x_107 - 0.180877918473066*x_108 + 1.54564998643586*x_109 + 4.27303021338576*x_11 + 7.70347041078457*x_110 + 7.5819745728611*x_111 + 0.561785538552988*x_112 - 7.36669595856574*x_113 + 0.466743519861848*x_114 + 9.30913264921245*x_115 + 12.2694208709805*x_116 - 0.747748101177069*x_117 + 12.9522776052489*x_118 + 3.47399748080185*x_119 - 0.193155274981568*x_12 + 12.6335359321455*x_120 - 3.56657460233985*x_13 - 0.605620521746207*x_14 + 0.988966330353378*x_15 - 4.24069252096574*x_16 + 1.48758842774093*x_17 + 1.73483467816921*x_18 + 1.26848160444729*x_19 - 1.99441031892341*x_2 + 4.46902398778376*x_20 + 4.2013824078705*x_21 + 1.56208480530249*x_22 + 8.9452878176916*x_23 + 0.314825789581124*x_24 + 8.63815549215819*x_25 + 9.9938174706262*x_26 + 0.0377075935213744*x_27 + 2.45144540506363*x_28 + 0.513779568562893*x_29 + 8.42404594368227*x_3 + 2.00639059366778*x_30 - 2.76615870636009*x_31 + 33.5579934750305*x_32 - 20.1387891553486*x_33 + 0.653220600945877*x_34 + 0.446754746071861*x_35 - 3.61690215688031*x_36 + 8.76180605106832*x_37 + 4.52119235720158*x_38 + 4.13632491479378*x_39 - 27.2149760539539*x_4 - 4.7962580130542*x_40 - 8.4157723938809*x_41 + 10.3872827995872*x_42 - 6.75835368095683*x_43 - 0.522236848853647*x_44 + 4.5227828897676*x_45 + 3.16204854203421*x_46 + 4.38567515884219*x_47 - 15.5910174343105*x_48 - 15.5380567283656*x_49 + 3.062462069779*x_5 - 1.3590902173118*x_50 + 2.96607048402319*x_51 + 15.8238430636922*x_52 + 1.78701812337332*x_53 - 12.5464245555651*x_54 - 9.23731344565355*x_55 - 8.98299265781398*x_56 + 0.731576938409808*x_57 - 1.30869811453851*x_58 + 4.08609992126147*x_59 + 1.24490755628848*x_6 - 3.98327186993692*x_60 - 3.65886922779108*x_61 + 4.64747453803484*x_62 - 3.81079204488723*x_63 - 2.96443460636496*x_64 - 0.759408129182384*x_65 + 8.71813523991391*x_66 - 5.3524984963663*x_67 - 1.33316283751487*x_68 + 1.08639916589444*x_69 + 1.8496680443688*x_7 - 4.07213008363153*x_70 - 0.0291484990488396*x_71 + 7.14849158242715*x_72 - 4.35785417361361*x_73 + 0.142119832478506*x_74 - 4.33787014875152*x_75 + 0.803979330290888*x_76 - 2.87159072783556*x_77 + 4.29402487012755*x_78 + 4.30263210928151*x_79 + 1.78817109746012*x_8 - 5.33195724730634*x_80 - 0.966129203371421*x_81 - 0.195781420967254*x_82 + 2.79420521942106*x_83 - 7.35921293344017*x_84 + 0.0861367123960766*x_85 + 7.61006043006481*x_86 + 1.00526271273391*x_87 + 3.03853955788605*x_88 - 11.5027954013855*x_89 + 65.7305227672019*x_9 - 25.0435001349698*x_90 - 0.201137478002848*x_91 + 2.84918215460398*x_92 + 243.91019283615*x_93 + 7.52923178095431*x_94 - 7.6552426294134*x_95 + 5.57754074661854*x_96 - 1.20962215001082*x_97 - 4.79405070884946*x_98 - 5.31309007067018*x_99 + 0.00997295263246962*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) - 5.10690091595937e-5*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) + 0.0536812312852856*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 0.619786110419923*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) - 0.387402120049998*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 7.14711594042117e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) + 2.55602807639111e-5*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) + 0.0226002376686777*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) - 1.20624065879105e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) + 0.029032073486815*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.110961646448212*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) + 6.04378549467138e-6*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00629146486597833*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) - 7.60310673734043e-6*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) - 0.000100524023908968*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 6.47213795634192e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) - 0.900277433107233*std::exp(0.696079850196838*x_1) + 0.00147037366308397*std::exp(0.727999866008759*x_1) - 0.00154867284233239*std::exp(1.07999980449677*x_1) + 0.0625307014702908*std::exp(1.13711988925934*x_1) - 0.0402407191542545*std::exp(1.19479990005493*x_1) - 0.71143708980414*std::exp(0.675999820232391*x_100) + 0.60481893795815*std::exp(0.842319846153259*x_108) + 1.85883002725368*std::exp(1.03287982940674*x_108) - 2.98384801974021*std::exp(0.796239912509918*x_15) - 0.0990710333342279*std::exp(3.03135991096497*x_17) + 8.58325267433278e-6*std::exp(3.22919988632202*x_17) + 0.00912010355018623*std::exp(4.0260796546936*x_17) + 2.40156511075116*std::exp(0.833279848098755*x_29) + 1.6847689620708*std::exp(0.907439827919006*x_29) - 0.587562006152382*std::exp(0.996239840984344*x_29) - 1.21702790122254*std::exp(1.09351980686188*x_29) - 0.00255307744013125*std::exp(1.31271982192993*x_29) - 1.81014961103936e-5*std::exp(2.63991975784302*x_29) + 0.00141801209040487*std::exp(1.18919992446899*x_38) + 0.00920514737465954*std::exp(1.94679975509644*x_38) - 0.376163445277868*std::exp(1.78463983535767*x_50) + 1.64958205682631*std::exp(1.8439998626709*x_50) - 0.010087685445482*std::exp(1.87887990474701*x_50) + 0.264384862594926*std::exp(1.90823984146118*x_50) - 0.000995484978863538*std::exp(1.92663979530334*x_50) - 0.000300638699951412*std::exp(1.94135975837708*x_50) - 0.833832625372576*std::exp(1.98175978660583*x_50) + 0.807857631434085*std::exp(2.01087975502014*x_50) - 0.621666026378114*std::exp(1.01135981082916*x_6) - 0.00297677394161635*std::exp(0.731919825077057*x_67) + 0.306730445782419*std::exp(1.35455989837646*x_71) + 0.805740424592867*std::exp(1.37727987766266*x_71) + 0.526426953363536*std::exp(1.5998398065567*x_71) + 0.00194328642441336*std::exp(1.83271992206573*x_71) + 0.226810720325113*std::exp(1.84047985076904*x_71) + 0.000571877833417073*std::exp(1.90183985233307*x_71) - 0.00188536702573795*std::exp(1.13671982288361*x_77) - 0.44275537089161*std::exp(1.22487986087799*x_77) - 1.52266288499322*std::exp(1.15663981437683*x_78) + 0.493968859325948*std::exp(1.21407985687256*x_78) + 0.00171683034844785*std::exp(1.42927980422974*x_78) + 0.073609636637623*std::exp(1.84039986133575*x_78) - 0.226497363448969*std::exp(1.85511994361877*x_78) - 0.000979209333081796*std::exp(0.919999837875366*x_87) - 0.00400500089799319*std::exp(0.944319844245911*x_87) - 17.9698694952724*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 2.36825823994748*std::sin(0.608719885349274*x_100 + 8.40664005279541) - 0.0024435582028377*std::sin(0.645599842071533*x_100 + 2.22887992858887) - 0.0228686597792456*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.0735331540301712*std::sin(0.386399865150452*x_105 - 7.40151977539063) - 24.1210593141609*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 17.7787915246469*std::sin(0.487759858369827*x_105 + 2.06295967102051) + 0.00205692934774893*std::sin(0.458719849586487*x_106 - 7.34887981414795) - 0.0161019451940112*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 6.63162329692416*std::sin(0.351759850978851*x_112 + 1.95887982845306) + 10.7170618039144*std::sin(0.357119828462601*x_112 + 1.9780797958374) - 21.6411707420903*std::sin(0.37679985165596*x_112 + 1.97215986251831) + 21.7249420949373*std::sin(0.44887986779213*x_116 - 7.35751962661743) - 11.8725158469451*std::sin(0.550959885120392*x_118 - 1.03543984889984) + 35.6300099299042*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.0104370249355061*std::sin(0.400399833917618*x_14 - 4.39455986022949) + 0.00537371127605745*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 3.23121124725255*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 3.25178328340687*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.0274012234120875*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 17.8708114026834*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 2.44992509749418*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.202705129315013*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 8.18307457728758*std::sin(0.323919832706451*x_28 + 5.13184022903442) + 0.00855884091803715*std::sin(0.32847985625267*x_28 + 8.31272029876709) - 0.0243718893487461*std::sin(0.280639946460724*x_3 - 1.10511994361877) - 0.00545358139361428*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 45.3903535455828*std::sin(0.313119828701019*x_33 - 1.17847990989685) - 0.0174885384306166*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 40.7521620994718*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0343816324125981*std::sin(0.354639858007431*x_36 + 1.97199988365173) - 28.3054167879419*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 4.6719179530919*std::sin(0.374879837036133*x_36 + 1.9851998090744) + 18.7476673270293*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0275181963605828*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.135505148936412*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.125085658850284*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 16.3146932453067*std::sin(0.439759850502014*x_46 + 5.22288036346436) + 23.3714611983514*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0317801860895521*std::sin(0.321279853582382*x_53 + 5.12463998794556) - 0.00450703805850009*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.0274106153963754*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 5.15074280733404*std::sin(0.29911994934082*x_55 + 5.10295963287354) - 6.14427681061138*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.052107332493791*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 2.29289925762229*std::sin(0.479919850826263*x_73 + 5.26471996307373) - 0.0101367357337335*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.068183317202347*std::sin(0.160800024867058*x_75 + 1.76423990726471) + 44.5997780953663*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 3.3275172377127*std::sin(0.475759834051132*x_75 + 8.47544002532959) - 11.6930026026762*std::sin(0.544639825820923*x_79 - 1.05215990543365) + 13.2726275327803*std::sin(0.469119846820831*x_84 - 1.14935982227325) + 7.19542024046173*std::sin(0.698319852352142*x_85 + 8.47064018249512) + 22.3070388208873*std::sin(0.421199858188629*x_86 - 1.15927994251251) + 18.5223707926887*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 2.36393717136462*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0838992240926859*std::sin(0.353119850158691*x_92 - 7.4125599861145) - 29.7377086224183*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.0363466977308632*std::sin(0.362399846315384*x_92 + 1.98511981964111) + 0.00547450094847828*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 5.33642456945933*std::sin(0.367599844932556*x_92 + 2.00479984283447) - 25.4327723501*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 25.3418798050391*std::sin(0.298239916563034*x_96 - 7.49088001251221) + 0.00861324695491469*std::sin(0.30855992436409*x_97 - 4.27671957015991) + 28.3321482725206*std::sin(0.37255984544754*x_97 + 5.16960000991821) - 0.0183441620573588*std::sin(0.395039826631546*x_97 - 1.18751990795135) + 17.5590321454598*std::sin(0.478719830513*x_98 + 2.05727982521057) - 4.67923525478811*std::sin(0.286079943180084*x_99 + 5.10951995849609) + 2066.10203533715 - 0.000470864974984316*std::exp(-2.410799741745*x_86) + 0.000200724868336943*std::exp(-2.0842399597168*x_23) + 0.148378607025987*std::exp(-2.03023982048035*x_23) + 0.000542786628478142*std::exp(-4.36887979507446*x_111) + 1.28700666441076e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.31144257681902*x_1 - 1.13215793910032*x_10 + 10.4280182959804*x_100 - 122.019558995409*x_101 - 1.92385438914698*x_102 + 5.31750659406618*x_103 + 2.33808418328604*x_104 + 1.27189606375213*x_105 + 5.73452836611586*x_106 - 0.26495514687262*x_107 + 2.038431272893*x_108 + 13.5061044772981*x_109 - 1.92534600491617*x_11 + 2.73245576959879*x_110 + 12.3787732772977*x_111 - 7.75901752750966*x_112 - 7.7322363377387*x_113 + 2.76876215546195*x_114 + 14.361229117449*x_115 + 4.66270435422115*x_116 - 8.39113528246487*x_117 + 15.99514593156*x_118 - 4.21692805757521*x_119 + 8.85279260244553*x_12 + 12.2438358851386*x_120 - 3.62928979439268*x_13 + 0.256972762006776*x_14 - 0.414646780086953*x_15 + 0.644897655875771*x_16 - 1.14367472115808*x_17 + 9.08764200697022*x_18 + 8.50908402455963*x_19 - 4.78225701913062*x_2 + 12.082978454395*x_20 + 3.70994894482802*x_21 + 4.34825329223675*x_22 + 6.76829705487695*x_23 + 8.03244102578958*x_24 + 19.3651551615394*x_25 + 12.1224420639209*x_26 - 3.79340359168766*x_27 - 2.12830166682194*x_28 + 0.530214839474612*x_29 + 12.3759506547126*x_3 + 10.4353933659805*x_30 + 79.0753733725711*x_31 + 22.7492323874441*x_32 - 4.96988228315793*x_33 + 8.44123414049201*x_34 + 10.8005273051745*x_35 - 0.0836127599799735*x_36 + 12.4544767331691*x_37 + 7.55494272387366*x_38 - 9.62381943421399*x_39 - 59.0124591303734*x_4 + 13.8916638218721*x_40 - 13.3607973316673*x_41 + 16.5755664141382*x_42 - 7.6890041787876*x_43 - 3.18517054313416*x_44 + 11.6407426321313*x_45 + 0.625670230316208*x_46 + 2.86230460144839*x_47 - 20.8974597684915*x_48 - 3.326306903721*x_49 + 2.5728202049072*x_5 - 3.17646110806473*x_50 + 3.77482309027873*x_51 + 16.901447913131*x_52 + 6.57356986166538*x_53 - 12.0993904377743*x_54 - 16.5501750882054*x_55 - 11.2940862183495*x_56 + 12.8073118638686*x_57 + 0.359036096646588*x_58 + 4.93953571744689*x_59 - 1.32071345718293*x_6 + 5.272987634883*x_60 + 0.645731627397148*x_61 - 4.07657917276669*x_62 - 10.5882039708578*x_63 + 5.16043142731397*x_64 + 4.86086253014478*x_65 + 12.960815176423*x_66 - 6.71496506571498*x_67 - 2.39566105732568*x_68 + 1.20587673919024*x_69 - 4.87433178933133*x_7 - 11.671251839967*x_70 + 0.773648163651471*x_71 - 2.14249398472065*x_72 - 7.43548946975503*x_73 + 7.93167182846262*x_74 - 6.24606735453185*x_75 - 15.7470257722355*x_76 + 2.5451741632367*x_77 + 8.26338706515953*x_78 - 2.1590460321087*x_79 - 6.35231420035154*x_8 - 4.91735306423173*x_80 + 11.1387575598619*x_81 + 7.58531945793102*x_82 + 12.4894755433436*x_83 - 25.335459922146*x_84 + 3.71044193792673*x_85 + 21.1657639095974*x_86 - 8.20635310634696*x_87 + 9.14006517658285*x_88 - 12.6510548727209*x_89 + 22.8981444550306*x_9 - 23.154720449921*x_90 - 8.10263316740446*x_91 + 10.7556949795832*x_92 + 402.15801269151*x_93 + 5.92115485625041*x_94 - 7.12821815910792*x_95 + 0.855116736971247*x_96 - 0.774106181763884*x_97 - 10.3623760829805*x_98 - 3.02866766730656*x_99 - 0.00545486202366352*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) - 5.07074662539159e-5*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) + 0.0193770352064998*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 1.43778791362788*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) - 0.215147796898374*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 0.000113079197297163*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) + 2.53793268286497e-5*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) + 0.00815789039289919*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) - 8.37510256226184e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) + 0.0104795567575945*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.257410276637848*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) + 4.19628728424013e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) + 0.00344121485736366*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) - 5.27894647332398e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) - 0.000697952770927699*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 0.000102399929006401*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) - 0.499978436631546*std::exp(0.696079850196838*x_1) + 0.00124059467684851*std::exp(0.727999866008759*x_1) - 0.00153770901733215*std::exp(1.07999980449677*x_1) + 0.0225713824900488*std::exp(1.13711988925934*x_1) - 0.0933509458553061*std::exp(1.19479990005493*x_1) + 0.033676900016834*std::exp(0.675999820232391*x_100) + 0.818533093716235*std::exp(0.842319846153259*x_108) + 0.670972219127668*std::exp(1.03287982940674*x_108) + 0.141244746536736*std::exp(0.796239912509918*x_15) - 0.229826277039458*std::exp(3.03135991096497*x_17) + 5.95947590901075e-5*std::exp(3.22919988632202*x_17) - 0.000431713246054334*std::exp(4.0260796546936*x_17) + 0.866880482946049*std::exp(0.833279848098755*x_29) - 0.0797509670218956*std::exp(0.907439827919006*x_29) + 0.321376205425183*std::exp(0.996239840984344*x_29) - 0.675889103751132*std::exp(1.09351980686188*x_29) - 0.00215410161466417*std::exp(1.31271982192993*x_29) - 1.79733466199577e-5*std::exp(2.63991975784302*x_29) + 0.00140797327782777*std::exp(1.18919992446899*x_38) - 0.000435738918056655*std::exp(1.94679975509644*x_38) - 0.509081659456167*std::exp(1.78463983535767*x_50) + 0.595441066194309*std::exp(1.8439998626709*x_50) - 0.0085112574984094*std::exp(1.87887990474701*x_50) - 0.144609425086924*std::exp(1.90823984146118*x_50) - 0.0015750219147087*std::exp(1.92663979530334*x_50) - 0.00208737777816383*std::exp(1.94135975837708*x_50) - 0.463077621536361*std::exp(1.98175978660583*x_50) - 0.0382411053226532*std::exp(2.01087975502014*x_50) - 0.841333139381238*std::exp(1.01135981082916*x_6) - 0.00295569987892924*std::exp(0.731919825077057*x_67) - 0.167771002416319*std::exp(1.35455989837646*x_71) + 0.447476325634828*std::exp(1.37727987766266*x_71) + 1.22121212177734*std::exp(1.5998398065567*x_71) + 0.00163960417290303*std::exp(1.83271992206573*x_71) + 0.0818706875331299*std::exp(1.84047985076904*x_71) + 0.000904805335381651*std::exp(1.90183985233307*x_71) - 0.00187201957522008*std::exp(1.13671982288361*x_77) - 0.599203994370403*std::exp(1.22487986087799*x_77) - 0.549627712027384*std::exp(1.15663981437683*x_78) - 0.270183973684657*std::exp(1.21407985687256*x_78) + 0.0027163096179807*std::exp(1.42927980422974*x_78) + 0.0996197701873062*std::exp(1.84039986133575*x_78) - 0.125787666683514*std::exp(1.85511994361877*x_78) - 0.00679879138106939*std::exp(0.919999837875366*x_87) - 0.0063365739480756*std::exp(0.944319844245911*x_87) - 6.4864904460853*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 3.20508770840988*std::sin(0.608719885349274*x_100 + 8.40664005279541) - 0.0169659764131421*std::sin(0.645599842071533*x_100 + 2.22887992858887) - 0.0227067611671204*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.0620419433182559*std::sin(0.386399865150452*x_105 - 7.40151977539063) + 1.14180510752785*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 41.2434727776135*std::sin(0.487759858369827*x_105 + 2.06295967102051) + 0.0142815566074429*std::sin(0.458719849586487*x_106 - 7.34887981414795) - 0.111798123756598*std::sin(0.195439994335175*x_109 + 1.79071986675262) + 3.62726981775265*std::sin(0.351759850978851*x_112 + 1.95887982845306) + 5.95183174536659*std::sin(0.357119828462601*x_112 + 1.9780797958374) + 1.02441600778679*std::sin(0.37679985165596*x_112 + 1.97215986251831) - 1.02838144551071*std::sin(0.44887986779213*x_116 - 7.35751962661743) - 4.28556037273761*std::sin(0.550959885120392*x_118 - 1.03543984889984) - 1.6865978723973*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.0165130999932814*std::sin(0.400399833917618*x_14 - 4.39455986022949) + 0.0373104510687532*std::sin(0.45415985584259*x_14 + 8.24919986724854) - 1.76736139964074*std::sin(0.511999845504761*x_14 + 5.14152002334595) + 1.77861359574587*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.0433532682865152*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 41.4569416925022*std::sin(0.44599986076355*x_16 - 1.14847981929779) - 1.34002475171005*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.171027889516634*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 11.0745827048183*std::sin(0.323919832706451*x_28 + 5.13184022903442) + 0.0594252647514689*std::sin(0.32847985625267*x_28 + 8.31272029876709) - 0.0241993486271419*std::sin(0.280639946460724*x_3 - 1.10511994361877) - 0.0378650007942357*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 105.297134972771*std::sin(0.313119828701019*x_33 - 1.17847990989685) - 0.0173647283723383*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 94.537397879288*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0543974300597901*std::sin(0.354639858007431*x_36 + 1.97199988365173) + 1.33987769932653*std::sin(0.35607984662056*x_36 - 1.20679986476898) + 2.55537840789704*std::sin(0.374879837036133*x_36 + 1.9851998090744) + 10.4117120522557*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0232178586834913*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.114329418893079*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.105538208698783*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 37.8470384674408*std::sin(0.439759850502014*x_46 + 5.22288036346436) + 8.43627494423613*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0502815116323584*std::sin(0.321279853582382*x_53 + 5.12463998794556) - 0.0312930141401363*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.043368127959328*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 6.97076956494955*std::sin(0.29911994934082*x_55 + 5.10295963287354) + 0.290848198375034*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0824424198629557*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 3.1031004572332*std::sin(0.479919850826263*x_73 + 5.26471996307373) - 0.0100649727418217*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.107877287042372*std::sin(0.160800024867058*x_75 + 1.76423990726471) - 2.11119477634225*std::sin(0.262959957122803*x_75 - 7.51624011993408) - 1.82003746352798*std::sin(0.475759834051132*x_75 + 8.47544002532959) - 6.49383061912013*std::sin(0.544639825820923*x_79 - 1.05215990543365) + 7.37109175438132*std::sin(0.469119846820831*x_84 - 1.14935982227325) + 2.59729346713413*std::sin(0.698319852352142*x_85 + 8.47064018249512) - 1.05593583299048*std::sin(0.421199858188629*x_86 - 1.15927994251251) + 6.68592396941074*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 3.19923978035519*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0707880815702303*std::sin(0.353119850158691*x_92 - 7.4125599861145) + 1.40767729762674*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.0575064884643025*std::sin(0.362399846315384*x_92 + 1.98511981964111) + 0.0380102482755455*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 7.22206240262457*std::sin(0.367599844932556*x_92 + 2.00479984283447) + 1.20389693461303*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 58.7884237476845*std::sin(0.298239916563034*x_96 - 7.49088001251221) + 0.0598030136986087*std::sin(0.30855992436409*x_97 - 4.27671957015991) - 1.34114307267628*std::sin(0.37255984544754*x_97 + 5.16960000991821) - 0.0182142946140388*std::sin(0.395039826631546*x_97 - 1.18751990795135) + 6.33819262204403*std::sin(0.478719830513*x_98 + 2.05727982521057) - 6.33265373974254*std::sin(0.286079943180084*x_99 + 5.10951995849609) + 54.595407288781 - 0.000397281722426084*std::exp(-2.410799741745*x_86) + 0.000317579946629251*std::exp(-2.0842399597168*x_23) - 0.00702371521679722*std::exp(-2.03023982048035*x_23) - 0.00029688561409567*std::exp(-4.36887979507446*x_111) + 1.08588289971661e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-11.96783165275*x_1 - 5.12847768956207*x_10 + 0.503283792194449*x_100 - 401.205359856694*x_101 - 3.31208420290041*x_102 + 10.8708152272234*x_103 - 9.77158512365877*x_104 - 2.61493110086147*x_105 - 2.03171336942644*x_106 - 27.9984989737888*x_107 - 0.888382305507002*x_108 + 16.6094129047152*x_109 - 9.88250738907726*x_11 - 9.41935330428019*x_110 + 15.943178882954*x_111 - 5.45593065232254*x_112 + 14.5124471535428*x_113 - 1.19545905413601*x_114 - 4.50068060310926*x_115 - 25.8895174330568*x_116 + 8.44761318319969*x_117 - 13.4268501449218*x_118 - 7.55048882179327*x_119 + 4.51916218440116*x_12 + 4.10230452742628*x_120 - 2.75454667644722*x_13 + 2.35835782031717*x_14 - 2.98366481397194*x_15 + 5.93414852277997*x_16 - 2.5848926239246*x_17 - 2.76706115199147*x_18 + 4.45113038344715*x_19 + 5.2351878079936*x_2 - 8.99532223058842*x_20 - 1.41039916762746*x_21 + 16.5832232588354*x_22 - 11.9197209872211*x_23 + 10.2566252173541*x_24 - 1.15030660110164*x_25 - 3.08648870372881*x_26 - 2.14783525583386*x_27 + 7.67028105197174*x_28 + 2.03358467241974*x_29 - 6.44897629425381*x_3 + 7.57963464595167*x_30 + 16.1896373463428*x_31 + 14.1495500794889*x_32 + 8.48856709324063*x_33 + 12.3561230587468*x_34 + 32.8362011878431*x_35 + 12.2067214918318*x_36 - 23.9377681882867*x_37 - 2.42933096986424*x_38 + 1.41885442788377*x_39 + 18.2559161980311*x_4 + 3.68280211615508*x_40 - 0.646270810001279*x_41 - 4.18883685740441*x_42 + 4.14373051989889*x_43 - 7.03298717188368*x_44 + 4.63629069878266*x_45 + 3.77812061657679*x_46 - 10.2445741396008*x_47 + 1.64193250872136*x_48 + 24.6569273847375*x_49 - 5.27657172281858*x_5 - 0.348070252629007*x_50 - 15.3514341221648*x_51 - 9.0939737553873*x_52 - 2.36688833995063*x_53 + 10.4147993821367*x_54 + 1.75098723089625*x_55 + 13.6757081719575*x_56 + 20.386690678033*x_57 - 7.27261829351306*x_58 + 9.60089740287236*x_59 + 1.34629836345103*x_6 + 8.08867045412046*x_60 + 8.01176428094331*x_61 - 15.2601092686229*x_62 - 9.90501723080001*x_63 - 0.698415289520889*x_64 + 3.71015919486758*x_65 - 4.05920390826588*x_66 + 1.64578779632159*x_67 + 3.85807792676928*x_68 - 11.8781426494525*x_69 + 4.9821934701673*x_7 + 4.37404713354952*x_70 + 1.07444533558573*x_71 + 16.4708634838182*x_72 + 1.61691899904929*x_73 + 3.66132944198352*x_74 + 2.93409316061368*x_75 - 13.1898851441102*x_76 + 2.40049793696802*x_77 + 1.99070897257684*x_78 + 6.33837065028985*x_79 - 6.1426481676924*x_8 + 3.12744457717871*x_80 + 2.30888785046193*x_81 + 8.66747032765129*x_82 + 13.6068970734672*x_83 + 8.7997428634387*x_84 - 3.73274634868175*x_85 + 0.464293471169356*x_86 - 3.15638055406029*x_87 + 15.0519966902275*x_88 + 1.45909654136328*x_89 - 28.3564437497608*x_9 - 5.25954424055564*x_90 + 12.6968481269095*x_91 + 6.25083283981711*x_92 - 568.883848845692*x_93 + 11.9080058855668*x_94 + 12.4853007988093*x_95 - 4.84434983112288*x_96 + 2.91640946726247*x_97 - 1.6359188314345*x_98 - 0.24713616802859*x_99 + 0.00170191048294195*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) - 0.000416691146825795*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.092783381193712*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 0.222073676663083*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.897677033936773*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 2.28901475391025e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) + 0.000208555890940026*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.0390625627705412*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 4.94950904307339e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.0501794365866079*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.0397583301417452*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 2.47991731519419e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00107365495486345*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 3.1197460703766e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.000412475372768668*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 2.0728388058773e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 2.08609693660843*std::exp(0.696079850196838*x_1) - 0.00138350008322865*std::exp(0.727999866008759*x_1) - 0.0126362009631475*std::exp(1.07999980449677*x_1) - 0.108078927623602*std::exp(1.13711988925934*x_1) - 0.0144185297216441*std::exp(1.19479990005493*x_1) - 0.721724803517389*std::exp(0.675999820232391*x_100) + 1.85702190652981*std::exp(0.842319846153259*x_108) - 3.2128274792436*std::exp(1.03287982940674*x_108) - 3.02699586040084*std::exp(0.796239912509918*x_15) - 0.0354978407122361*std::exp(3.03135991096497*x_17) - 3.52192461935185e-5*std::exp(3.22919988632202*x_17) + 0.00925198452139807*std::exp(4.0260796546936*x_17) - 4.15089828972351*std::exp(0.833279848098755*x_29) + 1.70913151078121*std::exp(0.907439827919006*x_29) - 0.100268995000883*std::exp(0.996239840984344*x_29) + 2.82006199771635*std::exp(1.09351980686188*x_29) + 0.00240223484655074*std::exp(1.31271982192993*x_29) - 0.000147696877179095*std::exp(2.63991975784302*x_29) + 0.0115700910177664*std::exp(1.18919992446899*x_38) + 0.00933825811942662*std::exp(1.94679975509644*x_38) - 1.15496343529683*std::exp(1.78463983535767*x_50) - 2.85116039860241*std::exp(1.8439998626709*x_50) + 0.00949167820657008*std::exp(1.87887990474701*x_50) + 0.0451179691475229*std::exp(1.90823984146118*x_50) - 0.000318825078942318*std::exp(1.92663979530334*x_50) + 0.00123359625897431*std::exp(1.94135975837708*x_50) + 1.9321329419869*std::exp(1.98175978660583*x_50) + 0.819539631364037*std::exp(2.01087975502014*x_50) - 1.90874881237495*std::exp(1.01135981082916*x_6) - 0.0242886119779013*std::exp(0.731919825077057*x_67) + 0.0523443538090169*std::exp(1.35455989837646*x_71) - 1.86703850350156*std::exp(1.37727987766266*x_71) + 0.188622440972062*std::exp(1.5998398065567*x_71) - 0.00182847190303588*std::exp(1.83271992206573*x_71) - 0.392022780008657*std::exp(1.84047985076904*x_71) + 0.000183155948362686*std::exp(1.90183985233307*x_71) - 0.0153834147376384*std::exp(1.13671982288361*x_77) - 1.3594257245899*std::exp(1.22487986087799*x_77) + 2.63179154995591*std::exp(1.15663981437683*x_78) + 0.0842970794022037*std::exp(1.21407985687256*x_78) + 0.000549851160988223*std::exp(1.42927980422974*x_78) + 0.226009304915686*std::exp(1.84039986133575*x_78) + 0.5248331666051*std::exp(1.85511994361877*x_78) + 0.00401794236815703*std::exp(0.919999837875366*x_87) - 0.00128268608223949*std::exp(0.944319844245911*x_87) + 31.0593704999113*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 7.27144465209606*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.0100265343686416*std::sin(0.645599842071533*x_100 + 2.22887992858887) - 0.186593948592258*std::sin(0.384079843759537*x_105 - 7.42007970809937) - 0.0691886200596324*std::sin(0.386399865150452*x_105 - 7.40151977539063) - 24.4698611354894*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 6.37026473186012*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.00844009885875511*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.0660703341145092*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 1.1317038818786*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 24.8332669202052*std::sin(0.357119828462601*x_112 + 1.9780797958374) - 21.9541122125377*std::sin(0.37679985165596*x_112 + 1.97215986251831) + 22.039094938404*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 20.5206202834889*std::sin(0.550959885120392*x_118 - 1.03543984889984) + 36.1452365704776*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.00334267755881609*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0220496899701331*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 0.551414660929484*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 0.554925332771294*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.00877582023130903*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 6.40323609455783*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 0.41808613351605*std::sin(0.462719857692719*x_21 + 5.03983974456787) - 0.190728772093205*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 25.1251205924403*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.0351190786128107*std::sin(0.32847985625267*x_28 + 8.31272029876709) - 0.198859360895444*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0223774171663918*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 16.2636795620916*std::sin(0.313119828701019*x_33 - 1.17847990989685) - 0.14269552620822*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 14.6017832882186*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0110114435685674*std::sin(0.354639858007431*x_36 + 1.97199988365173) - 28.714726379221*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 0.797275033065392*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 43.4415547266211*std::sin(0.380639851093292*x_36 + 1.96687984466553) - 0.025892348258821*std::sin(0.392479836940765*x_36 + 1.98215985298157) + 0.12749914497124*std::sin(0.381999850273132*x_41 - 7.41328001022339) - 0.117695266023134*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 5.84566812922105*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 40.395556165551*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0101782754676723*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0184935116101789*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.00877882821253988*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 15.8147201217135*std::sin(0.29911994934082*x_55 + 5.10295963287354) - 6.23312593263273*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0166884732050626*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 7.04006419713853*std::sin(0.479919850826263*x_73 + 5.26471996307373) - 0.0827094182454083*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.021837146668355*std::sin(0.160800024867058*x_75 + 1.76423990726471) + 45.2447117870379*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 0.567849530398392*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 27.0946888283178*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 30.7549502171957*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 12.4366636724801*std::sin(0.698319852352142*x_85 + 8.47064018249512) + 22.6296090557942*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 32.0143213693458*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 7.25817734428806*std::sin(0.6629598736763*x_87 - 3.95023989677429) - 0.0789422351809501*std::sin(0.353119850158691*x_92 - 7.4125599861145) - 30.1677298248265*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.0116407972188233*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0224632553656117*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 16.3848330567909*std::sin(0.367599844932556*x_92 + 2.00479984283447) - 25.8005421566251*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 9.08017189679515*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.0353423202765372*std::sin(0.30855992436409*x_97 - 4.27671957015991) + 28.7418444135936*std::sin(0.37255984544754*x_97 + 5.16960000991821) - 0.149676879403545*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 30.3492735531089*std::sin(0.478719830513*x_98 + 2.05727982521057) - 14.3670143717447*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 7365.06435845548 + 0.000443045022116296*std::exp(-2.410799741745*x_86) + 6.42863763411792e-5*std::exp(-2.0842399597168*x_23) + 0.150524231216981*std::exp(-2.03023982048035*x_23) + 9.26279595473134e-5*std::exp(-4.36887979507446*x_111) - 1.21096689367622e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.85257851438458*x_1 + 3.35443803239741*x_10 - 9.75850903703715*x_100 + 194.361620997783*x_101 - 5.12511715744237*x_102 - 5.77849526320949*x_103 - 0.803485556475563*x_104 - 0.388315041672992*x_105 - 5.79200640559922*x_106 + 4.56560517345233*x_107 - 1.78038214909831*x_108 - 14.5508653017006*x_109 - 1.81488141781584*x_11 - 6.60921829337482*x_110 - 12.1629797553133*x_111 + 9.13228211765074*x_112 + 2.04637817251375*x_113 - 0.452805674847358*x_114 - 8.19419595934811*x_115 - 12.7252733146096*x_116 + 1.18307550579046*x_117 - 14.1512605367555*x_118 - 5.9668656452327*x_119 - 8.33219718134774*x_12 - 15.6246213384499*x_120 - 1.12500372127514*x_13 + 1.85153015156933*x_14 + 0.545523163503062*x_15 + 6.05407573422493*x_16 - 2.01937659463672*x_17 - 9.11748904740775*x_18 - 2.62057884658073*x_19 + 6.99297939178746*x_2 - 18.5803795577937*x_20 + 1.63011683184401*x_21 - 2.24542964348547*x_22 - 7.05024527813661*x_23 - 5.06455579539835*x_24 - 13.2150278953386*x_25 - 13.0620069230015*x_26 + 6.44262492352451*x_27 - 0.267930731708214*x_28 + 1.69002792947521*x_29 - 10.7595405310625*x_3 + 0.605060806401296*x_30 - 50.9694400789945*x_31 - 41.5289440194628*x_32 + 12.3580173493595*x_33 - 1.40366112529504*x_34 - 13.7457976817579*x_35 + 6.07094702435764*x_36 - 11.4474062782158*x_37 - 7.04385597827585*x_38 + 30.5661653450096*x_39 + 53.9966932464551*x_4 - 0.909248355180553*x_40 + 7.59416307519577*x_41 - 19.5096831012141*x_42 + 10.4280190031041*x_43 + 7.15066424726384*x_44 - 5.11025585090055*x_45 - 0.0740940613778444*x_46 - 0.185773084128982*x_47 + 4.47580807143195*x_48 - 5.31099624745875*x_49 - 8.50713012429132*x_5 + 3.22385540792625*x_50 - 1.17474822005701*x_51 - 16.3744804619187*x_52 - 4.02049822950028*x_53 + 14.5254379386123*x_54 + 17.1053662611111*x_55 + 12.3909821381771*x_56 - 16.7987428264925*x_57 + 2.29751076642048*x_58 - 8.58196904568264*x_59 - 1.113946070281*x_6 - 0.57184462005267*x_60 - 0.112289713461482*x_61 - 2.0011133097601*x_62 + 12.4177533093735*x_63 - 8.57009995002876*x_64 - 1.64673158651158*x_65 - 9.96974850910616*x_66 + 10.1002234054224*x_67 + 4.08844107209197*x_68 + 1.02107003351495*x_69 + 5.19968806912589*x_7 + 8.43352259802597*x_70 + 1.41668646017503*x_71 - 4.01326679956118*x_72 + 7.73195543762566*x_73 - 7.05213188243435*x_74 + 4.88003828384938*x_75 + 7.85017292533638*x_76 - 0.812202187173154*x_77 - 8.41649170980222*x_78 + 4.48264071743627*x_79 - 36.3807598466225*x_8 + 5.45613682572257*x_80 - 8.43001379855784*x_81 - 4.36116464148268*x_82 - 12.2308006782505*x_83 + 25.4073079438336*x_84 - 1.39361274634893*x_85 - 24.4467524368155*x_86 + 3.10609470907812*x_87 - 15.6751121264084*x_88 + 15.8582998360951*x_89 - 30.6909605148678*x_9 + 17.4016167931894*x_90 - 3.20484145773645*x_91 - 9.43847071455592*x_92 - 401.841326963207*x_93 - 9.18676592298514*x_94 + 7.04551139996368*x_95 - 2.56385385393577*x_96 + 6.49569176594676*x_97 + 9.97065145771307*x_98 + 3.94979002225583*x_99 + 0.00711499010088299*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) - 0.000533178722460481*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.0405383041934306*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) + 1.36748616797008*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.0123460934729101*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 4.70010124432808e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) + 0.000266858473812256*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.0170669578085444*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 3.56243731474562e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.0219240691428988*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) + 0.244824003219931*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 1.78493460750317e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00448851126553521*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 2.24545499703531e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.000296881498059104*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 4.25622081908931e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 0.0286908841367698*std::exp(0.696079850196838*x_1) + 0.00138873537226914*std::exp(0.727999866008759*x_1) - 0.0161686984175393*std::exp(1.07999980449677*x_1) - 0.0472211336614047*std::exp(1.13711988925934*x_1) + 0.0887864795732972*std::exp(1.19479990005493*x_1) + 0.487870739648917*std::exp(0.675999820232391*x_100) + 1.17029156958195*std::exp(0.842319846153259*x_108) - 1.40372743479429*std::exp(1.03287982940674*x_108) + 2.04618533564419*std::exp(0.796239912509918*x_15) + 0.218588744493272*std::exp(3.03135991096497*x_17) - 2.53492529754213e-5*std::exp(3.22919988632202*x_17) - 0.00625414633067415*std::exp(4.0260796546936*x_17) - 1.81358315875005*std::exp(0.833279848098755*x_29) - 1.1553368406605*std::exp(0.907439827919006*x_29) - 0.419183566942694*std::exp(0.996239840984344*x_29) + 0.038785384617136*std::exp(1.09351980686188*x_29) - 0.0024113251197768*std::exp(1.31271982192993*x_29) - 0.000188986094102629*std::exp(2.63991975784302*x_29) + 0.0148045534314729*std::exp(1.18919992446899*x_38) - 0.00631246546267188*std::exp(1.94679975509644*x_38) - 0.727855695590093*std::exp(1.78463983535767*x_50) - 1.24571023448152*std::exp(1.8439998626709*x_50) - 0.00952759557259926*std::exp(1.87887990474701*x_50) + 0.188619734747541*std::exp(1.90823984146118*x_50) - 0.000654652901515784*std::exp(1.92663979530334*x_50) + 0.000887887931117273*std::exp(1.94135975837708*x_50) + 0.0265733587939148*std::exp(1.98175978660583*x_50) - 0.55399149949755*std::exp(2.01087975502014*x_50) - 1.20288976436806*std::exp(1.01135981082916*x_6) - 0.0310785847104397*std::exp(0.731919825077057*x_67) + 0.218830286857676*std::exp(1.35455989837646*x_71) - 0.0256780902377146*std::exp(1.37727987766266*x_71) - 1.16150001600314*std::exp(1.5998398065567*x_71) + 0.00183539100555771*std::exp(1.83271992206573*x_71) - 0.171280012673458*std::exp(1.84047985076904*x_71) + 0.000376079489804504*std::exp(1.90183985233307*x_71) - 0.019683906124175*std::exp(1.13671982288361*x_77) - 0.856707429980365*std::exp(1.22487986087799*x_77) + 1.14986504105806*std::exp(1.15663981437683*x_78) + 0.352411534855376*std::exp(1.21407985687256*x_78) + 0.00112902554321295*std::exp(1.42927980422974*x_78) + 0.142430621448169*std::exp(1.84039986133575*x_78) + 0.00721823004001052*std::exp(1.85511994361877*x_78) + 0.0028919368964183*std::exp(0.919999837875366*x_87) - 0.00263377701734661*std::exp(0.944319844245911*x_87) + 13.5702557201828*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 4.58245018279389*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.00721665519985566*std::sin(0.645599842071533*x_100 + 2.22887992858887) - 0.238756987968524*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.0694504360354433*std::sin(0.386399865150452*x_105 - 7.40151977539063) + 16.541109842832*std::sin(0.401199847459793*x_105 + 5.20136022567749) + 39.22684146101*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.00607480920893536*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.047554499163231*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 4.73119003461226*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 0.34154135958008*std::sin(0.357119828462601*x_112 + 1.9780797958374) + 14.8405166502055*std::sin(0.37679985165596*x_112 + 1.97215986251831) - 14.8979631798574*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 8.96573434366643*std::sin(0.550959885120392*x_118 - 1.03543984889984) - 24.4334173004477*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.00686361803773461*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0158703899002068*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 2.30523866755502*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 2.31991534746991*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.0180196495102156*std::sin(0.384399831295013*x_16 - 7.41287994384766) + 39.4298726491533*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 1.74784674699286*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.191450506961421*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 15.8338018042065*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.0252771567888832*std::sin(0.32847985625267*x_28 + 8.31272029876709) - 0.254451242363129*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0161062734156927*std::sin(0.332079827785492*x_3 - 4.25880002975464) + 100.148550587559*std::sin(0.313119828701019*x_33 - 1.17847990989685) - 0.1825865966774*std::sin(0.335519850254059*x_34 + 1.98951983451843) - 89.9149191132163*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0226101205901188*std::sin(0.354639858007431*x_36 + 1.97199988365173) + 19.4105491860226*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 3.3330801030943*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 0.597468215167884*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0259903272388841*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.127981613230138*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.118140635520251*std::sin(0.301039934158325*x_43 - 7.47904014587402) - 35.9964784182016*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 17.649360508678*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0208993520504831*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0133108102778358*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.0180258258864499*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 9.96640565663801*std::sin(0.29911994934082*x_55 + 5.10295963287354) + 4.21346161896888*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0342669323310644*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 4.43663467310567*std::sin(0.479919850826263*x_73 + 5.26471996307373) - 0.105831146861329*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.0448388548187288*std::sin(0.160800024867058*x_75 + 1.76423990726471) - 30.5844705588152*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 2.37394612000484*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 0.372643554694511*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 0.422984520915057*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 5.43374523131253*std::sin(0.698319852352142*x_85 + 8.47064018249512) - 15.2971382640726*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 13.9874865683892*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 4.5740891513897*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0792409597156898*std::sin(0.353119850158691*x_92 - 7.4125599861145) + 20.3927488586198*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.023902390930289*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0161680559483177*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 10.3256897120843*std::sin(0.367599844932556*x_92 + 2.00479984283447) + 17.4406221373441*std::sin(0.36287984251976*x_95 + 5.16520023345947) - 55.9139185617951*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.0254378362474203*std::sin(0.30855992436409*x_97 - 4.27671957015991) - 19.4288804051005*std::sin(0.37255984544754*x_97 + 5.16960000991821) - 0.191519613387941*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 13.260004836178*std::sin(0.478719830513*x_98 + 2.05727982521057) - 9.05406432750967*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 49.8000664870476 - 0.00044472154442146*std::exp(-2.410799741745*x_86) + 0.000132001105243364*std::exp(-2.0842399597168*x_23) - 0.101751204421705*std::exp(-2.03023982048035*x_23) + 0.000387239529839951*std::exp(-4.36887979507446*x_111) + 1.2155493015732e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.42433179637216*x_1 - 1.36086517168028*x_10 - 1.90072176198416*x_100 - 127.947201003707*x_101 - 1.45093952636022*x_102 + 2.19967775082369*x_103 - 3.06178414121193*x_104 - 1.6750401346658*x_105 - 1.66339191154567*x_106 - 10.8268986546837*x_107 - 0.0762266012281147*x_108 + 4.3226195648697*x_109 - 4.66568913959166*x_11 - 3.86323133097961*x_110 + 3.63316232472731*x_111 - 0.620340274072042*x_112 + 8.28032651893427*x_113 - 1.6537642352782*x_114 - 4.51623406642813*x_115 - 12.9934358793819*x_116 + 4.26705882503822*x_117 - 8.92408417709793*x_118 - 3.66564303504844*x_119 + 0.614040196755234*x_12 - 1.75871790058188*x_120 - 0.32023105691278*x_13 + 1.15436444095533*x_14 - 1.13867382479863*x_15 + 2.62293406907772*x_16 - 2.06451425260392*x_17 - 3.08080334876945*x_18 + 0.409555730014089*x_19 + 3.62933600974256*x_2 - 7.31057824227696*x_20 - 0.907012462263621*x_21 + 5.86382579781534*x_22 - 6.06180771026293*x_23 + 3.22470310117974*x_24 - 3.8828724995294*x_25 - 3.87802568736152*x_26 - 0.197106708951241*x_27 + 3.13788203520364*x_28 + 0.848662981011832*x_29 - 5.34340878408209*x_3 + 2.29181500225475*x_30 + 6.42934158262566*x_31 - 1.86544135090841*x_32 + 5.08078711394271*x_33 + 3.23289457209193*x_34 + 10.3085833268158*x_35 + 5.60864277602732*x_36 - 12.170379739002*x_37 - 2.55785523442915*x_38 + 3.96251837298543*x_39 + 17.8506729952815*x_4 - 0.467272543453805*x_40 + 1.79066164810139*x_41 - 6.24865067550527*x_42 + 3.64441302592234*x_43 - 2.67977738990211*x_44 + 0.201735118531691*x_45 + 1.17823670562233*x_46 - 3.76692162881276*x_47 + 1.51558275176677*x_48 + 9.95001119795375*x_49 - 2.52011628170922*x_5 + 0.406582631454688*x_50 - 5.99379218006058*x_51 - 7.62301338068317*x_52 - 2.00522834872851*x_53 + 7.35102596699207*x_54 + 4.50849690923972*x_55 + 7.80177884098284*x_56 + 5.60267968511072*x_57 - 2.15320150455672*x_58 + 1.6907370025681*x_59 + 0.420153941542364*x_6 + 3.31395410518801*x_60 + 3.57465169484322*x_61 - 4.66717998601118*x_62 - 1.5853636897579*x_63 - 1.73327994940403*x_64 + 0.390947135350904*x_65 - 4.8229899715179*x_66 + 2.86123553696792*x_67 + 2.03172412131458*x_68 - 5.39462427351945*x_69 + 1.75429451839834*x_7 + 3.41813519787901*x_70 + 0.448549416731232*x_71 + 6.40900766828802*x_72 + 2.41086324026325*x_73 - 0.119014702601134*x_74 + 2.45797054157252*x_75 - 3.36547231088339*x_76 + 0.568657612817172*x_77 - 0.99309333432875*x_78 + 2.82952602544509*x_79 - 17.5521337304948*x_8 + 2.47488031519961*x_80 - 0.744630751060103*x_81 + 3.3400877362422*x_82 + 3.56711121862612*x_83 + 7.4082361764282*x_84 - 1.95103173864051*x_85 - 4.08414733545922*x_86 - 0.637029517385642*x_87 + 4.16347769377276*x_88 + 3.23965072604193*x_89 - 11.9314198351368*x_9 + 5.63273595553798*x_90 + 6.7650824375509*x_91 + 0.203265919835212*x_92 - 318.543426597519*x_93 + 2.53620927717772*x_94 + 6.34549354863653*x_95 - 2.42850556061241*x_96 + 2.47537150397188*x_97 + 2.05312896548534*x_98 + 1.43115953244592*x_99 - 0.00714262981961975*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) + 0.000235654664132039*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.0461153112821451*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) + 0.220000042516435*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.379664342780723*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 0.000102308763170327*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) - 0.000117946274612781*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.0194149234320415*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 0.000115191374753588*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.0249402458541887*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) + 0.0393870829402108*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 5.77158425868968e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) + 0.00450594785886382*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 7.26067647520925e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.000959966025473062*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 9.26466612408204e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 0.882295739416349*std::exp(0.696079850196838*x_1) + 0.000305962075377636*std::exp(0.727999866008759*x_1) + 0.00714625140600931*std::exp(1.07999980449677*x_1) - 0.0537175227533161*std::exp(1.13711988925934*x_1) + 0.0142838953245173*std::exp(1.19479990005493*x_1) - 0.262024188709702*std::exp(0.675999820232391*x_100) + 0.694531371355486*std::exp(0.842319846153259*x_108) - 1.59684350144365*std::exp(1.03287982940674*x_108) - 1.09895923028236*std::exp(0.796239912509918*x_15) + 0.0351663762372959*std::exp(3.03135991096497*x_17) - 8.19667840084862e-5*std::exp(3.22919988632202*x_17) + 0.00335895860355539*std::exp(4.0260796546936*x_17) - 2.06308461998684*std::exp(0.833279848098755*x_29) + 0.620504928371698*std::exp(0.907439827919006*x_29) + 0.420811976220162*std::exp(0.996239840984344*x_29) + 1.19271959121913*std::exp(1.09351980686188*x_29) - 0.000531256028174497*std::exp(1.31271982192993*x_29) + 8.35281916837596e-5*std::exp(2.63991975784302*x_29) - 0.0065433257546716*std::exp(1.18919992446899*x_38) + 0.0033902804722515*std::exp(1.94679975509644*x_38) - 0.431959545421377*std::exp(1.78463983535767*x_50) - 1.41708728012798*std::exp(1.8439998626709*x_50) - 0.00209909171535546*std::exp(1.87887990474701*x_50) - 0.189352468924638*std::exp(1.90823984146118*x_50) - 0.00142500608344917*std::exp(1.92663979530334*x_50) + 0.00287098473253615*std::exp(1.94135975837708*x_50) + 0.817178067224688*std::exp(1.98175978660583*x_50) + 0.297536132854324*std::exp(2.01087975502014*x_50) - 0.713877378382262*std::exp(1.01135981082916*x_6) + 0.0137361322444383*std::exp(0.731919825077057*x_67) - 0.219680380462033*std::exp(1.35455989837646*x_71) - 0.78964696609154*std::exp(1.37727987766266*x_71) - 0.186861160930676*std::exp(1.5998398065567*x_71) + 0.000404367925238567*std::exp(1.83271992206573*x_71) - 0.194843648692297*std::exp(1.84047985076904*x_71) + 0.000818625503058216*std::exp(1.90183985233307*x_71) + 0.00869990509953794*std::exp(1.13671982288361*x_77) - 0.508429011760929*std::exp(1.22487986087799*x_77) + 1.3080563026966*std::exp(1.15663981437683*x_78) - 0.353780553724676*std::exp(1.21407985687256*x_78) + 0.00245758976050177*std::exp(1.42927980422974*x_78) + 0.084528110266357*std::exp(1.84039986133575*x_78) + 0.221973417761165*std::exp(1.85511994361877*x_78) + 0.00935107504685555*std::exp(0.919999837875366*x_87) - 0.00573303541995689*std::exp(0.944319844245911*x_87) + 15.437166876259*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 2.71954057633769*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.0233350473327097*std::sin(0.645599842071533*x_100 + 2.22887992858887) + 0.105525962381348*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.015301114934925*std::sin(0.386399865150452*x_105 - 7.40151977539063) - 8.88385085370177*std::sin(0.401199847459793*x_105 + 5.20136022567749) + 6.31078177706033*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.0196428894691439*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.153767425230388*std::sin(0.195439994335175*x_109 + 1.79071986675262) + 4.74956936613524*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 10.5030045416334*std::sin(0.357119828462601*x_112 + 1.9780797958374) - 7.97050123994162*std::sin(0.37679985165596*x_112 + 1.97215986251831) + 8.00135445392418*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 10.1991841631648*std::sin(0.550959885120392*x_118 - 1.03543984889984) + 13.1226282399361*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.014940279704859*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0513168897853525*std::sin(0.45415985584259*x_14 + 8.24919986724854) - 2.31419386601474*std::sin(0.511999845504761*x_14 + 5.14152002334595) + 2.3289275606688*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.039224007278092*std::sin(0.384399831295013*x_16 - 7.41287994384766) + 6.34344526651264*std::sin(0.44599986076355*x_16 - 1.14847981929779) - 1.75463663591707*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.04217981021561*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 9.39686516307633*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.0817336610618048*std::sin(0.32847985625267*x_28 + 8.31272029876709) + 0.112462518722336*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0520796188955057*std::sin(0.332079827785492*x_3 - 4.25880002975464) + 16.111815902261*std::sin(0.313119828701019*x_33 - 1.17847990989685) + 0.0806997378223659*std::sin(0.335519850254059*x_34 + 1.98951983451843) - 14.4654377434274*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0492162477456948*std::sin(0.354639858007431*x_36 + 1.97199988365173) - 10.4249609364509*std::sin(0.35607984662056*x_36 - 1.20679986476898) + 3.34602817403612*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 18.3732107440961*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.00572611213089469*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.0281965310137445*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.0260283958715235*std::sin(0.301039934158325*x_43 - 7.47904014587402) - 5.79108364525668*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 20.0774494637193*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0454923574662662*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0430404916499584*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.0392374516143*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 5.91474942493394*std::sin(0.29911994934082*x_55 + 5.10295963287354) - 2.2629536322762*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0745900414094944*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 2.63300364097821*std::sin(0.479919850826263*x_73 + 5.26471996307373) + 0.0467753162639823*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.0976023183333319*std::sin(0.160800024867058*x_75 + 1.76423990726471) + 16.4262179180008*std::sin(0.262959957122803*x_75 - 7.51624011993408) - 2.38316822743195*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 11.4594523842703*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 13.0075266716558*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 6.18128601468376*std::sin(0.698319852352142*x_85 + 8.47064018249512) + 8.21574223965181*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 15.9117977426551*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 2.71457856622156*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0174581341943592*std::sin(0.353119850158691*x_92 - 7.4125599861145) - 10.9524778614225*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.0520291782191406*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0522793926526291*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 6.12797325241518*std::sin(0.367599844932556*x_92 + 2.00479984283447) - 9.36695828370167*std::sin(0.36287984251976*x_95 + 5.16520023345947) - 8.99538492525689*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.0822532179294284*std::sin(0.30855992436409*x_97 - 4.27671957015991) + 10.4348062139324*std::sin(0.37255984544754*x_97 + 5.16960000991821) + 0.0846479581168552*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 15.0842336103983*std::sin(0.478719830513*x_98 + 2.05727982521057) - 5.37330343751207*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 3189.43110943255 - 9.79797371143557e-5*std::exp(-2.410799741745*x_86) + 0.000287331466122392*std::exp(-2.0842399597168*x_23) + 0.0546482390151509*std::exp(-2.03023982048035*x_23) - 0.000388743845592576*std::exp(-4.36887979507446*x_111) + 2.67806231813251e-6*std::exp(-4.23400020599365*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.1214157667142*x_1 + 1.63815595942893*x_10 - 6.81876987283946*x_100 + 96.3971458059583*x_101 + 3.33882396887657*x_102 - 3.99597193660478*x_103 - 1.01517325896082*x_104 - 1.33536436745225*x_105 - 8.44302656978862*x_106 + 6.84602126925472*x_107 - 1.34707482503032*x_108 - 7.83401687403338*x_109 - 0.663518814513594*x_11 - 4.91759464893526*x_110 - 8.7989654525671*x_111 + 3.99848150663819*x_112 + 6.18853089838315*x_113 - 1.41096245411682*x_114 - 11.3211494162307*x_115 - 3.60101428870539*x_116 + 5.52236132468274*x_117 - 14.6528096239248*x_118 + 3.09689188721452*x_119 - 3.64972356007488*x_12 - 10.6842889407132*x_120 + 3.83633258352039*x_13 - 0.741822423782142*x_14 - 0.3110011539137*x_15 + 1.23288117260728*x_16 + 1.79647517826293*x_17 - 5.52054566412977*x_18 - 4.14215540071505*x_19 + 1.70066815726749*x_2 - 3.53728058606766*x_20 - 5.1293204008991*x_21 - 3.96093988507245*x_22 - 5.65729070328685*x_23 - 5.45025221528457*x_24 - 12.9317890535593*x_25 - 10.4807779383214*x_26 + 0.622537512760461*x_27 - 1.20827446713186*x_28 - 0.718439427915689*x_29 - 8.66165230132986*x_3 - 9.46396709236313*x_30 - 50.212997190564*x_31 - 19.8006309204604*x_32 + 10.4616895848888*x_33 - 5.29841751237846*x_34 - 4.98995609555749*x_35 - 0.35658235230185*x_36 - 8.76737970532225*x_37 - 5.42536922803276*x_38 - 3.49784119351505*x_39 + 32.6572254511396*x_4 - 3.53477933825203*x_40 + 11.9633151687355*x_41 - 11.2474573765619*x_42 + 8.01959473065644*x_43 + 1.60603602202745*x_44 - 9.15984737310921*x_45 - 2.20754575962927*x_46 - 4.34522607534131*x_47 + 30.9568458822824*x_48 + 11.7765121524634*x_49 - 1.94734223260777*x_5 + 1.9735471459977*x_50 - 4.98694776289576*x_51 - 13.8167071690094*x_52 - 3.76803746594626*x_53 + 9.63490802991851*x_54 + 10.2548248734235*x_55 + 7.99269441042352*x_56 - 5.68829699008961*x_57 + 0.651389279773308*x_58 - 3.3365921297146*x_59 + 1.00532407883564*x_6 - 1.7677646904478*x_60 + 1.3987237839055*x_61 - 0.0927831609873246*x_62 + 6.30260250733632*x_63 + 1.12267083126099*x_64 - 0.813454740778504*x_65 - 10.2253665961767*x_66 + 5.25534671257267*x_67 - 0.648579353082969*x_68 - 0.890879296397179*x_69 + 2.32827858974034*x_7 + 6.791735630914*x_70 - 0.446157576568772*x_71 + 0.641888358567473*x_72 + 4.56323707489878*x_73 - 3.64617566950249*x_74 + 5.04811253352766*x_75 + 7.27112133691998*x_76 + 0.481650508006294*x_77 - 5.59370669351409*x_78 - 1.6311216172751*x_79 + 24.0289395345789*x_8 + 3.18046078466454*x_80 - 3.2268078779963*x_81 - 4.52947630024479*x_82 - 7.39501288541849*x_83 + 13.5650477664302*x_84 - 1.8538653208302*x_85 - 12.271897149993*x_86 + 5.98958288171778*x_87 - 4.99107516229364*x_88 + 12.851475787945*x_89 - 48.7727247175314*x_9 + 17.7546743109432*x_90 + 4.79778982429567*x_91 - 6.39404486131218*x_92 - 313.038673124679*x_93 - 5.06256879764367*x_94 + 6.73158536645333*x_95 - 3.69395347995828*x_96 - 1.42923541257379*x_97 + 6.1908544623516*x_98 + 3.68472297895446*x_99 + 0.00397837825966045*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) + 6.02870440812915e-5*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.0154062653069632*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) + 0.897820112847316*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.405333850624993*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) + 2.39219498106365e-6*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) - 3.01739508657495e-5*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.00648616377060471*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 2.68684417999934e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.00833207092758557*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) + 0.160738674618506*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 1.34622471587033e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00250977097421825*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 1.69355616876745e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.000223912522448567*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) + 2.16627462951165e-6*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 0.941948687697021*std::exp(0.696079850196838*x_1) + 0.00119032418721304*std::exp(0.727999866008759*x_1) + 0.00182821067903277*std::exp(1.07999980449677*x_1) - 0.0179460223548538*std::exp(1.13711988925934*x_1) + 0.0582925728807501*std::exp(1.19479990005493*x_1) + 0.408451692492693*std::exp(0.675999820232391*x_100) - 0.854925506463316*std::exp(0.842319846153259*x_108) - 0.533475627789291*std::exp(1.03287982940674*x_108) + 1.71309282474911*std::exp(0.796239912509918*x_15) + 0.143513971727717*std::exp(3.03135991096497*x_17) - 1.91187905377095e-5*std::exp(3.22919988632202*x_17) - 0.0052360521881249*std::exp(4.0260796546936*x_17) - 0.689238088663599*std::exp(0.833279848098755*x_29) - 0.967262944087469*std::exp(0.907439827919006*x_29) - 0.234388349932458*std::exp(0.996239840984344*x_29) + 1.27336062450283*std::exp(1.09351980686188*x_29) - 0.00206681465066653*std::exp(1.31271982192993*x_29) + 2.13688440779082e-5*std::exp(2.63991975784302*x_29) - 0.00167396545985234*std::exp(1.18919992446899*x_38) - 0.00528487771963007*std::exp(1.94679975509644*x_38) + 0.531715698342468*std::exp(1.78463983535767*x_50) - 0.473422427254165*std::exp(1.8439998626709*x_50) - 0.00816637041333375*std::exp(1.87887990474701*x_50) + 0.105467560941428*std::exp(1.90823984146118*x_50) + 3.33196521507845e-5*std::exp(1.92663979530334*x_50) + 0.000669658525734495*std::exp(1.94135975837708*x_50) + 0.872428340803592*std::exp(1.98175978660583*x_50) - 0.463808847727115*std::exp(2.01087975502014*x_50) + 0.878739254175143*std::exp(1.01135981082916*x_6) + 0.00351408622942808*std::exp(0.731919825077057*x_67) + 0.122359925094175*std::exp(1.35455989837646*x_71) - 0.843035832798988*std::exp(1.37727987766266*x_71) - 0.762580346233467*std::exp(1.5998398065567*x_71) + 0.00157316530602865*std::exp(1.83271992206573*x_71) - 0.0650936285947288*std::exp(1.84047985076904*x_71) - 1.91411933748658e-5*std::exp(1.90183985233307*x_71) + 0.00222567868185719*std::exp(1.13671982288361*x_77) + 0.625844919765152*std::exp(1.22487986087799*x_77) + 0.436997211457438*std::exp(1.15663981437683*x_78) + 0.197052472152871*std::exp(1.21407985687256*x_78) - 5.74636395593813e-5*std::exp(1.42927980422974*x_78) - 0.104048917673532*std::exp(1.84039986133575*x_78) + 0.236981275351127*std::exp(1.85511994361877*x_78) + 0.00218114260899542*std::exp(0.919999837875366*x_87) + 0.000134050477524087*std::exp(0.944319844245911*x_87) + 5.15726950271272*std::sin(0.447599858045578*x_100 + 2.02311968803406) + 3.34758759713824*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.00544291065629004*std::sin(0.645599842071533*x_100 + 2.22887992858887) + 0.0269964881418194*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.0595279240928405*std::sin(0.386399865150452*x_105 - 7.40151977539063) + 13.8484310739239*std::sin(0.401199847459793*x_105 + 5.20136022567749) + 25.7542986920642*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.00458171311536464*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.0358663235365966*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 2.64546588387912*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 11.2131237893226*std::sin(0.357119828462601*x_112 + 1.9780797958374) + 12.4246724605877*std::sin(0.37679985165596*x_112 + 1.97215986251831) - 12.4727674381242*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 3.40735718275706*std::sin(0.550959885120392*x_118 - 1.03543984889984) - 20.4559729426074*std::sin(0.27455997467041*x_14 - 7.49232006072998) - 0.000349335296587933*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0119696884380788*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 1.28898442138259*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 1.29719095202697*std::sin(0.601359844207764*x_15 + 2.19391989707947) - 0.000917140139712588*std::sin(0.384399831295013*x_16 - 7.41287994384766) + 25.8875983835126*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 0.977316257768464*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.164097619777638*std::sin(0.213440001010895*x_27 + 5.01231956481934) + 11.566964488633*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.0190644145018427*std::sin(0.32847985625267*x_28 + 8.31272029876709) + 0.0287710529671828*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0121475953581859*std::sin(0.332079827785492*x_3 - 4.25880002975464) + 65.7523162544959*std::sin(0.313119828701019*x_33 - 1.17847990989685) + 0.020645246591511*std::sin(0.335519850254059*x_34 + 1.98951983451843) - 59.0334474422642*std::sin(0.292239934206009*x_36 + 1.89231991767883) + 0.00115077982760898*std::sin(0.354639858007431*x_36 + 1.97199988365173) + 16.2507628003044*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 1.86370651706339*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 19.6154429586509*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0222770412303072*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.109696644003141*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.101261664936709*std::sin(0.301039934158325*x_43 - 7.47904014587402) - 23.6334107594738*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 6.70750135963991*std::sin(0.409119844436646*x_51 - 1.1885598897934) + 0.00106370740721768*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0100392147191037*std::sin(0.5275998711586*x_54 + 5.1482400894165) + 0.000917454496690466*std::sin(0.258479982614517*x_55 - 7.53800010681152) + 7.2806936536882*std::sin(0.29911994934082*x_55 + 5.10295963287354) + 3.52756455687281*std::sin(0.484159857034683*x_55 + 5.28151988983154) - 0.00174407271838542*std::sin(0.234959989786148*x_64 - 4.33743953704834) - 3.24106593902279*std::sin(0.479919850826263*x_73 + 5.26471996307373) + 0.0119664321684845*std::sin(0.651279807090759*x_73 + 8.62351989746094) - 0.00228214835974962*std::sin(0.160800024867058*x_75 + 1.76423990726471) - 25.6057142773734*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 1.32740249803868*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 12.2342380823809*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 13.8869793099708*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 2.06505235750865*std::sin(0.698319852352142*x_85 + 8.47064018249512) - 12.8069619808548*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 5.31583482185006*std::sin(0.434399873018265*x_86 + 2.02191972732544) + 3.34147966712014*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0679196575899411*std::sin(0.353119850158691*x_92 - 7.4125599861145) + 17.0730730682388*std::sin(0.3574398458004*x_92 - 7.41207981109619) + 0.0012165520835931*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0121941926800593*std::sin(0.365919858217239*x_92 + 1.99415981769562) - 7.54315910336786*std::sin(0.367599844932556*x_92 + 2.00479984283447) + 14.601514399593*std::sin(0.36287984251976*x_95 + 5.16520023345947) - 36.7101633996087*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.0191856013831469*std::sin(0.30855992436409*x_97 - 4.27671957015991) - 16.26610993398*std::sin(0.37255984544754*x_97 + 5.16960000991821) + 0.0216553116025865*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 5.03936108187965*std::sin(0.478719830513*x_98 + 2.05727982521057) + 6.61420686257932*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 309.111990482903 - 0.000381183356793629*std::exp(-2.410799741745*x_86) - 6.71841658387874e-6*std::exp(-2.0842399597168*x_23) - 0.0851874242122482*std::exp(-2.03023982048035*x_23) + 0.000216526699960581*std::exp(-4.36887979507446*x_111) + 1.04188152999107e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.14147091125717*x_1 + 0.29506332470323*x_10 + 10.4009800393114*x_100 - 215.967239298507*x_101 - 0.0733269748095483*x_102 + 1.53531907703598*x_103 + 4.83538715043298*x_104 - 1.85344923910701*x_105 + 4.01060356282479*x_106 + 6.44180113323948*x_107 + 1.99119276295424*x_108 + 20.6790123364998*x_109 - 3.57598487998129*x_11 - 3.02426356842854*x_110 + 11.3541843767222*x_111 - 14.4716797278266*x_112 - 0.969360549011216*x_113 + 3.68907301952874*x_114 + 7.69741075068781*x_115 - 2.34581329618548*x_116 - 6.95861575142005*x_117 + 10.940692464606*x_118 - 3.72862403547051*x_119 + 12.0532130255253*x_12 + 8.58568752576745*x_120 + 0.711384971537318*x_13 + 0.0520131009200659*x_14 - 1.90349829196192*x_15 + 1.05734882948581*x_16 - 0.594599357536583*x_17 + 13.0757679608839*x_18 + 6.91436656021676*x_19 - 6.44886316407004*x_2 + 16.4063836881678*x_20 - 1.90397203490723*x_21 + 5.35522867525267*x_22 - 1.81504292033161*x_23 + 10.587163084016*x_24 + 15.382033526528*x_25 + 8.84418503106519*x_26 - 6.37450780526496*x_27 - 2.23547102533161*x_28 - 1.19670368805465*x_29 + 8.09033585338333*x_3 + 8.05103037410856*x_30 + 89.0141125827322*x_31 + 10.8348428750357*x_32 + 9.75259385165358*x_33 + 9.64651590317052*x_34 + 20.6758727576708*x_35 + 1.04077341999137*x_36 + 7.08240413932798*x_37 + 6.26154456230404*x_38 - 30.6936654376491*x_39 - 46.6796782843466*x_4 + 15.7554007763815*x_40 - 8.22479318999829*x_41 + 17.7120230544622*x_42 - 8.48015067466235*x_43 - 5.87388046723647*x_44 + 9.15703406211233*x_45 - 1.8335745627091*x_46 - 3.61756961171539*x_47 - 11.1560144958094*x_48 + 16.8975427048348*x_49 + 3.43804998802015*x_5 - 3.25079353232166*x_50 + 0.00998425090359567*x_51 + 7.80010618108873*x_52 + 5.6336374068949*x_53 - 5.84816590425321*x_54 - 15.0940159625865*x_55 - 6.43899358697835*x_56 + 21.839254607527*x_57 - 2.22753027399583*x_58 + 7.54231694751327*x_59 - 1.94278870132384*x_6 + 8.55617506435226*x_60 + 3.78501359094393*x_61 - 9.77351742493088*x_62 - 14.1112575498515*x_63 + 12.3899034759302*x_64 + 5.64095362926892*x_65 + 9.88491344334724*x_66 - 8.24956940957851*x_67 - 0.723434106486354*x_68 - 0.48062807997584*x_69 - 7.93389863483159*x_7 - 9.16307698263469*x_70 - 0.424648564119127*x_71 - 8.58349429769104*x_72 - 6.46249801889224*x_73 + 11.6493099907542*x_74 - 4.0351120068813*x_75 - 18.2984419863649*x_76 + 5.4871747393037*x_77 + 8.34236127592152*x_78 - 8.4238230659905*x_79 + 31.7443686272603*x_8 - 0.899574493809278*x_80 + 13.9346703761935*x_81 + 8.09493662840753*x_82 + 15.3560498347132*x_83 - 26.5060221109732*x_84 + 3.41486133074254*x_85 + 25.6994128696568*x_86 - 11.2150254303647*x_87 + 15.1086164765105*x_88 - 11.1183842642268*x_89 - 35.227758004376*x_9 - 6.6476925008266*x_90 - 5.87807910987563*x_91 + 13.4298399509066*x_92 + 377.771607276891*x_93 + 4.42983020082529*x_94 - 1.65362209147368*x_95 - 2.35346967649052*x_96 - 3.58356871701062*x_97 - 11.2260179627856*x_98 - 1.16662951888222*x_99 - 0.00643114044271006*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) - 0.000241821604267212*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.0273584586495147*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 1.50124096646057*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.180330128872778*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) + 8.99534354358529e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) + 0.00012103285733493*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.0115181349779733*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 0.000156729902635762*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.0147960984310809*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.268770413782113*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 7.85284350372208e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) + 0.00405710280942778*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 9.87890907165224e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.00130613409231272*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) + 8.14581781855673e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 0.41906622894198*std::exp(0.696079850196838*x_1) + 0.00304875334854105*std::exp(0.727999866008759*x_1) - 0.0073332644862472*std::exp(1.07999980449677*x_1) - 0.0318685613116521*std::exp(1.13711988925934*x_1) - 0.0974707485349601*std::exp(1.19479990005493*x_1) + 0.307186368869027*std::exp(0.675999820232391*x_100) - 0.707852193003937*std::exp(0.842319846153259*x_108) - 0.947346460196339*std::exp(1.03287982940674*x_108) + 1.28837454720469*std::exp(0.796239912509918*x_15) - 0.239969065667113*std::exp(3.03135991096497*x_17) - 0.000111524375019375*std::exp(3.22919988632202*x_17) - 0.00393790474722439*std::exp(4.0260796546936*x_17) - 1.22394956679417*std::exp(0.833279848098755*x_29) - 0.727454426060701*std::exp(0.907439827919006*x_29) + 0.378894187069925*std::exp(0.996239840984344*x_29) + 0.566509027469706*std::exp(1.09351980686188*x_29) - 0.00529369070604758*std::exp(1.31271982192993*x_29) - 8.57140739772854e-5*std::exp(2.63991975784302*x_29) + 0.00671456063501069*std::exp(1.18919992446899*x_38) - 0.00397462521627089*std::exp(1.94679975509644*x_38) + 0.440244349105153*std::exp(1.78463983535767*x_50) - 0.840703937113948*std::exp(1.8439998626709*x_50) - 0.0209163599383551*std::exp(1.87887990474701*x_50) - 0.170490750827273*std::exp(1.90823984146118*x_50) + 0.00125291508519009*std::exp(1.92663979530334*x_50) + 0.00390627474115752*std::exp(1.94135975837708*x_50) + 0.388137124216969*std::exp(1.98175978660583*x_50) - 0.348819109826968*std::exp(2.01087975502014*x_50) + 0.727569248366096*std::exp(1.01135981082916*x_6) - 0.0140955985234201*std::exp(0.731919825077057*x_67) - 0.197797648056543*std::exp(1.35455989837646*x_71) - 0.375060607789358*std::exp(1.37727987766266*x_71) + 1.27510716189319*std::exp(1.5998398065567*x_71) + 0.00402931658962002*std::exp(1.83271992206573*x_71) - 0.115593319391356*std::exp(1.84047985076904*x_71) - 0.000719764114564604*std::exp(1.90183985233307*x_71) - 0.00892757635793695*std::exp(1.13671982288361*x_77) + 0.518180467873484*std::exp(1.22487986087799*x_77) + 0.776020008834198*std::exp(1.15663981437683*x_78) - 0.3185398773787*std::exp(1.21407985687256*x_78) - 0.00216079869405779*std::exp(1.42927980422974*x_78) - 0.0861493241201548*std::exp(1.84039986133575*x_78) + 0.105431273155721*std::exp(1.85511994361877*x_78) + 0.0127231147711233*std::exp(0.919999837875366*x_87) + 0.00504068483988988*std::exp(0.944319844245911*x_87) + 9.1582834400884*std::sin(0.447599858045578*x_100 + 2.02311968803406) + 2.77170022884182*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.0317497703650122*std::sin(0.645599842071533*x_100 + 2.22887992858887) - 0.108287513038999*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.152467672134485*std::sin(0.386399865150452*x_105 - 7.40151977539063) + 10.4150609100678*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 43.0636468327411*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.0267262037680305*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.209216650434671*std::sin(0.195439994335175*x_109 + 1.79071986675262) + 4.27645676836088*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 4.98863851335657*std::sin(0.357119828462601*x_112 + 1.9780797958374) + 9.34428743399857*std::sin(0.37679985165596*x_112 + 1.97215986251831) - 9.38045847155779*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 6.05078769781105*std::sin(0.550959885120392*x_118 - 1.03543984889984) - 15.3844289677782*std::sin(0.27455997467041*x_14 - 7.49232006072998) - 0.0131360153732599*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0698219910721041*std::sin(0.45415985584259*x_14 + 8.24919986724854) - 2.08367312038457*std::sin(0.511999845504761*x_14 + 5.14152002334595) + 2.09693916691829*std::sin(0.601359844207764*x_15 + 2.19391989707947) - 0.034487116224357*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 43.2865366463633*std::sin(0.44599986076355*x_16 - 1.14847981929779) - 1.57985432767503*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.420299925985751*std::sin(0.213440001010895*x_27 + 5.01231956481934) + 9.57709311253178*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.111207186889503*std::sin(0.32847985625267*x_28 + 8.31272029876709) - 0.115405594867109*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0708597637302349*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 109.94415182778*std::sin(0.313119828701019*x_33 - 1.17847990989685) - 0.0828116011878024*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 98.7095615519978*std::sin(0.292239934206009*x_36 + 1.89231991767883) + 0.0432726428000778*std::sin(0.354639858007431*x_36 + 1.97199988365173) + 12.2217949092393*std::sin(0.35607984662056*x_36 - 1.20679986476898) + 3.0127246764745*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 8.72677017025834*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0570577366872665*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.280963803240298*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.259359461372838*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 39.5173196741981*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 11.9111864512896*std::sin(0.409119844436646*x_51 - 1.1885598897934) + 0.0399984684924176*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0585610865407542*std::sin(0.5275998711586*x_54 + 5.1482400894165) + 0.0344989369539953*std::sin(0.258479982614517*x_55 - 7.53800010681152) + 6.02819184875283*std::sin(0.29911994934082*x_55 + 5.10295963287354) + 2.65299365162068*std::sin(0.484159857034683*x_55 + 5.28151988983154) - 0.0655821678042981*std::sin(0.234959989786148*x_64 - 4.33743953704834) - 2.6835035512022*std::sin(0.479919850826263*x_73 + 5.26471996307373) - 0.0479993980205061*std::sin(0.651279807090759*x_73 + 8.62351989746094) - 0.085815364867331*std::sin(0.160800024867058*x_75 + 1.76423990726471) - 19.2574214668112*std::sin(0.262959957122803*x_75 - 7.51624011993408) - 2.14577682958169*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 5.44292495347775*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 6.17821769575693*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 3.66712168110259*std::sin(0.698319852352142*x_85 + 8.47064018249512) - 9.63179788320463*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 9.4398638647034*std::sin(0.434399873018265*x_86 + 2.02191972732544) + 2.76664304944392*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.173961249996875*std::sin(0.353119850158691*x_92 - 7.4125599861145) + 12.8402340292951*std::sin(0.3574398458004*x_92 - 7.41207981109619) + 0.0457458694513216*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0711315768027858*std::sin(0.365919858217239*x_92 + 1.99415981769562) - 6.24550522019741*std::sin(0.367599844932556*x_92 + 2.00479984283447) + 10.981436166971*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 61.3828988595248*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.111914098300627*std::sin(0.30855992436409*x_97 - 4.27671957015991) - 12.2333371071369*std::sin(0.37255984544754*x_97 + 5.16960000991821) - 0.0868631440211699*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 8.94890156904317*std::sin(0.478719830513*x_98 + 2.05727982521057) + 5.47636115341396*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 2866.08335198453 - 0.000976317248625902*std::exp(-2.410799741745*x_86) - 0.000252631853671221*std::exp(-2.0842399597168*x_23) - 0.0640673450448099*std::exp(-2.03023982048035*x_23) - 0.000350020416902712*std::exp(-4.36887979507446*x_111) + 2.6685501626078e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.466049417445893*x_1 - 1.57488687803807*x_10 + 6.15206326894315*x_100 - 271.75772951991*x_101 + 1.13085253529687*x_102 + 2.51196310874477*x_103 + 0.25870303709134*x_104 - 2.36318507855698*x_105 + 4.25457877766288*x_106 - 2.81571417343655*x_107 - 0.0750905551023292*x_108 + 17.270830645442*x_109 - 0.563283441663398*x_11 - 3.68867382564013*x_110 + 9.25310047056006*x_111 - 12.3567890550037*x_112 + 4.00444715014775*x_113 + 2.68727354706305*x_114 + 0.211559893248129*x_115 - 4.05526453668488*x_116 + 0.48125858450852*x_117 + 5.11818630861647*x_118 + 0.988970163455349*x_119 + 6.87470780966008*x_12 + 7.68639056649676*x_120 + 2.25308163797616*x_13 - 0.149124717735091*x_14 - 1.93216101934509*x_15 - 1.58429419051501*x_16 + 1.40836316279919*x_17 + 9.34396474180097*x_18 + 1.00682355240021*x_19 - 4.26062988421089*x_2 + 10.7927972435865*x_20 - 4.07515634579018*x_21 + 6.26194787890841*x_22 - 6.64119211934455*x_23 + 7.41874105329698*x_24 + 4.87563494061187*x_25 + 5.33210243276041*x_26 - 4.45336232442431*x_27 + 2.66564669142788*x_28 - 1.74980731662222*x_29 + 2.02935671050476*x_3 + 2.26552923782692*x_30 + 29.6082966624713*x_31 + 13.6112293990379*x_32 + 7.05402363473452*x_33 + 6.5370391717175*x_34 + 22.0356700191277*x_35 + 0.935390251363976*x_36 - 1.6445340121906*x_37 + 3.0057199395192*x_38 - 28.797896523153*x_39 - 10.6435506788319*x_4 + 2.61111830876911*x_40 - 2.4467658046936*x_41 + 13.3795271089027*x_42 - 8.21016021090981*x_43 - 5.55708617075902*x_44 + 3.40503306391042*x_45 - 0.389526300656693*x_46 - 7.19780256738508*x_47 - 4.93667283404094*x_48 + 19.9651951058328*x_49 + 3.0667178458969*x_5 - 2.09431376120868*x_50 - 4.28867786025645*x_51 + 1.11223273390073*x_52 + 1.12057546667358*x_53 - 1.50293539644237*x_54 - 8.21263491620127*x_55 + 0.0558583301024411*x_56 + 19.4019588426497*x_57 - 6.1724898949206*x_58 + 9.71292904685614*x_59 - 0.309166098736291*x_6 + 4.07905042102582*x_60 + 2.74410803288215*x_61 - 8.64451516900743*x_62 - 11.82089566562*x_63 + 9.20641974454258*x_64 + 2.0434838146499*x_65 + 5.06879812606828*x_66 - 8.09910271931315*x_67 + 2.17831648587747*x_68 - 2.655210546981*x_69 - 3.19885778456906*x_7 - 1.03588554553135*x_70 - 1.42441794102717*x_71 - 3.62663298078651*x_72 - 3.26969005555622*x_73 + 8.03951584093048*x_74 - 1.1957778922012*x_75 - 8.27573493681833*x_76 + 3.01276566263285*x_77 + 5.63898948744804*x_78 - 5.51678419234317*x_79 + 57.8277939330033*x_8 + 1.69413701471472*x_80 + 5.66538333149145*x_81 + 3.11061453293827*x_82 + 10.7946841211473*x_83 - 10.8880143759966*x_84 + 0.00329115131166535*x_85 + 17.3126991513294*x_86 - 6.59874083725171*x_87 + 14.9832741915138*x_88 - 9.7777126737561*x_89 - 35.8575429603445*x_9 - 1.08131476685079*x_90 + 1.96414835657406*x_91 + 9.77352813817238*x_92 + 183.550071922114*x_93 + 6.54355748536261*x_94 + 2.42722777550181*x_95 - 0.56267554930135*x_96 - 4.67984763246356*x_97 - 7.73158359815021*x_98 - 2.56184399414549*x_99 + 0.00876654939469404*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) + 6.06953680545296e-5*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.0404340064282203*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 0.93319408789734*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.324254089105302*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 5.75207412628475e-6*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) - 3.0378318946712e-5*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.0170230475958755*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 0.000229882711256409*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.0218676624563978*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.167071753800144*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 0.000115181144462474*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00553040203289556*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 0.00014489834827019*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.00191576490099067*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 5.2088447411175e-6*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 0.753528759668559*std::exp(0.696079850196838*x_1) + 0.00142227692180237*std::exp(0.727999866008759*x_1) + 0.0018405931446148*std::exp(1.07999980449677*x_1) - 0.0470996421779898*std::exp(1.13711988925934*x_1) - 0.0605892913315607*std::exp(1.19479990005493*x_1) - 0.24628197008772*std::exp(0.675999820232391*x_100) - 1.3399960050686*std::exp(0.842319846153259*x_108) - 1.40011589658798*std::exp(1.03287982940674*x_108) - 1.03293457605123*std::exp(0.796239912509918*x_15) - 0.149168400251407*std::exp(3.03135991096497*x_17) - 0.000163577755549379*std::exp(3.22919988632202*x_17) + 0.00315715486574116*std::exp(4.0260796546936*x_17) - 1.80891713548529*std::exp(0.833279848098755*x_29) + 0.583225453195966*std::exp(0.907439827919006*x_29) - 0.51648609385853*std::exp(0.996239840984344*x_29) + 1.01864768699697*std::exp(1.09351980686188*x_29) - 0.00246956485541021*std::exp(1.31271982192993*x_29) + 2.15135751963494e-5*std::exp(2.63991975784302*x_29) - 0.00168530322301599*std::exp(1.18919992446899*x_38) + 0.00318659493983239*std::exp(1.94679975509644*x_38) + 0.833402332980622*std::exp(1.78463983535767*x_50) - 1.24250524610963*std::exp(1.8439998626709*x_50) - 0.00975771163733861*std::exp(1.87887990474701*x_50) + 0.232402884337561*std::exp(1.90823984146118*x_50) - 8.01176787638435e-5*std::exp(1.92663979530334*x_50) + 0.00572950670745087*std::exp(1.94135975837708*x_50) + 0.697914710357219*std::exp(1.98175978660583*x_50) + 0.279660383006964*std::exp(2.01087975502014*x_50) + 1.37732127675404*std::exp(1.01135981082916*x_6) + 0.00353788712518218*std::exp(0.731919825077057*x_67) + 0.269626027807797*std::exp(1.35455989837646*x_71) - 0.674401646015671*std::exp(1.37727987766266*x_71) + 0.792625895175061*std::exp(1.5998398065567*x_71) + 0.00187972044337217*std::exp(1.83271992206573*x_71) - 0.17083934000837*std::exp(1.84047985076904*x_71) + 4.60253298871248e-5*std::exp(1.90183985233307*x_71) + 0.00224075319705986*std::exp(1.13671982288361*x_77) + 0.980938907469322*std::exp(1.22487986087799*x_77) + 1.14690664512952*std::exp(1.15663981437683*x_78) + 0.434214676867391*std::exp(1.21407985687256*x_78) + 0.000138172313263823*std::exp(1.42927980422974*x_78) - 0.163084541238011*std::exp(1.84039986133575*x_78) + 0.189577424770983*std::exp(1.85511994361877*x_78) + 0.0186615576863436*std::exp(0.919999837875366*x_87) - 0.000322326687199876*std::exp(0.944319844245911*x_87) + 13.535341893048*std::sin(0.447599858045578*x_100 + 2.02311968803406) + 5.24695306534864*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.0465687987456966*std::sin(0.645599842071533*x_100 + 2.22887992858887) + 0.027179335277046*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.0711278436156801*std::sin(0.386399865150452*x_105 - 7.40151977539063) - 8.35011569347579*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 26.7690141192724*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.0392005104352323*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.306867356088897*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 5.82941234576915*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 8.9701396385363*std::sin(0.357119828462601*x_112 + 1.9780797958374) - 7.49163944605986*std::sin(0.37679985165596*x_112 + 1.97215986251831) + 7.52063902186461*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 8.94266712183465*std::sin(0.550959885120392*x_118 - 1.03543984889984) + 12.3342304829758*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.000839982750907711*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.102411016296476*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 2.84033967147358*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 2.85842315965834*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.00220527929770688*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 26.9075657981645*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 2.153563761103*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.196074531660897*std::sin(0.213440001010895*x_27 + 5.01231956481934) + 18.1298675596407*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.163112521627535*std::sin(0.32847985625267*x_28 + 8.31272029876709) + 0.0289659192247814*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.103933163559422*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 68.3429474526448*std::sin(0.313119828701019*x_33 - 1.17847990989685) + 0.0207850767862931*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 61.3593562374202*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.00276706996036621*std::sin(0.354639858007431*x_36 + 1.97199988365173) - 9.7986370272142*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 4.10676767584284*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 15.6917256704495*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0266180608344096*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.131072700060084*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.120994037296656*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 24.5645635267039*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 17.6039518786163*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0025577028224822*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0858941473306196*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.00220603517448665*std::sin(0.258479982614517*x_55 - 7.53800010681152) + 11.4116380156089*std::sin(0.29911994934082*x_55 + 5.10295963287354) - 2.12699705900666*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.00419365295772143*std::sin(0.234959989786148*x_64 - 4.33743953704834) - 5.07999279191093*std::sin(0.479919850826263*x_73 + 5.26471996307373) + 0.0120474807785629*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.00548746512569901*std::sin(0.160800024867058*x_75 + 1.76423990726471) + 15.4393429471408*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 2.92499576616164*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 9.78699834514936*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 11.1091383550513*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 5.41976518218062*std::sin(0.698319852352142*x_85 + 8.47064018249512) + 7.72214654867634*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 13.9514992813278*std::sin(0.434399873018265*x_86 + 2.02191972732544) + 5.23737959752996*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0811548337542127*std::sin(0.353119850158691*x_92 - 7.4125599861145) - 10.2944611271814*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.00292522048524752*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.104331843868809*std::sin(0.365919858217239*x_92 + 1.99415981769562) - 11.8230219916166*std::sin(0.367599844932556*x_92 + 2.00479984283447) - 8.8041983879411*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 38.1565382196846*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.16414938000028*std::sin(0.30855992436409*x_97 - 4.27671957015991) + 9.80789080773782*std::sin(0.37255984544754*x_97 + 5.16960000991821) + 0.0218019829647345*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 13.225889228764*std::sin(0.478719830513*x_98 + 2.05727982521057) + 10.3669977156471*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 3885.08575731189 - 0.000455462719456365*std::exp(-2.410799741745*x_86) + 1.61545486499385e-5*std::exp(-2.0842399597168*x_23) + 0.0513650134086938*std::exp(-2.03023982048035*x_23) + 0.000477127082088101*std::exp(-4.36887979507446*x_111) + 1.24490795976175e-5*std::exp(-4.23400020599365*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.77056937147875*x_1 + 1.06844163604909*x_10 - 7.34300444620983*x_100 + 103.939529396029*x_101 - 2.11243997850648*x_102 - 5.7431257435879*x_103 + 0.241072218679554*x_104 - 0.654042644335895*x_105 + 2.41660503853125*x_106 - 3.48626160929157*x_107 - 1.00781763644592*x_108 - 11.2169441726108*x_109 + 3.65367347732487*x_11 + 1.74119521751594*x_110 - 9.98564093236979*x_111 + 6.33354909428449*x_112 + 3.32630869022786*x_113 - 2.04976910036259*x_114 - 7.5378446326448*x_115 - 3.26075439383677*x_116 + 3.7290870075947*x_117 - 5.07307950147948*x_118 + 1.09543812637753*x_119 - 8.7132525992752*x_12 - 7.35952940485055*x_120 + 1.16682327756991*x_13 + 0.756189507775137*x_14 + 1.07295272279721*x_15 - 2.12439663303172*x_16 - 1.27060715444299*x_17 - 5.90662226134831*x_18 - 7.84449962556897*x_19 + 4.99254846928086*x_2 - 14.275576988878*x_20 + 0.986351954501187*x_21 - 2.80541660344413*x_22 - 3.89153265755566*x_23 - 5.24278327848368*x_24 - 13.080582674905*x_25 - 5.82006128704651*x_26 + 5.31845864031804*x_27 + 3.68139102101299*x_28 - 0.0724587049338527*x_29 - 8.19774873169477*x_3 - 2.7085774808242*x_30 - 45.9419731955373*x_31 - 18.3857495282351*x_32 - 2.43134537879064*x_33 - 6.25910961713886*x_34 - 12.8609756218882*x_35 + 0.810269935704671*x_36 - 6.41923707152084*x_37 - 4.69465946232469*x_38 + 19.2450422500456*x_39 + 49.8747650911245*x_4 - 15.1738051025851*x_40 + 5.07861650420833*x_41 - 11.471963767597*x_42 + 1.3626679346385*x_43 + 3.55246197385778*x_44 - 5.92918628189755*x_45 + 1.01751690064244*x_46 + 1.85883912887843*x_47 - 10.8687540229657*x_48 - 10.6437667009819*x_49 - 1.54681031338171*x_5 + 2.22293053584549*x_50 + 2.44054390239195*x_51 - 9.5729085609767*x_52 - 4.8790261170912*x_53 + 7.26422770491852*x_54 + 13.0852638925251*x_55 + 7.04774867202018*x_56 - 13.7074983773408*x_57 - 0.459444225923113*x_58 - 5.01286173777204*x_59 - 0.120158471487599*x_6 - 4.92438175410106*x_60 - 2.90766737699893*x_61 + 6.39981487728199*x_62 + 9.15677453053953*x_63 - 8.82681947563723*x_64 - 6.49790566185941*x_65 - 6.90896515098077*x_66 + 3.97587739065253*x_67 + 4.95275906962653*x_68 + 0.407345340635754*x_69 + 2.90156640399843*x_7 + 8.80567381271697*x_70 - 0.554440573551012*x_71 - 2.17991992165205*x_72 + 5.95671585613167*x_73 - 7.19687035231842*x_74 + 3.1288616253165*x_75 + 14.4641013650225*x_76 - 4.04873593172788*x_77 - 5.9005202595866*x_78 + 3.87354706144433*x_79 - 27.2738318449679*x_8 + 4.36119282313624*x_80 - 12.4578688185104*x_81 - 5.76152095173807*x_82 - 10.6089441636598*x_83 + 20.493277036359*x_84 - 2.57786566064984*x_85 - 16.741042326817*x_86 + 3.30986944466012*x_87 - 9.22276764126487*x_88 + 3.40507885479203*x_89 + 20.4608307597579*x_9 + 17.8562220218413*x_90 + 3.63077053761629*x_91 - 8.43885349382344*x_92 - 161.580883698756*x_93 - 5.31532312611445*x_94 + 2.08625235061518*x_95 + 3.16936671821909*x_96 + 3.72268014478026*x_97 + 8.40464238934713*x_98 + 0.833292291366258*x_99 - 0.00080992384282512*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) + 0.000586280350541896*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.0163161831115593*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) + 1.09262553233893*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) - 0.26736775296176*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 4.78286348415602e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) - 0.000293436089965727*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.00686924661260482*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 0.00026345055822424*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.00882417589495496*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) + 0.195615109763493*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 0.000132000082301533*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) + 0.00051094270563988*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 0.000166056640488172*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.00219550800420764*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 4.3311669425617e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) - 0.621331536081932*std::exp(0.696079850196838*x_1) + 9.24216841570335e-5*std::exp(0.727999866008759*x_1) + 0.017779010633238*std::exp(1.07999980449677*x_1) - 0.0190059421301533*std::exp(1.13711988925934*x_1) + 0.0709406623485465*std::exp(1.19479990005493*x_1) - 0.372888778344822*std::exp(0.675999820232391*x_100) - 0.338977797669845*std::exp(0.842319846153259*x_108) - 0.564983521647522*std::exp(1.03287982940674*x_108) - 1.56393792057405*std::exp(0.796239912509918*x_15) + 0.174653059686732*std::exp(3.03135991096497*x_17) - 0.000187463645165055*std::exp(3.22919988632202*x_17) + 0.00478016161927045*std::exp(4.0260796546936*x_17) - 0.729945553839946*std::exp(0.833279848098755*x_29) + 0.883045667794471*std::exp(0.907439827919006*x_29) + 0.0477171100132992*std::exp(0.996239840984344*x_29) - 0.839938653922809*std::exp(1.09351980686188*x_29) - 0.000160476022336631*std::exp(1.31271982192993*x_29) + 0.000207808055405373*std::exp(2.63991975784302*x_29) - 0.0162790044121903*std::exp(1.18919992446899*x_38) + 0.00482473602826331*std::exp(1.94679975509644*x_38) + 0.210825171372223*std::exp(1.78463983535767*x_50) - 0.501383486412282*std::exp(1.8439998626709*x_50) - 0.000634070713809156*std::exp(1.87887990474701*x_50) - 0.0214712344266542*std::exp(1.90823984146118*x_50) - 0.000666180427758902*std::exp(1.92663979530334*x_50) + 0.00656613858509717*std::exp(1.94135975837708*x_50) - 0.575474278156501*std::exp(1.98175978660583*x_50) + 0.423426118175719*std::exp(2.01087975502014*x_50) + 0.348419944023641*std::exp(1.01135981082916*x_6) + 0.034173838472583*std::exp(0.731919825077057*x_67) - 0.0249102056847973*std::exp(1.35455989837646*x_71) + 0.556086287721002*std::exp(1.37727987766266*x_71) - 0.92804198171961*std::exp(1.5998398065567*x_71) + 0.00012214704918414*std::exp(1.83271992206573*x_71) - 0.068938158754633*std::exp(1.84047985076904*x_71) + 0.000382701726073803*std::exp(1.90183985233307*x_71) + 0.021644313428825*std::exp(1.13671982288361*x_77) + 0.248147389428666*std::exp(1.22487986087799*x_77) + 0.462806941157746*std::exp(1.15663981437683*x_78) - 0.0401162194913725*std::exp(1.21407985687256*x_78) + 0.00114890611129476*std::exp(1.42927980422974*x_78) - 0.0412553756979506*std::exp(1.84039986133575*x_78) - 0.156318429825057*std::exp(1.85511994361877*x_78) + 0.0213865486574908*std::exp(0.919999837875366*x_87) - 0.00268015416409977*std::exp(0.944319844245911*x_87) + 5.46186579844817*std::sin(0.447599858045578*x_100 + 2.02311968803406) + 1.32731783366613*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.0533688503947642*std::sin(0.645599842071533*x_100 + 2.22887992858887) + 0.262535852808509*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.00462199378802315*std::sin(0.386399865150452*x_105 - 7.40151977539063) - 12.6426812278182*std::sin(0.401199847459793*x_105 + 5.20136022567749) + 31.3423634821355*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.0449246326545976*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.351676625965333*std::sin(0.195439994335175*x_109 + 1.79071986675262) + 0.538567666242224*std::sin(0.351759850978851*x_112 + 1.95887982845306) + 7.39644050604342*std::sin(0.357119828462601*x_112 + 1.9780797958374) - 11.3428858793282*std::sin(0.37679985165596*x_112 + 1.97215986251831) + 11.3867933419431*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 3.60860095634102*std::sin(0.550959885120392*x_118 - 1.03543984889984) + 18.6749201940449*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.00698447679642876*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.117365239274235*std::sin(0.45415985584259*x_14 + 8.24919986724854) - 0.262413261829207*std::sin(0.511999845504761*x_14 + 5.14152002334595) + 0.264083958882616*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.0183369504526537*std::sin(0.384399831295013*x_16 - 7.41287994384766) + 31.5045860078344*std::sin(0.44599986076355*x_16 - 1.14847981929779) - 0.1989634186305*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.0127412166777179*std::sin(0.213440001010895*x_27 + 5.01231956481934) + 4.58629917862952*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.186930477030119*std::sin(0.32847985625267*x_28 + 8.31272029876709) + 0.279793167439336*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.119109652953416*std::sin(0.332079827785492*x_3 - 4.25880002975464) + 80.0189910228753*std::sin(0.313119828701019*x_33 - 1.17847990989685) + 0.20077120371624*std::sin(0.335519850254059*x_34 + 1.98951983451843) - 71.8422889111366*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0230082533378072*std::sin(0.354639858007431*x_36 + 1.97199988365173) - 14.8358476636387*std::sin(0.35607984662056*x_36 - 1.20679986476898) + 0.379415994578413*std::sin(0.374879837036133*x_36 + 1.9851998090744) + 12.9388080939142*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.00172968145204309*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.00851730032377331*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.00786237372518493*std::sin(0.301039934158325*x_43 - 7.47904014587402) - 28.7612937631372*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 7.10365674122548*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0212673605457762*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0984365502684839*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.0183432355862752*std::sin(0.258479982614517*x_55 - 7.53800010681152) + 2.88679362304409*std::sin(0.29911994934082*x_55 + 5.10295963287354) - 3.22042792898533*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0348703253058803*std::sin(0.234959989786148*x_64 - 4.33743953704834) - 1.28508201686205*std::sin(0.479919850826263*x_73 + 5.26471996307373) + 0.116371339039528*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.0456284046312134*std::sin(0.160800024867058*x_75 + 1.76423990726471) + 23.3762858399887*std::sin(0.262959957122803*x_75 - 7.51624011993408) - 0.270234467920833*std::sin(0.475759834051132*x_75 + 8.47544002532959) - 8.06999153966957*std::sin(0.544639825820923*x_79 - 1.05215990543365) + 9.16017857331258*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 2.18701753661477*std::sin(0.698319852352142*x_85 + 8.47064018249512) + 11.6918903633505*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 5.62979623003812*std::sin(0.434399873018265*x_86 + 2.02191972732544) + 1.32489604059737*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.00527356262206905*std::sin(0.353119850158691*x_92 - 7.4125599861145) - 15.5865613388818*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.024323278759678*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.119566549209279*std::sin(0.365919858217239*x_92 + 1.99415981769562) - 2.99086112298908*std::sin(0.367599844932556*x_92 + 2.00479984283447) - 13.3301953854579*std::sin(0.36287984251976*x_95 + 5.16520023345947) - 44.6753879232463*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.188118739146944*std::sin(0.30855992436409*x_97 - 4.27671957015991) + 14.8498585590091*std::sin(0.37255984544754*x_97 + 5.16960000991821) + 0.21059389908616*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 5.33699352431969*std::sin(0.478719830513*x_98 + 2.05727982521057) + 2.62253173950205*std::sin(0.286079943180084*x_99 + 5.10951995849609) + 461.218015020466 - 2.95966495396379e-5*std::exp(-2.410799741745*x_86) + 0.00013432546094589*std::exp(-2.0842399597168*x_23) + 0.0777703584749269*std::exp(-2.03023982048035*x_23) - 4.40808101845205e-5*std::exp(-4.36887979507446*x_111) + 8.08959834037611e-7*std::exp(-4.23400020599365*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (12.2190943231425*x_1 - 1.52229058272926*x_10 + 11.9187978038584*x_100 - 200.919208284505*x_101 + 8.46700603444816*x_102 + 7.52572036051231*x_103 + 0.501142279271053*x_104 - 0.318321616993832*x_105 - 6.25594512166332*x_106 + 11.9419938454817*x_107 + 1.20309065418777*x_108 + 20.5827317519078*x_109 - 4.31012728255717*x_11 - 4.18850278066961*x_110 + 14.3268888112992*x_111 - 13.7089995714534*x_112 - 1.72256739070649*x_113 + 3.53475227278528*x_114 + 6.62240598041135*x_115 + 9.06229070986437*x_116 - 2.84975300899456*x_117 + 5.38252586252488*x_118 + 4.29679050108185*x_119 + 15.4725158477017*x_12 + 11.103279706516*x_120 + 2.73462241469618*x_13 - 2.75802041067391*x_14 - 2.45436668607831*x_15 + 0.548180516052781*x_16 + 5.17037092026554*x_17 + 11.9279541308921*x_18 + 9.55500464360648*x_19 - 11.2871604310488*x_2 + 31.3844089363877*x_20 - 7.4089601481193*x_21 + 2.17028722969146*x_22 + 3.21793405981966*x_23 + 6.89350345982447*x_24 + 16.7817973426927*x_25 + 7.94642665347174*x_26 - 11.386435344468*x_27 - 6.54805231753567*x_28 - 1.96523646808291*x_29 + 11.5172877665907*x_3 - 3.52205863759169*x_30 + 57.7456323263559*x_31 + 30.9979800906962*x_32 + 8.8935681266787*x_33 + 6.91267840175162*x_34 + 24.5903859959806*x_35 - 5.04390341616885*x_36 + 10.0071302894612*x_37 + 7.03450010803421*x_38 - 54.6810559416443*x_39 - 77.4197975409653*x_4 + 21.302469055423*x_40 - 2.16426979655945*x_41 + 21.7759784646717*x_42 - 3.18893862475517*x_43 - 7.86418108054007*x_44 + 4.39559424658006*x_45 - 3.9029826591766*x_46 - 7.60765622962868*x_47 + 38.247760953214*x_48 + 31.6670137331045*x_49 + 5.82212181923356*x_5 - 4.23278817361724*x_50 - 6.89309441136845*x_51 + 11.658888255928*x_52 + 6.75452754711259*x_53 - 11.1479114275393*x_54 - 21.6895408282847*x_55 - 10.9324907794322*x_56 + 27.3293001198891*x_57 - 0.941899864024686*x_58 + 10.6624719067513*x_59 + 1.12018487718007*x_6 + 6.82220731579309*x_60 + 5.36474393075416*x_61 - 10.4962614941672*x_62 - 16.6799933677612*x_63 + 21.249792189774*x_64 + 10.3254520655478*x_65 + 8.82074206506007*x_66 - 9.03517484742917*x_67 - 9.53208812844518*x_68 - 1.05534487146558*x_69 - 6.16686922887446*x_7 - 12.2096791060885*x_70 - 0.551112599923106*x_71 + 1.56206621210726*x_72 - 9.87064247158852*x_73 + 13.304151637931*x_74 - 3.49167314434809*x_75 - 20.7467779378391*x_76 + 7.66979110601606*x_77 + 9.71806988899056*x_78 - 11.7933922990752*x_79 + 98.6185832291141*x_8 - 5.99591748133285*x_80 + 21.5209058582686*x_81 + 6.74626014139797*x_82 + 17.0572406597354*x_83 - 35.2912290153592*x_84 + 3.56571343095591*x_85 + 31.6199914685417*x_86 - 3.5620716933906*x_87 + 19.6542431000368*x_88 - 4.80937728102099*x_89 - 68.6010592742758*x_9 - 20.3309922363746*x_90 - 1.90592158733045*x_91 + 14.4096104309593*x_92 + 297.90162848145*x_93 + 8.55348764857971*x_94 - 1.18966529139614*x_95 - 6.24531046743963*x_96 - 11.4470004600529*x_97 - 14.4906997412232*x_98 - 0.973993037609846*x_99 + 0.0060593627613607*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) + 0.000644905593466098*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) + 0.0260137148423373*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 1.80410557471286*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.721645565770171*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 2.97978710714493e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) - 0.000322778301488027*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) + 0.0109519868305104*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 2.47083202570634e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) + 0.0140688293261038*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.32299291896184*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 1.2379933181576e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00382256582661398*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 1.55740063017877e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.000205910798825238*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 2.69837419719184e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 1.67702029478037*std::exp(0.696079850196838*x_1) + 0.000737385760909658*std::exp(0.727999866008759*x_1) + 0.019556827024939*std::exp(1.07999980449677*x_1) + 0.0303021335016462*std::exp(1.13711988925934*x_1) - 0.117134773651926*std::exp(1.19479990005493*x_1) + 0.722746489223323*std::exp(0.675999820232391*x_100) - 1.31344628181435*std::exp(0.842319846153259*x_108) + 0.900781765089764*std::exp(1.03287982940674*x_108) + 3.03128092638087*std::exp(0.796239912509918*x_15) - 0.288381105232814*std::exp(3.03135991096497*x_17) - 1.75817117736077e-5*std::exp(3.22919988632202*x_17) - 0.00926508178546737*std::exp(4.0260796546936*x_17) + 1.16378906501557*std::exp(0.833279848098755*x_29) - 1.71155098594074*std::exp(0.907439827919006*x_29) - 0.356990699873454*std::exp(0.996239840984344*x_29) + 2.26705725880508*std::exp(1.09351980686188*x_29) - 0.001280356822295*std::exp(1.31271982192993*x_29) + 0.000228587871270744*std::exp(2.63991975784302*x_29) - 0.0179068273254889*std::exp(1.18919992446899*x_38) - 0.00935147751384461*std::exp(1.94679975509644*x_38) + 0.816889894722306*std::exp(1.78463983535767*x_50) + 0.799381016565435*std::exp(1.8439998626709*x_50) - 0.00505892875721971*std::exp(1.87887990474701*x_50) + 0.160634854101223*std::exp(1.90823984146118*x_50) - 0.00041503920323968*std::exp(1.92663979530334*x_50) + 0.000615820501981058*std::exp(1.94135975837708*x_50) + 1.55324812527345*std::exp(1.98175978660583*x_50) - 0.820699785376661*std::exp(2.01087975502014*x_50) + 1.35003201724006*std::exp(1.01135981082916*x_6) + 0.0375910595686948*std::exp(0.731919825077057*x_67) + 0.186363167403244*std::exp(1.35455989837646*x_71) - 1.5009184887635*std::exp(1.37727987766266*x_71) + 1.53235089537388*std::exp(1.5998398065567*x_71) + 0.000974549377962858*std::exp(1.83271992206573*x_71) + 0.109911588472448*std::exp(1.84047985076904*x_71) + 0.000238428228824528*std::exp(1.90183985233307*x_71) + 0.023808641691779*std::exp(1.13671982288361*x_77) + 0.96150328495692*std::exp(1.22487986087799*x_77) - 0.737876482018806*std::exp(1.15663981437683*x_78) + 0.300125411377822*std::exp(1.21407985687256*x_78) + 0.000715783678354403*std::exp(1.42927980422974*x_78) - 0.159853300681668*std::exp(1.84039986133575*x_78) + 0.421915135545691*std::exp(1.85511994361877*x_78) + 0.00200578695670393*std::exp(0.919999837875366*x_87) - 0.00166977143499938*std::exp(0.944319844245911*x_87) - 8.70812851366483*std::sin(0.447599858045578*x_100 + 2.02311968803406) + 5.14299368689815*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.00500532113575079*std::sin(0.645599842071533*x_100 + 2.22887992858887) + 0.288788187775876*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.036876545124522*std::sin(0.386399865150452*x_105 - 7.40151977539063) + 24.5045010802807*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 51.7514290204756*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.00421336063412671*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.0329828061851319*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 4.02923915650882*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 19.9635462188012*std::sin(0.357119828462601*x_112 + 1.9780797958374) + 21.9851908210665*std::sin(0.37679985165596*x_112 + 1.97215986251831) - 22.0702938499012*std::sin(0.44887986779213*x_116 - 7.35751962661743) - 5.75337477007943*std::sin(0.550959885120392*x_118 - 1.03543984889984) - 36.1964043720574*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.00435142127244384*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0110073705616003*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 1.96321809871502*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 1.975717248605*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.0114241622668464*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 52.0192852569401*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 1.4885245574663*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.10165570818695*std::sin(0.213440001010895*x_27 + 5.01231956481934) + 17.7706553198101*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.0175317073662622*std::sin(0.32847985625267*x_28 + 8.31272029876709) + 0.307771151682713*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0111709744352702*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 132.124596684317*std::sin(0.313119828701019*x_33 - 1.17847990989685) + 0.220847367925342*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 118.623508318776*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.014334445647683*std::sin(0.354639858007431*x_36 + 1.97199988365173) + 28.7553754262656*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 2.83856213022917*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 34.9228109369638*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.0138002513726001*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.06795522108719*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.0627298937990666*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 47.4896557679328*std::sin(0.439759850502014*x_46 + 5.22288036346436) + 11.3257187382979*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0132498464501939*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.00923209966009639*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.0114280779880863*std::sin(0.258479982614517*x_55 - 7.53800010681152) + 11.1855359749714*std::sin(0.29911994934082*x_55 + 5.10295963287354) + 6.24194964997987*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0217246731194853*std::sin(0.234959989786148*x_64 - 4.33743953704834) - 4.97934144500491*std::sin(0.479919850826263*x_73 + 5.26471996307373) + 0.128007918730969*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.0284270985969138*std::sin(0.160800024867058*x_75 + 1.76423990726471) - 45.3087609579638*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 2.0217316557122*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 21.7815108437489*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 24.7240071993252*std::sin(0.469119846820831*x_84 - 1.14935982227325) + 3.48687252182051*std::sin(0.698319852352142*x_85 + 8.47064018249512) - 22.661643908955*std::sin(0.421199858188629*x_86 - 1.15927994251251) + 8.97586848267982*std::sin(0.434399873018265*x_86 + 2.02191972732544) + 5.13360990092943*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.0420750825117179*std::sin(0.353119850158691*x_92 - 7.4125599861145) + 30.2104357678568*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.0151537238500902*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0112138255079354*std::sin(0.365919858217239*x_92 + 1.99415981769562) - 11.5887690828624*std::sin(0.367599844932556*x_92 + 2.00479984283447) + 25.8370658357314*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 73.7664588820781*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.0176431512786598*std::sin(0.30855992436409*x_97 - 4.27671957015991) - 28.7825318493814*std::sin(0.37255984544754*x_97 + 5.16960000991821) + 0.231652286052173*std::sin(0.395039826631546*x_97 - 1.18751990795135) + 8.50903833989796*std::sin(0.478719830513*x_98 + 2.05727982521057) + 10.1615934313904*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 1294.25263355167 - 0.000236136661436303*std::exp(-2.410799741745*x_86) + 8.36865359033956e-5*std::exp(-2.0842399597168*x_23) - 0.150737315836882*std::exp(-2.03023982048035*x_23) + 0.000329786092962775*std::exp(-4.36887979507446*x_111) + 6.45428038027998e-6*std::exp(-4.23400020599365*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.81821393935215*x_1 - 1.66006242827466*x_10 + 2.58389008922686*x_100 - 41.3314640286277*x_101 - 1.06374760755238*x_102 + 2.0489004086166*x_103 - 0.402627915918402*x_104 + 1.17747601819958*x_105 + 6.80591380615466*x_106 - 6.92830416933333*x_107 + 0.0755723887717956*x_108 + 1.18129281827035*x_109 + 3.74792655962113*x_11 + 5.35207291098072*x_110 + 3.08655549484007*x_111 - 0.659476553646366*x_112 - 4.01765649795914*x_113 + 0.385266604520007*x_114 + 5.0651946241301*x_115 + 6.27766797539705*x_116 - 1.10347190665172*x_117 + 9.84456772728622*x_118 + 1.74104507935222*x_119 - 0.921506137950459*x_12 + 7.18423731510994*x_120 - 1.62496681003443*x_13 - 0.0180603662836018*x_14 + 0.735030062214886*x_15 - 3.56615758922922*x_16 + 0.0683946867558681*x_17 + 2.204206230258*x_18 - 0.956122958822321*x_19 - 0.790107858892928*x_2 + 0.750849093844691*x_20 + 2.94613772248792*x_21 + 0.847111847726198*x_22 + 3.96368083337888*x_23 + 0.611951558790998*x_24 + 4.11658210980426*x_25 + 6.59098583421792*x_26 + 0.89002343760697*x_27 + 2.54989232345116*x_28 - 0.0630951105694103*x_29 + 4.2101788608041*x_3 + 2.4399264491926*x_30 + 2.94895395369443*x_31 + 15.9262779003866*x_32 - 11.9547473226722*x_33 - 0.0792896497732818*x_34 - 0.880283629693142*x_35 - 1.92173860905799*x_36 + 5.48218797957309*x_37 + 2.6639120459286*x_38 + 3.91183875031344*x_39 - 8.25568308542147*x_4 - 5.78965730622849*x_40 - 5.73432673497559*x_41 + 6.50350205944482*x_42 - 6.52293505367699*x_43 - 0.103375135009548*x_44 + 2.92067504116309*x_45 + 2.00180592500444*x_46 + 3.25283384902564*x_47 - 20.4005647026859*x_48 - 11.759345886569*x_49 + 2.31376891711721*x_5 - 0.618980089557955*x_50 + 3.82709116085934*x_51 + 8.52359590153972*x_52 + 0.631015367100593*x_53 - 6.78935782178391*x_54 - 4.25147970073169*x_55 - 4.84539647418286*x_56 - 0.502440317208797*x_57 - 1.45019613623386*x_58 + 2.11975910961004*x_59 + 0.0805832883440613*x_6 - 2.67069325129447*x_60 - 2.89112054701629*x_61 + 3.78158615499318*x_62 - 1.9190018869744*x_63 - 2.86648613179895*x_64 - 2.14176062946254*x_65 + 5.55110919923377*x_66 - 4.01068792501031*x_67 + 1.36618524486594*x_68 + 1.12590243289593*x_69 + 0.106083288429081*x_7 - 1.37900974573474*x_70 - 0.442905896237628*x_71 + 0.713339570715204*x_72 - 1.9650274566693*x_73 - 0.100012369644859*x_74 - 2.70931059217697*x_75 + 2.45299947157696*x_76 - 2.32104629385841*x_77 + 2.36066334132176*x_78 + 2.2293180264977*x_79 - 5.29727712664183*x_8 - 1.76136767887909*x_80 - 2.69981614066996*x_81 - 0.623748414235779*x_82 + 0.969530548950476*x_83 - 3.04637496671452*x_84 - 0.0410664181028518*x_85 + 4.31611337687138*x_86 - 1.0886412668402*x_87 + 1.35374265598934*x_88 - 9.37313410395282*x_89 + 45.3201172536764*x_9 - 9.72201639776602*x_90 - 0.532701905340678*x_91 + 1.52093476810392*x_92 + 210.84145446551*x_93 + 3.30037714837265*x_94 - 5.03586963547939*x_95 + 4.66487668441394*x_96 + 0.0833167156241503*x_97 - 2.30406800886116*x_98 - 3.45985614204311*x_99 + 0.0036125224245627*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) - 0.000234344438659415*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) + 0.0217146440861603*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 0.31540151202671*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) - 0.371772019717666*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) + 0.00019220194144084*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) + 0.000117290500563208*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) + 0.0091420428609373*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) - 0.000136405119929779*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) + 0.011743790664918*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.0564670141494901*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) + 6.83448430644645e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) - 0.00227896980455896*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) - 8.59780905897551e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) - 0.00113675421543736*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) + 0.000174050272984457*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) - 0.863954899289957*std::exp(0.696079850196838*x_1) + 0.000516803396048541*std::exp(0.727999866008759*x_1) - 0.00710651868669136*std::exp(1.07999980449677*x_1) + 0.0252943513845499*std::exp(1.13711988925934*x_1) - 0.0204780059651464*std::exp(1.19479990005493*x_1) - 0.546243884532466*std::exp(0.675999820232391*x_100) + 0.0281789569742607*std::exp(0.842319846153259*x_108) + 0.751917038638148*std::exp(1.03287982940674*x_108) - 2.29100894023689*std::exp(0.796239912509918*x_15) - 0.0504160277010617*std::exp(3.03135991096497*x_17) + 9.7061859248169e-5*std::exp(3.22919988632202*x_17) + 0.00700244738710988*std::exp(4.0260796546936*x_17) + 0.971459304883644*std::exp(0.833279848098755*x_29) + 1.293571498549*std::exp(0.907439827919006*x_29) - 0.212833751574824*std::exp(0.996239840984344*x_29) - 1.16792577395256*std::exp(1.09351980686188*x_29) - 0.000897349513638147*std::exp(1.31271982192993*x_29) - 8.30637800633516e-5*std::exp(2.63991975784302*x_29) + 0.0065069452649791*std::exp(1.18919992446899*x_38) + 0.00706774433282941*std::exp(1.94679975509644*x_38) - 0.0175257302219399*std::exp(1.78463983535767*x_50) + 0.667273950266452*std::exp(1.8439998626709*x_50) - 0.00354559540026037*std::exp(1.87887990474701*x_50) + 0.0957686534807682*std::exp(1.90823984146118*x_50) + 0.00267708187760965*std::exp(1.92663979530334*x_50) - 0.00339970781315777*std::exp(1.94135975837708*x_50) - 0.800190869376859*std::exp(1.98175978660583*x_50) + 0.62027591345461*std::exp(2.01087975502014*x_50) - 0.0289638751537913*std::exp(1.01135981082916*x_6) - 0.0136597601920188*std::exp(0.731919825077057*x_67) + 0.111107578118589*std::exp(1.35455989837646*x_71) + 0.773232074673209*std::exp(1.37727987766266*x_71) + 0.267892187758096*std::exp(1.5998398065567*x_71) + 0.000683021635143703*std::exp(1.83271992206573*x_71) + 0.0917474124356659*std::exp(1.84047985076904*x_71) - 0.00153790746877496*std::exp(1.90183985233307*x_71) - 0.00865153416101734*std::exp(1.13671982288361*x_77) - 0.0206282967735723*std::exp(1.22487986087799*x_77) - 0.615933759699305*std::exp(1.15663981437683*x_78) + 0.178931320253223*std::exp(1.21407985687256*x_78) - 0.00461694099895609*std::exp(1.42927980422974*x_78) + 0.0034295268443563*std::exp(1.84039986133575*x_78) - 0.21735911579235*std::exp(1.85511994361877*x_78) - 0.0110731772753581*std::exp(0.919999837875366*x_87) + 0.0107703436530685*std::exp(0.944319844245911*x_87) - 7.26900838564686*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 0.110338884679627*std::sin(0.608719885349274*x_100 + 8.40664005279541) - 0.0276324502315759*std::sin(0.645599842071533*x_100 + 2.22887992858887) - 0.104939244505661*std::sin(0.384079843759537*x_105 - 7.42007970809937) + 0.0258452559910838*std::sin(0.386399865150452*x_105 - 7.40151977539063) - 18.520233661746*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 9.04740786314505*std::sin(0.487759858369827*x_105 + 2.06295967102051) + 0.0232603413192836*std::sin(0.458719849586487*x_106 - 7.34887981414795) - 0.182085369887393*std::sin(0.195439994335175*x_109 + 1.79071986675262) - 2.40218606808508*std::sin(0.351759850978851*x_112 + 1.95887982845306) + 10.2846719366587*std::sin(0.357119828462601*x_112 + 1.9780797958374) - 16.6161665471281*std::sin(0.37679985165596*x_112 + 1.97215986251831) + 16.6804864846848*std::sin(0.44887986779213*x_116 - 7.35751962661743) - 4.8025622708542*std::sin(0.550959885120392*x_118 - 1.03543984889984) + 27.3568461765176*std::sin(0.27455997467041*x_14 - 7.49232006072998) - 0.0280674956470975*std::sin(0.400399833917618*x_14 - 4.39455986022949) + 0.0607674534709572*std::sin(0.45415985584259*x_14 + 8.24919986724854) + 1.17044806281291*std::sin(0.511999845504761*x_14 + 5.14152002334595) - 1.17789991229673*std::sin(0.601359844207764*x_15 + 2.19391989707947) - 0.073688021595842*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 9.09423564482859*std::sin(0.44599986076355*x_16 - 1.14847981929779) + 0.887441230231236*std::sin(0.462719857692719*x_21 + 5.03983974456787) + 0.0712463109593077*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 0.381255433583181*std::sin(0.323919832706451*x_28 + 5.13184022903442) + 0.0967858041740066*std::sin(0.32847985625267*x_28 + 8.31272029876709) - 0.111837234019026*std::sin(0.280639946460724*x_3 - 1.10511994361877) - 0.0616706474467816*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 23.0985914318153*std::sin(0.313119828701019*x_33 - 1.17847990989685) - 0.0802510522318712*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 20.7382729758538*std::sin(0.292239934206009*x_36 + 1.89231991767883) + 0.0924599034728581*std::sin(0.354639858007431*x_36 + 1.97199988365173) - 21.7329979574336*std::sin(0.35607984662056*x_36 - 1.20679986476898) - 1.69231811212184*std::sin(0.374879837036133*x_36 + 1.9851998090744) + 17.9912751800766*std::sin(0.380639851093292*x_36 + 1.96687984466553) + 0.00967202942308656*std::sin(0.392479836940765*x_36 + 1.98215985298157) - 0.04762702359992*std::sin(0.381999850273132*x_41 - 7.41328001022339) + 0.0439648063031879*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 8.30234629545885*std::sin(0.439759850502014*x_46 + 5.22288036346436) + 9.45401119804076*std::sin(0.409119844436646*x_51 - 1.1885598897934) + 0.0854640321590073*std::sin(0.321279853582382*x_53 + 5.12463998794556) - 0.0509668665549662*std::sin(0.5275998711586*x_54 + 5.1482400894165) + 0.0737132787433286*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 0.23997687711854*std::sin(0.29911994934082*x_55 + 5.10295963287354) - 4.71759721382407*std::sin(0.484159857034683*x_55 + 5.28151988983154) - 0.140128277645092*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 0.106827854539375*std::sin(0.479919850826263*x_73 + 5.26471996307373) - 0.0465152483757238*std::sin(0.651279807090759*x_73 + 8.62351989746094) - 0.183360198007302*std::sin(0.160800024867058*x_75 + 1.76423990726471) + 34.2438655297067*std::sin(0.262959957122803*x_75 - 7.51624011993408) + 1.20533317286792*std::sin(0.475759834051132*x_75 + 8.47544002532959) - 11.2212374924531*std::sin(0.544639825820923*x_79 - 1.05215990543365) + 12.7371309795238*std::sin(0.469119846820831*x_84 - 1.14935982227325) + 2.91062603876615*std::sin(0.698319852352142*x_85 + 8.47064018249512) + 17.1274223857131*std::sin(0.421199858188629*x_86 - 1.15927994251251) + 7.49250119203904*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 0.110137562931848*std::sin(0.6629598736763*x_87 - 3.95023989677429) + 0.029488697346493*std::sin(0.353119850158691*x_92 - 7.4125599861145) - 22.8327166348276*std::sin(0.3574398458004*x_92 - 7.41207981109619) + 0.0977444038556287*std::sin(0.362399846315384*x_92 + 1.98511981964111) + 0.0619072117152222*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 0.248627926312696*std::sin(0.367599844932556*x_92 + 2.00479984283447) - 19.5273715161141*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 12.8961702654051*std::sin(0.298239916563034*x_96 - 7.49088001251221) + 0.0974010430926335*std::sin(0.30855992436409*x_97 - 4.27671957015991) + 21.7535224847387*std::sin(0.37255984544754*x_97 + 5.16960000991821) - 0.084177320663789*std::sin(0.395039826631546*x_97 - 1.18751990795135) + 7.10282019258789*std::sin(0.478719830513*x_98 + 2.05727982521057) - 0.21800899515855*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 253.722962397503 - 0.000165498488079427*std::exp(-2.410799741745*x_86) - 0.000539794089132182*std::exp(-2.0842399597168*x_23) + 0.113925613163779*std::exp(-2.03023982048035*x_23) + 0.000196614677657855*std::exp(-4.36887979507446*x_111) + 4.52354004702137e-6*std::exp(-4.23400020599365*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.86667070622554*x_1 - 0.230307132658696*x_10 + 11.1398065145584*x_100 - 398.642468744228*x_101 - 5.59970499965841*x_102 + 4.65623535889238*x_103 + 2.36722977174436*x_104 - 3.84930868501817*x_105 + 2.98804574480231*x_106 - 1.74885720528572*x_107 + 1.8993025630234*x_108 + 30.8145309054253*x_109 - 11.2068110892345*x_11 - 11.7930281561667*x_110 + 18.670211142851*x_111 - 18.9166281671562*x_112 + 5.23230320493302*x_113 + 4.76882691916294*x_114 + 6.90600490327542*x_115 - 22.6960316025704*x_116 - 6.82292663308338*x_117 + 4.10101451329839*x_118 - 13.5231716501157*x_119 + 15.7344473435245*x_12 + 7.06692883368391*x_120 - 1.79647087054125*x_13 + 2.54159586661716*x_14 - 3.79423342624307*x_15 + 7.95372701203322*x_16 - 3.76524680335957*x_17 + 13.3225445407949*x_18 + 11.8131968364189*x_19 - 3.03196467743728*x_2 + 9.37221930227756*x_20 - 1.26565299712385*x_21 + 14.9905295580846*x_22 - 11.007115835616*x_23 + 18.3549027668276*x_24 + 16.9326413322386*x_25 + 5.75005304958439*x_26 - 6.63572380929622*x_27 + 0.0831313761796222*x_28 + 0.440661333142877*x_29 + 4.36098843058675*x_3 + 17.8621366770496*x_30 + 119.72640781598*x_31 + 0.885581702677605*x_32 + 23.9205853354308*x_33 + 20.1798749619577*x_34 + 38.0718608213356*x_35 + 11.0214393703973*x_36 - 5.57081358232071*x_37 + 4.96989829838997*x_38 - 24.8437423980688*x_39 - 35.625616055221*x_4 + 25.7635752842331*x_40 - 10.4133374955525*x_41 + 14.3922672040338*x_42 - 5.44249732372122*x_43 - 7.92747973942364*x_44 + 14.513757069676*x_45 - 0.616753807316202*x_46 - 9.16159187254567*x_47 - 18.4518220394266*x_48 + 30.6074796686069*x_49 - 2.26772633915273*x_5 - 3.71843016600055*x_50 - 6.73015807160361*x_51 + 0.283566276200755*x_52 + 5.74486848065055*x_53 + 2.96150752594014*x_54 - 13.1672024570693*x_55 + 2.68744328284507*x_56 + 32.5490448459796*x_57 - 4.98615506071039*x_58 + 10.8255154080323*x_59 - 3.12953123027444*x_6 + 16.6304902515103*x_60 + 9.03030418218546*x_61 - 22.6899584139865*x_62 - 18.8850004083904*x_63 + 12.5036545637771*x_64 + 9.39361562304093*x_65 + 8.60967393414681*x_66 - 6.0869691764397*x_67 + 2.93741267823509*x_68 - 5.48643105143247*x_69 - 6.66419919178514*x_7 - 8.04952534172071*x_70 + 1.01770858335381*x_71 - 7.39520659022921*x_72 - 5.0829960362429*x_73 + 15.313651306969*x_74 - 2.68324756787064*x_75 - 30.2506879795928*x_76 + 8.69509370000293*x_77 + 9.28164521004828*x_78 - 6.42639228773645*x_79 + 14.2327827233635*x_8 + 2.7340162742154*x_80 + 17.4965962307165*x_81 + 14.5239765527457*x_82 + 23.1822966693474*x_83 - 22.655961860157*x_84 + 2.9996025464839*x_85 + 25.7532397758649*x_86 - 17.3371795410073*x_87 + 20.6810729949042*x_88 - 8.2734420838986*x_89 - 73.4899547326076*x_9 - 5.72284822222372*x_90 - 5.86801497076859*x_91 + 18.3028956877158*x_92 + 102.972624944774*x_93 + 7.4557045377695*x_94 + 6.25989243214391*x_95 - 6.70109289408905*x_96 + 0.424391542770366*x_97 - 12.4300846590109*x_98 - 0.181412269021913*x_99 - 0.00625653439840186*std::pow(-4.51087999343872*x_106 - 6.56143999099731, 2) + 2.35336532294866e-5*std::pow(-5.92712020874023*x_117 - 7.14391994476318, 2) - 0.103862855524071*std::pow(-4.87399959564209*x_13 - 6.5097599029541, 2) - 1.67009460145461*std::pow(-1.31599986553192*x_14 - 2.19871973991394, 2) + 0.610425006753991*std::pow(-1.9586398601532*x_24 - 2.17487978935242, 2) - 3.2690269206017e-5*std::pow(-4.93351984024048*x_26 - 5.34791994094849, 2) - 1.17787048122746e-5*std::pow(-8.36975955963135*x_44 - 9.78880023956299, 2) - 0.0437271121319259*std::pow(-7.6547999382019*x_44 - 8.05655956268311, 2) + 7.67150649032561e-5*std::pow(-3.25671982765198*x_6 - 5.49599981307983, 2) - 0.0561714771052916*std::pow(-6.67704010009766*x_66 - 8.50512027740479, 2) - 0.299000644877498*std::pow(-4.31407976150513*x_69 - 5.68591976165771, 2) - 3.84375533278544e-5*std::pow(-7.10464000701904*x_71 - 9.74824047088623, 2) + 0.00394695210144427*std::pow(-6.72776031494141*x_73 - 8.35127925872803, 2) + 4.83545984435674e-5*std::pow(-6.70800018310547*x_74 - 5.6945595741272, 2) + 0.000639317449823152*std::pow(-2.14527988433838*x_78 - 2.36055994033813, 2) - 2.96029802643484e-5*std::pow(-5.69855976104736*x_85 - 8.52960014343262, 2) + 1.41855666178085*std::exp(0.696079850196838*x_1) - 0.00016435834274037*std::exp(0.727999866008759*x_1) + 0.000713660402603036*std::exp(1.07999980449677*x_1) - 0.120984877901037*std::exp(1.13711988925934*x_1) - 0.108433872086352*std::exp(1.19479990005493*x_1) + 0.357587461705467*std::exp(0.675999820232391*x_100) + 0.788844108562106*std::exp(0.842319846153259*x_108) - 3.59647850732839*std::exp(1.03287982940674*x_108) + 1.49976245937294*std::exp(0.796239912509918*x_15) - 0.266959835256587*std::exp(3.03135991096497*x_17) - 5.45881770104175e-5*std::exp(3.22919988632202*x_17) - 0.00458400992264816*std::exp(4.0260796546936*x_17) - 4.64656648436394*std::exp(0.833279848098755*x_29) - 0.846810301769487*std::exp(0.907439827919006*x_29) + 0.368607175644036*std::exp(0.996239840984344*x_29) + 1.91765668377779*std::exp(1.09351980686188*x_29) + 0.000285382952295055*std::exp(1.31271982192993*x_29) + 8.34154293195009e-6*std::exp(2.63991975784302*x_29) - 0.000653449231930879*std::exp(1.18919992446899*x_38) - 0.00462675524161306*std::exp(1.94679975509644*x_38) - 0.490616776428391*std::exp(1.78463983535767*x_50) - 3.1916239389653*std::exp(1.8439998626709*x_50) + 0.00112760130539068*std::exp(1.87887990474701*x_50) - 0.165861911532241*std::exp(1.90823984146118*x_50) - 0.000455325927561174*std::exp(1.92663979530334*x_50) + 0.00191201624743096*std::exp(1.94135975837708*x_50) + 1.31386035241382*std::exp(1.98175978660583*x_50) - 0.406051025429999*std::exp(2.01087975502014*x_50) - 0.810817174569893*std::exp(1.01135981082916*x_6) + 0.00137175885801205*std::exp(0.731919825077057*x_67) - 0.19242742403356*std::exp(1.35455989837646*x_71) - 1.269595798961*std::exp(1.37727987766266*x_71) + 1.41852616264176*std::exp(1.5998398065567*x_71) - 0.000217220523058429*std::exp(1.83271992206573*x_71) - 0.438835110753036*std::exp(1.84047985076904*x_71) + 0.00026157180719047*std::exp(1.90183985233307*x_71) + 0.000868816029999093*std::exp(1.13671982288361*x_77) - 0.577470287291573*std::exp(1.22487986087799*x_77) + 2.9460597577475*std::exp(1.15663981437683*x_78) - 0.309891490916147*std::exp(1.21407985687256*x_78) + 0.000785262849234162*std::exp(1.42927980422974*x_78) + 0.0960064649943289*std::exp(1.84039986133575*x_78) + 0.356889256556609*std::exp(1.85511994361877*x_78) + 0.00622762190892594*std::exp(0.919999837875366*x_87) - 0.0018318515974434*std::exp(0.944319844245911*x_87) + 34.7682404908898*std::sin(0.447599858045578*x_100 + 2.02311968803406) - 3.08883608447047*std::sin(0.608719885349274*x_100 + 8.40664005279541) + 0.0155406572278418*std::sin(0.645599842071533*x_100 + 2.22887992858887) + 0.0105383503209553*std::sin(0.384079843759537*x_105 - 7.42007970809937) - 0.00821953469128552*std::sin(0.386399865150452*x_105 - 7.40151977539063) + 12.1238947159367*std::sin(0.401199847459793*x_105 + 5.20136022567749) - 47.9072751817274*std::sin(0.487759858369827*x_105 + 2.06295967102051) - 0.0130817567177783*std::sin(0.458719849586487*x_106 - 7.34887981414795) + 0.102405913913172*std::sin(0.195439994335175*x_109 + 1.79071986675262) + 4.16035058056569*std::sin(0.351759850978851*x_112 + 1.95887982845306) - 16.8867494147763*std::sin(0.357119828462601*x_112 + 1.9780797958374) + 10.8774358617276*std::sin(0.37679985165596*x_112 + 1.97215986251831) - 10.9195416021473*std::sin(0.44887986779213*x_116 - 7.35751962661743) + 22.9710341695628*std::sin(0.550959885120392*x_118 - 1.03543984889984) - 17.9086035771379*std::sin(0.27455997467041*x_14 - 7.49232006072998) + 0.00477380187611032*std::sin(0.400399833917618*x_14 - 4.39455986022949) - 0.0341759835659392*std::sin(0.45415985584259*x_14 + 8.24919986724854) - 2.02710120683009*std::sin(0.511999845504761*x_14 + 5.14152002334595) + 2.04000707900136*std::sin(0.601359844207764*x_15 + 2.19391989707947) + 0.0125330745629764*std::sin(0.384399831295013*x_16 - 7.41287994384766) - 48.1552347583484*std::sin(0.44599986076355*x_16 - 1.14847981929779) - 1.53696113988107*std::sin(0.462719857692719*x_21 + 5.03983974456787) - 0.0226583758643432*std::sin(0.213440001010895*x_27 + 5.01231956481934) - 10.6728969036752*std::sin(0.323919832706451*x_28 + 5.13184022903442) - 0.054432921966163*std::sin(0.32847985625267*x_28 + 8.31272029876709) + 0.0112310695257157*std::sin(0.280639946460724*x_3 - 1.10511994361877) + 0.0346839453236157*std::sin(0.332079827785492*x_3 - 4.25880002975464) - 122.310234353643*std::sin(0.313119828701019*x_33 - 1.17847990989685) + 0.00805907938473023*std::sin(0.335519850254059*x_34 + 1.98951983451843) + 109.812021882546*std::sin(0.292239934206009*x_36 + 1.89231991767883) - 0.0157258512199806*std::sin(0.354639858007431*x_36 + 1.97199988365173) + 14.2270655926892*std::sin(0.35607984662056*x_36 - 1.20679986476898) + 2.93092892919841*std::sin(0.374879837036133*x_36 + 1.9851998090744) - 29.5404809690935*std::sin(0.380639851093292*x_36 + 1.96687984466553) - 0.00307598351533528*std::sin(0.392479836940765*x_36 + 1.98215985298157) + 0.015146763214776*std::sin(0.381999850273132*x_41 - 7.41328001022339) - 0.0139820727923673*std::sin(0.301039934158325*x_43 - 7.47904014587402) + 43.9620711972942*std::sin(0.439759850502014*x_46 + 5.22288036346436) - 45.2192812964812*std::sin(0.409119844436646*x_51 - 1.1885598897934) - 0.0145359729343295*std::sin(0.321279853582382*x_53 + 5.12463998794556) + 0.0286640741761941*std::sin(0.5275998711586*x_54 + 5.1482400894165) - 0.0125373703726052*std::sin(0.258479982614517*x_55 - 7.53800010681152) - 6.71793302637169*std::sin(0.29911994934082*x_55 + 5.10295963287354) + 3.08827917494034*std::sin(0.484159857034683*x_55 + 5.28151988983154) + 0.0238334279313382*std::sin(0.234959989786148*x_64 - 4.33743953704834) + 2.99054800930675*std::sin(0.479919850826263*x_73 + 5.26471996307373) + 0.00467121699759501*std::sin(0.651279807090759*x_73 + 8.62351989746094) + 0.0311864395832457*std::sin(0.160800024867058*x_75 + 1.76423990726471) - 22.4170508823763*std::sin(0.262959957122803*x_75 - 7.51624011993408) - 2.08751879470917*std::sin(0.475759834051132*x_75 + 8.47544002532959) + 18.4245279602286*std::sin(0.544639825820923*x_79 - 1.05215990543365) - 20.9135245576224*std::sin(0.469119846820831*x_84 - 1.14935982227325) - 13.9217539347854*std::sin(0.698319852352142*x_85 + 8.47064018249512) - 11.2121191099587*std::sin(0.421199858188629*x_86 - 1.15927994251251) - 35.8372242130672*std::sin(0.434399873018265*x_86 + 2.02191972732544) - 3.08320026640929*std::sin(0.6629598736763*x_87 - 3.95023989677429) - 0.00937825382437447*std::sin(0.353119850158691*x_92 - 7.4125599861145) + 14.9469740833372*std::sin(0.3574398458004*x_92 - 7.41207981109619) - 0.0166246545246561*std::sin(0.362399846315384*x_92 + 1.98511981964111) - 0.0348169904997538*std::sin(0.365919858217239*x_92 + 1.99415981769562) + 6.96011123033874*std::sin(0.367599844932556*x_92 + 2.00479984283447) + 12.783197051631*std::sin(0.36287984251976*x_95 + 5.16520023345947) + 68.2870040834443*std::sin(0.298239916563034*x_96 - 7.49088001251221) - 0.0547789360571134*std::sin(0.30855992436409*x_97 - 4.27671957015991) - 14.2405015575203*std::sin(0.37255984544754*x_97 + 5.16960000991821) + 0.00845336840772225*std::sin(0.395039826631546*x_97 - 1.18751990795135) - 33.9733492544964*std::sin(0.478719830513*x_98 + 2.05727982521057) - 6.102962277896*std::sin(0.286079943180084*x_99 + 5.10951995849609) - 7617.79243451646 + 5.26332787956691e-5*std::exp(-2.410799741745*x_86) + 9.18097598664436e-5*std::exp(-2.0842399597168*x_23) - 0.0745790881839219*std::exp(-2.03023982048035*x_23) - 0.000340517330946665*std::exp(-4.36887979507446*x_111) - 1.43861582786174e-6*std::exp(-4.23400020599365*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
