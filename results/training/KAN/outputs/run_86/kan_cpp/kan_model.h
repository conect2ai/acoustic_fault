
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.97389013194237e-6*x_1 + 3.21553338413444e-5*x_10 + 1.73348638137989e-6*x_100 - 4.91864989644731e-7*x_101 + 2.050020795331e-5*x_102 - 2.74068608928324e-5*x_103 + 2.83757191807128e-5*x_104 + 2.16891768233755e-6*x_105 + 2.10061428621502e-5*x_106 + 2.74234067012402e-5*x_107 + 3.22164834133104e-5*x_108 - 6.0342390388111e-5*x_109 - 2.84249570676595e-5*x_11 + 1.91483238213003e-5*x_110 + 4.98920253249115e-5*x_111 + 2.39359898825249e-5*x_112 + 2.94201811368171e-5*x_113 + 3.46977956796608e-5*x_114 + 1.72029859848569e-6*x_115 + 0.000132121880368031*x_116 - 3.74662484697321e-5*x_117 + 1.48960081662735e-5*x_118 + 1.79142320157622e-5*x_119 - 6.6343975394672e-5*x_12 + 3.9552580694968e-5*x_120 + 9.52768447413481e-5*x_13 + 3.27669796323956e-6*x_14 - 8.20135478262332e-5*x_15 + 2.81165263150254e-5*x_16 + 0.000121746435113535*x_17 - 1.07806261349303e-5*x_18 - 2.79996716857279e-6*x_19 - 0.000105679636704677*x_2 - 3.00795386496015e-5*x_20 - 2.35740599409083e-5*x_21 + 1.26753968829736e-5*x_22 + 9.56216738512258e-6*x_23 + 6.5883100110826e-5*x_24 + 2.32636754851243e-5*x_25 + 6.44717133099286e-5*x_26 + 5.16389014271589e-5*x_27 + 0.00011628456326789*x_28 + 3.39139639287751e-5*x_29 - 2.13822487816169e-5*x_3 - 1.53523133058045e-5*x_30 - 0.000299326693076654*x_31 - 6.93939143285911e-5*x_32 - 1.65086451597569e-5*x_33 - 1.49345248050788e-5*x_34 - 4.85489881458536e-5*x_35 - 1.36863864742967e-5*x_36 - 9.15194184590514e-6*x_37 + 1.97572344731717e-5*x_38 - 3.44722567684601e-7*x_39 - 1.57798024850963e-5*x_4 + 1.18693608280287e-6*x_40 - 2.30537815388692e-5*x_41 - 4.61511368473916e-6*x_42 - 8.14993927681995e-6*x_43 - 2.92794338962565e-5*x_44 - 9.32201828747334e-6*x_45 - 6.01778471020652e-6*x_46 - 2.51549510125608e-5*x_47 - 0.000101149985228817*x_48 - 2.20101007949326e-5*x_49 - 1.12283510285497e-5*x_5 + 1.50163693842196e-5*x_50 + 1.87571229362308e-5*x_51 + 9.82871355952651e-7*x_52 - 2.5595257777619e-5*x_53 + 8.49119824603022e-5*x_54 - 7.82101654596872e-6*x_55 + 3.74157311785817e-5*x_56 - 3.52416644509602e-5*x_57 - 3.77111027333046e-6*x_58 - 4.64104047676246e-6*x_59 + 9.94664140176443e-6*x_6 + 4.52533878055453e-5*x_60 + 1.05805126165499e-5*x_61 - 3.69396045528245e-5*x_62 - 1.64642780470278e-5*x_63 + 1.73504438925923e-5*x_64 + 7.63247446568184e-5*x_65 - 7.21313387437674e-6*x_66 + 2.1469505498057e-5*x_67 + 2.90805262160942e-5*x_68 + 1.47054128577019e-5*x_69 + 1.14236832925044e-5*x_7 - 1.83484607340207e-6*x_70 + 2.8489550625717e-6*x_71 + 7.61365475113595e-5*x_72 - 3.73660255877997e-6*x_73 + 0.000127155375487944*x_74 + 6.02208814706744e-5*x_75 - 2.3726241935253e-5*x_76 + 3.41709317726553e-5*x_77 - 5.00597051225112e-5*x_78 + 1.31784174227512e-6*x_79 - 5.4016562787176e-6*x_8 + 0.000142514189218441*x_80 + 2.71003285479547e-5*x_81 + 1.03734255967593e-5*x_82 + 1.4128830300221e-5*x_83 + 4.44173776227046e-5*x_84 - 1.13613488510869e-5*x_85 + 2.35174141132194e-5*x_86 + 0.000154580513073737*x_87 + 8.86234117184132e-7*x_88 - 9.53924137411406e-6*x_89 + 2.08841312865341e-5*x_9 - 2.88379051919903e-6*x_90 - 0.000118717885129172*x_91 - 1.07983863533146e-5*x_92 - 8.08525892809064e-6*x_93 + 1.02451946598328e-5*x_94 - 2.80558021838884e-6*x_95 - 2.91919098056957e-5*x_96 - 2.48771455183252e-5*x_97 - 2.10818463731169e-5*x_98 + 1.59418540807966e-5*x_99 + 0.00156359501409581*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 2.64828385463432e-5*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.0385926887939374);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.66984136044811e-5*x_1 - 6.35474407282282e-6*x_10 - 2.00729898466044e-5*x_100 - 9.38837122316084e-5*x_101 - 1.97570583081098e-5*x_102 - 5.4841919518214e-6*x_103 - 6.36769251580203e-5*x_104 + 7.14821918931765e-6*x_105 + 9.86417069245238e-6*x_106 + 7.41993809845491e-6*x_107 - 1.39859017535653e-5*x_108 + 2.15197391597811e-5*x_109 + 9.71746920702446e-6*x_11 - 2.41804680978657e-5*x_110 + 2.79447437557055e-5*x_111 - 1.80658430887545e-5*x_112 + 7.73958557858829e-5*x_113 - 2.06899227224121e-6*x_114 + 3.72299538262109e-6*x_115 + 5.6912854617559e-5*x_116 - 8.44938461373818e-6*x_117 - 1.66846644384086e-5*x_118 - 3.03179459247629e-5*x_119 + 3.43190137581263e-5*x_12 - 5.05918760927577e-5*x_120 - 3.8884891361806e-6*x_13 + 7.696739464613e-6*x_14 - 2.9150284300335e-5*x_15 - 5.85791594174568e-5*x_16 - 4.77694299983e-5*x_17 + 2.08615465922905e-5*x_18 - 2.50092545631644e-5*x_19 - 1.85023404181596e-5*x_2 - 1.18309932150482e-5*x_20 - 3.19930329690921e-6*x_21 - 1.29408918923276e-5*x_22 - 1.87835984909727e-5*x_23 - 3.56463111157948e-5*x_24 - 2.46138753503399e-5*x_25 - 4.21932720179041e-5*x_26 - 5.20541274203358e-5*x_27 - 5.0457869704701e-5*x_28 - 2.60976480068019e-5*x_29 + 1.5427523829496e-6*x_3 + 2.34184029726546e-6*x_30 - 0.000121271278754875*x_31 - 1.16031863956537e-5*x_32 + 7.86496324682188e-6*x_33 + 3.40181889065501e-5*x_34 + 8.52726771328075e-5*x_35 - 2.20961230233366e-6*x_36 - 1.69709393993923e-5*x_37 - 3.52227569599154e-5*x_38 + 2.49389047778873e-5*x_39 - 3.21843178207912e-6*x_4 + 1.79776773810524e-5*x_40 + 2.20183532087798e-5*x_41 + 4.46081841293669e-5*x_42 + 1.32753362528527e-5*x_43 - 2.26323761476166e-5*x_44 + 7.25345927401318e-6*x_45 + 1.03332678316822e-5*x_46 + 2.24323380975221e-5*x_47 + 2.95547310505908e-5*x_48 - 1.76384778135575e-5*x_49 - 2.8197873853159e-5*x_5 - 2.71973857858131e-5*x_50 - 2.55713902097883e-6*x_51 + 1.71216794728616e-5*x_52 + 3.23050655263941e-5*x_53 - 3.57678979496964e-5*x_54 - 1.70094753934513e-5*x_55 + 2.42172917860791e-6*x_56 + 5.15604702732914e-7*x_57 - 1.6054324019438e-5*x_58 + 1.03041655635378e-6*x_59 - 1.19617120136084e-7*x_6 - 7.84784298360182e-6*x_60 + 3.5998832927634e-6*x_61 - 3.34138816250255e-5*x_62 - 2.39794036720957e-5*x_63 + 1.67415211976821e-5*x_64 - 2.63662324029608e-5*x_65 - 1.69216116514862e-5*x_66 - 3.97840630094871e-5*x_67 - 2.67816637226412e-6*x_68 - 1.05318679800894e-5*x_69 + 1.12775866440351e-5*x_7 - 1.41843758552989e-6*x_70 - 3.0670897904454e-6*x_71 - 2.78595301355995e-5*x_72 - 1.39723051337508e-5*x_73 - 9.23695227021466e-5*x_74 - 2.28214970225638e-6*x_75 + 1.77317290431437e-6*x_76 + 6.94772277028425e-6*x_77 - 2.23610105367376e-5*x_78 + 2.63080387000861e-5*x_79 - 6.3864469781051e-6*x_8 - 8.32185318376036e-5*x_80 - 6.96490964386805e-6*x_81 - 2.89078792989809e-5*x_82 - 9.18827140149855e-6*x_83 + 1.59674635100088e-5*x_84 - 2.86064627379485e-5*x_85 - 5.98715962742334e-5*x_86 - 8.77990950874572e-5*x_87 - 2.93829480858036e-5*x_88 - 1.10145980046869e-5*x_89 + 3.19877382550915e-5*x_9 - 1.49206950306577e-5*x_90 - 8.85881123130156e-5*x_91 - 2.34770677238613e-5*x_92 + 1.69261561847157e-5*x_93 + 5.0699021677976e-7*x_94 + 5.26360223811249e-5*x_95 + 2.63835564220053e-6*x_96 + 5.66358923345538e-5*x_97 + 2.48589186848071e-6*x_98 - 1.95476541776032e-5*x_99 - 0.000661112917985259*std::sin(0.310479938983917*x_3 - 1.07119989395142) + 1.11973666518948e-5*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.0565425908818511);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.53971409234859e-5*x_1 + 1.43265305747989e-6*x_10 - 2.74443949216418e-6*x_100 - 7.09855769667426e-5*x_101 + 1.660663817793e-5*x_102 - 3.51822780398071e-5*x_103 - 2.7707610455427e-5*x_104 - 1.73812981129569e-5*x_105 - 2.38755975361172e-6*x_106 + 2.86015578782848e-5*x_107 - 3.80571281054974e-5*x_108 - 8.59365317382638e-5*x_109 + 1.42905340421989e-5*x_11 - 1.17947677900909e-5*x_110 + 3.0495475106248e-5*x_111 - 1.24979928579613e-5*x_112 + 2.47254218473757e-5*x_113 + 5.24475995038306e-5*x_114 - 2.08206842197815e-5*x_115 + 3.99678904639125e-5*x_116 - 2.35008407166234e-5*x_117 - 1.71488198081787e-5*x_118 - 2.17296861892278e-5*x_119 - 3.78123442450716e-5*x_12 + 1.05611403038472e-5*x_120 - 7.13176941645796e-6*x_13 - 5.70319384094687e-6*x_14 - 1.09786627711203e-5*x_15 - 3.3642805853272e-5*x_16 - 4.91097315850161e-6*x_17 + 2.50889286954805e-7*x_18 - 1.8588581584915e-5*x_19 - 1.33863688650627e-5*x_2 - 1.41049496041266e-5*x_20 + 3.70615432886524e-5*x_21 + 7.39582443884278e-6*x_22 + 9.65713432469632e-6*x_23 + 7.48742371369926e-6*x_24 + 4.78714981172093e-6*x_25 - 9.13620757391676e-6*x_26 + 1.28503128038092e-5*x_27 + 2.02480128943045e-6*x_28 + 5.42893283037675e-7*x_29 - 2.8707537698813e-5*x_3 - 2.90353930663224e-5*x_30 - 0.000290326960343957*x_31 + 4.65810822419852e-6*x_32 + 1.87972203026548e-5*x_33 - 4.85301670445594e-5*x_34 + 1.19505969395765e-5*x_35 - 1.51598094895284e-6*x_36 - 3.94705044635894e-5*x_37 - 1.39783233426713e-5*x_38 - 6.57581901928853e-5*x_39 - 2.32627866990758e-5*x_4 - 5.41154645478279e-6*x_40 - 4.23033825929236e-6*x_41 + 7.26965690196299e-6*x_42 - 1.6031969144897e-5*x_43 - 2.73924934179144e-5*x_44 - 2.99254229237572e-5*x_45 - 8.30987245762061e-6*x_46 - 2.44393615896025e-5*x_47 - 1.90328642628219e-5*x_48 - 6.30562092124877e-5*x_49 - 2.69284352089406e-6*x_5 - 3.4692173279424e-6*x_50 + 1.12109272504121e-5*x_51 - 2.79545097405618e-5*x_52 - 1.58453885753487e-5*x_53 + 1.2219936337159e-6*x_54 - 7.64599823926689e-6*x_55 + 1.75955856294495e-5*x_56 + 8.46757744421671e-6*x_57 - 1.18943898416184e-5*x_58 + 5.92555299864087e-6*x_59 - 6.71562287436801e-6*x_6 + 2.14760302096658e-5*x_60 - 4.90383353899229e-6*x_61 - 3.39482854622923e-5*x_62 + 1.05858019382165e-6*x_63 - 1.55346159485306e-6*x_64 - 4.2543057814967e-6*x_65 - 2.38193804617233e-5*x_66 - 3.56906321801857e-5*x_67 - 1.66636327223348e-6*x_68 - 2.04366860621876e-5*x_69 - 6.7073473768179e-6*x_7 - 1.20458393760771e-5*x_70 + 1.37764339985562e-5*x_71 - 6.1226729423284e-6*x_72 - 3.02633068235782e-5*x_73 + 1.63984987317375e-6*x_74 + 1.91699172200602e-6*x_75 - 4.92313212477357e-5*x_76 - 1.51270033527083e-6*x_77 - 2.21201720888817e-5*x_78 + 1.53117834925335e-6*x_79 + 9.2325865154528e-6*x_8 - 2.7207147581303e-5*x_80 + 8.30948300422445e-6*x_81 - 0.000105895335042311*x_82 - 6.51819938041722e-5*x_83 - 8.33339911847372e-6*x_84 - 3.13587075860119e-5*x_85 - 4.87080644987262e-5*x_86 - 4.53899480709672e-5*x_87 - 2.65623639408418e-5*x_88 + 1.51535487877612e-5*x_89 - 3.92453115274409e-6*x_9 - 1.68219572979782e-5*x_90 - 0.000159225303680633*x_91 + 2.21678306826594e-5*x_92 - 9.99138914193385e-6*x_93 - 5.01148678310231e-5*x_94 + 8.02301678731514e-6*x_95 - 1.46214060737181e-5*x_96 - 2.97025565476493e-5*x_97 - 1.35399497828588e-5*x_98 + 1.49388495620765e-5*x_99 - 1.97829454609479e-5*std::sin(0.310479938983917*x_3 - 1.07119989395142) + 3.35066654658246e-7*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.0251596691881555);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.32240428356533e-5*x_1 - 4.90138901229911e-5*x_10 - 1.40715885520858e-5*x_100 - 0.000171383657090352*x_101 - 3.98482122435632e-5*x_102 - 7.35309456510687e-5*x_103 - 0.000110331025703261*x_104 - 9.12775678315501e-5*x_105 + 8.27622249942373e-6*x_106 + 2.25980754694781e-5*x_107 - 5.13663784690736e-5*x_108 - 0.00013545434814499*x_109 + 5.09406436918164e-5*x_11 - 6.68580361967795e-5*x_110 + 4.08002066625311e-5*x_111 - 5.72426350361159e-5*x_112 + 2.19089091039407e-5*x_113 + 7.1583171054307e-5*x_114 - 2.98648667397512e-5*x_115 + 0.000122800941911485*x_116 - 5.66047828752951e-5*x_117 - 3.13671167629819e-5*x_118 - 5.3662371429081e-5*x_119 - 7.47635741791793e-6*x_12 - 1.43115358183704e-6*x_120 + 2.1527496189694e-5*x_13 - 2.98577310638308e-5*x_14 + 4.23740081118119e-5*x_15 + 1.74229776478051e-5*x_16 - 6.27605609716707e-5*x_17 + 5.72142674840558e-6*x_18 - 7.19726759720748e-5*x_19 + 8.28021789898591e-5*x_2 - 3.5558016213206e-5*x_20 - 1.88016582162274e-6*x_21 - 1.19152003408082e-5*x_22 - 1.44765177192238e-5*x_23 - 7.47069336424638e-5*x_24 - 2.52203346336748e-5*x_25 - 4.60569560126572e-5*x_26 + 9.23970628241033e-6*x_27 - 3.11556380754071e-5*x_28 - 4.33283135859705e-5*x_29 - 3.39624834061813e-5*x_3 - 4.80127691697691e-5*x_30 - 0.00059709554169363*x_31 - 2.70554383892346e-5*x_32 + 1.90179591907703e-5*x_33 - 4.35962266851325e-5*x_34 + 8.10624082699592e-5*x_35 - 2.89804280000951e-5*x_36 - 7.70381189908149e-5*x_37 - 3.72304961662137e-5*x_38 - 0.000111932126061674*x_39 - 4.49701556667191e-5*x_4 + 2.34518583540778e-5*x_40 - 2.34137960153526e-5*x_41 + 4.49342591750618e-5*x_42 - 4.52717485979736e-5*x_43 - 6.46011644651419e-5*x_44 - 7.74592429104713e-5*x_45 + 9.42318610604323e-6*x_46 - 4.66990368207054e-5*x_47 + 7.84231662115146e-5*x_48 - 0.00011656048452475*x_49 + 3.892347906911e-5*x_5 - 3.92036372452376e-5*x_50 - 7.16654879108909e-6*x_51 + 1.92081692431745e-6*x_52 - 2.66078332757632e-5*x_53 + 8.41263227413362e-5*x_54 + 2.73438812758361e-5*x_55 - 1.20473522125143e-5*x_56 + 2.57112882508812e-5*x_57 - 1.8200260009019e-5*x_58 + 3.57507143703621e-5*x_59 + 1.80172760810286e-5*x_6 + 7.76383874512527e-6*x_60 - 1.72956196060955e-5*x_61 - 8.76024890804073e-5*x_62 - 6.09414381855641e-6*x_63 + 8.6452080442437e-6*x_64 - 3.8084645392317e-5*x_65 - 2.66580895287968e-5*x_66 - 8.87692288349724e-5*x_67 + 3.1691784892744e-5*x_68 - 5.39033687645138e-5*x_69 + 1.22244785001917e-5*x_7 - 9.04351688873885e-5*x_70 - 3.88426491025388e-5*x_71 - 5.68667115271152e-5*x_72 - 6.17853942234662e-5*x_73 - 5.55154966520986e-5*x_74 + 2.75981900596425e-5*x_75 - 5.64376408432277e-5*x_76 + 1.08330326114568e-5*x_77 - 8.45089940442541e-5*x_78 + 2.77476100223268e-6*x_79 + 2.44481942743286e-5*x_8 - 0.000133029333619138*x_80 + 1.10737579383519e-5*x_81 - 0.00018385765246475*x_82 - 0.000167096492282355*x_83 + 3.01202961034226e-5*x_84 - 7.00968340435678e-5*x_85 - 0.000200064776639688*x_86 - 0.000118032635937326*x_87 - 4.0729858125991e-5*x_88 + 5.8664720078182e-5*x_89 + 1.36094081308179e-5*x_9 - 5.04990454974716e-5*x_90 - 0.000495635415000819*x_91 - 3.43416300775528e-5*x_92 + 4.55671531718143e-5*x_93 - 6.57007696966924e-5*x_94 + 5.70027077605902e-5*x_95 - 2.54176995074876e-5*x_96 - 4.94371801761778e-5*x_97 - 6.09062844277472e-5*x_98 + 3.5085296891937e-5*x_99 - 0.00034448785646785*std::sin(0.310479938983917*x_3 - 1.07119989395142) + 5.83464145240291e-6*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.043595922323719);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.57065429134111e-5*x_1 + 1.07044241135912e-5*x_10 + 2.54407354894632e-5*x_100 + 3.68259224974241e-5*x_101 + 6.70241390358039e-5*x_102 - 7.67678539552706e-5*x_103 + 8.61593825423966e-5*x_104 - 1.42885076321477e-5*x_105 - 1.53724236806714e-5*x_106 + 6.12837171572313e-5*x_107 - 8.65251212872314e-6*x_108 - 6.30276662578153e-5*x_109 + 5.98938022110589e-7*x_11 - 3.04885976880236e-5*x_110 + 3.15043965807137e-5*x_111 + 1.46601209768718e-5*x_112 + 6.72629876662468e-6*x_113 + 1.03517656793696e-6*x_114 - 2.90963912884574e-5*x_115 + 6.6889615670804e-5*x_116 - 2.42993718949808e-5*x_117 + 3.85090383039867e-5*x_118 + 4.61097025808475e-5*x_119 - 7.26469705230412e-5*x_12 + 4.33218453367011e-5*x_120 + 0.000113406266461621*x_13 + 1.08088398261894e-5*x_14 - 3.30986801382047e-5*x_15 + 7.94755578796794e-5*x_16 + 7.58675454574745e-5*x_17 - 2.62059215359616e-5*x_18 + 2.06833940218681e-5*x_19 - 4.31189183002395e-5*x_2 - 2.63711914258446e-5*x_20 + 1.50137601907942e-5*x_21 + 2.11351861285024e-5*x_22 + 1.85006972136274e-5*x_23 + 1.06811600504687e-6*x_24 + 1.24920654188533e-5*x_25 + 5.74486158481573e-5*x_26 + 4.73896014869021e-5*x_27 + 8.64549533886136e-5*x_28 + 2.10430673485794e-5*x_29 - 1.94087983500388e-5*x_3 + 3.06748536495747e-5*x_30 - 0.000258012059890308*x_31 - 5.09345609521042e-5*x_32 - 4.58641728056783e-5*x_33 - 4.65026522796641e-5*x_34 - 2.37148320809355e-5*x_35 + 3.64566768412375e-6*x_36 - 1.07716305865982e-5*x_37 - 1.83848357089196e-5*x_38 + 6.61301249998582e-6*x_39 - 2.53425330120438e-5*x_4 - 7.68898546866058e-6*x_40 - 5.11553335477881e-6*x_41 + 6.2188940541735e-6*x_42 - 5.38745940679525e-5*x_43 - 1.42789828405175e-5*x_44 - 1.58559974177053e-5*x_45 - 3.01723704909e-5*x_46 + 1.28503291689078e-5*x_47 + 1.16153490183209e-5*x_48 - 7.54467360773712e-5*x_49 + 1.58109611566518e-5*x_5 - 2.2101639205828e-5*x_50 + 4.512529265248e-5*x_51 + 1.4802418582006e-5*x_52 - 2.12252086209641e-5*x_53 + 4.56015594491031e-5*x_54 + 4.02752024307253e-5*x_55 + 3.51551373137891e-5*x_56 + 9.70861127044019e-6*x_57 + 9.14574017122496e-6*x_58 + 9.3431613852e-6*x_59 + 1.34406559571658e-5*x_6 + 5.93125639021667e-5*x_60 + 6.59115112786165e-6*x_61 - 2.82156288550845e-5*x_62 + 3.27333566873873e-5*x_63 - 4.43811613992328e-6*x_64 + 4.88692717248373e-5*x_65 + 3.37746069876919e-5*x_66 + 2.08469308233887e-5*x_67 + 2.60597521057089e-5*x_68 - 6.18837820291127e-6*x_69 + 2.27204324858549e-5*x_7 - 1.03908464740853e-5*x_70 + 1.82579566214559e-5*x_71 + 7.36294415940856e-5*x_72 - 5.17326643666645e-6*x_73 + 0.000130822395723559*x_74 + 3.86596506941673e-5*x_75 - 1.12759026826462e-5*x_76 + 5.01162129043139e-5*x_77 - 2.41562197068518e-5*x_78 + 1.36231725425914e-6*x_79 + 3.8592700483928e-5*x_8 + 0.00010424138796055*x_80 + 2.54507350358957e-5*x_81 - 3.46413064668998e-5*x_82 + 4.37760155589548e-6*x_83 + 1.92147743254045e-5*x_84 - 1.86144903205061e-5*x_85 + 4.87336723467744e-5*x_86 + 0.000106692344843548*x_87 - 1.5803253271239e-6*x_88 + 1.72809614692701e-5*x_89 + 3.2167861123665e-5*x_9 + 3.9116400100406e-5*x_90 - 0.000107446441257515*x_91 - 3.85246726778809e-6*x_92 - 5.92804611576859e-5*x_93 - 2.99455382068907e-5*x_94 + 5.04421104767407e-7*x_95 - 4.18723191426566e-6*x_96 - 5.47104429550673e-5*x_97 - 4.57262622929609e-5*x_98 + 2.71555583146039e-5*x_99 + 0.00114618906506785*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 1.94131726438954e-5*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.037131969667917);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000265464957680842*x_1 - 2.43571061788652e-5*x_10 + 4.67176055771175e-6*x_100 - 3.74512788544368e-5*x_101 - 5.05722556654155e-5*x_102 - 1.55700613340863e-5*x_103 - 8.09701701271359e-5*x_104 - 2.35398632840625e-5*x_105 - 7.87476403771947e-7*x_106 - 1.92059191462618e-5*x_107 + 6.99839866648522e-5*x_108 + 0.00010321892074491*x_109 + 2.02301675744946e-5*x_11 - 2.40535805442807e-5*x_110 - 6.75017296783796e-6*x_111 - 3.30969984198355e-6*x_112 + 7.36770299732397e-5*x_113 - 1.34545980501301e-5*x_114 - 1.33076859029501e-6*x_115 + 0.000232704714581635*x_116 + 4.82403465570877e-6*x_117 + 2.14797917066182e-5*x_118 - 1.85850754650133e-5*x_119 + 9.00201272818103e-5*x_12 - 4.24116431605023e-5*x_120 + 9.13721673294657e-5*x_13 - 6.48246476811439e-7*x_14 + 0.000185027259425977*x_15 + 0.000190928118722544*x_16 - 1.36288357981731e-5*x_17 - 5.05721528609693e-6*x_18 - 1.55191961795378e-5*x_19 + 0.000260956246722469*x_2 + 3.70218767491609e-5*x_20 - 0.000105884292912728*x_21 - 2.43432154475423e-5*x_22 - 3.96005276285825e-5*x_23 - 9.23590546902862e-5*x_24 - 3.31674112163006e-5*x_25 - 2.06887902717606e-5*x_26 + 3.28922716077311e-5*x_27 - 2.01716327756815e-5*x_28 - 3.37893585692066e-5*x_29 + 4.58433685579346e-5*x_3 + 1.74558113406332e-5*x_30 - 8.08795927915029e-5*x_31 - 3.94372285664847e-5*x_32 + 1.89036053528213e-5*x_33 + 6.03608626331814e-5*x_34 + 3.39767800375384e-5*x_35 + 1.33718024265093e-5*x_36 - 3.93899509581307e-6*x_37 - 2.26423825162755e-5*x_38 + 7.28603713801121e-5*x_39 + 2.74948461078049e-5*x_4 + 4.83771071643605e-5*x_40 - 7.63483177247262e-6*x_41 + 0.000140535607158061*x_42 + 3.10968411516862e-6*x_43 + 4.66708362457441e-6*x_44 - 1.49403442386498e-5*x_45 + 2.36682565654598e-5*x_46 + 5.99354546570712e-5*x_47 + 9.70608310453596e-5*x_48 - 2.72470051970599e-5*x_49 + 0.000130552169419493*x_5 - 1.57595107075154e-5*x_50 - 8.0987458619086e-7*x_51 + 5.4064144689322e-5*x_52 - 1.07469880439238e-6*x_53 + 6.50287683996915e-5*x_54 + 6.89262989163624e-5*x_55 - 2.91635470547186e-5*x_56 + 0.000111399177720132*x_57 + 1.36055352265888e-5*x_58 + 3.04412110527759e-5*x_59 + 6.02558608277181e-5*x_6 - 4.3788727381851e-5*x_60 + 3.87034156390318e-6*x_61 - 2.70853346306448e-5*x_62 - 1.8020871277285e-5*x_63 + 5.74727187286423e-6*x_64 - 1.1001299334784e-5*x_65 + 7.78727082683625e-5*x_66 - 2.23784927333897e-5*x_67 + 3.37995315365532e-5*x_68 - 7.44397204541992e-6*x_69 + 5.06695472767392e-5*x_7 + 1.08838386531798e-6*x_70 - 4.08239160145971e-5*x_71 - 3.77869414016235e-5*x_72 - 4.02886881845618e-6*x_73 - 9.03458030431634e-6*x_74 + 2.12893364680043e-5*x_75 + 4.51715049669739e-5*x_76 + 5.68513874973699e-5*x_77 - 3.31356254044895e-6*x_78 - 3.24199499191981e-5*x_79 + 7.02205850865677e-5*x_8 - 3.88704132166148e-5*x_80 - 2.16574893507056e-6*x_81 + 0.000113119819455252*x_82 + 5.50705940644211e-6*x_83 + 9.44130197403506e-5*x_84 + 3.42280248042117e-6*x_85 - 3.42517420982224e-5*x_86 + 1.98905230146347e-5*x_87 + 1.05597866810296e-5*x_88 + 9.19774007746145e-5*x_89 + 2.36296131474059e-5*x_9 - 9.09977594416959e-6*x_90 - 0.000144826318182963*x_91 - 8.05295218877703e-5*x_92 + 5.16963834841934e-5*x_93 + 1.99320982454922e-5*x_94 + 2.258759646637e-5*x_95 + 3.78268132940874e-5*x_96 + 3.85901929118991e-6*x_97 - 4.67260681846942e-5*x_98 + 3.15819801577305e-5*x_99 + 2.78562953958858e-5*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 4.71806169000283e-7*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.057284074195253);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000259587925945118*x_1 - 2.71828578591124e-5*x_10 - 2.44341273915012e-5*x_100 - 7.84957607259527e-5*x_101 + 1.1749822001522e-5*x_102 - 2.66501892892519e-5*x_103 - 6.52762875930935e-5*x_104 - 1.29870715456372e-5*x_105 - 2.28846838073238e-6*x_106 + 2.07244980891702e-5*x_107 - 7.95924535300182e-5*x_108 - 2.95004316984713e-5*x_109 - 6.62048166202709e-6*x_11 - 5.50251404587818e-5*x_110 + 2.81299161005738e-5*x_111 - 1.37832144739465e-5*x_112 - 1.65492248357917e-5*x_113 - 1.32209555901388e-5*x_114 - 5.04195397401615e-6*x_115 - 8.74996505887618e-5*x_116 - 1.70413909981151e-5*x_117 - 2.8820080688754e-5*x_118 - 1.52527164817356e-5*x_119 - 1.98402251072818e-5*x_12 - 2.92536300210096e-5*x_120 - 6.49761303366256e-5*x_13 - 1.10878286150062e-6*x_14 - 0.000165382750368769*x_15 - 0.000168615359662827*x_16 - 4.00280482093532e-5*x_17 - 1.88850825399027e-6*x_18 - 2.5332876061986e-5*x_19 - 0.00021800872042814*x_2 - 5.85378485396269e-5*x_20 + 4.73052259253562e-5*x_21 - 9.31341650456038e-6*x_22 - 1.70582734184708e-5*x_23 - 4.57923294289392e-5*x_24 - 1.96954490598219e-5*x_25 - 3.79877539108356e-5*x_26 - 9.28207857870734e-5*x_27 - 3.93246104097141e-5*x_28 - 1.28469494934863e-5*x_29 - 2.63787538930826e-5*x_3 - 2.3649759286815e-5*x_30 - 0.00019068704597722*x_31 - 7.15271086371871e-6*x_32 - 2.59973818015878e-5*x_33 - 1.143995161028e-5*x_34 + 3.97615636763677e-5*x_35 - 9.25970814536243e-6*x_36 - 1.79482486103292e-5*x_37 - 3.8596752690087e-5*x_38 + 2.00882120852404e-5*x_39 - 2.64162288738556e-5*x_4 - 1.14372978610059e-5*x_40 + 2.95657705330396e-5*x_41 - 5.21086023972601e-5*x_42 - 1.6218325339816e-5*x_43 - 6.48978662410473e-5*x_44 + 1.88604059148405e-6*x_45 - 1.20436721904329e-5*x_46 - 1.9364286644711e-5*x_47 - 1.29581035722143e-5*x_48 - 4.33995547833921e-5*x_49 - 0.000120419739847755*x_5 - 5.8957774435505e-5*x_50 - 8.77044926852318e-6*x_51 - 5.22106616959933e-5*x_52 + 1.07295084007539e-5*x_53 - 4.8240071682868e-5*x_54 - 5.20828422404963e-5*x_55 + 1.05194934963666e-6*x_56 - 5.96206890282487e-5*x_57 - 2.39141113092832e-5*x_58 + 4.95367896097805e-6*x_59 - 3.86818894139187e-5*x_6 + 4.60659040611281e-6*x_60 - 1.85613899924603e-5*x_61 - 5.06688611602412e-5*x_62 - 1.07607319302567e-5*x_63 - 9.91484948362474e-7*x_64 - 2.32306514710556e-5*x_65 - 6.73224510352114e-5*x_66 - 3.21972252886308e-5*x_67 - 7.12154917623108e-6*x_68 - 2.39523008360651e-5*x_69 - 7.19375809568063e-6*x_7 - 2.63150103780863e-5*x_70 + 1.02134260434566e-5*x_71 - 1.27759057860256e-5*x_72 - 1.90090598316709e-5*x_73 - 6.6495908501637e-5*x_74 - 1.54054235275698e-5*x_75 - 2.29494758696088e-5*x_76 + 1.96049524435187e-8*x_77 - 6.88939642915708e-5*x_78 + 1.80483027418553e-5*x_79 - 1.59342813618741e-5*x_8 - 6.37941944020654e-5*x_80 - 2.16829542599394e-5*x_81 - 0.000135678249948586*x_82 - 3.49081033276481e-5*x_83 - 4.36931675325521e-5*x_84 - 4.94758567193439e-5*x_85 - 4.02040964048712e-5*x_86 - 9.46797153102626e-5*x_87 - 5.94788701677302e-5*x_88 - 7.23890182263097e-5*x_89 + 7.07610119616878e-6*x_9 - 1.29791804652868e-5*x_90 - 9.43996472722545e-5*x_91 + 2.19663234543743e-6*x_92 - 2.41301892751745e-5*x_93 - 3.72982137427283e-5*x_94 + 4.10063679863072e-5*x_95 - 2.35015963047408e-5*x_96 + 2.07962222725853e-5*x_97 + 2.08774347106069e-6*x_98 - 3.42836701877332e-5*x_99 - 0.000462785954797676*std::sin(0.310479938983917*x_3 - 1.07119989395142) + 7.83827372940903e-6*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.00473724766001732);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000252601925193254*x_1 + 2.62618318483694e-5*x_10 + 5.49028873144778e-5*x_100 + 1.79278605378418e-5*x_101 + 4.58226784230095e-5*x_102 - 1.7349596498057e-5*x_103 + 6.2517297511458e-5*x_104 + 8.18581527409478e-6*x_105 + 2.57289817628992e-6*x_106 + 1.46040185659801e-5*x_107 + 2.45404582284516e-5*x_108 + 2.91190194997345e-5*x_109 + 1.9843316577008e-5*x_11 + 9.61462301328722e-6*x_110 + 1.04945842771244e-5*x_111 + 2.06276379932538e-5*x_112 + 7.56422236621255e-5*x_113 + 3.74729013271548e-5*x_114 - 3.1586033100959e-5*x_115 + 0.000229941178273499*x_116 + 3.49184092245463e-5*x_117 + 5.2576637233685e-5*x_118 + 3.11573952897817e-5*x_119 - 1.67347695193495e-5*x_12 + 3.46018597211799e-5*x_120 + 0.000131603456603229*x_13 - 7.15883024787985e-6*x_14 + 0.000186766818847917*x_15 + 0.000175285554157159*x_16 + 4.96269877676244e-5*x_17 + 7.71643307211963e-6*x_18 + 2.40603537829851e-5*x_19 + 0.00019571931668877*x_2 + 4.23819382496728e-5*x_20 + 7.09914640250128e-6*x_21 + 1.99654855247705e-5*x_22 + 3.15862903513202e-5*x_23 + 2.6928212064032e-5*x_24 + 7.57959921513113e-6*x_25 + 2.40887442985977e-5*x_26 + 8.9896333825239e-5*x_27 + 5.62012083020317e-5*x_28 + 1.77566201970289e-5*x_29 - 5.3229764676669e-6*x_3 + 3.66012058764341e-5*x_30 - 5.94506161072733e-5*x_31 + 1.23072522666791e-5*x_32 + 2.71540740970608e-5*x_33 - 1.66426473212011e-5*x_34 + 1.50494059569046e-6*x_35 + 2.40472673684089e-5*x_36 - 1.24118073535102e-5*x_37 + 5.96606088514778e-6*x_38 + 5.69256090323116e-6*x_39 + 7.78529068564136e-9*x_4 + 1.11022444807731e-5*x_40 - 1.39903068577968e-5*x_41 + 7.37316983055379e-5*x_42 + 1.42678923153362e-5*x_43 + 3.31610175548045e-5*x_44 - 1.15212797278594e-5*x_45 - 1.03890415179174e-5*x_46 + 2.69414988348928e-5*x_47 + 8.03836142241522e-5*x_48 - 5.66322670637092e-5*x_49 + 0.000117164920831766*x_5 + 2.85837403367038e-5*x_50 + 5.51768508876467e-5*x_51 + 3.96047119577626e-5*x_52 - 3.6970397448886e-6*x_53 + 3.24485297965889e-5*x_54 + 7.24622331765898e-5*x_55 + 2.62655281762616e-5*x_56 + 0.000127940541648412*x_57 + 3.15749541048818e-5*x_58 + 2.46952917121656e-5*x_59 + 4.31180320923038e-5*x_6 + 2.35007002163232e-5*x_60 + 2.67184504574466e-5*x_61 + 1.04671115246134e-5*x_62 + 2.32125122857987e-5*x_63 - 6.91727133295206e-6*x_64 + 3.62523610115847e-5*x_65 + 9.02462073150143e-5*x_66 + 1.13762539354145e-5*x_67 + 2.27332311844983e-5*x_68 - 6.27535909894858e-6*x_69 + 3.93592390878053e-5*x_7 + 2.32142799413237e-5*x_70 + 2.8686832532711e-5*x_71 + 2.7893017393132e-5*x_72 - 1.53458303669512e-5*x_73 + 0.000119256082838956*x_74 + 1.41739403034153e-5*x_75 + 5.98489762280058e-6*x_76 + 3.09773750484878e-5*x_77 + 3.55680204309478e-5*x_78 - 2.05525741222198e-5*x_79 + 0.000108221680500173*x_8 + 6.57326720339472e-5*x_80 + 3.48780619692188e-5*x_81 + 2.67990878913012e-5*x_82 - 1.00374827104914e-5*x_83 + 4.40126099982809e-5*x_84 + 3.08865652612227e-5*x_85 + 3.88504773373022e-5*x_86 + 8.40245884618729e-5*x_87 + 2.13062071967735e-5*x_88 + 0.000103813732254433*x_89 + 1.7906572076915e-5*x_9 + 3.38312811309782e-5*x_90 - 4.31816225629913e-5*x_91 + 1.00018581612067e-5*x_92 - 3.24738117728029e-5*x_93 - 2.56939535451239e-5*x_94 - 1.38512409344895e-6*x_95 + 2.93896715969192e-5*x_96 - 3.31122959137457e-5*x_97 - 3.16079711155603e-5*x_98 + 6.45602568435601e-5*x_99 + 0.000726048552425615*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 1.22971910356294e-5*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.0547957724258018);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000100657550384078*x_1 + 3.59661598252576e-5*x_10 + 1.25824202422911e-5*x_100 + 1.22434759871416e-5*x_101 + 4.24862550931478e-5*x_102 - 6.22974336984448e-5*x_103 - 2.97975878507375e-5*x_104 - 7.82364048936672e-6*x_105 + 1.92478308163245e-6*x_106 + 5.54426896327532e-5*x_107 + 1.92737594613585e-5*x_108 + 2.51854409843891e-6*x_109 + 6.36025924352596e-6*x_11 + 1.61589345805216e-6*x_110 + 4.97796529703297e-5*x_111 + 2.68695618054512e-5*x_112 + 0.000109574659054734*x_113 + 4.84543338223119e-5*x_114 - 1.66977377252906e-5*x_115 + 0.000191661604492509*x_116 - 1.48549618826859e-5*x_117 + 3.14129399054137e-5*x_118 + 3.5701182604177e-5*x_119 - 5.96160076994397e-5*x_12 - 6.0845554742005e-6*x_120 + 0.000140052138615454*x_13 + 1.00383373589962e-5*x_14 + 0.000114514671707942*x_15 + 0.000106757196877679*x_16 + 8.85193824207529e-5*x_17 - 1.75895319079371e-5*x_18 + 1.06604738361614e-5*x_19 + 0.000127279539325621*x_2 + 4.13659082914158e-5*x_20 + 3.15445143720516e-5*x_21 + 2.02110890582877e-5*x_22 + 1.16323502441241e-5*x_23 + 1.18088025682025e-5*x_24 + 2.02285441733787e-5*x_25 + 2.82083706791419e-5*x_26 + 8.55397414426485e-5*x_27 + 7.06047325515128e-5*x_28 + 2.17941037580165e-5*x_29 - 4.83772066276983e-6*x_3 + 1.41821094703255e-5*x_30 - 0.000370369584078979*x_31 - 2.31141880936202e-5*x_32 - 2.17808636985774e-5*x_33 - 2.84462097401235e-5*x_34 + 4.25479803685407e-6*x_35 + 1.66508253240667e-5*x_36 - 3.52659560709623e-5*x_37 - 1.61833855247477e-5*x_38 - 1.79461763046637e-5*x_39 + 3.15995862082184e-6*x_4 + 1.00983032250473e-5*x_40 - 6.19075516366483e-7*x_41 + 9.85992198428036e-5*x_42 - 1.29576447846338e-5*x_43 + 1.631910511988e-6*x_44 - 1.71520318247578e-5*x_45 - 1.03388055738954e-5*x_46 + 2.75716136110672e-5*x_47 + 5.86190778203058e-5*x_48 - 9.92977864135056e-5*x_49 + 0.000106971584086504*x_5 + 1.77580319671053e-5*x_50 + 5.86079388157669e-5*x_51 - 2.905534596926e-5*x_52 - 2.17364137479524e-5*x_53 + 1.62134128086738e-5*x_54 + 4.80198385250487e-5*x_55 + 3.8220397870602e-5*x_56 + 9.05274857580018e-5*x_57 + 3.10603142739903e-6*x_58 + 3.05535263288108e-5*x_59 + 4.73194751337619e-5*x_6 + 2.37179099149978e-5*x_60 + 2.40234762612833e-5*x_61 - 6.57627320344032e-5*x_62 + 2.86243874457148e-5*x_63 + 8.29017944934025e-6*x_64 + 5.37089559885238e-5*x_65 + 5.34712979522585e-5*x_66 - 1.77043058215816e-5*x_67 + 1.18327530191462e-5*x_68 - 1.60682357164968e-5*x_69 + 3.34401125996991e-5*x_7 + 4.36960898772181e-5*x_70 + 3.41866445251793e-5*x_71 + 4.56470580001024e-5*x_72 - 2.0424374599668e-5*x_73 + 0.000122863809482988*x_74 + 2.74806309628729e-5*x_75 - 3.11315910309029e-5*x_76 + 7.16528570847497e-5*x_77 + 5.47791782115344e-6*x_78 - 8.26712044807317e-6*x_79 + 0.000123587507383073*x_8 + 0.000103555211157654*x_80 + 2.42910032174711e-5*x_81 - 6.94906689928714e-5*x_82 - 3.03311607506363e-5*x_83 + 6.30780037688249e-5*x_84 - 2.33327348580324e-5*x_85 + 8.19182648159581e-5*x_86 + 7.90056866534431e-5*x_87 - 4.0711193412057e-5*x_88 + 6.9389754577428e-5*x_89 + 2.65754036025881e-5*x_9 + 1.49907266140197e-5*x_90 - 0.00017448511991709*x_91 + 1.14954206946849e-5*x_92 - 4.38702321620722e-5*x_93 - 6.03373215881692e-5*x_94 + 1.34456834007733e-5*x_95 + 2.38590170285205e-5*x_96 - 6.19654688190661e-5*x_97 - 3.83114521749192e-5*x_98 + 4.59641732632919e-5*x_99 + 0.00114095636347893*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 1.93245456080636e-5*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.038403949557908);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000132183154319076*x_1 + 4.29795842398385e-5*x_10 + 5.31377633286174e-8*x_100 + 9.04729564327313e-5*x_101 - 1.46894557579161e-5*x_102 - 5.25825020312247e-6*x_103 + 9.46914305721089e-5*x_104 + 2.32870357230016e-5*x_105 + 3.36105325419733e-5*x_106 + 9.15550552865879e-6*x_107 + 9.49235726841279e-5*x_108 + 5.09161333971258e-5*x_109 - 3.22454139503282e-5*x_11 + 2.8065281659088e-5*x_110 + 2.98332942977565e-5*x_111 + 2.53628254974048e-5*x_112 + 4.06054602249851e-5*x_113 - 5.91233959274145e-5*x_114 + 3.4858006244701e-5*x_115 + 4.24367280419032e-5*x_116 - 1.31002029324951e-5*x_117 + 5.49388175852689e-5*x_118 + 6.08769092733264e-5*x_119 - 2.17674686210725e-6*x_12 - 2.19142147375846e-6*x_120 + 0.000154523946637383*x_13 + 1.97550586769755e-5*x_14 - 6.42572423827692e-5*x_15 + 7.7581293736488e-5*x_16 + 8.46161803965164e-5*x_17 + 1.50283227598162e-5*x_18 + 2.28816972729037e-5*x_19 - 3.34093738101018e-5*x_2 - 3.1290916103359e-7*x_20 - 6.45133392284165e-5*x_21 + 5.4309003742396e-6*x_22 - 5.31836943854735e-7*x_23 + 4.14126171224083e-5*x_24 + 6.31361733792585e-6*x_25 + 7.64941101926207e-5*x_26 + 2.2211777770478e-5*x_27 + 9.60840379969323e-5*x_28 + 7.79464887033936e-6*x_29 + 3.00935857492073e-5*x_3 + 8.57289560070348e-5*x_30 + 0.000103304054313598*x_31 - 9.25544111937259e-5*x_32 - 5.79378937341651e-5*x_33 + 8.46355485955556e-5*x_34 + 4.75562879675177e-5*x_35 - 1.09657130119879e-5*x_36 + 4.4483956746149e-5*x_37 + 9.8796561005113e-6*x_38 + 6.60010803001781e-5*x_39 + 1.29724677170416e-5*x_4 + 2.42576688404581e-5*x_40 - 3.24643059935209e-6*x_41 + 2.66685813449864e-5*x_42 + 5.53309810535209e-6*x_43 + 3.5496588973795e-5*x_44 + 6.05911692812641e-5*x_45 + 1.12157893990817e-5*x_46 + 4.54140770629806e-5*x_47 + 2.95913643581709e-5*x_48 + 5.9161116704853e-5*x_49 + 2.0235307920984e-6*x_5 + 1.21057845685079e-5*x_50 + 1.88622044634764e-5*x_51 + 0.00011580745700891*x_52 + 3.97488085353683e-5*x_53 + 6.88124128034539e-5*x_54 + 2.23624548787542e-5*x_55 + 1.50034050837401e-5*x_56 - 5.82002092388285e-5*x_57 + 1.39811376999817e-5*x_58 - 1.73973369981504e-5*x_59 + 3.49921331238879e-5*x_6 + 4.42588768944567e-5*x_60 + 4.0604736077799e-5*x_61 + 9.1178558491266e-6*x_62 - 7.3165503345234e-6*x_63 + 4.85265357747736e-5*x_64 + 6.70133577005723e-5*x_65 + 4.61667340179728e-5*x_66 + 5.27875137773493e-5*x_67 + 3.1538567277679e-5*x_68 + 4.90694254212786e-5*x_69 + 3.70187164895871e-5*x_7 + 1.92689217090771e-6*x_70 - 2.93529057075209e-5*x_71 + 9.88627524437688e-5*x_72 + 4.73726879319661e-5*x_73 + 7.45255636465301e-5*x_74 + 6.79101904187076e-5*x_75 + 7.43298851190903e-5*x_76 + 3.51350184128528e-5*x_77 - 4.75269782440733e-7*x_78 + 5.71900471805026e-5*x_79 - 2.1798631662561e-6*x_8 + 0.000144973712872524*x_80 + 2.80819401798584e-5*x_81 + 0.00014963750760428*x_82 + 9.38878121582696e-5*x_83 + 9.05945126896044e-5*x_84 + 2.40390048480052e-5*x_85 + 5.23335395856808e-5*x_86 + 0.000178753568784813*x_87 + 4.05136162690221e-5*x_88 - 3.73928461043994e-5*x_89 + 9.08316336053908e-5*x_9 + 3.71198863638657e-5*x_90 + 7.95641389957558e-5*x_91 - 6.0722924689252e-5*x_92 + 9.78053859277446e-6*x_93 + 0.00010670863242473*x_94 + 3.42999413007294e-5*x_95 + 1.40349201725926e-5*x_96 + 4.18162155132962e-5*x_97 - 5.56050549710781e-6*x_98 - 6.74174729156351e-6*x_99 + 0.0011344541920519*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 1.92144173750172e-5*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.065239276441137);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.79582221315259e-5*x_1 + 2.62221653679968e-5*x_10 + 1.55887516572983e-5*x_100 + 6.50184200482525e-5*x_101 + 5.37013507323703e-5*x_102 - 3.29743022927716e-6*x_103 + 8.30312959438777e-5*x_104 + 3.91038311009455e-5*x_105 - 7.38909326043222e-6*x_106 + 4.74511361924899e-5*x_107 + 1.26896378187555e-5*x_108 + 6.99917534351775e-5*x_109 + 3.47463149758501e-5*x_11 - 9.13903690991626e-6*x_110 - 1.40993701090216e-6*x_111 - 3.75935203505404e-6*x_112 + 0.000143309525553765*x_113 - 1.555423185229e-5*x_114 + 5.5524199490436e-7*x_115 + 0.000109374518903187*x_116 + 7.16555123875333e-6*x_117 + 2.86227582788295e-5*x_118 + 5.10358734510831e-5*x_119 - 1.49070627471736e-5*x_12 - 2.32455809458138e-5*x_120 + 0.000133336976937175*x_13 + 4.26123396742937e-5*x_14 + 0.000120829851034968*x_15 + 0.000103554961134522*x_16 + 3.67403659366486e-5*x_17 - 7.4165423983398e-7*x_18 + 3.23287547821887e-5*x_19 + 0.000121444217583216*x_2 + 4.5524359365909e-5*x_20 + 4.26443830654709e-5*x_21 + 2.105486106628e-5*x_22 + 2.38824929259494e-5*x_23 + 7.40552791807478e-6*x_24 + 1.22574495896536e-5*x_25 - 1.19105205014239e-6*x_26 + 3.62116692210374e-5*x_27 - 1.72976364203421e-6*x_28 + 1.03852860239735e-5*x_29 + 7.16882781610063e-6*x_3 + 5.91986660585497e-5*x_30 + 3.90846767686041e-5*x_31 + 6.62204358407583e-6*x_32 - 7.23920320839926e-5*x_33 + 7.55921168579256e-6*x_34 + 4.42273825929961e-5*x_35 - 1.02805061793063e-5*x_36 - 4.53780200585886e-6*x_37 - 1.64263135343501e-5*x_38 + 3.42187876500922e-5*x_39 + 1.3493138589472e-5*x_4 + 7.76379982374089e-6*x_40 + 2.05340928844614e-5*x_41 + 7.63151530054802e-5*x_42 - 1.27175513339336e-6*x_43 + 5.08840942291663e-5*x_44 - 1.20135081811705e-5*x_45 - 5.05099820540578e-6*x_46 + 6.57917541143497e-5*x_47 + 0.000125453417748849*x_48 - 3.24281408072683e-6*x_49 + 9.13900691253165e-5*x_5 + 9.35689002530989e-6*x_50 + 5.16650627926171e-5*x_51 + 2.94003177299428e-5*x_52 + 2.55786239628579e-5*x_53 - 7.51624961682928e-5*x_54 + 6.30551035654583e-5*x_55 + 4.74516270486816e-5*x_56 + 6.47542049902845e-5*x_57 - 2.34619601231432e-7*x_58 + 4.61265906806209e-6*x_59 + 4.27333704126222e-5*x_6 - 5.52895398648212e-7*x_60 + 3.04045190709446e-5*x_61 - 1.03557759368609e-5*x_62 + 5.76682881727851e-5*x_63 + 2.18539346987992e-6*x_64 + 1.87058086562009e-5*x_65 + 6.36378125154589e-5*x_66 + 1.73391423564983e-5*x_67 - 1.07935633583239e-5*x_68 - 1.43838457498777e-5*x_69 + 1.54483312962196e-5*x_7 + 5.70244793798764e-5*x_70 + 4.58808835042247e-5*x_71 + 1.42245094980967e-5*x_72 - 6.57921782028854e-7*x_73 + 1.66937595418041e-5*x_74 + 1.11094846491377e-5*x_75 - 4.71799386788042e-6*x_76 + 5.32712512371812e-5*x_77 + 6.73665406220523e-5*x_78 + 2.53032720856075e-5*x_79 + 1.45737625692939e-5*x_8 + 2.90763243981183e-5*x_80 + 2.26630838531961e-5*x_81 - 5.31943519782042e-6*x_82 + 6.79076937816874e-5*x_83 + 9.27612103194784e-6*x_84 - 9.96685606382884e-6*x_85 + 0.000111067061841489*x_86 - 2.30464780843693e-6*x_87 - 7.36332208910631e-6*x_88 + 6.4518753541508e-5*x_89 + 3.26996537898124e-5*x_9 + 5.37893298596509e-5*x_90 + 9.43309341461223e-6*x_91 + 9.52541770270486e-6*x_92 - 4.6296708424122e-5*x_93 - 2.53631215318363e-5*x_94 + 3.24578094040121e-5*x_95 + 2.14905739727837e-5*x_96 + 4.58439125726093e-5*x_97 + 8.33519349280727e-7*x_98 - 1.19927679319926e-5*x_99 + 0.000122362329310404*std::sin(0.310479938983917*x_3 - 1.07119989395142) - 2.07246875442093e-6*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.0671108417464247);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.13235439487271e-5*x_1 - 1.45095826702411e-5*x_10 + 3.84279040183429e-6*x_100 + 2.30518630640476e-5*x_101 - 2.0288966084488e-5*x_102 + 1.57763897682464e-5*x_103 - 1.490712876472e-5*x_104 - 8.20241804950418e-6*x_105 - 7.78683997719306e-6*x_106 - 2.45800796690827e-5*x_107 + 2.5596406038624e-5*x_108 + 3.39729898056264e-5*x_109 + 1.91687063897139e-6*x_11 + 5.16678893512423e-6*x_110 - 2.93725982061435e-5*x_111 + 1.94260529526021e-6*x_112 - 2.7076748746918e-5*x_113 - 7.76014184875104e-6*x_114 + 2.74122123725481e-6*x_115 + 1.89126336086132e-5*x_116 + 9.20030634893654e-6*x_117 + 8.09129275133275e-7*x_118 - 7.10766624212483e-6*x_119 + 3.22504010963549e-5*x_12 + 2.64862365311141e-6*x_120 - 1.0791956760108e-5*x_13 - 4.76354321947221e-6*x_14 + 6.88026431525917e-5*x_15 + 6.59039980651663e-5*x_16 - 3.07238029069661e-6*x_17 - 1.13523026976239e-5*x_18 + 1.94287795365922e-6*x_19 + 8.65117352864736e-5*x_2 + 1.66907196999783e-5*x_20 - 4.01981975693803e-5*x_21 - 8.59348474760132e-6*x_22 - 1.10313990633021e-5*x_23 - 2.11400914401705e-5*x_24 - 3.3363158243584e-6*x_25 - 2.41304878858182e-6*x_26 + 1.77769925958173e-5*x_27 - 9.0858153977996e-6*x_28 - 3.61072402318317e-6*x_29 + 1.80407716927419e-5*x_3 - 1.00042112814118e-5*x_30 + 0.000100310271706927*x_31 + 5.1025346137524e-6*x_32 + 1.18389549379917e-5*x_33 + 8.33992328249489e-6*x_34 - 3.8535608361262e-5*x_35 + 3.6028157497787e-6*x_36 + 1.04796976510414e-5*x_37 + 1.27522266534661e-5*x_38 + 1.67624399354082e-5*x_39 + 1.53779449027157e-5*x_4 + 5.79525711768721e-6*x_40 - 1.14771770983837e-5*x_41 + 1.41664316848848e-5*x_42 + 1.50200038389863e-6*x_43 + 1.00368605410056e-5*x_44 - 1.02370578432049e-5*x_45 + 7.60021426103062e-6*x_46 + 3.91156390273933e-6*x_47 - 1.10330627726992e-6*x_48 + 1.92426682433541e-5*x_49 + 4.35234049774125e-5*x_5 + 6.53351091404529e-6*x_50 - 1.48786062466848e-5*x_51 - 1.69390942809715e-6*x_52 - 1.60242663285265e-5*x_53 + 2.47550784332904e-5*x_54 + 1.77631455365931e-5*x_55 - 2.08033715658161e-5*x_56 + 2.8413042102759e-5*x_57 + 8.01743144472623e-6*x_58 + 5.22629051056562e-6*x_59 + 1.08396785625461e-5*x_6 - 2.85342785618839e-5*x_60 - 8.76974584303973e-6*x_61 + 1.55504357998063e-5*x_62 - 2.47317384603991e-6*x_63 - 1.12164673736491e-5*x_64 - 7.25862311485405e-6*x_65 + 1.95055665238677e-5*x_66 + 8.97678652169038e-6*x_67 + 4.84303828000412e-6*x_68 + 2.23769059731548e-6*x_69 + 1.12892144670014e-6*x_7 + 1.48089852659815e-6*x_70 - 1.63937596505159e-5*x_71 - 2.18976294950907e-5*x_72 + 6.35806149484228e-6*x_73 + 4.78309674145183e-6*x_74 - 4.25029353069065e-6*x_75 + 1.33160905183917e-5*x_76 + 2.63644039359754e-6*x_77 + 1.19980398111475e-5*x_78 - 3.02677637476837e-5*x_79 + 1.93211315493363e-6*x_8 - 5.5951198971076e-6*x_80 - 7.69817962866921e-6*x_81 + 6.16841503660346e-5*x_82 + 1.10081800159847e-5*x_83 + 7.8437401326994e-6*x_84 + 1.66439654836666e-5*x_85 + 5.94147933210403e-6*x_86 + 1.65529094769072e-5*x_87 + 1.87493057412722e-5*x_88 + 2.76944648412243e-5*x_89 - 2.41960030630996e-5*x_9 - 6.05150088647458e-6*x_90 + 2.68964170129761e-5*x_91 - 1.43839726290137e-5*x_92 + 2.19352691129897e-5*x_93 + 1.00752514855277e-5*x_94 - 2.48281773533858e-5*x_95 + 7.4200432293172e-6*x_96 - 1.30639126691627e-5*x_97 - 5.8266836335962e-6*x_98 + 8.10455626448653e-6*x_99 - 3.68532536125027e-6*std::sin(0.310479938983917*x_3 - 1.07119989395142) + 6.24188972546535e-8*std::sin(2.51871991157532*x_43 + 2.37559986114502) + 0.038763895524791);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
