
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000799214230300754*x_1 + 0.00129962032338392*x_10 + 0.000925229623464439*x_100 - 0.000142738073742161*x_101 + 0.000966209264371716*x_102 - 0.00197583449729147*x_103 - 0.000964258389179321*x_104 - 0.000570921531547259*x_105 + 0.000468504780357794*x_106 - 8.9136909975558e-5*x_107 - 0.0010507150286116*x_108 - 0.00217956191010467*x_109 + 0.0037431960027346*x_11 - 0.00080789229458391*x_110 + 0.00083092627507093*x_111 - 0.000513275488496784*x_112 + 7.67105859655565e-5*x_113 - 0.0010687052316086*x_114 + 4.54689977340435e-5*x_115 + 0.000713910565128299*x_116 - 0.000387402071095168*x_117 - 0.00110191225483426*x_118 + 0.000127884962601213*x_119 + 0.00143021037593836*x_12 + 0.000872464535016338*x_120 + 0.00110213563623217*x_13 + 0.00100290710641238*x_14 - 0.00139631395565674*x_15 + 0.00103075092705526*x_16 + 0.00893255536519549*x_17 - 1.39246438941518e-6*x_18 - 0.00269257970171607*x_19 + 0.00245455719661304*x_2 - 0.0024903864468536*x_20 - 0.00272212983601257*x_21 + 0.00652868634287433*x_22 + 0.000412611463206168*x_23 - 0.000946681488912307*x_24 + 0.000167340655583649*x_25 - 0.000244567400647468*x_26 + 0.000206987373113381*x_27 + 0.000800429307714293*x_28 + 0.00658995120513623*x_29 - 0.00532314296556804*x_3 - 7.4228126905135e-5*x_30 + 0.00139573808418298*x_31 + 0.000293736914477541*x_32 + 0.00109982273845096*x_33 + 2.40534103705892e-6*x_34 + 0.000251133950691183*x_35 - 0.000450876743814232*x_36 + 0.00030430673730527*x_37 + 0.000144082365098413*x_38 - 0.00459247488189064*x_39 - 0.00275207130248876*x_4 - 0.000567125730213216*x_40 + 0.000816938558059122*x_41 - 0.00242185653343939*x_42 - 0.000757986726737334*x_43 - 0.000220291661699002*x_44 - 0.00153484101471547*x_45 + 0.000102460129068297*x_46 - 0.000196660162477017*x_47 + 0.00144229318080155*x_48 - 0.000369267172947347*x_49 - 0.00182150366075164*x_5 + 0.000670647088815737*x_50 + 0.000190153592358312*x_51 - 0.000352871462615596*x_52 - 0.000591199358261409*x_53 + 0.00113125556726106*x_54 + 7.43711301000074e-5*x_55 - 0.000208570856785099*x_56 - 0.000344055470876319*x_57 - 0.000490318724413217*x_58 - 0.000143326631121021*x_59 - 0.00076559499810395*x_6 + 0.00157135159966883*x_60 - 0.00237261202996816*x_61 - 0.00137284555859572*x_62 - 0.000564565589565426*x_63 + 0.00017144940426961*x_64 - 0.000784721178209283*x_65 + 0.000143747768652164*x_66 - 0.000108575002763171*x_67 + 0.000332158761413103*x_68 - 0.000344176377321606*x_69 + 0.000797100681258401*x_7 + 0.000590405802357768*x_70 + 0.000112170913689127*x_71 + 0.000804352153300462*x_72 + 0.000443975047543488*x_73 + 0.000377826097963497*x_74 + 0.000102268891682686*x_75 + 0.000852220541904356*x_76 + 0.00114446968743752*x_77 + 0.00184517252755455*x_78 - 0.000731762900164449*x_79 - 0.00328991659475717*x_8 + 3.48946531110949e-5*x_80 + 0.000901322017789429*x_81 + 0.00139406165020539*x_82 + 0.00257399588842585*x_83 - 0.000515374699871887*x_84 + 0.000176145619248118*x_85 - 0.000231405240284628*x_86 + 0.000521454818887909*x_87 - 0.000321471268711162*x_88 - 0.00049328831198342*x_89 - 0.00534249518448861*x_9 + 0.00159207065645649*x_90 - 0.00296658519794772*x_91 - 0.00102405233751955*x_92 - 3.81402052004862e-5*x_93 - 0.000350780502050849*x_94 + 0.000440850151433955*x_95 + 0.000457365629444184*x_96 - 0.00159939068330395*x_97 + 0.000868800262414829*x_98 + 7.43083109733354e-5*x_99 - 9.38631623255356e-6*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) - 7.94229010507337e-6*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) + 1.75717003439392e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 2.5417818802095e-6*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) + 1.26466996731141e-5*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 1.13401234796695e-6*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) + 6.30790152445405e-5*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) + 2.24997961946891e-5*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) - 3.72977750559156e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) - 0.000158414237872177*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 2.54062315557021e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) + 2.05607125498011e-6*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) + 1.96575393346335e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 6.80434098933924e-6*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 3.34855438753855e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 2.12787718995606e-6*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) + 3.64880879222972e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 7.41764293094661e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) + 3.22820579677057e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 5.2656314341494e-6*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 1.00205921831e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 3.17226577588935e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) - 4.36934749078316e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) - 9.52453221810202e-6*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 1.22897897053585e-6*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 1.6122370956155e-5*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 4.28642667947158e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 2.96728031969114e-5*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) + 2.77864624753485e-5*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 3.10122201170162e-7*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) - 8.07141466927257e-6*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 7.92216484663365e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) - 4.88452327395228e-6*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) + 1.46539129694852e-5*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 2.05165309614741e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) + 1.08459861710927e-5*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) - 8.41918768489045e-6*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) + 1.10113126519887e-5*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) - 9.39507142178097e-6*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) - 1.44735936698691e-5*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) + 7.78344140884494e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) - 5.3405621085944e-6*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) - 1.05571126327471e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 0.000183076950852557*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 1.3409690131248e-6*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) - 5.51414156444909e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) + 1.2333742583372e-6*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 6.89062027433469e-7*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) + 1.6046850626516e-5*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) - 2.11276610943319e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) + 0.000119208460322292*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) - 8.34470287685185e-6*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 7.54976639296488e-7*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) + 3.46565266870636e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 2.33466898171713e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) + 7.19995570219328e-6*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) - 5.52029811748652e-5*std::exp(0.759199857711792*x_22) - 0.000628284992881437*std::exp(0.627279818058014*x_38) - 0.000285949998310851*std::exp(0.757519841194153*x_72) - 0.00119471186791467*std::exp(0.511599838733673*x_73) - 0.0206535824824459*std::exp(0.000774560650380308*x_10 + 0.00235443389171528*x_100 + 0.00386566146986717*x_101 - 0.0276090398423664*x_102 - 0.000720775642206851*x_103 - 0.00132329027265859*x_104 + 0.00138369550278824*x_105 + 0.000595696273199732*x_106 + 0.00116113445444794*x_107 + 0.0180331466679606*x_108 + 0.00960365053647641*x_11 + 0.00821458729679595*x_111 - 0.0025563322517558*x_112 - 0.000540283626684695*x_114 - 0.00612449568511296*x_116 - 0.00629101384298343*x_119 - 0.0163362689597161*x_13 + 0.0054029686758696*x_14 - 0.00243457055760114*x_15 - 0.0114038916378829*x_16 - 0.0211630645522422*x_17 + 0.00300014875506388*x_18 - 0.000681978516477433*x_19 - 0.028284595060638*x_2 + 0.0511117679346712*x_20 + 0.0025472415268985*x_21 + 0.000441691476461393*x_24 + 0.00869746260736459*x_25 - 0.000679573075925834*x_26 + 0.0264838448307899*x_27 + 0.0583732762209714*x_29 - 0.0461290258501034*x_30 + 0.0420650482456492*x_31 + 0.0268821516678703*x_32 - 0.000597672786528131*x_33 + 0.00162134356854697*x_37 - 0.0256913218390908*x_38 + 0.00671382537879546*x_4 + 0.000850417805416868*x_42 - 0.0273190668371305*x_44 - 0.0218580950064996*x_45 + 0.00236351651808187*x_47 - 0.00154345906429237*x_49 + 0.000243644831762105*x_50 + 0.00307489651625719*x_51 + 0.0226210732875097*x_52 + 0.00103852974605294*x_54 - 0.000294787976116475*x_58 - 0.00595960533271501*x_59 + 0.0014279583024138*x_6 - 0.0257835593735054*x_61 - 0.00201942325751721*x_63 + 1.26429681113073e-5*x_70 + 0.00124281139651539*x_71 - 0.004999802593355*x_72 - 0.00490715376466834*x_77 + 0.0105653394831967*x_8 + 0.00606947909076856*x_81 + 0.000167488256634101*x_82 + 0.000816318398157007*x_83 + 0.000326516983927626*x_84 + 0.00864230848770712*x_85 + 0.0219426099691508*x_86 + 0.00715366902438879*x_9 + 0.00238616640482617*x_91 + 0.0213232075770205*x_92 + 0.0107061795205942*x_94 + 0.000213123464519946*x_96 - 0.000756364856469659*x_99 + 0.000472132323506944*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 0.000230987485118812*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) + 0.00229113543814824*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) + 0.000246407036669685*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 0.000126242657530529*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) - 0.000537667470864672*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 0.000294619380126392*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 0.000506350150944086*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 0.000215550867456636*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) - 0.000144587401508949*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) - 0.0621889876007131*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 0.000144062115745636*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 0.000587200639910551*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) + 0.000422115482581649*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 0.76070308980043*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 0.0434108547237129*std::sin(0.373039841651917*x_109 + 8.18727970123291) - 0.31618608706534*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.231987487685338*std::sin(0.310799926519394*x_113 - 7.49704027175903) + 0.397648803514436*std::sin(0.334959834814072*x_115 - 4.27088022232056) - 0.24488229031078*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.305080249796788*std::sin(0.368079841136932*x_118 + 5.17296028137207) + 0.388060137689386*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.289290925471427*std::sin(0.416159868240356*x_120 - 1.16447985172272) - 1.22364787277559*std::sin(0.295439928770065*x_23 + 5.13943958282471) + 0.589620625220434*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.758242698765429*std::sin(0.315519839525223*x_3 + 8.31960010528564) - 0.340605472768715*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.398486295133196*std::sin(0.342639863491058*x_35 - 1.21223986148834) + 0.0929808631650513*std::sin(0.355199843645096*x_36 - 4.24295997619629) + 0.405727444208189*std::sin(0.319519847631454*x_39 + 1.94815981388092) - 0.544318935083453*std::sin(0.336239844560623*x_41 - 7.43887996673584) - 0.210579398792266*std::sin(0.344799846410751*x_43 - 4.25375986099243) + 0.426358660309845*std::sin(0.296719938516617*x_46 + 5.10799980163574) + 0.133057530252628*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 0.261033158741263*std::sin(0.2811199426651*x_55 + 1.88439989089966) + 0.443126935787738*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.178649972314638*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.525986990322806*std::sin(0.288639932870865*x_60 - 7.49160003662109) + 0.372283639278074*std::sin(0.27167996764183*x_62 - 4.30463981628418) + 0.935602434057387*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.298364214239285*std::sin(0.236399978399277*x_65 - 4.34391975402832) + 0.249235533485802*std::sin(0.242479979991913*x_68 + 5.06775999069214) + 1.59078844534676*std::sin(0.145920038223267*x_73 - 7.66184043884277) + 0.430671631363019*std::sin(0.317759841680527*x_74 - 4.29056024551392) + 0.399039463387254*std::sin(0.243279978632927*x_76 - 7.53600025177002) + 0.542859464649865*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.982868829539001*std::sin(0.174000009894371*x_87 + 4.95519971847534) - 0.333837197356914*std::sin(0.338559836149216*x_93 + 1.98655986785889) - 0.0681336115224163*std::sin(0.367679834365845*x_95 + 1.98583984375) - 0.205474372935061*std::sin(0.472959846258163*x_97 - 1.13407981395721) + 0.222023156767072*std::sin(0.375119835138321*x_98 - 7.40303993225098)) - 0.0455210984635498*std::sin(0.358559846878052*x_1 + 8.25119972229004) + 0.0131220086078905*std::sin(0.20160000026226*x_10 + 5.00271987915039) - 0.021487259218982*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.000950387047149845*std::sin(0.348559856414795*x_10 - 4.24007987976074) + 0.0243118841781107*std::sin(0.140800043940544*x_100 + 1.73271989822388) - 0.00640495375970662*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.000663127096876463*std::sin(0.378879845142365*x_101 - 4.40639972686768) - 0.00740917208861791*std::sin(0.344959855079651*x_102 - 7.43727970123291) - 0.00716410191632957*std::sin(0.36847984790802*x_102 + 1.96815979480743) - 0.00563345149942151*std::sin(0.333679854869843*x_103 + 1.94599986076355) - 0.00393924036619411*std::sin(0.385199844837189*x_104 + 1.99399983882904) + 0.00263102373769542*std::sin(0.409279853105545*x_105 - 1.17479979991913) + 0.0106762976682661*std::sin(0.300639927387238*x_106 - 7.50688028335571) + 0.0176117807765601*std::sin(0.369759827852249*x_107 + 5.16495990753174) - 0.00267541929812611*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.000598572797655863*std::sin(0.330879837274551*x_109 + 1.928879737854) - 0.00654563184304211*std::sin(0.362399846315384*x_109 - 1.22647988796234) - 0.0104729594865029*std::sin(0.238639980554581*x_11 - 4.33599996566772) - 0.00838908827493161*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.00697445388056117*std::sin(0.32423985004425*x_110 + 5.12512016296387) - 0.00948203790983685*std::sin(0.24679996073246*x_111 + 1.84103989601135) - 0.00976446403275727*std::sin(0.385039836168289*x_111 - 7.41479969024658) + 0.00370922601520685*std::sin(0.352639853954315*x_112 - 4.23967981338501) + 0.00458660310977085*std::sin(0.345999836921692*x_113 + 1.96959984302521) - 0.000678978178766585*std::sin(0.256479978561401*x_114 - 7.52464008331299) - 0.00634356308802721*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.000671228772925781*std::sin(0.31687992811203*x_115 + 1.91471993923187) - 0.00495047101316563*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.0138379977197402*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.000514919342698375*std::sin(0.352479845285416*x_117 + 5.15328025817871) + 0.00572419946736111*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.000656903947035279*std::sin(0.271039962768555*x_118 + 5.06983995437622) + 0.0139036721905677*std::sin(0.277119934558868*x_118 - 7.51272010803223) + 0.00893584303243227*std::sin(0.303199917078018*x_118 + 5.1017599105835) - 0.000325241449865729*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.00119577506509569*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.0119393228480207*std::sin(0.310799926519394*x_12 + 5.12871980667114) + 0.0110628350537696*std::sin(0.327679842710495*x_12 - 4.2513599395752) + 0.000414595459679165*std::sin(0.44463986158371*x_120 + 2.0079197883606) - 0.0495483769062029*std::sin(0.190880000591278*x_13 - 4.42511987686157) + 0.0212350129327285*std::sin(0.123040057718754*x_14 + 4.89599990844727) - 0.0883814483138998*std::sin(0.126320049166679*x_14 - 4.50839996337891) + 0.107461871456811*std::sin(0.221919998526573*x_14 + 5.03495979309082) + 0.00689739259333284*std::sin(0.399439841508865*x_15 - 0.997359812259674) - 0.00112017561206353*std::sin(1.36559987068176*x_15 - 2.19623994827271) + 0.0169617836184405*std::sin(0.207520008087158*x_16 - 1.18359982967377) - 0.00304296228956152*std::sin(0.352719843387604*x_16 - 4.25216007232666) + 0.0654320109969253*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.00448190632099552*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.000542671936850253*std::sin(0.271839946508408*x_21 + 8.30095958709717) + 0.00453675794443683*std::sin(0.288319945335388*x_21 - 1.0707198381424) - 0.00129485900932327*std::sin(0.292639940977097*x_21 + 5.07719993591309) - 0.00756941165242249*std::sin(0.33943983912468*x_21 - 4.23839998245239) + 0.00529653435357047*std::sin(0.349679857492447*x_21 - 4.02647972106934) - 0.00599502868319983*std::sin(0.3503198325634*x_21 - 4.22424030303955) - 0.0464877396985114*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.00933840656646506*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.00330801173108764*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.00147526284196169*std::sin(0.258639991283417*x_24 + 5.07799959182739) - 0.00130123578508616*std::sin(0.568079829216003*x_24 + 2.35255980491638) - 0.00377933721652824*std::sin(0.609839856624603*x_24 + 2.38503980636597) - 0.0198797932443609*std::sin(0.345119833946228*x_26 + 1.93407988548279) + 0.00656521006305786*std::sin(0.3503198325634*x_26 + 5.16328001022339) - 0.0151474903546505*std::sin(0.357919842004776*x_26 + 5.1561598777771) - 0.00405589117535263*std::sin(0.371439844369888*x_26 + 5.18544006347656) - 0.00447479301398683*std::sin(0.288959950208664*x_27 - 4.27960014343262) + 0.00759844085778021*std::sin(0.540319859981537*x_27 + 5.33847999572754) + 0.0228668999890742*std::sin(0.278879970312119*x_28 + 5.09839963912964) - 0.00357085201918537*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.000650260150314031*std::sin(0.312159925699234*x_28 + 5.14895963668823) + 0.0382086922574957*std::sin(0.360399842262268*x_28 + 8.36839962005615) + 0.001169343119006*std::sin(0.407039850950241*x_28 - 4.18111991882324) + 0.0110424124600161*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.00366485382108024*std::sin(0.247039973735809*x_30 + 8.25191974639893) - 0.00918281816575503*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.000486691470214095*std::sin(0.258159965276718*x_32 + 1.97111988067627) - 0.0235366890776802*std::sin(0.263439953327179*x_32 + 5.1547999382019) + 0.0170832157996382*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.00518807539812878*std::sin(0.361119836568832*x_34 + 1.98511981964111) + 0.00838498888839827*std::sin(0.361359834671021*x_34 + 2.00311970710754) + 0.0053859119077629*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 0.00125373469137326*std::sin(0.270799964666367*x_35 + 8.24799919128418) - 0.00976811612442772*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.0277343579752968*std::sin(0.304399937391281*x_35 - 1.12175977230072) - 0.00854359500268237*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.00572497682838604*std::sin(0.340399831533432*x_37 - 7.45648002624512) + 0.012619744564532*std::sin(0.386319845914841*x_37 + 5.17471981048584) - 0.00412673941909133*std::sin(0.413759857416153*x_37 + 5.19672012329102) - 0.0117490581998799*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.00104601204375685*std::sin(0.346879839897156*x_38 - 4.25672006607056) + 0.00114220514625644*std::sin(0.179680019617081*x_40 + 1.7875999212265) + 0.00974626756426943*std::sin(0.329919844865799*x_40 - 4.27824020385742) + 0.00647174104809176*std::sin(0.263519942760468*x_41 + 8.27439975738525) + 0.00673215235604655*std::sin(0.291759938001633*x_41 - 7.50631999969482) - 0.0113331943720392*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.000474383019305578*std::sin(0.405519872903824*x_42 - 1.18847990036011) + 0.0128519415286369*std::sin(0.332159847021103*x_43 + 5.14351987838745) + 0.00661732993373233*std::sin(0.347919851541519*x_43 - 7.45056009292603) - 0.000963633289712792*std::sin(0.386239856481552*x_43 + 1.97567975521088) - 0.00793761579637525*std::sin(0.206960007548332*x_45 - 7.57656002044678) - 0.00863628498276377*std::sin(0.282239943742752*x_45 + 5.07999992370605) + 0.0122450581890562*std::sin(0.315279841423035*x_46 + 5.10735988616943) + 0.0130648033809914*std::sin(0.22647999227047*x_47 - 4.37087965011597) + 0.0184810995326748*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.00966448451751514*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.00192309820499996*std::sin(0.293039947748184*x_49 + 1.90383982658386) + 0.192607131631617*std::sin(0.163760021328926*x_5 + 8.13551998138428) + 0.00924561311699916*std::sin(0.211119994521141*x_5 - 4.36911964416504) - 0.00721092526951424*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.000649781046249674*std::sin(0.215759992599487*x_52 + 1.79055988788605) - 0.0146232462737449*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.00615610883109678*std::sin(0.26335996389389*x_56 - 7.52920007705688) - 0.00610332061025153*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.0638699020951683*std::sin(0.140080034732819*x_57 + 4.9115195274353) - 0.0093742256074677*std::sin(0.231359988451004*x_57 + 1.84351992607117) - 0.00462022172925601*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.0218368928115892*std::sin(0.273039966821671*x_58 - 7.5079197883606) + 0.00986756492085088*std::sin(0.284239947795868*x_58 - 7.50048017501831) + 0.00639717692911602*std::sin(0.359839856624603*x_58 + 5.1528000831604) + 0.00319931516895686*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.00276647530803755*std::sin(0.261439979076385*x_59 + 5.08079957962036) - 0.00525221137413739*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 0.00905000798835127*std::sin(0.322079837322235*x_59 + 5.1165599822998) - 0.0399920878356689*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 0.0106601205379411*std::sin(0.313759922981262*x_7 + 8.38703918457031) - 0.00209481255021479*std::sin(0.534639835357666*x_7 - 3.87391996383667) + 0.0184993498921306*std::sin(0.205680012702942*x_70 - 7.60304021835327) + 0.032829397502794*std::sin(0.180800005793571*x_74 - 7.61600017547607) + 0.0194909967332931*std::sin(0.170960023999214*x_75 - 7.64040040969849) + 0.00755570536921532*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.0313359007880827*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.0145161552234735*std::sin(0.243199974298477*x_88 + 5.05599975585938) + 0.00605325281340272*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.0386204276495192*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.00108342967123966*std::sin(0.3711998462677*x_93 + 8.19575977325439) + 0.0030487702208443*std::sin(0.256959974765778*x_94 + 5.05655956268311) + 0.0104629609987066*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.000733542784724455*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.00867309252233394*std::sin(0.328879833221436*x_95 - 1.22527992725372) - 0.00813030653970493*std::sin(0.335519850254059*x_95 + 5.14463996887207) - 0.00412912256018444*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 0.0108821660230535*std::sin(0.280479967594147*x_96 - 7.50864028930664) - 0.00945151070538989*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.000381218335616776*std::sin(0.386399865150452*x_96 - 7.41824007034302) + 0.00635784708536069*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.0110479364622066*std::sin(0.316639840602875*x_99 + 1.92487978935242) - 0.00516932754495603*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 0.00633330222336849*std::sin(0.379759848117828*x_99 + 5.18016004562378) - 0.00727743195278313*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 0.0126719838900027*std::sin(0.395599842071533*x_99 - 7.39767980575562) - 0.00499995210364938*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.314919034271917);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00163083659542608*x_1 + 0.000728924174914392*x_10 + 0.000769521517536816*x_100 + 0.000849883441836822*x_101 - 0.000994555554967132*x_102 - 0.000397645364098055*x_103 - 0.000892603576228793*x_104 + 4.38921322179887e-5*x_105 + 0.000372217647113738*x_106 - 0.000424916497007005*x_107 + 0.00077961002323501*x_108 - 0.000441450277820357*x_109 + 0.00263247093299365*x_11 - 0.000507773378254718*x_110 + 0.000465511753691434*x_111 - 0.000399094697410105*x_112 + 0.000354288626761659*x_113 - 0.000450803720938713*x_114 + 9.23015690501633e-5*x_115 - 0.000119754360918989*x_116 + 1.0191547735936e-5*x_117 - 0.000369227258824624*x_118 + 0.000499617883548569*x_119 + 0.000824576121796132*x_12 - 0.000267960634782279*x_120 + 5.783748610459e-5*x_13 + 0.000461944816147518*x_14 - 0.000141008786133446*x_15 - 0.00046012443504791*x_16 + 0.00297523446258663*x_17 + 0.000741401981771271*x_18 - 0.00159456356366489*x_19 - 0.00369298587080471*x_2 + 0.00259869651564253*x_20 - 0.00150123882879227*x_21 + 0.00213947515101231*x_22 - 0.000152721250155752*x_23 - 0.000725676063593192*x_24 - 0.000437013127758509*x_25 - 0.000152368094896119*x_26 + 0.00166282740576275*x_27 - 9.42924956544407e-5*x_28 + 0.00591275428408166*x_29 - 0.0018098921162953*x_3 - 0.00230525368176389*x_30 + 0.00918197926116871*x_31 + 0.00106923370336284*x_32 - 0.000400866254656628*x_33 + 0.000189037235983787*x_34 + 0.000240074443464418*x_35 + 2.60460559618242e-5*x_36 + 0.000414459361519718*x_37 - 0.00129533798423088*x_38 + 6.71130090773965e-5*x_39 + 0.000900855584770614*x_4 - 0.000283100642781594*x_40 - 0.000245312823452867*x_41 - 0.00105677128433111*x_42 - 0.000273799171032263*x_43 - 0.00131413581363921*x_44 - 0.00157079529100537*x_45 + 0.000110192351800772*x_46 + 0.000155329840196682*x_47 + 0.000698966172919597*x_48 + 4.88534305602752e-5*x_49 - 0.000278732404160031*x_5 - 0.000436427665142949*x_50 + 0.000428331977643656*x_51 + 0.00107872988855512*x_52 - 0.000276944566448183*x_53 + 5.07295210677408e-5*x_54 + 0.000426862875148001*x_55 + 6.34161479818608e-6*x_56 + 4.35347138583364e-5*x_57 - 0.000328083539477204*x_58 - 0.000345446195359679*x_59 + 0.000934208857197811*x_6 + 0.000780817568399397*x_60 - 0.00188119222979375*x_61 - 0.000319237977088255*x_62 - 0.000178591016135865*x_63 + 0.000107817461411324*x_64 - 0.000203120873074455*x_65 - 0.00030436990757598*x_66 + 4.25907450669286e-5*x_67 + 2.70783184531022e-5*x_68 + 7.00690614513183e-5*x_69 + 5.13673609063786e-5*x_7 + 0.00034839351523674*x_70 + 8.0362145168002e-5*x_71 + 0.000198730517455095*x_72 - 9.36758322316746e-6*x_73 + 6.50773749911169e-5*x_74 + 6.19767411673574e-5*x_75 + 0.000726433466386283*x_76 - 0.000277874039613705*x_77 + 0.000726361852096099*x_78 - 0.000102870572032909*x_79 - 0.00110908156385715*x_8 + 6.848230345895e-5*x_80 - 8.08083672813866e-5*x_81 + 0.000359431347302812*x_82 + 0.000893226422652279*x_83 + 5.04902136833169e-5*x_84 + 0.000920371128716352*x_85 + 0.000932511074407632*x_86 - 0.000254395745891147*x_87 - 0.00025449400910924*x_88 + 9.86324000371219e-5*x_89 - 0.000891969577408497*x_9 + 0.00105047614709418*x_90 + 0.000474280459857988*x_91 + 0.00356654413560179*x_92 + 0.000196673173313029*x_93 + 0.000596927787712734*x_94 + 0.000312575693206878*x_95 + 0.000156145021110434*x_96 - 0.000658564789727501*x_97 - 0.00058928993589164*x_98 + 6.35079894188241e-6*x_99 - 3.68584815079751e-7*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 4.45074421577816e-7*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) - 1.14754175851758e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) - 2.11893250606771e-6*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) + 8.3214628416344e-6*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) - 9.45358704890637e-7*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) + 4.15056651151644e-5*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) + 1.48047492877918e-5*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) - 1.46462075017164e-6*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) - 6.80605930481868e-6*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) + 2.32846407801184e-5*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) - 9.97659883581849e-7*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) - 1.71402442156433e-6*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) + 1.139185001303e-5*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) + 7.71918431157277e-7*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) + 0.000112994309009848*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) + 1.21523120720259e-5*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 3.81305403099527e-7*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 1.31492085833935e-7*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 9.14214438218462e-8*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 8.2931121420369e-8*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 3.46565237091332e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) - 2.10821996982237e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) + 6.22604042420036e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 1.19678707404535e-7*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 4.30521559069781e-8*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) - 2.6516705793931e-5*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 2.07168764302584e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) - 1.71576910153959e-7*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) - 1.45300503514526e-5*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) - 6.26709283730221e-6*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) - 1.02452673465727e-6*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 6.92676455953517e-7*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) + 2.49721969597754e-5*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 2.79930428657353e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 1.95245507201506e-5*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) + 1.82833483015846e-5*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) - 2.58530449850624e-7*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) + 5.27113779657432e-6*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 3.11090058408717e-7*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 1.11016777194625e-7*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) + 6.8465641577294e-6*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) + 1.06305462868756e-5*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) - 1.25853561994383e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) + 6.65320075570787e-6*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 5.49825529237475e-6*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 6.17057995182746e-7*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 2.13533745723254e-7*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) - 7.13076724012335e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) - 8.87846645045837e-6*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) + 4.77455875809197e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 2.99277357026371e-7*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) + 6.89445378553211e-6*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 8.5536749974129e-5*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) - 0.00306703897332407*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 5.76129693381209e-8*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) - 2.1653104354264e-7*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) - 1.02819082490369e-6*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) + 5.74430064197859e-7*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 8.99242242005244e-7*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) - 9.87121238445489e-6*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) + 7.84385490776925e-5*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 1.89660682952425e-7*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) - 6.29379159078446e-7*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) + 1.36090337932101e-7*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) + 7.10486117587676e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 5.30629933833384e-7*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) + 2.89595846024971e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) + 2.08179082224932e-5*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) + 4.73753353727439e-6*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) + 4.60194449232696e-5*std::exp(0.759199857711792*x_22) + 3.5208180020282e-5*std::exp(0.627279818058014*x_38) + 1.60242232926096e-5*std::exp(0.757519841194153*x_72) - 0.000732866313590573*std::exp(0.511599838733673*x_73) - 0.037516385353075*std::sin(0.144320040941238*x_1 + 8.1526403427124) - 0.0212682525008854*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.000298240590588772*std::sin(0.20160000026226*x_10 + 5.00271987915039) - 0.0131808253319411*std::sin(0.323119848966599*x_10 + 8.31192016601563) - 0.000792281203682799*std::sin(0.348559856414795*x_10 - 4.24007987976074) + 0.000954686706905399*std::sin(0.140800043940544*x_100 + 1.73271989822388) + 0.0041828347608788*std::sin(0.439679861068726*x_100 + 5.22295999526978) - 0.000552809653796901*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.000415199260929245*std::sin(0.344959855079651*x_102 - 7.43727970123291) - 0.00439464033346541*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.000315690453813831*std::sin(0.333679854869843*x_103 + 1.94599986076355) - 0.000154687328442305*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 5.97986251061837e-5*std::sin(0.409279853105545*x_105 - 1.17479979991913) + 0.00498815279611754*std::sin(0.300639927387238*x_106 - 7.50688028335571) + 0.00822853167407749*std::sin(0.369759827852249*x_107 + 5.16495990753174) - 0.000114945870099097*std::sin(0.226719990372658*x_109 + 5.01807975769043) - 0.00049899457072861*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.00427470633390581*std::sin(0.362399846315384*x_109 - 1.22647988796234) + 0.00214093826639831*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.000586889464373216*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.00547859849812124*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.000273875046414193*std::sin(0.32423985004425*x_110 + 5.12512016296387) - 0.0155936780652965*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.00053135965600196*std::sin(0.24679996073246*x_111 + 1.84103989601135) - 0.0045621281909703*std::sin(0.385039836168289*x_111 - 7.41479969024658) + 0.000145655052635285*std::sin(0.352639853954315*x_112 - 4.23967981338501) + 0.0114411681795301*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.000104245566447183*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 3.80489526547841e-5*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.000144178232033221*std::sin(0.311999946832657*x_114 - 1.30423986911774) - 0.000559563539670505*std::sin(0.31687992811203*x_115 + 1.91471993923187) + 0.0196112595674491*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.000277417217650486*std::sin(0.368559837341309*x_115 + 1.98191976547241) - 0.0120771145702235*std::sin(0.271519958972931*x_117 - 7.50487995147705) + 0.0064653542982003*std::sin(0.335359841585159*x_117 - 7.44863986968994) + 0.000429257656505394*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.000130101166735034*std::sin(0.24967996776104*x_118 - 4.34711980819702) - 0.000547621783590065*std::sin(0.271039962768555*x_118 + 5.06983995437622) + 0.00649603855836903*std::sin(0.277119934558868*x_118 - 7.51272010803223) - 0.00583566349673794*std::sin(0.303199917078018*x_118 + 5.1017599105835) - 0.0150459599394968*std::sin(0.368079841136932*x_118 + 5.17296028137207) + 0.000271134469014423*std::sin(0.361119836568832*x_119 - 1.20559990406036) + 0.000996846611860983*std::sin(0.248959973454475*x_12 - 4.32624006271362) + 0.0191383653634716*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.000271360186068049*std::sin(0.310799926519394*x_12 + 5.12871980667114) + 0.000434418882927636*std::sin(0.327679842710495*x_12 - 4.2513599395752) + 0.0142672614120459*std::sin(0.416159868240356*x_120 - 1.16447985172272) - 0.000345623597060916*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.00277661919923588*std::sin(0.190880000591278*x_13 - 4.42511987686157) + 0.000912334391782127*std::sin(0.123040057718754*x_14 + 4.89599990844727) - 0.0581545349414349*std::sin(0.126320049166679*x_14 - 4.50839996337891) + 0.0502080638100427*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.000156765820083462*std::sin(0.399439841508865*x_15 - 0.997359812259674) - 0.000523365616534448*std::sin(1.36559987068176*x_15 - 2.19623994827271) + 0.0111607657141383*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 6.91612768667497e-5*std::sin(0.352719843387604*x_16 - 4.25216007232666) + 0.0401376415334642*std::sin(0.202480003237724*x_18 + 5.00679969787598) + 0.0037362989588725*std::sin(0.150320038199425*x_19 + 8.10863971710205) + 0.000452393345029255*std::sin(0.271839946508408*x_21 + 8.30095958709717) + 0.00017815083644981*std::sin(0.288319945335388*x_21 - 1.0707198381424) - 5.56319136916466e-5*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.00494329847911409*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.000296810105472801*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 0.00013625664701965*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.00260510552788274*std::sin(0.192800000309944*x_23 + 4.99607992172241) - 0.0603479146424436*std::sin(0.295439928770065*x_23 + 5.13943958282471) - 0.00609856262244399*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.000142124371680436*std::sin(0.193599998950958*x_24 - 7.59560012817383) + 0.0012298389626449*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 2.95748418276436e-5*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.00246814320219251*std::sin(0.609839856624603*x_24 + 2.38503980636597) - 0.00928818672346009*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.000149215884934592*std::sin(0.3503198325634*x_26 + 5.16328001022339) - 0.00929185162924518*std::sin(0.357919842004776*x_26 + 5.1561598777771) - 0.000159268009069011*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.00292231926550225*std::sin(0.288959950208664*x_27 - 4.27960014343262) + 0.00355012432104898*std::sin(0.540319859981537*x_27 + 5.33847999572754) + 0.0140271316861432*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 8.11592986203778e-5*std::sin(0.309839934110641*x_28 + 1.91183984279633) + 0.000542083245076603*std::sin(0.312159925699234*x_28 + 5.14895963668823) + 0.0290789335346253*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.0178517685664317*std::sin(0.360399842262268*x_28 + 8.36839962005615) + 5.0239288605221e-5*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.000618800783331489*std::sin(0.310399949550629*x_3 - 4.25767993927002) + 0.0373950436897822*std::sin(0.315519839525223*x_3 + 8.31960010528564) - 0.000143912631374203*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.000208709595829502*std::sin(0.276239961385727*x_30 + 8.2806396484375) - 0.000405725756679614*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.00131896192892952*std::sin(0.263439953327179*x_32 + 5.1547999382019) + 0.0112406674600273*std::sin(0.312719941139221*x_34 - 1.14543986320496) - 0.0167979943043347*std::sin(0.312719941139221*x_34 - 1.1386399269104) + 0.00020372697487083*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.000190576314410619*std::sin(0.361359834671021*x_34 + 2.00311970710754) - 0.00351733679773726*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 5.38650614781239e-5*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.000547391064348995*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.0129579765927854*std::sin(0.304399937391281*x_35 - 1.12175977230072) + 0.00557950103947778*std::sin(0.324799835681915*x_35 - 7.42127990722656) - 0.0196525630125391*std::sin(0.342639863491058*x_35 - 1.21223986148834) + 0.00458563392174042*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.000320819400542003*std::sin(0.340399831533432*x_37 - 7.45648002624512) + 0.00774126877437515*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.00269501853391283*std::sin(0.413759857416153*x_37 + 5.19672012329102) - 0.00720716785557373*std::sin(0.343759834766388*x_38 - 4.26360034942627) + 0.00087199808076058*std::sin(0.346879839897156*x_38 - 4.25672006607056) + 0.0200096822917152*std::sin(0.319519847631454*x_39 + 1.94815981388092) - 0.000952188553960856*std::sin(0.179680019617081*x_40 + 1.7875999212265) + 0.00597860569809261*std::sin(0.329919844865799*x_40 - 4.27824020385742) + 0.000254134360952166*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.000377260056759595*std::sin(0.291759938001633*x_41 - 7.50631999969482) - 0.0268447429718258*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.000257583932748059*std::sin(0.34775984287262*x_41 + 5.16032028198242) - 0.000395464932596925*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.00839312035458418*std::sin(0.332159847021103*x_43 + 5.14351987838745) - 0.0103853631968054*std::sin(0.344799846410751*x_43 - 4.25375986099243) + 0.000259851391058757*std::sin(0.347919851541519*x_43 - 7.45056009292603) - 0.000591116900778465*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.00018040829675681*std::sin(0.206960007548332*x_45 - 7.57656002044678) - 0.00529771446020972*std::sin(0.282239943742752*x_45 + 5.07999992370605) + 0.0210271734310969*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.00799678763715448*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.000732132638180552*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.00103565402117118*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.000379508014696447*std::sin(0.261839956045151*x_48 + 5.08527946472168) + 0.00656213658918574*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 8.26233841605904e-5*std::sin(0.293039947748184*x_49 + 1.90383982658386) + 0.0899894169358112*std::sin(0.163760021328926*x_5 + 8.13551998138428) - 0.00603796270547822*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.000163891876261858*std::sin(0.342719823122025*x_51 + 5.15288019180298) - 0.000541683844489299*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.00954989296183669*std::sin(0.297439932823181*x_52 + 5.10951995849609) - 0.0128736437442851*std::sin(0.2811199426651*x_55 + 1.88439989089966) + 0.021854151910572*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.00013991772055469*std::sin(0.26335996389389*x_56 - 7.52920007705688) - 0.000239667111438242*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.0298411341293661*std::sin(0.140080034732819*x_57 + 4.9115195274353) - 0.00881066646703181*std::sin(0.221599996089935*x_57 - 7.57183980941772) - 0.000368110036614903*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.00301729329783402*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.0102025778337387*std::sin(0.273039966821671*x_58 - 7.5079197883606) + 0.00605301254793942*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.00014539678203634*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.00208935258579175*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.000118857971762695*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.000294326309971402*std::sin(0.295199930667877*x_59 - 7.48152017593384) + 0.00591022034195613*std::sin(0.322079837322235*x_59 + 5.1165599822998) + 0.025940647388236*std::sin(0.288639932870865*x_60 - 7.49160003662109) + 0.0183602993849618*std::sin(0.27167996764183*x_62 - 4.30463981628418) + 0.0461420781958181*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.0261173306529564*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 0.014714738229741*std::sin(0.236399978399277*x_65 - 4.34391975402832) + 0.012291807990928*std::sin(0.242479979991913*x_68 + 5.06775999069214) + 0.00498059455819917*std::sin(0.313759922981262*x_7 + 8.38703918457031) - 8.22597574296309e-5*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.001036676744853*std::sin(0.205680012702942*x_70 - 7.60304021835327) + 0.0784545680582228*std::sin(0.145920038223267*x_73 - 7.66184043884277) + 0.020138378274644*std::sin(0.180800005793571*x_74 - 7.61600017547607) + 0.0212398807096884*std::sin(0.317759841680527*x_74 - 4.29056024551392) + 0.00076537858395875*std::sin(0.170960023999214*x_75 - 7.64040040969849) + 0.0196798441865774*std::sin(0.243279978632927*x_76 - 7.53600025177002) + 0.0267727647507142*std::sin(0.244879975914955*x_79 - 7.55568027496338) + 0.00463485974252398*std::sin(0.445039868354797*x_81 - 4.1593599319458) - 0.0484731641752431*std::sin(0.174000009894371*x_87 + 4.95519971847534) + 0.0146406803174421*std::sin(0.206560000777245*x_88 + 5.00391960144043) + 0.00947995581873468*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.000339215510759112*std::sin(0.359999865293503*x_88 - 4.24480009078979) - 0.0252215508984116*std::sin(0.175840020179749*x_91 - 4.16767978668213) - 0.016464196227359*std::sin(0.338559836149216*x_93 + 1.98655986785889) + 4.65481303581262e-5*std::sin(0.3711998462677*x_93 + 8.19575977325439) + 0.0018701923474108*std::sin(0.256959974765778*x_94 + 5.05655956268311) + 0.00688457411140276*std::sin(0.358319848775864*x_94 - 1.20919990539551) + 0.000611511028246045*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.00405222035395836*std::sin(0.328879833221436*x_95 - 1.22527992725372) + 0.00530959786545528*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 9.38478237411246e-5*std::sin(0.347519844770432*x_95 + 1.94063985347748) - 0.00336021617322769*std::sin(0.367679834365845*x_95 + 1.98583984375) + 0.00716040884483481*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.00617242668792253*std::sin(0.362479835748672*x_96 - 7.42711973190308) + 0.000317799072192944*std::sin(0.386399865150452*x_96 - 7.41824007034302) - 0.0101335933277668*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.000144502882620491*std::sin(0.228159993886948*x_98 + 1.83047986030579) + 0.0109497469094873*std::sin(0.375119835138321*x_98 - 7.40303993225098) - 0.00726948493466928*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.000289681620361351*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 0.000248698101684284*std::sin(0.379759848117828*x_99 + 5.18016004562378) + 0.00475261750264777*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 0.00592057226552947*std::sin(0.395599842071533*x_99 - 7.39767980575562) + 0.000113640275118497*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.33279958016998);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00213010454489468*x_1 - 0.000609996654982037*x_10 + 0.000112382428128745*x_100 - 7.23159929766598e-6*x_101 + 0.00042639425927952*x_102 - 0.000923578040316407*x_103 + 0.000521060694720074*x_104 + 0.000164153612502951*x_105 - 0.000334513825285764*x_106 + 0.000513426970429567*x_107 - 0.000250003160825517*x_108 - 0.0013421056965767*x_109 + 7.13343073308055e-5*x_11 + 4.29635337157615e-5*x_110 + 0.000564401637507502*x_111 + 0.000348053389039281*x_112 + 0.000417057009603295*x_113 + 8.41790118713882e-5*x_114 + 1.45920542110411e-5*x_115 + 0.00019317930603594*x_116 - 0.000221115567127217*x_117 - 0.00035415936642386*x_118 - 0.00160273671894424*x_119 - 0.000392423058311955*x_12 + 0.000673724472366443*x_120 - 0.000443239708919084*x_13 + 0.000428415147811002*x_14 - 0.000761199021615347*x_15 + 0.000300277597671633*x_16 + 0.00342162600693687*x_17 - 0.000393704728878394*x_18 - 9.05333001335286e-5*x_19 + 0.00170174364145319*x_2 - 0.000222789641677048*x_20 - 5.08808351979821e-5*x_21 + 0.00340808203952422*x_22 + 0.000531376239286176*x_23 - 0.00081578361320969*x_24 + 0.00361187645097305*x_25 + 0.000574367564591659*x_26 + 0.000389684073610829*x_27 - 6.61168230877869e-5*x_28 + 0.00557745025031338*x_29 - 0.00303316346929355*x_3 - 0.000457143945718099*x_30 - 0.00222563568117893*x_31 + 0.000115089649124256*x_32 + 0.0012651823071062*x_33 + 1.11871290782548e-5*x_34 - 8.07751061544247e-5*x_35 - 0.00015318610853328*x_36 + 0.000199765512702897*x_37 + 0.000506564696358903*x_38 - 0.00332604612932362*x_39 + 0.000683971483130343*x_4 - 0.000129774328194896*x_40 + 0.00083088245696762*x_41 - 0.00157334701773066*x_42 - 0.000567154040779594*x_43 - 0.000574506434284893*x_44 - 0.000803974040434025*x_45 - 0.000194652025958478*x_46 - 0.000157870489188411*x_47 + 0.00170555808598364*x_48 - 0.000542035603960603*x_49 - 0.000138833654540183*x_5 + 0.000942741366731994*x_50 + 0.000456051703656745*x_51 + 0.0001252998500217*x_52 - 0.000142783529714058*x_53 + 0.00103245848568702*x_54 + 9.25799348947746e-5*x_55 - 4.76237331520548e-5*x_56 - 0.000177077076234986*x_57 - 5.41548613185153e-5*x_58 - 0.000116597042497827*x_59 - 0.00137296001247923*x_6 + 0.000475390827897524*x_60 - 0.00105125512467539*x_61 - 0.000871474010312966*x_62 - 0.000391904729829208*x_63 - 8.19568374965108e-5*x_64 + 0.000654883739346065*x_65 + 8.33617005329576e-5*x_66 - 0.000185149261876723*x_67 + 0.000207613478826821*x_68 + 0.000217938939084477*x_69 - 7.79705565594589e-5*x_7 + 0.000143608703982201*x_70 - 4.39807342998176e-5*x_71 - 1.75296672850045e-5*x_72 + 0.000244703922820316*x_73 + 0.000188354846521873*x_74 + 8.43693585955955e-5*x_75 - 6.25511808218805e-5*x_76 + 0.00112756819076847*x_77 + 4.24775573595758e-5*x_78 - 0.000258356144284272*x_79 - 0.000986738790491983*x_8 + 3.28344075586414e-6*x_80 + 0.0007932770114438*x_81 + 0.000390185192781974*x_82 + 0.00188022869727089*x_83 - 0.00033831478726848*x_84 - 0.000240498359705601*x_85 + 0.000107341292129578*x_86 + 0.000838632499292893*x_87 + 0.000248516412525645*x_88 + 0.000110408869439786*x_89 - 0.00164368205980229*x_9 - 2.96486814169875e-5*x_90 + 0.00116394711870207*x_91 - 0.00312072298316523*x_92 - 0.000250157362145199*x_93 - 0.000570597807300394*x_94 - 9.65250439327312e-5*x_95 + 0.000771292134065528*x_96 - 0.00040031315960959*x_97 + 0.00145319566698141*x_98 + 1.90477377877342e-5*x_99 - 6.35659212296664e-6*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 2.78488152363571e-6*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) + 2.35341135335499e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 7.28915726567367e-7*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 2.7287242898207e-8*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 3.2520470815795e-7*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 1.36102892869096e-7*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 4.85468477779908e-8*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) - 2.52587636353389e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) - 0.000808455304429763*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) + 3.96336897885142e-6*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) - 1.72055838925541e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) + 5.89626782835738e-7*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) + 1.93905095550895e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) + 1.33124600317716e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) + 1.92331994015028e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) + 2.06849215078783e-6*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 2.38587148681758e-6*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 2.26770480727371e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 1.08594632938433e-5*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) + 1.81502096187013e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 4.07114434950469e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) + 4.32359761683888e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) + 1.05975847819049e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) - 2.61927439191002e-6*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 5.11393484119235e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) - 4.51351129516808e-6*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) + 4.2486760795534e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) - 2.95900533865353e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) - 2.47321620152576e-6*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 2.05506757371389e-8*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 3.52438620409994e-7*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 8.22793234658934e-5*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) + 4.25061445863706e-6*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) - 5.74089303558582e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) - 6.40237381477595e-8*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 5.99536614646316e-8*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 8.89348340039264e-8*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) - 1.0810199666792e-5*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 5.36504091842799e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) - 2.42970038601237e-6*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) + 8.04274289544967e-6*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) + 1.80946649679998e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 7.49849072511726e-7*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 3.96404864259983e-7*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) - 1.12759787020166e-5*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 3.86100239978781e-6*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) - 4.67337493954544e-6*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) - 1.21375553704252e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 5.28988590207708e-7*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 2.84473351383396e-7*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 1.87261262750312e-6*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) - 1.41393423756649e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 0.000100481069381001*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) - 0.0005220525941796*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 6.84353582290656e-6*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) - 3.73428168890538e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) + 3.53699072546402e-7*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 1.97604740315189e-7*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 5.62666148316346e-6*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) - 1.15958342674582e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 2.57210995470304e-7*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) - 4.15089184018567e-6*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 2.1650730531167e-7*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) + 2.34700599351573e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) + 1.20934596541251e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) - 1.16133055529477e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) + 4.92932316791259e-6*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) + 3.54349686700152e-6*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 1.55350364269148e-8*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) - 1.58307530024744e-5*std::exp(0.759199857711792*x_22) + 0.000220301606350974*std::exp(0.627279818058014*x_38) + 0.000100265396559975*std::exp(0.757519841194153*x_72) + 4.36649640115475e-5*std::exp(0.511599838733673*x_73) - 0.00638580939732483*std::sin(0.144320040941238*x_1 + 8.1526403427124) - 0.0249840770873393*std::sin(0.358559846878052*x_1 + 8.25119972229004) + 0.00652725918000422*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.000785327764544024*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.00027254583502513*std::sin(0.348559856414795*x_10 - 4.24007987976074) + 0.0164644710056836*std::sin(0.140800043940544*x_100 + 1.73271989822388) - 0.00857827677502275*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.00019016728909342*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.00259794922900752*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.000261837402601187*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.00197531124996496*std::sin(0.333679854869843*x_103 + 1.94599986076355) - 0.00266772860213016*std::sin(0.385199844837189*x_104 + 1.99399983882904) + 0.00130874581459692*std::sin(0.409279853105545*x_105 - 1.17479979991913) + 0.00585964427385088*std::sin(0.300639927387238*x_106 - 7.50688028335571) + 0.00966615708799804*std::sin(0.369759827852249*x_107 + 5.16495990753174) - 0.013653803800698*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.000171654825736197*std::sin(0.330879837274551*x_109 + 1.928879737854) - 0.00876668961613073*std::sin(0.362399846315384*x_109 - 1.22647988796234) + 0.000364417402476064*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.00367223445453305*std::sin(0.238639980554581*x_11 - 4.33599996566772) - 0.0112356659879708*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.00472323300225186*std::sin(0.32423985004425*x_110 + 5.12512016296387) - 0.002654260398252*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.00332477809701891*std::sin(0.24679996073246*x_111 + 1.84103989601135) - 0.00535918794460338*std::sin(0.385039836168289*x_111 - 7.41479969024658) + 0.00251195850282495*std::sin(0.352639853954315*x_112 - 4.23967981338501) + 0.00194744559182934*std::sin(0.310799926519394*x_113 - 7.49704027175903) + 0.00228150644827998*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 0.000238076645398666*std::sin(0.256479978561401*x_114 - 7.52464008331299) - 0.00315546816326299*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.000192490635219176*std::sin(0.31687992811203*x_115 + 1.91471993923187) + 0.00333810852139913*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.00173583123701973*std::sin(0.368559837341309*x_115 + 1.98191976547241) - 0.00205569249247464*std::sin(0.271519958972931*x_117 - 7.50487995147705) + 0.00759493099757361*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.000147665230336618*std::sin(0.352479845285416*x_117 + 5.15328025817871) + 0.00284737913516081*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.000188382654533176*std::sin(0.271039962768555*x_118 + 5.06983995437622) + 0.0076309761743643*std::sin(0.277119934558868*x_118 - 7.51272010803223) + 0.0119679450666126*std::sin(0.303199917078018*x_118 + 5.1017599105835) - 0.00256103117262432*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 9.32706341108865e-5*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.000342916619703623*std::sin(0.248959973454475*x_12 - 4.32624006271362) + 0.00325761536558787*std::sin(0.296079933643341*x_12 + 5.11303997039795) - 0.00593895774583747*std::sin(0.310799926519394*x_12 + 5.12871980667114) + 0.00749196259940411*std::sin(0.327679842710495*x_12 - 4.2513599395752) + 0.00242848587734919*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.000118894997669376*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.0173736236710971*std::sin(0.190880000591278*x_13 - 4.42511987686157) + 0.108371312299285*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 0.000190696870343475*std::sin(0.126320049166679*x_14 - 4.50839996337891) + 0.0589800284054337*std::sin(0.221919998526573*x_14 + 5.03495979309082) + 0.00343095866404575*std::sin(0.399439841508865*x_15 - 0.997359812259674) - 0.00061480400930049*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 3.65977149411697e-5*std::sin(0.207520008087158*x_16 - 1.18359982967377) - 0.00151365573156259*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.00239144389715562*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.00128529203383339*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.000155623939338304*std::sin(0.271839946508408*x_21 + 8.30095958709717) + 0.00307237888634059*std::sin(0.288319945335388*x_21 - 1.0707198381424) - 0.00660821684109445*std::sin(0.292639940977097*x_21 + 5.07719993591309) - 0.0101378574482537*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.00185717475254877*std::sin(0.349679857492447*x_21 - 4.02647972106934) - 0.00298209726697438*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.0163004430270398*std::sin(0.192800000309944*x_23 + 4.99607992172241) - 0.0102720525126786*std::sin(0.295439928770065*x_23 + 5.13943958282471) + 0.0125071060885374*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.0168821923271291*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.000423066312140721*std::sin(0.258639991283417*x_24 + 5.07799959182739) - 0.000647271578411122*std::sin(0.568079829216003*x_24 + 2.35255980491638) - 0.0050617384427469*std::sin(0.609839856624603*x_24 + 2.38503980636597) - 0.0109109468721451*std::sin(0.345119833946228*x_26 + 1.93407988548279) + 0.00326572165384667*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.000553618524235099*std::sin(0.357919842004776*x_26 + 5.1561598777771) - 0.00274672675180501*std::sin(0.371439844369888*x_26 + 5.18544006347656) - 0.00599317566137675*std::sin(0.288959950208664*x_27 - 4.27960014343262) + 0.00417037458545471*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.000835751608311552*std::sin(0.278879970312119*x_28 + 5.09839963912964) - 0.00177624305235167*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.000186477389588162*std::sin(0.312159925699234*x_28 + 5.14895963668823) + 0.00494963801235117*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.0209706915032396*std::sin(0.360399842262268*x_28 + 8.36839962005615) + 0.00596765581147853*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.00387190722441881*std::sin(0.310399949550629*x_3 - 4.25767993927002) + 0.00636515536238917*std::sin(0.315519839525223*x_3 + 8.31960010528564) - 0.00248190880785668*std::sin(0.247039973735809*x_30 + 8.25191974639893) - 0.00456779415117071*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.000139570224096494*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.00825289553426409*std::sin(0.263439953327179*x_32 + 5.1547999382019) - 3.6859723964049e-5*std::sin(0.312719941139221*x_34 - 1.14543986320496) - 0.00285925173428354*std::sin(0.312719941139221*x_34 - 1.1386399269104) + 0.00351346347086908*std::sin(0.361119836568832*x_34 + 1.98511981964111) + 0.00417093124471204*std::sin(0.361359834671021*x_34 + 2.00311970710754) + 0.00721345457969352*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 0.00639834193695506*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.00342508845128561*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.0152218940449673*std::sin(0.304399937391281*x_35 - 1.12175977230072) - 0.0114425997963907*std::sin(0.324799835681915*x_35 - 7.42127990722656) - 0.00334513894091624*std::sin(0.342639863491058*x_35 - 1.21223986148834) + 0.000780538527754016*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.00200740365583354*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.000461233128291457*std::sin(0.386319845914841*x_37 + 5.17471981048584) - 0.00552702084097224*std::sin(0.413759857416153*x_37 + 5.19672012329102) + 0.00042941082050419*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.00029996855151489*std::sin(0.346879839897156*x_38 - 4.25672006607056) + 0.00340592559793199*std::sin(0.319519847631454*x_39 + 1.94815981388092) + 0.000327554185728901*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.000356211764417773*std::sin(0.329919844865799*x_40 - 4.27824020385742) + 0.00438278629751518*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.00236055929242356*std::sin(0.291759938001633*x_41 - 7.50631999969482) - 0.00456934777497705*std::sin(0.336239844560623*x_41 - 7.43887996673584) - 0.00563745225400803*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.000136040486353552*std::sin(0.405519872903824*x_42 - 1.18847990036011) + 0.0172128505005953*std::sin(0.332159847021103*x_43 + 5.14351987838745) - 0.00176773293249466*std::sin(0.344799846410751*x_43 - 4.25375986099243) + 0.00448138186373365*std::sin(0.347919851541519*x_43 - 7.45056009292603) + 3.5219381380284e-5*std::sin(0.386239856481552*x_43 + 1.97567975521088) - 0.00394839518266144*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.000315643531376372*std::sin(0.282239943742752*x_45 + 5.07999992370605) + 0.00357911670945325*std::sin(0.296719938516617*x_46 + 5.10799980163574) + 0.0164000400647381*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.00458103759297524*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.00648020557598897*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.0065449729834914*std::sin(0.261839956045151*x_48 + 5.08527946472168) + 0.00111696670943585*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 0.00981438894416847*std::sin(0.293039947748184*x_49 + 1.90383982658386) + 0.105711671876917*std::sin(0.163760021328926*x_5 + 8.13551998138428) + 0.0123828260511958*std::sin(0.211119994521141*x_5 - 4.36911964416504) - 0.00358691870796812*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.00018633999523112*std::sin(0.215759992599487*x_52 + 1.79055988788605) - 0.0195851927416959*std::sin(0.297439932823181*x_52 + 5.10951995849609) - 0.00219127281123658*std::sin(0.2811199426651*x_55 + 1.88439989089966) + 0.00371987992253781*std::sin(0.217999994754791*x_56 - 7.58768033981323) + 0.00306222310025913*std::sin(0.26335996389389*x_56 - 7.52920007705688) - 0.00413328496013289*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.0350547462905416*std::sin(0.140080034732819*x_57 + 4.9115195274353) - 0.00149969769721578*std::sin(0.221599996089935*x_57 - 7.57183980941772) - 0.00634840412138239*std::sin(0.231359988451004*x_57 + 1.84351992607117) - 0.00618795111447419*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.0119850933252318*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.000360645004642522*std::sin(0.284239947795868*x_58 - 7.50048017501831) + 0.00318213720813863*std::sin(0.359839856624603*x_58 + 5.1528000831604) + 0.00428490384778324*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.0141185013885026*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.00184163336022204*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 0.0121208483703089*std::sin(0.322079837322235*x_59 + 5.1165599822998) + 0.00441545816062766*std::sin(0.288639932870865*x_60 - 7.49160003662109) + 0.00312517773892032*std::sin(0.27167996764183*x_62 - 4.30463981628418) + 0.00785402201683061*std::sin(0.223439991474152*x_64 + 5.04335975646973) - 0.0535621662756708*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 0.00250465264130125*std::sin(0.236399978399277*x_65 - 4.34391975402832) + 0.00209223629195255*std::sin(0.242479979991913*x_68 + 5.06775999069214) + 0.00585076551905948*std::sin(0.313759922981262*x_7 + 8.38703918457031) - 0.00141864695647106*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.00648660487495384*std::sin(0.205680012702942*x_70 - 7.60304021835327) + 0.0133540561878304*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.00119986625978899*std::sin(0.180800005793571*x_74 - 7.61600017547607) + 0.00361532243998206*std::sin(0.317759841680527*x_74 - 4.29056024551392) + 0.0131996742102001*std::sin(0.170960023999214*x_75 - 7.64040040969849) + 0.00334978257531503*std::sin(0.243279978632927*x_76 - 7.53600025177002) + 0.00455709608291101*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.000276149933627517*std::sin(0.445039868354797*x_81 - 4.1593599319458) - 0.00825080519872008*std::sin(0.174000009894371*x_87 + 4.95519971847534) + 0.0171985867502202*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.0194417636548014*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.00212251021996449*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.0517250756174845*std::sin(0.175840020179749*x_91 - 4.16767978668213) - 0.00280243466950772*std::sin(0.338559836149216*x_93 + 1.98655986785889) + 0.00552920290786648*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.000111428073619967*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 2.25754833739854e-5*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.000210360643475673*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.00476019295397995*std::sin(0.328879833221436*x_95 - 1.22527992725372) - 0.0108890746725018*std::sin(0.335519850254059*x_95 + 5.14463996887207) - 0.00205394265022199*std::sin(0.347519844770432*x_95 + 1.94063985347748) - 0.000571955421986876*std::sin(0.367679834365845*x_95 + 1.98583984375) - 2.34799841227317e-5*std::sin(0.280479967594147*x_96 - 7.50864028930664) - 0.0126585886197934*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.000109323322449683*std::sin(0.386399865150452*x_96 - 7.41824007034302) - 0.00172487820700502*std::sin(0.472959846258163*x_97 - 1.13407981395721) + 0.00316257342858541*std::sin(0.228159993886948*x_98 + 1.83047986030579) + 0.00186379887227598*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 2.38376599081486e-5*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.00181257100648758*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 0.00428903288872881*std::sin(0.379759848117828*x_99 + 5.18016004562378) - 0.0097468034656393*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 0.0069549688615458*std::sin(0.395599842071533*x_99 - 7.39767980575562) - 0.00248711795909829*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.0356297100309377);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000874174196304494*x_1 + 0.000580187000039837*x_10 + 6.06221861152735e-5*x_100 - 0.000696865138624177*x_101 - 0.00131452672251346*x_102 + 0.000825974534176403*x_103 + 4.29166246391312e-5*x_104 - 0.000217253173972302*x_105 + 0.000530338886160287*x_106 + 0.000150944914853013*x_107 + 0.00113177993310452*x_108 + 0.00215551587571657*x_109 + 0.000824635641887943*x_11 + 9.52811061416109e-5*x_110 - 0.000606981682560223*x_111 - 0.000578685939095886*x_112 - 0.000374577926663421*x_113 + 1.86022191689697e-5*x_114 - 0.000161959475787172*x_115 - 0.0009729042402601*x_116 + 0.000140177282024965*x_117 + 0.000582979174588873*x_118 - 0.00056232183655371*x_119 + 0.000568329352047351*x_12 - 0.000519767725617899*x_120 + 0.000515990762293176*x_13 - 0.000702753095964811*x_14 - 0.000622071558152214*x_15 - 0.000603601661988065*x_16 - 0.00760839114950456*x_17 - 0.000722717383336286*x_18 - 0.000194984863345266*x_19 - 0.000378907774954343*x_2 + 0.00273704537388424*x_20 + 0.00020025748321504*x_21 - 0.00510575527827532*x_22 - 0.0010054776731537*x_23 + 0.00130609286159997*x_24 - 0.00203916170594858*x_25 - 0.000244467668924335*x_26 + 0.000589426388855893*x_27 - 5.15121146194688e-5*x_28 - 0.00805885136100042*x_29 + 0.00446598616604026*x_3 - 0.000721491430129633*x_30 - 0.00636141989995383*x_31 + 5.88286761744375e-5*x_32 - 0.000581667328439386*x_33 - 0.000114310194168643*x_34 + 8.86007487935437e-5*x_35 - 0.000259375461522826*x_36 - 0.000188069291805386*x_37 - 0.00149705587966849*x_38 + 0.00216202307430073*x_39 - 0.00150152863147526*x_4 + 0.000112127048034313*x_40 - 0.000123155683252295*x_41 + 0.00205905485970402*x_42 + 0.00112213131193148*x_43 - 0.000221805039353421*x_44 - 0.000227626462972437*x_45 + 0.000181599855289016*x_46 + 0.000158377954132506*x_47 - 0.00357088817089286*x_48 + 0.00073980708979*x_49 + 0.00085737424591138*x_5 + 0.000194289743993219*x_50 - 0.0011137391700756*x_51 - 0.000672351240910531*x_52 + 0.000134085241051833*x_53 - 0.00170201845515538*x_54 + 0.000177807617817903*x_55 + 0.000353155921294982*x_56 + 0.000143415322909568*x_57 + 0.000124253006486829*x_58 + 2.55739380201045e-5*x_59 - 0.000459759527789873*x_6 - 0.00155563060681029*x_60 + 0.00145632928541946*x_61 + 0.00157556817029795*x_62 + 0.000194545926340285*x_63 - 0.000149033117150071*x_64 - 0.00064336733820487*x_65 - 0.000659242770360276*x_66 + 0.000324761957238081*x_67 - 0.00036115473190879*x_68 - 4.42901681914313e-5*x_69 - 0.000957778774446203*x_7 - 0.000212432672887344*x_70 + 0.000100732808785352*x_71 + 1.10439153823265e-5*x_72 - 0.000402821768972622*x_73 - 5.60920763851877e-5*x_74 - 0.000455250849998998*x_75 - 0.000254286746010931*x_76 - 0.00134236155489934*x_77 - 0.000241872294556598*x_78 + 4.85512427732368e-5*x_79 + 0.00170524470599659*x_8 - 8.11094902621939e-5*x_80 + 8.87948747828629e-5*x_81 - 0.000725048754441656*x_82 - 0.00299127597590723*x_83 + 0.000344120389690954*x_84 + 0.000544735827749649*x_85 + 0.000759693109812048*x_86 - 0.000324983748736913*x_87 - 0.000522034746556659*x_88 + 3.79248240874308e-5*x_89 - 0.000927710139816195*x_9 - 0.000146433451232953*x_90 + 0.00117613430150705*x_91 + 0.0021847058933914*x_92 + 0.000285273959599376*x_93 + 0.000829999433834037*x_94 + 0.000114175527853776*x_95 - 0.00130892885833363*x_96 - 0.000113581321395495*x_97 - 1.94155753038391e-5*x_98 - 4.64571331720791e-5*x_99 + 1.07281247514098e-5*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) - 1.60073858524594e-5*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 1.49079086549825e-6*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) - 7.14167228773552e-6*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 7.43574388273823e-6*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 2.65227225360017e-6*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) + 4.26296295411546e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) + 0.00123907345799022*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) + 8.50035296423373e-6*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 2.90381460457811e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) - 1.29485248812555e-5*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) + 4.15873909934003e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) - 2.24676570725682e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) + 4.12500033220833e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) + 4.43635540351306e-6*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 3.82724258552082e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) - 1.66436816750322e-5*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 5.2471359554284e-7*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) + 8.35367136690354e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) + 2.27289489561201e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 7.57219289895303e-7*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) + 7.83783703674538e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) - 9.68025922433873e-6*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) + 4.99396182719797e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) - 5.30437887110952e-6*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 1.12275028235836e-6*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) - 7.73974381480141e-6*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) - 0.000126104838807248*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) + 9.11641671670984e-6*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) - 3.49782513249088e-6*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 3.27546360026428e-6*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) - 1.95305733123554e-6*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) - 9.05466752560047e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 7.02414381111484e-7*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) - 1.65030824920907e-5*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) + 3.88081553391297e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) - 1.48578126398959e-6*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) + 7.85452622217665e-7*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 1.35104961284968e-6*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) - 2.603176876089e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) - 1.04815937634248e-6*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) + 5.63666997911993e-7*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) - 0.000206179334394281*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) - 0.00111966141434212*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) - 1.04886980770691e-5*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 6.30240843528989e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) - 7.76742402934562e-6*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) + 4.33950758532294e-6*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) + 2.37937494668322e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 1.40522735837865e-5*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 1.20000232941062e-6*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) - 4.75461819478227e-6*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) - 3.96108049779858e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) + 2.59371953929392e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 3.35734927631146e-6*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) + 1.05720630669554e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) + 7.5998410084691e-6*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 8.48729587185551e-7*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) + 0.00165068893693388*std::pow(0.110923203478917*x_1 - 0.0504529416278344*x_10 + 0.00620018011866532*x_100 + 0.0132982389004645*x_101 + 0.0307560694055898*x_104 + 0.0726789047890062*x_105 + 0.00426833039598522*x_106 - 0.000214915207007769*x_107 + 0.0798589450738603*x_108 - 0.00173535002929347*x_109 + 0.00917059701135294*x_110 + 0.0163079160204878*x_112 + 0.0609736673216442*x_113 - 0.003212065910008*x_117 - 0.00123528474079686*x_118 - 0.124946657379565*x_119 + 0.000867295835760883*x_12 - 0.0583674822257212*x_120 + 0.00345203534092169*x_14 + 0.0133316974292033*x_15 - 0.0433466419800002*x_16 + 0.00451103960141265*x_17 + 0.00280369500883899*x_18 - 0.0178152528772222*x_19 - 0.199173892957762*x_2 + 0.158341744018462*x_20 + 0.00123125235683867*x_22 - 0.0675476639243023*x_24 + 0.159058087209695*x_25 + 0.0307037009957175*x_26 + 0.0383777605233313*x_27 - 0.0835757558681032*x_28 + 0.0531265550094095*x_29 - 0.000399523279074113*x_30 + 0.109791307537231*x_31 + 0.00130474929163483*x_33 + 0.0474520319744315*x_34 + 0.0163897477869091*x_36 + 0.0415044277789376*x_39 + 0.319287263470611*x_4 - 0.000557513264278239*x_40 - 0.0757080068789414*x_42 + 0.00504233259897229*x_43 - 0.00726057962419065*x_44 - 0.000124063632380804*x_45 - 0.00301275279773427*x_46 - 0.00359676445163896*x_49 + 0.151638608223848*x_5 - 0.000857353889927244*x_50 + 0.0265730912290071*x_51 - 0.0549345760071639*x_52 - 0.00415566257214341*x_54 + 0.0478387046390265*x_55 + 0.00165333086989927*x_56 - 0.0034781313920152*x_57 + 0.000211797676652117*x_58 - 0.000150088490661819*x_6 - 0.0115980997460942*x_60 + 0.0848111150748045*x_61 - 0.00217802145721756*x_62 + 0.0597869825069956*x_63 - 0.000405173009192973*x_64 + 0.050717672787069*x_65 - 0.0428457517992356*x_66 + 0.00405059814546401*x_67 + 0.00268841563135832*x_68 + 0.0612539590836475*x_69 - 0.0407810983427436*x_7 - 0.00795225005610329*x_71 - 0.000833126565946974*x_73 - 0.00358746217396067*x_74 + 0.0094561457230834*x_75 + 0.00161915386427675*x_76 - 0.0572945044123611*x_78 + 0.00404293073283379*x_79 - 0.00696234690022947*x_8 - 0.0292313174838761*x_81 - 0.00338339328556126*x_82 - 0.00156780728891932*x_83 + 0.045754811035419*x_85 + 0.00522174027933297*x_86 + 0.00344013561131304*x_87 + 0.0697848102369569*x_89 - 0.020962529639062*x_9 - 0.000308095523565191*x_90 + 0.371210048685236*x_91 + 0.0352844918408257*x_92 + 0.00459043191036186*x_93 - 0.00128521798507262*x_94 + 0.000113258407675397*x_95 - 0.0158786538578526*x_96 - 0.00377413949797466*x_97 + 0.0309693923319809*x_98 + 0.00102059780638792*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) + 0.000874369406778409*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 0.00141497243104888*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 0.000686271327388077*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) - 0.00206204763767007*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 0.0807356917259472*std::exp(0.627279818058014*x_38) + 0.0367450618337729*std::exp(0.757519841194153*x_72) + 0.952091233228025*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.723908112979867*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 1.34579313232172*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 1.21845802191044*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.0872498524565088*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.636143957193962*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 6.36705082684529*std::sin(0.190880000591278*x_13 - 4.42511987686157) - 0.680613685876228*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 5.9737537325571*std::sin(0.192800000309944*x_23 + 4.99607992172241) - 1.41896880935187*std::sin(0.310399949550629*x_3 - 4.25767993927002) + 3.0245046358821*std::sin(0.263439953327179*x_32 + 5.1547999382019) + 1.25521955975459*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.735669273644405*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.86509304444337*std::sin(0.291759938001633*x_41 - 7.50631999969482) - 1.67884948738046*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 2.3748527683012*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.674918107524956*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 2.3771979705766*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.777853296862574*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.664267394301387*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 3.69591165735755, 2) + 0.000347651947144768*std::exp(0.759199857711792*x_22) - 8.65195247942679e-5*std::exp(0.511599838733673*x_73) - 0.0136958315335335*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 0.051265381788393*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.00188699839028365*std::sin(0.20160000026226*x_10 + 5.00271987915039) - 0.00155608017856432*std::sin(0.323119848966599*x_10 + 8.31192016601563) - 0.00598525478970414*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.0277873576749972*std::sin(0.140800043940544*x_100 + 1.73271989822388) - 0.00417617711085732*std::sin(0.378879845142365*x_101 - 4.40639972686768) - 0.000518815213964886*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.00450236930306605*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 0.000378351950999632*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.012023534021009*std::sin(0.300639927387238*x_106 - 7.50688028335571) - 0.0198342020724038*std::sin(0.369759827852249*x_107 + 5.16495990753174) + 0.0209264084202946*std::sin(0.226719990372658*x_109 + 5.01807975769043) - 0.00376963334559368*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.000781576624302457*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.00797147778210525*std::sin(0.32423985004425*x_110 + 5.12512016296387) - 0.00569266963649397*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.0109966365815878*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.00423947355239362*std::sin(0.352639853954315*x_112 - 4.23967981338501) + 0.00417674332052419*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.000659572245654772*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 0.000912230260889493*std::sin(0.311999946832657*x_114 - 1.30423986911774) - 0.00422719905557366*std::sin(0.31687992811203*x_115 + 1.91471993923187) + 0.00715933863746191*std::sin(0.334959834814072*x_115 - 4.27088022232056) - 0.00440890360327336*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.0155842073287718*std::sin(0.335359841585159*x_117 - 7.44863986968994) + 0.00324280878136888*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.000823163244541523*std::sin(0.24967996776104*x_118 - 4.34711980819702) - 0.00413698556515423*std::sin(0.271039962768555*x_118 + 5.06983995437622) - 0.0156581692263174*std::sin(0.277119934558868*x_118 - 7.51272010803223) - 0.00549271819905623*std::sin(0.368079841136932*x_118 + 5.17296028137207) + 0.00204827386006267*std::sin(0.361119836568832*x_119 - 1.20559990406036) + 0.00753063549975372*std::sin(0.248959973454475*x_12 - 4.32624006271362) + 0.00698670262016155*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.00171692335133392*std::sin(0.310799926519394*x_12 + 5.12871980667114) - 0.0126443081205268*std::sin(0.327679842710495*x_12 - 4.2513599395752) + 0.00520844444114997*std::sin(0.416159868240356*x_120 - 1.16447985172272) - 0.00261099882229673*std::sin(0.44463986158371*x_120 + 2.0079197883606) - 0.166094545909779*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 0.0104183905075231*std::sin(0.126320049166679*x_14 - 4.50839996337891) - 0.121022428145927*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.000991873203996153*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 0.00126152997974043*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 0.00199945224718873*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 0.000437590395927925*std::sin(0.352719843387604*x_16 - 4.25216007232666) + 0.00473850360896526*std::sin(0.202480003237724*x_18 + 5.00679969787598) + 0.0282257122034558*std::sin(0.150320038199425*x_19 + 8.10863971710205) + 0.00341758636022203*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.00518530422255195*std::sin(0.288319945335388*x_21 - 1.0707198381424) + 0.0101280380592214*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.00086210959106519*std::sin(0.3503198325634*x_21 - 4.22424030303955) - 0.0220307704104341*std::sin(0.295439928770065*x_23 + 5.13943958282471) + 0.0258743758753446*std::sin(0.193599998950958*x_24 - 7.59560012817383) + 0.0092907663434638*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 0.000187123016392518*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.0223884138332589*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.000944104000466418*std::sin(0.3503198325634*x_26 + 5.16328001022339) - 0.00109696212325876*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.00463569577556068*std::sin(0.371439844369888*x_26 + 5.18544006347656) - 0.008557284088444*std::sin(0.540319859981537*x_27 + 5.33847999572754) + 0.00165599202092639*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 0.000513503093428252*std::sin(0.309839934110641*x_28 + 1.91183984279633) + 0.00409514491058416*std::sin(0.312159925699234*x_28 + 5.14895963668823) + 0.0106156329059138*std::sin(0.316799849271774*x_28 - 4.29735994338989) - 0.0430302269130037*std::sin(0.360399842262268*x_28 + 8.36839962005615) - 0.00914628660596106*std::sin(0.407039850950241*x_28 - 4.18111991882324) + 0.01365153422283*std::sin(0.315519839525223*x_3 + 8.31960010528564) + 0.00418875818948766*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.00132052672840251*std::sin(0.276239961385727*x_30 + 8.2806396484375) - 0.00306503804102013*std::sin(0.258159965276718*x_32 + 1.97111988067627) - 0.00201376665262147*std::sin(0.312719941139221*x_34 - 1.14543986320496) - 0.00613232052950341*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.00592972990807744*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.00120579562228297*std::sin(0.361359834671021*x_34 + 2.00311970710754) + 0.00980637473189528*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.0312341419308685*std::sin(0.304399937391281*x_35 - 1.12175977230072) - 0.00717441698310699*std::sin(0.342639863491058*x_35 - 1.21223986148834) + 0.00167404372984098*std::sin(0.355199843645096*x_36 - 4.24295997619629) + 0.000913905965171461*std::sin(0.386319845914841*x_37 + 5.17471981048584) - 0.000850851958144612*std::sin(0.343759834766388*x_38 - 4.26360034942627) + 0.00658747256053121*std::sin(0.346879839897156*x_38 - 4.25672006607056) + 0.0073047878980803*std::sin(0.319519847631454*x_39 + 1.94815981388092) - 0.00719326809320266*std::sin(0.179680019617081*x_40 + 1.7875999212265) + 0.000705812389434308*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.0073969002964073*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.00980001334998011*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.00162975960280579*std::sin(0.34775984287262*x_41 + 5.16032028198242) - 0.00298752308016816*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.00379130834219206*std::sin(0.344799846410751*x_43 - 4.25375986099243) - 0.00756330165013048*std::sin(0.347919851541519*x_43 - 7.45056009292603) - 6.9785105966523e-5*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.00114146154586756*std::sin(0.206960007548332*x_45 - 7.57656002044678) - 0.000625428852565782*std::sin(0.282239943742752*x_45 + 5.07999992370605) + 0.00767623592274171*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.0110460582184928*std::sin(0.261839956045151*x_48 + 5.08527946472168) + 0.00239559105653971*std::sin(0.475279867649078*x_48 + 2.04215979576111) + 0.0150419556659218*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.216912123642372*std::sin(0.163760021328926*x_5 + 8.13551998138428) + 0.00103696048239497*std::sin(0.342719823122025*x_51 + 5.15288019180298) - 0.00409212765576723*std::sin(0.215759992599487*x_52 + 1.79055988788605) - 0.00469968666450976*std::sin(0.2811199426651*x_55 + 1.88439989089966) + 0.00797813488849109*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.000885273573719906*std::sin(0.26335996389389*x_56 - 7.52920007705688) + 0.00697581279837361*std::sin(0.314399927854538*x_56 + 5.12855958938599) - 0.0719296112398944*std::sin(0.140080034732819*x_57 + 4.9115195274353) - 0.00321644536100624*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.010714305726882*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.0245924787591568*std::sin(0.273039966821671*x_58 - 7.5079197883606) + 0.000714596590823841*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.000919940150042491*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.0216386239798757*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.00946996180885948*std::sin(0.288639932870865*x_60 - 7.49160003662109) + 0.00670265978225605*std::sin(0.27167996764183*x_62 - 4.30463981628418) + 0.0168447499307194*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.00537180151973407*std::sin(0.236399978399277*x_65 - 4.34391975402832) + 0.00448728015510942*std::sin(0.242479979991913*x_68 + 5.06775999069214) - 0.0120053155071694*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 0.00239427372919539*std::sin(0.534639835357666*x_7 - 3.87391996383667) + 0.028640833519786*std::sin(0.145920038223267*x_73 - 7.66184043884277) + 0.00237746351024508*std::sin(0.180800005793571*x_74 - 7.61600017547607) + 0.00775388740824938*std::sin(0.317759841680527*x_74 - 4.29056024551392) - 0.022277306592216*std::sin(0.170960023999214*x_75 - 7.64040040969849) + 0.00718437632114421*std::sin(0.243279978632927*x_76 - 7.53600025177002) + 0.00977373678892153*std::sin(0.244879975914955*x_79 - 7.55568027496338) + 0.000547174641506699*std::sin(0.445039868354797*x_81 - 4.1593599319458) - 0.0176957423854542*std::sin(0.174000009894371*x_87 + 4.95519971847534) - 0.0352901615252233*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.00601046331470374*std::sin(0.338559836149216*x_93 + 1.98655986785889) - 0.00847429478097376*std::sin(0.3711998462677*x_93 + 8.19575977325439) + 0.000220788089411701*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 0.00123337211178475*std::sin(0.358319848775864*x_94 - 1.20919990539551) + 0.00461963415735898*std::sin(0.359999865293503*x_94 + 1.97703981399536) - 0.00976754547783014*std::sin(0.328879833221436*x_95 - 1.22527992725372) + 0.000593784675592019*std::sin(0.347519844770432*x_95 + 1.94063985347748) - 0.00122668946359484*std::sin(0.367679834365845*x_95 + 1.98583984375) - 0.00128278793071147*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.0024007996279158*std::sin(0.386399865150452*x_96 - 7.41824007034302) - 0.00369939656340205*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.00091428435800073*std::sin(0.228159993886948*x_98 + 1.83047986030579) + 0.00399734376315321*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 0.00130232892265773*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.00723867113117645*std::sin(0.379759848117828*x_99 + 5.18016004562378) - 0.0142710548309272*std::sin(0.395599842071533*x_99 - 7.39767980575562) + 0.000719013517900633*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.649630844593048*std::sin(-0.00968055626191739*x_1 - 0.000129757592820956*x_10 + 0.00418222892831539*x_101 - 0.000932785107610739*x_102 + 0.00234075355924548*x_103 - 0.00306364102062206*x_104 + 0.000228572472662766*x_105 + 8.20593842400679e-5*x_106 - 0.00398905990686892*x_107 + 0.000311617093341948*x_108 - 2.13842897820049e-5*x_11 - 0.000243253903587932*x_111 + 0.000113279280961033*x_112 + 0.000171035820232472*x_113 - 0.000117847648498116*x_114 + 0.000510489583237195*x_115 + 0.000645896939052555*x_116 + 9.86307325390725e-5*x_117 + 0.00817232472604136*x_119 - 0.000269449424963227*x_12 - 0.00273084627519456*x_120 + 5.7403083783538e-5*x_14 + 0.00517377519471312*x_15 - 0.00235498029663448*x_16 + 0.00139406704820009*x_17 + 0.00503423047882126*x_18 + 0.000728325580305889*x_19 - 0.0158860449346617*x_2 + 0.00189726792025872*x_20 - 0.00563537193237275*x_22 - 0.00859243921736559*x_25 - 0.000891048388253956*x_26 - 0.00074433489103509*x_28 - 5.95559090110412e-5*x_29 + 0.00480221554385018*x_3 - 2.4537195476893e-6*x_30 + 0.0332018842644633*x_31 + 0.00370217185004692*x_32 - 0.00371956384657864*x_33 + 0.000796322219107625*x_36 - 0.000259946361428054*x_38 + 0.0121644217277983*x_39 + 0.00948916176281846*x_4 + 0.000597570326979804*x_40 - 0.00434999270661048*x_41 + 0.00242127288483218*x_42 + 0.000966369473277655*x_44 + 0.00300815405792683*x_45 + 0.000566614841267193*x_47 - 0.00100908803344844*x_48 + 0.000391572646878396*x_49 - 0.00549714769152704*x_50 + 0.00193218926361683*x_51 + 0.000338039055523634*x_53 - 0.000388819985141345*x_54 + 0.00020895070059344*x_55 + 0.000235371734696561*x_56 + 0.00879582082861515*x_6 + 0.00014763369350881*x_60 + 0.000532890470338142*x_61 - 4.4871508118832e-5*x_62 - 0.000161261649709323*x_63 - 0.000170478483272188*x_66 + 7.52278491236682e-5*x_67 - 0.000120672768651446*x_69 - 0.000298093028561244*x_70 - 0.000395185479292626*x_72 - 2.8232884444143e-5*x_73 + 0.000182175534712353*x_74 + 0.000215072598233585*x_75 - 0.002289281790808*x_77 + 0.00013504732122098*x_78 + 0.000409343705978284*x_79 - 0.00015901184886885*x_8 - 0.00447432959505101*x_81 - 0.000941243653894756*x_82 - 0.00123558318337343*x_83 + 0.000178072777288228*x_84 + 0.000444654117384481*x_85 - 0.000523105662500961*x_86 - 0.00338562727244834*x_87 + 0.000240516900502458*x_89 + 0.0128753768192809*x_9 + 0.000172886290815772*x_90 + 0.0137737307769723*x_92 + 0.000661373119773655*x_93 + 0.00117980891850296*x_94 + 0.00370315905050935*x_97 - 0.00768815328112356*x_98 - 0.000132775117682278*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) - 0.00024392938428219*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 0.000239702449659887*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) + 0.000323890571580113*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 6.09891479821855e-5*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 6.36169871879293e-5*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) + 7.97715556697131e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 0.0483970516540204*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.0494600420706894*std::sin(0.362399846315384*x_109 - 1.22647988796234) + 0.0633895503081039*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.0675209334895577*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.0571959174845964*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.0705627802977542*std::sin(0.382159858942032*x_23 + 5.17600011825562) + 0.0285573925040572*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 0.0338123890919222*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.040696977149753*std::sin(0.398559868335724*x_34 - 7.60168027877808) + 0.0645570325982789*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.0311824297756669*std::sin(0.413759857416153*x_37 + 5.19672012329102) - 0.0971117202951328*std::sin(0.332159847021103*x_43 + 5.14351987838745) - 0.0925259940845202*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.06986161530337*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.11049603663217*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.0349112761891466*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.0241746353367255*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.0683835856609831*std::sin(0.322079837322235*x_59 + 5.1165599822998) + 0.302187839810985*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 0.109686836240392*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.291823313950006*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.0614341461823673*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.0714174167337367*std::sin(0.362479835748672*x_96 - 7.42711973190308) + 0.0549896632108702*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 5.08346438989747) + 0.373428329436001);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00245480120370496*x_1 - 0.000109940838084812*x_10 - 0.000280590869118803*x_100 - 0.00149063606042436*x_101 + 0.000824239719271737*x_102 - 0.000166658807056226*x_103 + 0.0016372204307654*x_104 + 4.9242965878529e-5*x_105 - 0.00017300833135031*x_106 + 0.00131852183502496*x_107 - 7.51459290942306e-5*x_108 + 0.00129112578702927*x_109 - 0.00310238041549042*x_11 - 8.33486733977105e-5*x_110 - 0.000148907594326951*x_111 + 0.000142214477398426*x_112 - 0.000461540501638243*x_113 - 0.000475197200803498*x_114 - 0.00027823874591172*x_115 + 0.000331614063515452*x_116 + 0.000390679369271581*x_117 + 0.000207540966803301*x_118 - 0.00138084432049659*x_119 - 0.000732729980617765*x_12 + 0.000284923353592684*x_120 + 3.29787892170986e-5*x_13 - 0.000720233142871556*x_14 - 0.000436365916634837*x_15 + 0.000172535611505244*x_16 - 0.00680153631177052*x_17 - 0.00167328885561647*x_18 + 0.00212971768187204*x_19 + 0.00446380002253131*x_2 - 0.00413401998750299*x_20 + 0.00177661021110769*x_21 - 0.00313405189638943*x_22 - 0.000706767780596532*x_23 + 0.00108607495551862*x_24 - 0.000447326636923979*x_25 - 4.15349951166311e-5*x_26 - 0.00129475942364958*x_27 + 0.000101652917846464*x_28 - 0.00916920240728339*x_29 + 0.00322195991255342*x_3 + 0.0021093822450294*x_30 - 0.0140427301712468*x_31 - 0.00392694398258383*x_32 - 0.000397621079657504*x_33 - 0.00013167721210433*x_34 - 3.20021214080638e-5*x_35 + 0.000159351802592107*x_36 - 0.000176896127549144*x_37 + 0.000692364310514142*x_38 + 0.00040539632006031*x_39 - 0.00376962556297688*x_4 - 4.57578326497524e-5*x_40 + 0.000609821134281687*x_41 + 0.000801803204505764*x_42 + 0.000911098364938328*x_43 + 0.00120571279829656*x_44 + 0.000585189445960612*x_45 - 7.75174510513893e-5*x_46 - 7.59486828113893e-5*x_47 - 0.000797125108319595*x_48 - 0.000263168618635346*x_49 + 0.000842547614345942*x_5 + 0.0010049328119108*x_50 - 0.000702037958939187*x_51 + 0.00073229858408995*x_52 + 0.00040730684214972*x_53 - 0.00110144853592428*x_54 + 3.3264674368199e-6*x_55 + 9.39208324787222e-6*x_56 + 0.000629626426565461*x_57 + 4.57995844698675e-5*x_58 + 0.000297705322719178*x_59 - 0.00123270180598693*x_6 - 0.00131255313296884*x_60 + 0.00309190604992014*x_61 + 0.000258294629519629*x_62 + 0.000608052439760701*x_63 - 7.0148366441071e-6*x_64 - 7.05463503129075e-5*x_65 - 0.000209715773911772*x_66 + 0.000113135130811418*x_67 + 0.000263160071513911*x_68 - 4.63464943837248e-5*x_69 - 0.000242499745629936*x_7 - 0.000539797583183889*x_70 - 8.91676389959046e-5*x_71 - 0.000259695214303747*x_72 + 0.000186771179006622*x_73 - 0.000723429326121371*x_74 - 0.000154127191242935*x_75 + 0.000364014113440443*x_76 + 0.000501266363968197*x_77 - 0.00113494032848087*x_78 + 0.000614484115025993*x_79 + 0.00252965413375309*x_8 + 0.000143964637524033*x_80 + 0.000453563626442888*x_81 + 0.000417425346974473*x_82 - 0.00229681271291084*x_83 + 0.000292691614038739*x_84 + 4.84012358701087e-6*x_85 - 0.000602086860618855*x_86 + 0.000415044706120354*x_87 + 8.03808429408082e-5*x_88 - 0.000107396315656049*x_89 - 0.000406422321709168*x_9 - 0.00101628363519995*x_90 - 6.71013227036141e-5*x_91 - 0.00617737885261891*x_92 - 3.4002918673889e-5*x_93 - 0.000136649380870292*x_94 - 6.62645973671994e-5*x_95 - 0.000822235382387342*x_96 - 0.000730635526841921*x_97 + 0.00138837396982367*x_98 - 3.48028598712619e-5*x_99 - 3.24813704051336e-6*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 6.13875134365721e-7*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) + 2.4364223499255e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) - 3.03254807209105e-9*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) - 1.51256969022441e-8*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 5.39521893745143e-9*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) - 1.29069042301909e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) + 0.000581376722973671*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 2.01482219913298e-5*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) - 8.79183267763023e-6*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) - 9.85737873828153e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) + 6.80249632083842e-6*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 9.77740839202137e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) - 1.05154072870284e-5*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 5.25920821808387e-7*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 1.15876806926827e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) - 7.809261870674e-6*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 6.29466435681498e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) + 6.36199611791736e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) + 4.4761022550238e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 5.38739874831532e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 9.08389131687281e-6*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) + 3.6775350018519e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 2.29449309465441e-5*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) + 4.39853803843544e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) - 1.51201377367465e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) + 1.25728664998875e-5*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 2.28388453605636e-9*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) - 5.91687421468921e-5*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 2.16084659715419e-5*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) - 5.94338940385111e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) - 7.11523199365839e-9*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 6.66290695500476e-9*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) - 1.11915037878023e-5*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 2.74146709335864e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 8.42643073488978e-6*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) - 1.25684315478727e-5*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 9.19862189413544e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 1.37935777701786e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 7.29192250025976e-6*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) - 1.16737120723549e-5*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 8.5108588887538e-7*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 1.62077062887905e-5*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) + 6.17025972954592e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 9.73081854209142e-6*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 5.23292678446149e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 4.12782489512398e-7*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) - 1.46380740996291e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) - 0.000157022232189798*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 0.0026539117641599*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) - 4.9213263967396e-6*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) - 1.90817004438905e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) - 1.24029246655278e-6*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 1.81208638800924e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 2.85849585956279e-8*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 1.43956854848051e-5*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 1.19928995826264e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 6.14784318731574e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 4.0276042020815e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) - 2.50587563217215e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) - 1.80137559442216e-5*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 1.72647507635885e-9*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) + 4.85613757899235e-5*std::exp(0.627279818058014*x_38) + 2.21016345805376e-5*std::exp(0.757519841194153*x_72) + 0.000803223073821849*std::exp(0.511599838733673*x_73) - 0.00565967072547985*std::exp(-0.106927663894321*x_1 + 0.0412371093785399*x_100 + 0.0423984289910069*x_102 - 0.00183523657908824*x_103 + 0.000466446747033986*x_104 - 0.0425596136742202*x_105 - 0.00173713718363854*x_106 + 0.000625784574409623*x_107 - 0.00121243972395326*x_108 + 0.0585449137135409*x_11 + 0.00237052364943593*x_110 - 0.000762057110116946*x_111 + 0.00120760235625005*x_112 + 0.0360760893429343*x_113 - 0.00040461216806442*x_114 - 0.0316979148862196*x_116 - 0.0514147789333465*x_14 - 0.0582341948589828*x_15 - 0.0123869754414645*x_16 - 0.00955389674499257*x_18 - 0.110411749887619*x_2 + 0.00732740318044978*x_20 - 0.0464277605288997*x_23 - 0.00178171100500917*x_25 + 0.0444635991708125*x_26 + 0.0363667830608737*x_27 + 0.0185137852983996*x_29 + 0.00718724714154276*x_3 - 0.00402846835212374*x_30 - 0.0797032979977272*x_31 - 0.0027191863879155*x_33 - 0.056783366182285*x_34 + 0.000622712161522348*x_35 - 0.0406536559549083*x_36 + 0.0587518347134065*x_37 + 0.00155234510984189*x_39 - 0.000857256896296252*x_41 - 0.00396808385728926*x_43 - 0.000147253915348631*x_44 - 0.0251712137063236*x_45 - 0.0250686265361853*x_46 + 0.000608122156650532*x_47 - 0.0545180549994891*x_48 - 0.00406655255752713*x_49 + 0.000500871296235164*x_5 + 0.024315850248412*x_50 - 0.00287211315507447*x_51 - 8.48071590911014e-5*x_53 - 0.0819157450475912*x_54 + 0.0440329855562351*x_55 + 0.0454313940409512*x_56 + 0.0208160820241392*x_57 - 0.00143300583045342*x_58 + 0.000825545429961032*x_59 - 0.0091206856687847*x_6 - 0.0637389291376258*x_60 + 0.00395950394761458*x_61 - 0.00517314472447357*x_62 - 0.113004726838791*x_63 - 0.0453476390263342*x_64 - 0.00252791730347056*x_65 - 0.0691028262136293*x_66 - 0.000761503680309209*x_67 - 0.00176265005696681*x_68 - 0.150955031693182*x_7 + 0.0012274007795153*x_70 + 0.00225504032890134*x_72 - 0.00396262540105314*x_73 + 0.0174612849426436*x_74 - 0.0445167272305606*x_75 - 0.00492126152735081*x_76 - 0.00141573512160239*x_77 + 0.00231153374059342*x_78 - 0.00290110171270512*x_79 - 0.0564877909826061*x_8 + 1.90072419891573e-5*x_80 - 0.00120980201238463*x_82 - 0.00582227077188762*x_83 - 0.00736997990839311*x_85 + 0.00462785945503978*x_87 - 0.0227424092377356*x_88 - 0.00411186990298637*x_89 - 0.00335328214468866*x_9 - 0.00277574269774627*x_90 + 0.22014345028092*x_91 + 0.0473153807576136*x_92 + 0.00979636622536889*x_93 + 3.71613066092158e-5*x_95 + 0.00182100517691516*x_97 - 0.00031081061778786*x_98 + 0.000818322187451809*x_99 - 0.00246500057212717*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 0.00109975647725816*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 0.00199396213314829*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) - 0.00119185437943772*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) - 0.000300754132077918*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) - 0.0011961168958359*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) + 0.000668247069144506*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 0.000732170554168521*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) + 0.0535354277401461*std::exp(0.759199857711792*x_22) - 0.921678068919718*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.643095572409536*std::sin(0.378879845142365*x_101 - 4.40639972686768) - 0.580491308152631*std::sin(0.330879837274551*x_109 + 1.928879737854) - 0.650952515702841*std::sin(0.31687992811203*x_115 + 1.91471993923187) + 0.499364829151361*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.637060409424706*std::sin(0.271039962768555*x_118 + 5.06983995437622) + 0.315416663499235*std::sin(0.361119836568832*x_119 - 1.20559990406036) + 1.15965348661362*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.402071496876921*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 4.34651837417448*std::sin(0.150320038199425*x_19 + 8.10863971710205) + 0.526279082099279*std::sin(0.271839946508408*x_21 + 8.30095958709717) + 1.43069858896538*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 0.630617306321923*std::sin(0.312159925699234*x_28 + 5.14895963668823) - 0.471989654922034*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 1.01441445719175*std::sin(0.346879839897156*x_38 - 4.25672006607056) - 1.10770179020108*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.460053013635964*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.630152674875006*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.711384166400819*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.369702617961565*std::sin(0.386399865150452*x_96 - 7.41824007034302)) + 0.0324629642150822*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 0.0390427329010672*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.022637152171362*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.0144462132346628*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.00841313349849802*std::sin(0.140800043940544*x_100 + 1.73271989822388) - 0.00888085511643219*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.000572669400294722*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.00481653536467441*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.00043542048331137*std::sin(0.333679854869843*x_103 + 1.94599986076355) - 0.00136317509744071*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 0.00453885426358149*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.00915689322761337*std::sin(0.300639927387238*x_106 - 7.50688028335571) - 0.0151053484204029*std::sin(0.369759827852249*x_107 + 5.16495990753174) + 0.00981872920652583*std::sin(0.226719990372658*x_109 + 5.01807975769043) - 0.00907591377306441*std::sin(0.362399846315384*x_109 - 1.22647988796234) - 0.00185255593455226*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.000809475519897842*std::sin(0.238639980554581*x_11 - 4.33599996566772) - 0.0116319774230564*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.00241351148049269*std::sin(0.32423985004425*x_110 + 5.12512016296387) + 0.0134932245804363*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.000732885253365873*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.00837482780557863*std::sin(0.385039836168289*x_111 - 7.41479969024658) + 0.00128357857471753*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.00990005379503809*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.00791248014294788*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 5.24795512638706e-5*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.0109434620280585*std::sin(0.311999946832657*x_114 - 1.30423986911774) - 0.0169696417061301*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.000382631585874637*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.0104503388166227*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.0118686338224023*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.00987498014015659*std::sin(0.24967996776104*x_118 - 4.34711980819702) - 0.0119249617870052*std::sin(0.277119934558868*x_118 - 7.51272010803223) + 0.0123900859071692*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.0130192835610537*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 0.0165604458980381*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.0205968671572997*std::sin(0.310799926519394*x_12 + 5.12871980667114) + 0.0038282967908767*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.0123454749786684*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.00382969094914693*std::sin(0.190880000591278*x_13 - 4.42511987686157) - 0.0779320242735676*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 2.11929592400081e-5*std::sin(0.126320049166679*x_14 - 4.50839996337891) - 0.0921683633732311*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.0118988891401132*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 0.000960757070902096*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 4.06726067202175e-6*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 0.0052495012355882*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.0439909424278433*std::sin(0.202480003237724*x_18 + 5.00679969787598) + 0.00156994620233028*std::sin(0.288319945335388*x_21 - 1.0707198381424) + 0.00475210371027839*std::sin(0.292639940977097*x_21 + 5.07719993591309) - 0.0104954462941942*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.0004093794982248*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 0.0103421953626573*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.00359312831390446*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.0522191083990427*std::sin(0.295439928770065*x_23 + 5.13943958282471) + 0.0129482645537341*std::sin(0.382159858942032*x_23 + 5.17600011825562) + 0.0121403293391469*std::sin(0.193599998950958*x_24 - 7.59560012817383) + 0.00224479905157999*std::sin(0.568079829216003*x_24 + 2.35255980491638) - 0.00524027924561703*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 0.0170505871774935*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.0113258315609571*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.0101838895972348*std::sin(0.357919842004776*x_26 + 5.1561598777771) - 0.00140354213863623*std::sin(0.371439844369888*x_26 + 5.18544006347656) - 0.00620457070014198*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.00651706366691518*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.0153737668397489*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 0.0061601788990679*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.0251620290671186*std::sin(0.316799849271774*x_28 - 4.29735994338989) - 0.0327709966731797*std::sin(0.360399842262268*x_28 + 8.36839962005615) - 0.00429146318974222*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.000853489653857398*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.0323579671574979*std::sin(0.315519839525223*x_3 + 8.31960010528564) - 0.00126822356602822*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.0158415421290873*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.00181919672776189*std::sin(0.263439953327179*x_32 + 5.1547999382019) - 4.09637885593527e-6*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.0145353205767217*std::sin(0.312719941139221*x_34 - 1.1386399269104) + 0.00179533476734927*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.0144651840349894*std::sin(0.361359834671021*x_34 + 2.00311970710754) + 0.0074678920593644*std::sin(0.398559868335724*x_34 - 7.60168027877808) + 0.00460117837979393*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.000754996798033436*std::sin(0.304399937391281*x_35 - 1.12567985057831) + 0.0237873242773161*std::sin(0.304399937391281*x_35 - 1.12175977230072) - 0.0118462103301385*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.0170053816167664*std::sin(0.342639863491058*x_35 - 1.21223986148834) - 0.00396795342898686*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.0004424946549763*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.00848444741547838*std::sin(0.386319845914841*x_37 + 5.17471981048584) - 0.00572197337547966*std::sin(0.413759857416153*x_37 + 5.19672012329102) + 0.00789907164669879*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.0173143972714277*std::sin(0.319519847631454*x_39 + 1.94815981388092) - 0.00655256484973815*std::sin(0.329919844865799*x_40 - 4.27824020385742) + 0.00223954758119191*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.000520341221167267*std::sin(0.291759938001633*x_41 - 7.50631999969482) + 0.0232287818310842*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.0195512175958493*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.01781999292465*std::sin(0.332159847021103*x_43 + 5.14351987838745) + 0.00898646473122686*std::sin(0.344799846410751*x_43 - 4.25375986099243) + 0.00228992865087035*std::sin(0.347919851541519*x_43 - 7.45056009292603) + 0.000647865409047273*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.0136934079247826*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.00580630657194781*std::sin(0.282239943742752*x_45 + 5.07999992370605) - 0.0181948333298607*std::sin(0.296719938516617*x_46 + 5.10799980163574) + 0.0169785125309431*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.00100980420317872*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.00142844032498888*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.00334439724393014*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.00567822308211145*std::sin(0.475279867649078*x_48 + 2.04215979576111) + 0.00705772755906929*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.165196118919567*std::sin(0.163760021328926*x_5 + 8.13551998138428) + 0.0128196008332175*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.0124397733228248*std::sin(0.342719823122025*x_51 + 5.15288019180298) - 0.0202760139044289*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.0111395762746154*std::sin(0.2811199426651*x_55 + 1.88439989089966) - 0.0189104186010213*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.0106200793306297*std::sin(0.26335996389389*x_56 - 7.52920007705688) - 0.00211205559807709*std::sin(0.314399927854538*x_56 + 5.12855958938599) - 0.0547802142761498*std::sin(0.140080034732819*x_57 + 4.9115195274353) + 0.00762387814120358*std::sin(0.221599996089935*x_57 - 7.57183980941772) - 0.00324395307672913*std::sin(0.231359988451004*x_57 + 1.84351992607117) - 0.00640621639479156*std::sin(0.333759844303131*x_57 - 7.44903993606567) + 0.0187291608113278*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.00663411491901961*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.0110359527979921*std::sin(0.359839856624603*x_58 + 5.1528000831604) + 0.00443604365515531*std::sin(0.403839856386185*x_58 + 2.014399766922) - 0.0101529027338579*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.000405953688465271*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 0.0125483825117862*std::sin(0.322079837322235*x_59 + 5.1165599822998) - 0.0224464670557967*std::sin(0.288639932870865*x_60 - 7.49160003662109) - 0.015887184660858*std::sin(0.27167996764183*x_62 - 4.30463981628418) - 0.0399267845018442*std::sin(0.223439991474152*x_64 + 5.04335975646973) - 0.0554514444907522*std::sin(0.125280052423477*x_65 + 4.9015998840332) - 0.0127326770980411*std::sin(0.236399978399277*x_65 - 4.34391975402832) - 0.0106361132393969*std::sin(0.242479979991913*x_68 + 5.06775999069214) - 0.0091430183564063*std::sin(0.313759922981262*x_7 + 8.38703918457031) - 0.00072491039814816*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.00142985093096209*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.0678868129595824*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.0220717063938942*std::sin(0.180800005793571*x_74 - 7.61600017547607) - 0.0183788891419603*std::sin(0.317759841680527*x_74 - 4.29056024551392) + 0.00674486421268921*std::sin(0.170960023999214*x_75 - 7.64040040969849) - 0.0170289880428178*std::sin(0.243279978632927*x_76 - 7.53600025177002) - 0.0231664990073468*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.00507981635952648*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.0419438754347838*std::sin(0.174000009894371*x_87 + 4.95519971847534) - 0.0268763111167694*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.0201275256971119*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.000467867747843108*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.0535495548223509*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.0142464847806836*std::sin(0.338559836149216*x_93 + 1.98655986785889) - 0.00397616275088858*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.00204973488079385*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 2.50891007338823e-6*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.00743877556133388*std::sin(0.328879833221436*x_95 - 1.22527992725372) - 0.0112731609220248*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.00712326736875425*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 0.00290759827632195*std::sin(0.367679834365845*x_95 + 1.98583984375) - 2.60943111217722e-6*std::sin(0.280479967594147*x_96 - 7.50864028930664) - 0.013105090271537*std::sin(0.362479835748672*x_96 - 7.42711973190308) + 0.00876860802216185*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.0109681037601984*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.00947482649891688*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 2.64918115279313e-6*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.000399547435218119*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 0.0021916407918522*std::sin(0.379759848117828*x_99 + 5.18016004562378) - 0.0100905988110243*std::sin(0.382479846477509*x_99 - 7.39991998672485) - 0.0108685620304212*std::sin(0.395599842071533*x_99 - 7.39767980575562) + 0.00862556030879087*std::sin(0.417999863624573*x_99 + 2.01671981811523) - 0.279612739897289);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00313145059488328*x_1 + 0.000970602218701656*x_10 - 0.000233064763700667*x_100 + 0.00100446976190764*x_101 - 0.000845407270146077*x_102 + 0.00225218596520005*x_103 - 0.000872233398405714*x_104 - 0.00055354288965743*x_105 - 0.000122104769440668*x_106 - 0.000897120024898946*x_107 - 0.000496234513539999*x_108 + 0.00155714133411255*x_109 - 0.000939342563294162*x_11 - 0.00016078484586962*x_110 - 0.00122781594392042*x_111 - 4.95557727187751e-5*x_112 - 0.000874323842564764*x_113 + 0.000857769866252599*x_114 + 0.000162599266864286*x_115 - 0.000737432516550643*x_116 + 0.000273038131590105*x_117 + 0.0010846908305485*x_118 + 0.00332563627070596*x_119 - 0.000387080198955531*x_12 - 0.000180196869632259*x_120 - 0.000540934857391466*x_13 - 0.000514162139940959*x_14 + 0.00168173056445186*x_15 + 0.000397295355163738*x_16 - 0.00166839881024158*x_17 + 0.00108573468439409*x_18 + 0.00123774581782191*x_19 - 0.00169593179670397*x_2 + 0.00184790927564544*x_20 + 0.000648744049870715*x_21 - 0.00250561265776692*x_22 + 0.000202652130273615*x_23 + 0.00094892505395761*x_24 - 0.00399436422663861*x_25 - 0.000826384962250755*x_26 - 0.000508371852139693*x_27 + 0.000578341953471516*x_28 - 0.00163959916509682*x_29 + 0.0015020861661808*x_3 - 6.73309900629825e-5*x_30 + 0.00677877472853557*x_31 + 0.00201753134150049*x_32 - 0.00113620565216873*x_33 - 0.000283555349691648*x_34 + 0.000188492934532124*x_35 + 0.000278315009550203*x_36 - 0.000351871241941642*x_37 - 0.000223579910292013*x_38 + 0.0031937045207807*x_39 - 0.0012591306087394*x_4 + 9.11804458330876e-5*x_40 - 0.00119522213922363*x_41 + 0.00198070508253412*x_42 + 0.000110440202409769*x_43 + 0.000299521947391038*x_44 + 0.000808895884005084*x_45 + 0.000259690091752933*x_46 + 0.000193264097284635*x_47 - 0.00027711191454567*x_48 + 0.000838061770834357*x_49 - 0.00134228540926372*x_5 - 0.00149618979916065*x_50 - 0.000510378367633943*x_51 - 0.000218696598519821*x_52 + 0.000166102346145753*x_53 + 3.08033786905435e-6*x_54 - 0.000628902851884999*x_55 - 0.000194539690062933*x_56 - 8.15281683534969e-5*x_57 - 8.24106796723067e-6*x_58 + 6.75072022420879e-5*x_59 + 0.00166309369273334*x_6 + 0.000626082013877219*x_60 - 0.000384773230581511*x_61 + 0.00147460095804166*x_62 + 9.99320356019276e-5*x_63 + 0.00041760160924149*x_64 - 0.000510444634170993*x_65 + 0.000723628475886971*x_66 - 2.29987105342428e-5*x_67 - 0.000705079661339338*x_68 - 0.000674055446089986*x_69 + 0.0011158470888608*x_7 + 4.0769549283726e-5*x_70 + 7.95059733813504e-5*x_71 - 0.000283165509969224*x_72 - 0.000731610326451116*x_73 + 5.35792247137889e-5*x_74 + 0.000177308568755563*x_75 + 5.92989275791314e-5*x_76 - 0.00159091827812183*x_77 + 0.00104068502880827*x_78 + 8.95520185697965e-5*x_79 + 0.000975460727954002*x_8 - 6.84618390714954e-5*x_80 - 0.000870102404232553*x_81 - 0.00129646541868368*x_82 - 0.000556204188734631*x_83 + 0.000485843720233386*x_84 - 0.000116952998453907*x_85 - 0.00011436112592642*x_86 - 0.00098863534076224*x_87 + 0.000194872452101824*x_88 - 0.000570644355295919*x_89 + 0.0045449274585563*x_9 - 0.000336354048619129*x_90 - 0.00438938295141709*x_91 + 0.00570425483877651*x_92 - 7.74083274969991e-6*x_93 + 0.000321045314730563*x_94 + 4.42399742972444e-5*x_95 + 0.000214203884200348*x_96 + 0.00134837531354682*x_97 - 0.00233936840467608*x_98 - 2.66294474147603e-5*x_99 + 1.59691083621818e-5*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) - 1.03841281484899e-5*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) - 3.51481161709779e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 1.27719707447288e-5*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) + 7.84883107335724e-7*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 5.69819646806255e-6*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) + 3.91482796085259e-6*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) + 1.39638881353775e-6*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) + 6.3455374481258e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) + 8.47972878245878e-5*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) + 1.25180999063005e-6*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 4.32240779807302e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) + 1.03313671885643e-5*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) + 6.12439409855374e-7*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) - 3.34437246722948e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) + 6.07470848438605e-6*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) + 6.53322754886791e-7*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) - 8.89631930646643e-6*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) + 5.69695571152889e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) - 1.13902776010369e-6*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) + 3.20862836084515e-8*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) + 8.52954030738888e-6*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) - 6.45727790411883e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) + 3.3471934047337e-7*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) - 4.6304027751054e-8*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) + 5.3639057381242e-7*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) - 1.42556965103723e-6*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 6.34538285047833e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) + 7.433649349076e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) - 7.81152793640545e-7*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) - 5.91114254033861e-7*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 6.17538569292073e-6*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) - 8.63011651444471e-6*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) + 1.34253501857413e-6*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 8.57400365015962e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 1.84156203424876e-6*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) + 1.72449141461654e-6*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 1.55830510535773e-6*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) + 1.6144995356558e-5*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) - 1.34781213166672e-5*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) - 4.29527026447287e-8*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) - 1.68505201042674e-6*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) + 5.71510815796164e-7*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 5.13516673705564e-6*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 2.71468639220473e-6*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 1.68406347150043e-5*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) + 1.43967143164789e-5*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) - 8.26168054634371e-8*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) - 3.833585304724e-7*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 3.62265516128127e-6*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 1.94814949455033e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) - 6.98250511967438e-6*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) + 2.11170583371506e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) - 2.10520005638969e-5*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) - 0.000164887664135108*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) - 7.17805021172078e-7*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 9.38130806436109e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) + 6.19747117855998e-6*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 3.4624056942913e-6*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) + 2.09804163636603e-5*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 2.42946767029076e-6*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) + 7.39834970204747e-6*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) - 7.33802504820517e-8*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 3.79361408826067e-6*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) - 5.8961771200841e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) + 3.81965789637442e-7*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) - 2.05302210515268e-7*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) + 1.55690172213676e-6*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) + 1.11919551360174e-6*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) + 4.46845718668474e-7*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) - 0.000277384486087014*std::exp(0.759199857711792*x_22) - 0.000821449707016673*std::exp(0.627279818058014*x_38) - 0.000373864639447457*std::exp(0.757519841194153*x_72) + 0.000299029336684715*std::exp(0.511599838733673*x_73) - 0.00201692551071717*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 0.00523446663308065*std::sin(0.358559846878052*x_1 + 8.25119972229004) + 0.000115390121456057*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.00537813429663163*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.00477551423939122*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.0413622451353784*std::sin(0.140800043940544*x_100 + 1.73271989822388) + 0.0128116263315154*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.00333208759858068*std::sin(0.378879845142365*x_101 - 4.40639972686768) - 0.00968710427654576*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.00179313247111289*std::sin(0.36847984790802*x_102 + 1.96815979480743) - 0.00736544265122326*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 0.00670190037431976*std::sin(0.385199844837189*x_104 + 1.99399983882904) + 2.31362558674049e-5*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.00122766641833401*std::sin(0.300639927387238*x_106 - 7.50688028335571) - 0.00202517693851025*std::sin(0.369759827852249*x_107 + 5.16495990753174) + 0.00143212064345955*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.00300771451703837*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.0130930202500892*std::sin(0.362399846315384*x_109 - 1.22647988796234) + 0.000115099388326744*std::sin(0.373039841651917*x_109 + 8.18727970123291) - 0.0136928457614915*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.016780427817709*std::sin(0.287039935588837*x_110 - 7.50984001159668) + 0.0118657636314711*std::sin(0.32423985004425*x_110 + 5.12512016296387) - 0.000838334684959979*std::sin(0.384959846735001*x_110 - 7.40488004684448) - 0.0123972677227806*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.00112281475831061*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.00631057282847878*std::sin(0.352639853954315*x_112 - 4.23967981338501) + 0.00061509081316141*std::sin(0.310799926519394*x_113 - 7.49704027175903) + 4.03329022043882e-5*std::sin(0.345999836921692*x_113 + 1.96959984302521) - 0.000887728391315845*std::sin(0.256479978561401*x_114 - 7.52464008331299) - 5.57829625832942e-5*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.00337279698056613*std::sin(0.31687992811203*x_115 + 1.91471993923187) + 0.00105432464632796*std::sin(0.334959834814072*x_115 - 4.27088022232056) - 0.00647248145257996*std::sin(0.368559837341309*x_115 + 1.98191976547241) - 0.000649280047725636*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.00159122999614403*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.00258737180874725*std::sin(0.352479845285416*x_117 + 5.15328025817871) + 5.03365065147355e-5*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.00330081745367544*std::sin(0.271039962768555*x_118 + 5.06983995437622) - 0.00159878189708217*std::sin(0.277119934558868*x_118 - 7.51272010803223) - 0.0178740840579997*std::sin(0.303199917078018*x_118 + 5.1017599105835) - 0.000808888706883707*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 0.00163427645582079*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.00600854238028463*std::sin(0.248959973454475*x_12 - 4.32624006271362) + 0.00102890129130865*std::sin(0.296079933643341*x_12 + 5.11303997039795) - 0.000104990017512088*std::sin(0.310799926519394*x_12 + 5.12871980667114) - 0.0188213999389756*std::sin(0.327679842710495*x_12 - 4.2513599395752) + 0.00076702494761179*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.00208326336856381*std::sin(0.44463986158371*x_120 + 2.0079197883606) - 0.0647819065454469*std::sin(0.190880000591278*x_13 - 4.42511987686157) - 0.0113668539381439*std::sin(0.123040057718754*x_14 + 4.89599990844727) - 0.00548515482904355*std::sin(0.126320049166679*x_14 - 4.50839996337891) - 0.0123570300246488*std::sin(0.221919998526573*x_14 + 5.03495979309082) + 6.06531357246787e-5*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 0.000128808883406721*std::sin(1.36559987068176*x_15 - 2.19623994827271) + 0.00105268708647365*std::sin(0.207520008087158*x_16 - 1.18359982967377) - 2.67586921081248e-5*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.0163772465745314*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.0225207272339403*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.00272682331847668*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.00771846776016742*std::sin(0.288319945335388*x_21 - 1.0707198381424) + 0.000693122875700369*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.0151408546069968*std::sin(0.33943983912468*x_21 - 4.23839998245239) + 0.00692494113696783*std::sin(0.349679857492447*x_21 - 4.02647972106934) - 5.27180791110746e-5*std::sin(0.3503198325634*x_21 - 4.22424030303955) - 0.060780283769114*std::sin(0.192800000309944*x_23 + 4.99607992172241) - 0.003244375688527*std::sin(0.295439928770065*x_23 + 5.13943958282471) - 0.0186793191566773*std::sin(0.382159858942032*x_23 + 5.17600011825562) + 0.00177073997044692*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.00741291532724561*std::sin(0.258639991283417*x_24 + 5.07799959182739) - 1.14425892994592e-5*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.00755968864343013*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 0.00228597546901188*std::sin(0.345119833946228*x_26 + 1.93407988548279) + 5.77320446280792e-5*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.00379132752828131*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.00690036049071004*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.00895078686855355*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.0008737439665551*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.00572345024721641*std::sin(0.278879970312119*x_28 + 5.09839963912964) - 3.14007603948407e-5*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.0032674336381646*std::sin(0.312159925699234*x_28 + 5.14895963668823) + 0.00156331806272023*std::sin(0.316799849271774*x_28 - 4.29735994338989) - 0.00439361376298193*std::sin(0.360399842262268*x_28 + 8.36839962005615) - 0.000625935688356885*std::sin(0.407039850950241*x_28 - 4.18111991882324) + 0.0144373756858923*std::sin(0.310399949550629*x_3 - 4.25767993927002) + 0.00201040203853549*std::sin(0.315519839525223*x_3 + 8.31960010528564) + 0.00623508161779294*std::sin(0.247039973735809*x_30 + 8.25191974639893) - 8.07503283314567e-5*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.0024455321157499*std::sin(0.258159965276718*x_32 + 1.97111988067627) - 0.0307729876824409*std::sin(0.263439953327179*x_32 + 5.1547999382019) + 0.00106022344537934*std::sin(0.312719941139221*x_34 - 1.14543986320496) - 0.000903080158774342*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.00882656584023364*std::sin(0.361119836568832*x_34 + 1.98511981964111) + 7.37345108627777e-5*std::sin(0.361359834671021*x_34 + 2.00311970710754) - 0.0107732691609436*std::sin(0.398559868335724*x_34 - 7.60168027877808) + 0.000671109509524216*std::sin(0.270799964666367*x_35 + 8.24799919128418) - 0.0127712999982958*std::sin(0.304399937391281*x_35 - 1.12567985057831) + 0.00318917109453875*std::sin(0.304399937391281*x_35 - 1.12175977230072) + 0.0170894827361224*std::sin(0.324799835681915*x_35 - 7.42127990722656) - 0.00105654516867569*std::sin(0.342639863491058*x_35 - 1.21223986148834) + 0.000246529135270496*std::sin(0.355199843645096*x_36 - 4.24295997619629) + 0.00748510722305668*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.00315864766025081*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.00825458627625669*std::sin(0.413759857416153*x_37 + 5.19672012329102) + 0.0029407199966236*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.0052560116686312*std::sin(0.346879839897156*x_38 - 4.25672006607056) + 0.0010757443259975*std::sin(0.319519847631454*x_39 + 1.94815981388092) + 0.00573936372198214*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.00243943330870419*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.0110104892620735*std::sin(0.263519942760468*x_41 + 8.27439975738525) + 0.00880193645101057*std::sin(0.291759938001633*x_41 - 7.50631999969482) - 0.00144320531999448*std::sin(0.336239844560623*x_41 - 7.43887996673584) - 9.9659946442067e-5*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.00238368448982239*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.025707331961585*std::sin(0.332159847021103*x_43 + 5.14351987838745) - 0.000558329481173834*std::sin(0.344799846410751*x_43 - 4.25375986099243) - 0.0112581822476412*std::sin(0.347919851541519*x_43 - 7.45056009292603) + 0.000241191730967811*std::sin(0.386239856481552*x_43 + 1.97567975521088) - 6.9800476297851e-5*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.00216161121285561*std::sin(0.282239943742752*x_45 + 5.07999992370605) + 0.00113044586018407*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.0244934024212279*std::sin(0.315279841423035*x_46 + 5.10735988616943) + 0.0170815458448664*std::sin(0.22647999227047*x_47 - 4.37087965011597) + 0.0241630692575312*std::sin(0.186160013079643*x_48 - 4.42583990097046) - 0.0164423610606225*std::sin(0.261839956045151*x_48 + 5.08527946472168) + 0.000352788270164585*std::sin(0.475279867649078*x_48 + 2.04215979576111) + 0.00102941196570924*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.0221478751139181*std::sin(0.163760021328926*x_5 + 8.13551998138428) - 0.0184937073560038*std::sin(0.211119994521141*x_5 - 4.36911964416504) - 6.34102268580636e-5*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.00326502623132088*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.0292504167932551*std::sin(0.297439932823181*x_52 + 5.10951995849609) - 0.000692102403772887*std::sin(0.2811199426651*x_55 + 1.88439989089966) + 0.00117490520711661*std::sin(0.217999994754791*x_56 - 7.58768033981323) + 5.41345587359098e-5*std::sin(0.26335996389389*x_56 - 7.52920007705688) + 0.010383688955228*std::sin(0.314399927854538*x_56 + 5.12855958938599) - 0.00734439375717155*std::sin(0.140080034732819*x_57 + 4.9115195274353) - 0.000473671911527059*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.0159485383646046*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.00924168332585857*std::sin(0.333759844303131*x_57 - 7.44903993606567) + 0.00251102215567029*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.00246979332190425*std::sin(0.284239947795868*x_58 - 7.50048017501831) + 5.62544229991366e-5*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.00639948889549857*std::sin(0.403839856386185*x_58 + 2.014399766922) - 0.00148086186005934*std::sin(0.261439979076385*x_59 + 5.08079957962036) - 0.00686699116381563*std::sin(0.295199930667877*x_59 - 7.48152017593384) + 0.0181024446067658*std::sin(0.322079837322235*x_59 + 5.1165599822998) + 0.00139460006579668*std::sin(0.288639932870865*x_60 - 7.49160003662109) + 0.000987071538620366*std::sin(0.27167996764183*x_62 - 4.30463981628418) + 0.00248065302013495*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.0799949078151036*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 0.000791081833704889*std::sin(0.236399978399277*x_65 - 4.34391975402832) + 0.00066082222144858*std::sin(0.242479979991913*x_68 + 5.06775999069214) - 0.00122580621170975*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 0.00356394220949209*std::sin(0.534639835357666*x_7 - 3.87391996383667) + 0.0241869306462286*std::sin(0.205680012702942*x_70 - 7.60304021835327) + 0.00421781091807547*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.00821700463740643*std::sin(0.180800005793571*x_74 - 7.61600017547607) + 0.00114188125654405*std::sin(0.317759841680527*x_74 - 4.29056024551392) - 0.0331603827539285*std::sin(0.170960023999214*x_75 - 7.64040040969849) + 0.00105801183704905*std::sin(0.243279978632927*x_76 - 7.53600025177002) + 0.00143933568519333*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.00189114850653093*std::sin(0.445039868354797*x_81 - 4.1593599319458) - 0.00260597497573727*std::sin(0.174000009894371*x_87 + 4.95519971847534) - 0.00360331214819182*std::sin(0.206560000777245*x_88 + 5.00391960144043) + 0.0290362059541139*std::sin(0.243199974298477*x_88 + 5.05599975585938) + 0.00791431087230482*std::sin(0.359999865293503*x_88 - 4.24480009078979) - 0.0772512193486357*std::sin(0.175840020179749*x_91 - 4.16767978668213) - 0.000885134777028617*std::sin(0.338559836149216*x_93 + 1.98655986785889) - 0.00057994722509689*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.000763089211153881*std::sin(0.256959974765778*x_94 + 5.05655956268311) + 0.000649355290539225*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.00368591304370124*std::sin(0.359999865293503*x_94 + 1.97703981399536) - 0.000997318055717192*std::sin(0.328879833221436*x_95 - 1.22527992725372) + 0.0162627949014493*std::sin(0.335519850254059*x_95 + 5.14463996887207) - 3.63099863720653e-5*std::sin(0.347519844770432*x_95 + 1.94063985347748) - 0.000180649219201814*std::sin(0.367679834365845*x_95 + 1.98583984375) + 0.000675372113158931*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.0189055577867777*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.00191554966528063*std::sin(0.386399865150452*x_96 - 7.41824007034302) - 0.000544794033477719*std::sin(0.472959846258163*x_97 - 1.13407981395721) + 5.59085708065808e-5*std::sin(0.228159993886948*x_98 + 1.83047986030579) + 0.000588671421028338*std::sin(0.375119835138321*x_98 - 7.40303993225098) - 0.000685660205764112*std::sin(0.316639840602875*x_99 + 1.92487978935242) - 0.00675862490014729*std::sin(0.321679830551147*x_99 + 1.9223198890686) + 0.0107749608035424*std::sin(0.379759848117828*x_99 + 5.18016004562378) + 0.0145568168530164*std::sin(0.382479846477509*x_99 - 7.39991998672485) - 0.00145715018059742*std::sin(0.395599842071533*x_99 - 7.39767980575562) - 4.39677413538383e-5*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.261280821229755);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000637640131852753*x_1 - 0.000229479033021078*x_10 + 8.44688520696211e-5*x_100 + 0.00040572971949378*x_101 - 0.00119915912689595*x_102 + 0.00144895817566878*x_103 + 0.0013708680489577*x_104 + 0.000158436620853793*x_105 - 0.000984679207910109*x_106 + 0.0001373907231386*x_107 + 0.00113603875113572*x_108 - 4.37558324702789e-5*x_109 - 0.0045454464382511*x_11 - 0.00010108310646204*x_110 + 0.000166904262904373*x_111 + 0.000917584212731988*x_112 - 0.00012322191933289*x_113 + 0.000175046773255148*x_114 + 3.28196136608357e-5*x_115 - 0.000399738617167128*x_116 + 1.52912087455404e-5*x_117 + 0.00093693728433639*x_118 + 0.000141338758430593*x_119 - 0.00235728624709994*x_12 + 0.000153059867236417*x_120 - 0.00405976963477363*x_13 - 0.000270532761439707*x_14 + 0.00138429110399199*x_15 - 0.000559383702468032*x_16 - 0.00333027690872515*x_17 + 0.000392486978856217*x_18 + 0.00516543335631112*x_19 - 0.00187406044147637*x_2 + 0.00249300189130045*x_20 + 0.00399606599949182*x_21 - 0.000742130518635285*x_22 + 0.000843504129420247*x_23 + 0.000463691806391172*x_24 + 0.00047141677804096*x_25 + 3.51611944297678e-5*x_26 + 0.000906239843524747*x_27 - 2.9683553015731e-5*x_28 + 0.00280997519056027*x_29 + 0.000639360202891945*x_3 - 0.00173232440339004*x_30 - 0.00427921768953711*x_31 + 0.00443724296627097*x_32 - 8.56076252440326e-6*x_33 - 0.000657003771246261*x_34 - 2.39550531690338e-5*x_35 + 5.16274326688802e-5*x_36 - 2.98026063429686e-5*x_37 - 0.000640204893826141*x_38 + 0.00101067364665055*x_39 + 0.00184411547081798*x_4 - 1.99779282307495e-5*x_40 - 0.000396737988564681*x_41 + 0.000158583267300465*x_42 + 3.23239123100169e-5*x_43 - 0.00101883589056036*x_44 - 0.000748764977966333*x_45 - 0.000530789096755529*x_46 + 5.76497420994432e-5*x_47 + 0.000570747247962298*x_48 - 0.000810367477078985*x_49 + 0.000579760482762597*x_5 - 0.000224270119480427*x_50 + 0.000341753762551102*x_51 + 0.000796803312170196*x_52 + 0.000647068434401331*x_53 + 0.000648891682583847*x_54 - 3.85451856864895e-6*x_55 - 0.00011469071998286*x_56 - 4.47246858775935e-5*x_57 - 7.60075292375391e-5*x_58 - 0.000225246984793*x_59 + 0.000380628803201209*x_6 - 0.000295923541443399*x_60 + 0.0001712132154523*x_61 + 2.10593912062598e-5*x_62 - 0.000273097774997603*x_63 + 6.48652311640236e-5*x_64 + 0.000400790190006544*x_65 + 7.09152824871659e-5*x_66 - 0.0003978244055199*x_67 - 7.69293901837209e-5*x_68 - 9.68455534845893e-5*x_69 - 0.000240412133115376*x_7 - 0.000562063126881013*x_70 - 4.53469298541078e-5*x_71 - 0.00149050934664014*x_72 - 1.80687618798234e-5*x_73 + 1.43562898026184e-5*x_74 + 0.000101220829185521*x_75 + 9.5734951820701e-5*x_76 - 0.000139871760791955*x_77 + 9.03087807923268e-5*x_78 + 2.83921816088927e-6*x_79 + 0.00260307729272212*x_8 - 3.91371900163944e-5*x_80 + 5.84400250030722e-5*x_81 - 0.000196755641178606*x_82 + 0.000198538222879181*x_83 - 4.04480169134642e-5*x_84 + 0.000657767220624043*x_85 + 0.000715666199761526*x_86 - 8.06388738803697e-5*x_87 + 0.000762346257630693*x_88 - 9.57849992146903e-5*x_89 + 0.00710355450940309*x_9 - 0.00240057771432958*x_90 + 0.00112870469143049*x_91 - 0.000720743937872134*x_92 - 0.000509705401921201*x_93 + 0.000254333340429234*x_94 - 0.00025648418979924*x_95 + 0.000330596335872006*x_96 + 0.00197992606951665*x_97 - 0.000357284617970892*x_98 - 0.000127378746029489*x_99 - 5.40393461267632e-6*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 4.55787398509226e-6*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) + 1.07128014334729e-6*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 2.03348895505776e-6*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) + 5.34331471767587e-6*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) + 1.90591897615579e-6*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) - 0.000443670944826093*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) + 1.85321339583409e-5*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 3.6869071093533e-6*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) + 9.06671880697686e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) + 8.99316287880483e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) + 9.67196691368508e-6*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 5.95954818217451e-6*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) + 1.92313802945433e-8*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 9.927902650598e-6*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) + 4.95527572277796e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) - 2.77529918302863e-8*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 2.80646844709769e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) - 2.11045190066507e-5*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 9.75586681504603e-6*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) - 1.15643974101793e-5*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) - 8.06806716665845e-7*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 2.20378126134456e-6*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 4.51539435535191e-5*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) + 1.98752518307167e-5*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 1.31823153391557e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 2.51353204266262e-6*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) + 2.35374336966252e-6*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 5.56105118192331e-7*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) + 2.48225249980374e-6*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) - 2.57443264330442e-8*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) + 8.46080082141254e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 3.28961491003348e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 1.73904242824685e-5*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 2.58920530457887e-6*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 4.95175827769958e-8*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) - 5.67534345784494e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 2.32069201306861e-5*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 1.24799484659412e-5*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 3.246694699395e-6*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) - 0.00244104161390481*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 3.75565351338969e-6*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 2.21166280620989e-6*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 1.23561266739972e-6*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) + 1.00979433182688e-5*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) - 4.39815193417249e-8*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 1.35380947137692e-6*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) + 5.65472494551808e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) - 1.23050862914193e-7*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) + 2.30487945379698e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) + 1.65688733425128e-5*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) + 6.0989584445793e-7*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) - 9.89889155145436e-5*std::exp(0.759199857711792*x_22) + 0.00191559771058083*std::exp(0.511599838733673*x_73) + 0.0911903699692703*std::exp(-0.003453133208218*x_10 - 0.000992704789912723*x_100 + 0.00629495807890208*x_101 - 0.00629276082941797*x_102 - 0.000197094846546474*x_103 + 0.000997674926549818*x_104 + 0.000342245032096701*x_105 - 0.00058096082699674*x_108 + 0.0074174801033128*x_109 + 0.000387483379740615*x_11 - 0.000347120849424024*x_110 - 0.000611005833434706*x_112 - 0.0041004989411379*x_113 + 6.87316543107846e-5*x_114 - 0.00055033085899329*x_115 - 0.000676826200197078*x_116 - 0.000135826280850217*x_119 - 0.00404336492639215*x_12 + 0.000602739763521024*x_120 + 0.00951070973678762*x_13 - 0.0055033660176902*x_16 - 0.0472069779834246*x_17 - 0.00256679122786689*x_18 + 0.00228729779770862*x_19 + 0.00482677836582203*x_2 - 0.000116095155246746*x_20 + 0.00215536869985151*x_21 - 0.0376684224390636*x_22 - 0.00330496358938094*x_23 + 0.00830714655031695*x_24 - 0.000476769266268581*x_25 - 0.0462766860864439*x_29 + 0.031017929960542*x_3 + 0.00100710170613353*x_30 - 0.0367962899657725*x_31 - 0.0152480918849343*x_32 + 0.000863901153123818*x_33 + 0.00102650613819767*x_34 + 0.00046671619851624*x_36 - 0.00388890198649545*x_37 + 0.000221543932617125*x_38 + 0.0129663851487219*x_39 - 0.0017997887259224*x_4 + 0.000521368975608*x_40 - 0.000748435943317635*x_41 + 0.0131125379098827*x_42 + 0.00768340713338283*x_43 + 0.00131902274095589*x_44 + 0.00190853411909904*x_45 + 0.00123718030291957*x_46 + 0.00071717305122654*x_47 - 0.0127432248637371*x_48 + 0.00136296269115108*x_49 - 5.21832802917607e-6*x_50 - 0.00088329305475106*x_51 - 0.00445939592823931*x_52 + 0.000974345463488772*x_53 - 2.3750147794492e-5*x_54 - 0.000323707410272533*x_55 + 0.00161531103471971*x_56 + 0.000466492441484686*x_59 - 0.00912592290094558*x_60 + 0.013648820544017*x_61 + 0.00474087454330693*x_62 + 0.00180781027228389*x_63 + 0.0004725657875943*x_64 + 0.00463973639662599*x_65 - 0.00100907823898116*x_66 + 0.00186212682717806*x_67 + 0.000758125698334523*x_68 - 0.000298622762823647*x_69 - 0.00261475179644849*x_70 + 0.000314782363950768*x_71 + 0.00047744063447322*x_73 - 0.000427935145696232*x_74 - 0.000919611360210732*x_75 - 0.000906159627268235*x_76 + 5.5198640157853e-6*x_77 - 0.00221257630403197*x_78 - 0.00020564581544876*x_79 + 0.0118123766829665*x_8 - 6.99783807355084e-5*x_81 - 0.00517228775856829*x_82 - 0.0149961100444161*x_83 - 7.51662495454192e-5*x_85 + 0.00223157839569561*x_86 - 0.000163128573954056*x_87 - 0.000436640138935253*x_89 + 0.000826548601982528*x_9 - 0.00180730652742627*x_90 - 0.00232261790584914*x_91 - 0.0107083387722506*x_92 + 0.00134486989018646*x_93 + 0.000525855689157866*x_94 - 0.0017937780945729*x_96 - 0.000635039066572541*x_97 - 8.32570923211845e-5*x_98 + 0.000544789095564283*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) - 0.000107625725145343*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 0.00134460943189271*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 0.000155172195347247*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) + 0.334329898215863*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.0784121129153288*std::sin(0.300639927387238*x_106 - 7.50688028335571) - 0.129349797635975*std::sin(0.369759827852249*x_107 + 5.16495990753174) + 0.0717151469624184*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.101633232178187*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.102115578604092*std::sin(0.277119934558868*x_118 - 7.51272010803223) - 0.789254164747589*std::sin(0.221919998526573*x_14 + 5.03495979309082) + 0.00822713447183121*std::sin(1.36559987068176*x_15 - 2.19623994827271) + 0.146007224699588*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.0558067806868738*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.280623900225926*std::sin(0.360399842262268*x_28 + 8.36839962005615) + 0.203695108244982*std::sin(0.304399937391281*x_35 - 1.12175977230072) - 1.41460388451765*std::sin(0.163760021328926*x_5 + 8.13551998138428) - 0.469092763295976*std::sin(0.140080034732819*x_57 + 4.9115195274353) + 0.160381150663472*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.0782932999139394*std::sin(0.313759922981262*x_7 + 8.38703918457031) - 0.230146654509468*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.063699564335657*std::sin(0.328879833221436*x_95 - 1.22527992725372) - 0.0930694387247719*std::sin(0.395599842071533*x_99 - 7.39767980575562)) - 0.0298591112296467*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 6.91607459135736e-5*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.0344526121083771*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.00170421562593557*std::sin(0.348559856414795*x_10 - 4.24007987976074) + 0.00196975538150514*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.00118910665277615*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.0114869012335524*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 1.38670511240113e-5*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.00749305001715411*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.0010733491350543*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.00201301898997225*std::sin(0.362399846315384*x_109 - 1.22647988796234) + 0.00170396250146616*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.002579948645285*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.0124109336080488*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.00910597089923754*std::sin(0.310799926519394*x_113 - 7.49704027175903) + 2.41741109734162e-5*std::sin(0.345999836921692*x_113 + 1.96959984302521) - 3.34343291509472e-5*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.00120363442118474*std::sin(0.31687992811203*x_115 + 1.91471993923187) + 0.015608507463258*std::sin(0.334959834814072*x_115 - 4.27088022232056) - 0.00961211758253607*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.000923343381577764*std::sin(0.352479845285416*x_117 + 5.15328025817871) + 3.016991656923e-5*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.00117794742114132*std::sin(0.271039962768555*x_118 + 5.06983995437622) - 0.0027480955463174*std::sin(0.303199917078018*x_118 + 5.1017599105835) - 0.0119750073777675*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 0.000583216661806759*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.00214424066189834*std::sin(0.248959973454475*x_12 - 4.32624006271362) + 0.0152321332336106*std::sin(0.296079933643341*x_12 + 5.11303997039795) - 6.29272925012071e-5*std::sin(0.310799926519394*x_12 + 5.12871980667114) + 0.011355244953251*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.000743444539723164*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.0594729260311814*std::sin(0.123040057718754*x_14 + 4.89599990844727) - 0.00748664023549485*std::sin(0.126320049166679*x_14 - 4.50839996337891) + 3.63533381868695e-5*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 0.00143680347093388*std::sin(0.207520008087158*x_16 - 1.18359982967377) - 1.60382109188985e-5*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.104913505783775*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.00803686751532051*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.00097310879531706*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.0036265131707832*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.00232786838071878*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 3.15973467091044e-5*std::sin(0.3503198325634*x_21 - 4.22424030303955) - 0.0480306159249495*std::sin(0.295439928770065*x_23 + 5.13943958282471) - 0.00287189842098407*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.00926475239815058*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.00264541272439798*std::sin(0.258639991283417*x_24 + 5.07799959182739) - 6.85828215749514e-6*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.00116228314833613*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 3.46025397946583e-5*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.0242874442145294*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.00137616100773004*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.0366647243101464*std::sin(0.278879970312119*x_28 + 5.09839963912964) - 1.88205019958109e-5*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.00116603389367707*std::sin(0.312159925699234*x_28 + 5.14895963668823) + 0.0231437837808304*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.0032749806671664*std::sin(0.407039850950241*x_28 - 4.18111991882324) + 0.0297625359816064*std::sin(0.315519839525223*x_3 + 8.31960010528564) - 4.83988825880238e-5*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.000872725707947958*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.00144708978181679*std::sin(0.312719941139221*x_34 - 1.14543986320496) - 0.0133694431285873*std::sin(0.312719941139221*x_34 - 1.1386399269104) + 4.41938504483176e-5*std::sin(0.361359834671021*x_34 + 2.00311970710754) - 0.00165636308436277*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 0.00351133624448362*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.00262746506302722*std::sin(0.324799835681915*x_35 - 7.42127990722656) - 0.0156413806771752*std::sin(0.342639863491058*x_35 - 1.21223986148834) + 0.00364968405242339*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.0202344635934085*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.00126912191465951*std::sin(0.413759857416153*x_37 + 5.19672012329102) + 0.0188384074801694*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.00187568851578231*std::sin(0.346879839897156*x_38 - 4.25672006607056) + 0.0159256101992577*std::sin(0.319519847631454*x_39 + 1.94815981388092) + 0.00204818012210065*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.0156271385044584*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.021365602223758*std::sin(0.336239844560623*x_41 - 7.43887996673584) - 5.97326369594382e-5*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.000850654432426831*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.00395243774405974*std::sin(0.332159847021103*x_43 + 5.14351987838745) - 0.0082656607755596*std::sin(0.344799846410751*x_43 - 4.25375986099243) + 0.0015450869562678*std::sin(0.386239856481552*x_43 + 1.97567975521088) - 4.18359296702922e-5*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.01384739549778*std::sin(0.282239943742752*x_45 + 5.07999992370605) + 0.0167354265187153*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.00376579912511997*std::sin(0.315279841423035*x_46 + 5.10735988616943) + 0.00522277304907178*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 0.0053860234349273*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.00284336107265789*std::sin(0.211119994521141*x_5 - 4.36911964416504) - 3.8005840818208e-5*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.00116517477355819*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.00449717814108051*std::sin(0.297439932823181*x_52 + 5.10951995849609) - 0.0102460713332007*std::sin(0.2811199426651*x_55 + 1.88439989089966) + 0.017393614725569*std::sin(0.217999994754791*x_56 - 7.58768033981323) + 3.24463343537035e-5*std::sin(0.26335996389389*x_56 - 7.52920007705688) - 0.00701236719823964*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.00142088560766844*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.0158216263511159*std::sin(0.284239947795868*x_58 - 7.50048017501831) + 3.37169058015039e-5*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.000983905350078976*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.00774807069264477*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.00278320540733083*std::sin(0.322079837322235*x_59 + 5.1165599822998) + 0.0206460368834786*std::sin(0.288639932870865*x_60 - 7.49160003662109) + 0.0146128742517635*std::sin(0.27167996764183*x_62 - 4.30463981628418) + 0.0367242588071737*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.0122990162282676*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 0.0117113896070203*std::sin(0.236399978399277*x_65 - 4.34391975402832) + 0.00978299104672401*std::sin(0.242479979991913*x_68 + 5.06775999069214) + 0.06244161456595*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.0526385653185726*std::sin(0.180800005793571*x_74 - 7.61600017547607) + 0.0169047192219181*std::sin(0.317759841680527*x_74 - 4.29056024551392) + 0.0156630936327923*std::sin(0.243279978632927*x_76 - 7.53600025177002) + 0.021308315102676*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.0121147971287466*std::sin(0.445039868354797*x_81 - 4.1593599319458) - 0.0385795589617718*std::sin(0.174000009894371*x_87 + 4.95519971847534) + 0.00446424376239534*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.0118771810153013*std::sin(0.175840020179749*x_91 - 4.16767978668213) - 0.0131037748395221*std::sin(0.338559836149216*x_93 + 1.98655986785889) + 0.00303436277160505*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.00488838975487058*std::sin(0.256959974765778*x_94 + 5.05655956268311) + 0.000886299402077246*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.00131537469893843*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.00250036388406397*std::sin(0.335519850254059*x_95 + 5.14463996887207) - 2.17629179163318e-5*std::sin(0.347519844770432*x_95 + 1.94063985347748) - 0.00267437994166567*std::sin(0.367679834365845*x_95 + 1.98583984375) + 0.000921809537541987*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.00290668204233029*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.000683593328002109*std::sin(0.386399865150452*x_96 - 7.41824007034302) - 0.00806527834390615*std::sin(0.472959846258163*x_97 - 1.13407981395721) + 3.35096142646619e-5*std::sin(0.228159993886948*x_98 + 1.83047986030579) + 0.00871485106653704*std::sin(0.375119835138321*x_98 - 7.40303993225098) - 0.000935851665876563*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.00223807404242503*std::sin(0.382479846477509*x_99 - 7.39991998672485) - 2.63527046318653e-5*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.397181838750839*std::sin(-0.000607645730446616*x_1 + 0.0041310844630865*x_10 + 0.000846572804414251*x_101 - 0.00196826637783543*x_102 + 0.013490332720265*x_103 - 0.00108281944670858*x_105 - 0.00016834411383707*x_106 + 0.00116622888154186*x_107 + 0.0136443302365068*x_109 + 0.000522968020320572*x_11 - 0.0111664824452845*x_111 - 0.000422870829854847*x_113 + 0.00927244779754133*x_114 + 0.00044558951049363*x_115 - 0.00975292907570844*x_116 + 0.00210487209437538*x_117 + 0.00881303290508354*x_118 - 0.000553307997686583*x_119 - 0.000319625321672708*x_120 - 0.000134612218699749*x_13 - 0.00654305942181049*x_14 - 0.000106007646292549*x_15 + 0.00595732907676755*x_16 - 0.0083956456881667*x_17 - 0.00216856985393236*x_18 + 0.000192022926634918*x_19 + 0.0264563165801446*x_20 - 0.00451647680183787*x_22 - 0.000939009240221863*x_23 + 0.000590984261065364*x_24 + 0.000906771531583967*x_25 - 0.000719112906758931*x_28 - 0.00253510959253177*x_29 - 0.0024225486111075*x_3 + 0.00663518210157876*x_31 + 0.00411549540276582*x_32 - 0.00123907533212191*x_33 + 0.00170501693694556*x_35 + 0.000436999336026041*x_36 + 9.83683159526771e-5*x_37 - 0.000170237805753045*x_38 + 0.00112613009526656*x_39 - 0.00573160172288065*x_4 - 0.000509624436598316*x_40 + 0.00414205539311332*x_42 + 5.62970616578173e-5*x_44 - 0.000284444226299088*x_45 + 0.00161264265835254*x_46 + 0.000403779131623725*x_47 + 0.00750711286079469*x_49 + 0.000671281799690215*x_50 - 0.00682517594737732*x_51 - 0.00658827072593276*x_52 - 0.000406083774355284*x_53 - 0.00331399037236153*x_54 + 0.000109860240284119*x_58 + 0.000761706040982492*x_59 - 0.00686338777177029*x_6 + 0.0032125994982838*x_60 - 8.25843521852082e-5*x_61 + 0.0129968525333927*x_62 + 0.00120400759373976*x_63 + 0.00155337688065597*x_64 + 0.000236397064437001*x_65 + 0.000358735789086788*x_66 + 0.000271113421158387*x_67 - 0.00654602313435758*x_68 + 0.00242691932900504*x_70 + 0.000442578921041006*x_72 - 0.00731293256838342*x_73 + 0.000650167896667241*x_74 + 4.27755904518315e-5*x_76 - 0.00891204205248722*x_77 + 0.00389335351356333*x_78 + 0.000285253650802817*x_79 + 0.0011048351159663*x_8 - 0.000550964418086174*x_80 - 0.0104041308048108*x_82 + 1.65979124694777e-5*x_83 + 0.00429146516750722*x_84 + 0.000107497952065738*x_85 + 2.80991011426506e-5*x_86 + 9.05890863495762e-5*x_88 + 0.0006542955256982*x_89 + 5.80730210597005e-5*x_9 + 3.87183185974224e-5*x_90 + 0.00282614992798992*x_91 + 0.0280217324178553*x_92 - 0.000246143015031071*x_93 - 0.000770799204356046*x_94 + 0.000537222358872518*x_95 + 0.00166258449332868*x_96 + 0.000757150466800922*x_97 + 0.000156171828786769*x_98 + 0.000152278136101115*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 0.000605097412607454*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) + 0.000412175926189005*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) - 0.000318912486650579*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) + 5.43249990874067e-5*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 7.08857527692238e-5*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) - 0.000128524595468797*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 8.94582260844582e-5*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) - 5.62247335045185e-5*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 0.394421870734448*std::sin(0.140800043940544*x_100 + 1.73271989822388) + 0.0639079449015241*std::sin(0.385199844837189*x_104 + 1.99399983882904) + 0.113149483880761*std::sin(0.32423985004425*x_110 + 5.12512016296387) - 0.0601763258321206*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.179477002504933*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.0736017226145407*std::sin(0.288319945335388*x_21 - 1.0707198381424) + 0.0658004197929771*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.0594564571585208*std::sin(0.247039973735809*x_30 + 8.25191974639893) - 0.0841683182204243*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.10499376323105*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.107355712646892*std::sin(0.347919851541519*x_43 - 7.45056009292603) - 0.1567909765922*std::sin(0.261839956045151*x_48 + 5.08527946472168) + 0.0990167242962983*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.152081984830824*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.0339850206113448*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.316210596336507*std::sin(0.170960023999214*x_75 - 7.64040040969849) + 0.102747812245532*std::sin(0.379759848117828*x_99 + 5.18016004562378) - 1.9410237214258) - 0.0614755898714066*std::sin(0.0306536247294866*x_1 - 0.0139426692581258*x_10 + 0.00171341963315109*x_100 + 0.00367496801420252*x_101 + 0.008499439072657*x_104 + 0.0200848136663825*x_105 + 0.00117955300673281*x_106 - 5.93918125122327e-5*x_107 + 0.0220690176339171*x_108 - 0.000479563940671584*x_109 + 0.00253429427310756*x_110 + 0.00450669221707998*x_112 + 0.0168500715615691*x_113 - 0.000887654340333548*x_117 - 0.000341370909700108*x_118 - 0.0345290058923053*x_119 + 0.000239677184259411*x_12 - 0.0161298523702689*x_120 + 0.00095396988704578*x_14 + 0.00368421427784976*x_15 - 0.0119788435139351*x_16 + 0.00124662569006888*x_17 + 0.00077480105119052*x_18 - 0.00492324472276057*x_19 - 0.0550417007366598*x_2 + 0.0437577373166734*x_20 + 0.000340256560486032*x_22 - 0.0186667953714715*x_24 + 0.0439556987410904*x_25 + 0.00848496706379361*x_26 + 0.0106056932376994*x_27 - 0.0230961582113967*x_28 + 0.0146815222546146*x_29 - 0.000110408248980652*x_30 + 0.0303408253120422*x_31 + 0.000360567436726071*x_33 + 0.0131133679444471*x_34 + 0.00452930642384788*x_36 + 0.0114697476618537*x_39 + 0.0882350279145431*x_4 - 0.000154068777757076*x_40 - 0.0209219059592482*x_42 + 0.0013934484977215*x_43 - 0.00200646101210734*x_44 - 3.42849819542127e-5*x_45 - 0.000832574166342122*x_46 - 0.000993965773462843*x_49 + 0.0419053258940447*x_5 - 0.00023692972775701*x_50 + 0.00734347314979248*x_51 - 0.0151811688157485*x_52 - 0.00114841725620617*x_54 + 0.0132202249264121*x_55 + 0.000456897947859941*x_56 - 0.000961181530165105*x_57 + 5.85302830701704e-5*x_58 - 4.14769509414402e-5*x_6 - 0.00320513459800591*x_60 + 0.0234375496997478*x_61 - 0.000601896179594258*x_62 + 0.0165221312403419*x_63 - 0.000111969551769021*x_64 + 0.0140158277078898*x_65 - 0.0118404225240044*x_66 + 0.00111938270431045*x_67 + 0.000742943597875868*x_68 + 0.0169275301835502*x_69 - 0.0112698555888025*x_7 - 0.00219760412005375*x_71 - 0.000230234507332439*x_73 - 0.000991395089240459*x_74 + 0.0026132056530249*x_75 + 0.000447453133142436*x_76 - 0.0158333349762319*x_78 + 0.00111726381500648*x_79 - 0.00192404440570185*x_8 - 0.00807807391417006*x_81 - 0.000935000656626112*x_82 - 0.000433263508223696*x_83 + 0.0126443409769975*x_85 + 0.0014430278060617*x_86 + 0.000950681397042197*x_87 + 0.0192850307035055*x_89 - 0.00579299458348838*x_9 - 8.51421908491588e-5*x_90 + 0.102583888414063*x_91 + 0.00975086850845305*x_92 + 0.00126856575282049*x_93 - 0.000355169960606944*x_94 + 3.12989583554598e-5*x_95 - 0.00438806562831141*x_96 - 0.001042983363437*x_97 + 0.00855839085845747*x_98 + 0.000282042180315309*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) + 0.000241631965447369*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 0.000391027598767338*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 0.000189651065535257*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) - 0.000569846817230414*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 0.0223113065510508*std::exp(0.627279818058014*x_38) + 0.010154496992402*std::exp(0.757519841194153*x_72) + 0.263110390398642*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.200051990367672*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 0.371909901155632*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.336720846322963*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.0241114947190759*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.175798367935349*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 1.75953434951758*std::sin(0.190880000591278*x_13 - 4.42511987686157) - 0.188087576433618*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 1.65084670655928*std::sin(0.192800000309944*x_23 + 4.99607992172241) - 0.392131997819426*std::sin(0.310399949550629*x_3 - 4.25767993927002) + 0.83582178654391*std::sin(0.263439953327179*x_32 + 5.1547999382019) + 0.346879896460452*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.203302186846738*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.239068442929494*std::sin(0.291759938001633*x_41 - 7.50631999969482) - 0.463950017213783*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.656290507883895*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.186513603487277*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 0.65693860447875*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.214959740692588*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.183570279132975*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 2.32149228036688) + 0.153448113945613);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00231327919337101*x_1 + 0.00073988392058662*x_10 - 0.000102038443933511*x_100 - 0.00182012000671933*x_101 + 0.00150006866771889*x_102 + 0.00117909587904365*x_103 + 0.00150184404059818*x_104 - 0.00057804773060577*x_105 - 0.000657246762118264*x_106 + 0.00163589982182195*x_107 - 0.000699816912220762*x_108 + 0.000975596028078118*x_109 - 0.00366494092262851*x_11 - 0.000102820588367398*x_110 - 0.0010389892151497*x_111 + 0.000490421210250547*x_112 - 7.16486301535227e-5*x_113 + 0.000829685583988906*x_114 - 6.72527435433726e-5*x_115 - 0.00061551346362442*x_116 + 0.000669855040129373*x_117 + 0.00111770120113039*x_118 - 0.000684691373587737*x_119 - 0.000816424281474222*x_12 + 0.000986827384937797*x_120 - 0.00221644064170168*x_13 - 0.00129216061171489*x_14 - 0.000459969266555893*x_15 + 0.00197802499789953*x_16 + 0.00143679984483634*x_17 - 0.00133671004794469*x_18 + 0.00247277879908725*x_19 + 0.00468004477707236*x_2 - 0.00192318647351649*x_20 + 0.00180539698885668*x_21 + 0.00406074162294433*x_22 + 3.43694128601164e-5*x_23 - 0.000172522272915853*x_24 + 0.000579124106560064*x_25 + 0.000112028557241407*x_26 - 0.00103615603820268*x_27 + 0.000598647458578187*x_28 + 0.00272287861638463*x_29 - 0.00368700949597874*x_3 + 0.00102619441007382*x_30 - 0.00543100585658313*x_31 - 0.00100852869552417*x_32 - 0.000329303826170702*x_33 - 0.000748890923669933*x_34 + 0.000117799865787522*x_35 + 0.000109571381243722*x_36 + 0.000718076358702826*x_37 + 0.000878074089847895*x_38 - 0.00283753742363571*x_39 - 0.00561856209677031*x_4 - 0.000230577308681991*x_40 + 0.000884083789949577*x_41 - 0.00100327791714338*x_42 - 0.000796951815373438*x_43 + 0.000375480525987747*x_44 - 0.000304580492288254*x_45 - 0.000231979656365149*x_46 - 0.000142297333884952*x_47 + 0.00307586368332798*x_48 + 2.29298457399333e-5*x_49 - 0.000660086660117356*x_5 + 0.00123209095771847*x_50 - 0.000931489395336522*x_51 + 0.00219081312509258*x_52 + 0.000200974149799727*x_53 - 0.000743831092820413*x_54 - 0.000268869984545734*x_55 - 0.000272876473138328*x_56 + 0.00071796324068987*x_57 - 1.77690091210124e-6*x_58 + 0.000152213377754336*x_59 - 0.00208967977378191*x_6 + 0.00101802128631667*x_60 - 0.000795175023141398*x_61 + 0.000441265717384506*x_62 - 0.00044232145538811*x_63 + 6.73836534177238e-5*x_64 - 0.000455208333551059*x_65 + 0.000464512124965682*x_66 - 0.000335642369459873*x_67 - 0.000508119702833172*x_68 - 0.000386941939462785*x_69 + 7.47127227513062e-5*x_7 + 0.000204881189216451*x_70 - 0.000118393215471333*x_71 - 0.000449448645269492*x_72 - 0.000625437689860495*x_73 - 0.000543853159522287*x_74 + 2.65911905594026e-5*x_75 + 0.000599112327856515*x_76 + 7.36056271580938e-5*x_77 + 2.14157565049209e-5*x_78 + 0.000712864339747734*x_79 + 0.000630771494931823*x_8 + 0.000137989480015675*x_80 + 0.000898108447183692*x_81 + 0.000119511987179583*x_82 + 0.00143880259352155*x_83 + 0.00071500308326476*x_84 - 0.000452472293889856*x_85 - 0.000705404488418237*x_86 + 0.000746026008259816*x_87 + 0.000419936799689825*x_88 - 0.000479684415950324*x_89 + 0.000640296397875604*x_9 - 0.000892611969726393*x_90 - 0.00172365301075002*x_91 - 0.00261788980190564*x_92 - 0.000454536123040707*x_93 - 0.000540693019037264*x_94 - 0.000119279354796884*x_95 + 0.000619612491837309*x_96 - 0.000460931313933466*x_97 + 0.00144745008117098*x_98 - 3.28732029661137e-5*x_99 + 1.0548456173558e-5*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) - 5.98484814037438e-6*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) + 2.82512590339186e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 1.84172938417949e-6*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 1.45325997581797e-8*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 8.21684928803161e-7*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 7.24854788508864e-8*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 2.58550089105988e-8*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) + 4.19156925678731e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) - 0.000275107997758628*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 1.11379105811844e-5*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 2.85518315663739e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) + 1.48979221063278e-6*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) - 5.4491459841515e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) - 2.2091381433775e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 5.40493848206147e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) - 5.81290329926163e-6*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) - 5.12735583537891e-6*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) + 3.76314608698374e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 3.69534986922965e-6*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 6.78850836248316e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 5.50206760070151e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) + 5.19021360450297e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 2.97814693275376e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 9.79656240157045e-6*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 1.74021293090636e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 1.26839276083037e-5*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) + 5.10027489684551e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) + 4.9103257733554e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) + 6.95026404241407e-6*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 1.09448487105159e-8*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 8.90496033588838e-7*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 2.7998702972952e-5*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 1.19451315302743e-5*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) - 6.89158977682086e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) - 3.40976684597559e-8*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 3.19300329957537e-8*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 2.2470896304227e-7*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) - 1.29769812897157e-5*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) - 8.90302506478441e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 9.08752115555664e-6*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) + 1.08696011015207e-5*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 5.08498606830386e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 1.75894669383745e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 9.29860489225683e-6*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) - 1.35361204371469e-5*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) + 8.29748513042088e-6*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 1.74792718787308e-5*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) + 3.41091145213402e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 1.24086668362056e-5*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 6.67298899530022e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) - 4.02433715985244e-6*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) - 1.69734128058282e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 0.00013579809234529*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 0.00146707892797122*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 2.32877615807991e-6*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 6.19685925620704e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) + 8.93680779990052e-7*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 4.99281938126773e-7*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) + 1.20919738337967e-5*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) - 1.56715307905621e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 1.36985054317031e-7*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 1.55250901013449e-5*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 5.4704247905285e-7*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) - 3.89474255745142e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 3.39851961711222e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 4.34358740303621e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) - 1.38524474917502e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) - 9.95798056147865e-6*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 8.27362689089887e-9*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) - 3.999908619841e-5*std::exp(0.759199857711792*x_22) - 0.000473439048627759*std::exp(0.627279818058014*x_38) - 0.0002154752965442*std::exp(0.757519841194153*x_72) + 0.00102426404059387*std::exp(0.511599838733673*x_73) + 0.0179454838637059*std::sin(0.144320040941238*x_1 + 8.1526403427124) - 0.0337654647623592*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.024413135968357*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.018421702788755*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.00068863334210848*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.0273219906932169*std::sin(0.140800043940544*x_100 + 1.73271989822388) - 0.0102976948288419*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.000480489954418259*std::sin(0.378879845142365*x_101 - 4.40639972686768) - 0.00558312139315503*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.00614200977918979*std::sin(0.36847984790802*x_102 + 1.96815979480743) - 0.0042450415792122*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 0.00442696616333847*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 0.00489494727245565*std::sin(0.409279853105545*x_105 - 1.17479979991913) + 0.0079191883517256*std::sin(0.300639927387238*x_106 - 7.50688028335571) + 0.0130636118917365*std::sin(0.369759827852249*x_107 + 5.16495990753174) - 0.00464623165290333*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.00043371507153968*std::sin(0.330879837274551*x_109 + 1.928879737854) - 0.0105238728818996*std::sin(0.362399846315384*x_109 - 1.22647988796234) - 0.00102409048076622*std::sin(0.373039841651917*x_109 + 8.18727970123291) - 0.0078918134792099*std::sin(0.238639980554581*x_11 - 4.33599996566772) - 0.0134877274978826*std::sin(0.287039935588837*x_110 - 7.50984001159668) + 0.00783797597170733*std::sin(0.32423985004425*x_110 + 5.12512016296387) + 0.00745903677721091*std::sin(0.384959846735001*x_110 - 7.40488004684448) - 0.0071451125809918*std::sin(0.24679996073246*x_111 + 1.84103989601135) - 0.00724283194715507*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.00416847324230693*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.0054727366993226*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.00853324888724682*std::sin(0.345999836921692*x_113 + 1.96959984302521) - 0.000511638486731963*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.0118020245847678*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.000486360283008335*std::sin(0.31687992811203*x_115 + 1.91471993923187) - 0.00938079558578158*std::sin(0.334959834814072*x_115 - 4.27088022232056) - 0.00373038718620917*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.00577693353451787*std::sin(0.271519958972931*x_117 - 7.50487995147705) + 0.0102643925598947*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.000373101284305252*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.0106497156100516*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.00047598077209467*std::sin(0.271039962768555*x_118 + 5.06983995437622) + 0.0103131068727158*std::sin(0.277119934558868*x_118 - 7.51272010803223) + 0.0143667835926166*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.00719704280588627*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 0.000235664098416454*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.000866437081561988*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.00915459268198763*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.0222127816532273*std::sin(0.310799926519394*x_12 + 5.12871980667114) - 0.0124325483851978*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.00682456230896345*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.000300408405057787*std::sin(0.44463986158371*x_120 + 2.0079197883606) - 0.0373367766050543*std::sin(0.190880000591278*x_13 - 4.42511987686157) + 0.0368775052594407*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 0.000101561059216478*std::sin(0.126320049166679*x_14 - 4.50839996337891) + 0.0797102916327379*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.0128324091409999*std::sin(0.399439841508865*x_15 - 0.997359812259674) - 0.000830894935171034*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 1.94911572887022e-5*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 0.00566134761388416*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.0560969199082904*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.0032475086209352*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.00039321031432655*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.00509846367427511*std::sin(0.288319945335388*x_21 - 1.0707198381424) - 0.00224869982786572*std::sin(0.292639940977097*x_21 + 5.07719993591309) - 0.0121698757172756*std::sin(0.33943983912468*x_21 - 4.23839998245239) + 0.00399116040298586*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 0.0111535859143661*std::sin(0.3503198325634*x_21 - 4.22424030303955) - 0.0350304583192097*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.0288666543493511*std::sin(0.295439928770065*x_23 + 5.13943958282471) + 0.0150140133117082*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.0057448149618716*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.0010689488923436*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 0.00242091337518998*std::sin(0.568079829216003*x_24 + 2.35255980491638) - 0.00607630636710096*std::sin(0.609839856624603*x_24 + 2.38503980636597) - 0.0147459196050145*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.0122143926832878*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.0129864196482722*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.00455805975932783*std::sin(0.371439844369888*x_26 + 5.18544006347656) - 0.00719443958677084*std::sin(0.288959950208664*x_27 - 4.27960014343262) + 0.0056361752174695*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.0196045121904974*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 0.00664347193118242*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.000471166796615771*std::sin(0.312159925699234*x_28 + 5.14895963668823) - 0.0139095365293934*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.02834145694154*std::sin(0.360399842262268*x_28 + 8.36839962005615) + 0.00203072431167545*std::sin(0.407039850950241*x_28 - 4.18111991882324) + 0.00832092013792838*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.0178874416285566*std::sin(0.315519839525223*x_3 + 8.31960010528564) + 0.00411860723167266*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.0170843805359548*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.000352647876161953*std::sin(0.258159965276718*x_32 + 1.97111988067627) - 0.0177358807086565*std::sin(0.263439953327179*x_32 + 5.1547999382019) - 1.9630697669412e-5*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.00803510607149562*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.00583042213861014*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.0156000411173742*std::sin(0.361359834671021*x_34 + 2.00311970710754) + 0.00865930954101197*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 0.00217728182325717*std::sin(0.270799964666367*x_35 + 8.24799919128418) - 0.00736068449387146*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.0205720757743005*std::sin(0.304399937391281*x_35 - 1.12175977230072) - 0.0137361388355865*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.00940055256131115*std::sin(0.342639863491058*x_35 - 1.21223986148834) - 0.00219347942966767*std::sin(0.355199843645096*x_36 - 4.24295997619629) + 0.00431400974678148*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.0108193037217349*std::sin(0.386319845914841*x_37 + 5.17471981048584) - 0.00663484933229266*std::sin(0.413759857416153*x_37 + 5.19672012329102) + 0.0100728369309553*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.000757921492867767*std::sin(0.346879839897156*x_38 - 4.25672006607056) - 0.00957137600822796*std::sin(0.319519847631454*x_39 + 1.94815981388092) + 0.000827621282927756*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.0083557815605466*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.00727302118541987*std::sin(0.263519942760468*x_41 + 8.27439975738525) + 0.00507295867763193*std::sin(0.291759938001633*x_41 - 7.50631999969482) + 0.0128408400034399*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.0210850963010373*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.000343729394254261*std::sin(0.405519872903824*x_42 - 1.18847990036011) + 0.0206629706919359*std::sin(0.332159847021103*x_43 + 5.14351987838745) + 0.00496770586806334*std::sin(0.344799846410751*x_43 - 4.25375986099243) - 0.00743663574319605*std::sin(0.347919851541519*x_43 - 7.45056009292603) + 0.000826153111456731*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.0147677157889504*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.00740415860068913*std::sin(0.282239943742752*x_45 + 5.07999992370605) - 0.0100580799017773*std::sin(0.296719938516617*x_46 + 5.10799980163574) + 0.0196872416449871*std::sin(0.315279841423035*x_46 + 5.10735988616943) + 0.00984487637503153*std::sin(0.22647999227047*x_47 - 4.37087965011597) + 0.0139262823073598*std::sin(0.186160013079643*x_48 - 4.42583990097046) - 0.0108610650703917*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.00313891424145463*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 0.00333972314469386*std::sin(0.293039947748184*x_49 + 1.90383982658386) + 0.142867143711261*std::sin(0.163760021328926*x_5 + 8.13551998138428) + 0.0148648227538111*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.0134157280583139*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.000470819646437277*std::sin(0.215759992599487*x_52 + 1.79055988788605) - 0.0235108219642982*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.00615794309355635*std::sin(0.2811199426651*x_55 + 1.88439989089966) - 0.0104536544972343*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.0114532710974749*std::sin(0.26335996389389*x_56 - 7.52920007705688) + 0.00685898582312061*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.0473757664327147*std::sin(0.140080034732819*x_57 + 4.9115195274353) + 0.00421446979565303*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.0105348685822528*std::sin(0.231359988451004*x_57 + 1.84351992607117) - 0.00742825556505531*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.016197606376734*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.00845977359737329*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.011901771660951*std::sin(0.359839856624603*x_58 + 5.1528000831604) + 0.00514376410934646*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.00480436287208602*std::sin(0.261439979076385*x_59 + 5.08079957962036) - 0.00395776118216585*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 0.0145503346251935*std::sin(0.322079837322235*x_59 + 5.1165599822998) - 0.0124083774259856*std::sin(0.288639932870865*x_60 - 7.49160003662109) - 0.00878241475677337*std::sin(0.27167996764183*x_62 - 4.30463981628418) - 0.0220714738882231*std::sin(0.223439991474152*x_64 + 5.04335975646973) - 0.064298093561697*std::sin(0.125280052423477*x_65 + 4.9015998840332) - 0.00703860713059953*std::sin(0.236399978399277*x_65 - 4.34391975402832) - 0.00587962939075875*std::sin(0.242479979991913*x_68 + 5.06775999069214) + 0.00790718889779363*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 0.00235417578422547*std::sin(0.534639835357666*x_7 - 3.87391996383667) + 0.0139400347173581*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.0375277407957283*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.0281456744839801*std::sin(0.180800005793571*x_74 - 7.61600017547607) - 0.0101598257123007*std::sin(0.317759841680527*x_74 - 4.29056024551392) - 0.0219042188358245*std::sin(0.170960023999214*x_75 - 7.64040040969849) - 0.00941360216254218*std::sin(0.243279978632927*x_76 - 7.53600025177002) - 0.0128064101405056*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.00647774372955507*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.0231865190994019*std::sin(0.174000009894371*x_87 + 4.95519971847534) + 0.0232435351863054*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.0233386441475694*std::sin(0.243199974298477*x_88 + 5.05599975585938) + 0.00456137944651099*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.0620927789668123*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.00787543802384846*std::sin(0.338559836149216*x_93 + 1.98655986785889) + 0.00188152385524546*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.00261380654960338*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 1.20232177888199e-5*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.000531511893958629*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.00643330257458623*std::sin(0.328879833221436*x_95 - 1.22527992725372) - 0.0130716658935964*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.00768211891212884*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 0.00160731649778405*std::sin(0.367679834365845*x_95 + 1.98583984375) - 1.25049354695522e-5*std::sin(0.280479967594147*x_96 - 7.50864028930664) - 0.0151958587941618*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.000276223941936176*std::sin(0.386399865150452*x_96 - 7.41824007034302) + 0.00484727496621397*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.0118285995687885*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.00523767161005989*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 1.26954259141914e-5*std::sin(0.316639840602875*x_99 + 1.92487978935242) - 0.00389530474650552*std::sin(0.321679830551147*x_99 + 1.9223198890686) + 0.00711744195293592*std::sin(0.379759848117828*x_99 + 5.18016004562378) - 0.0117004394097072*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 0.00939949693546353*std::sin(0.395599842071533*x_99 - 7.39767980575562) + 0.00930227331723173*std::sin(0.417999863624573*x_99 + 2.01671981811523) - 0.178152319651054);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00174254682621373*x_1 + 0.000376882397490301*x_10 + 0.000260264271589254*x_100 - 0.000680297113567445*x_101 + 0.00113648084933851*x_102 + 0.00367557819636757*x_103 + 0.00116561889850683*x_104 + 0.0008976332889244*x_105 - 0.000541997501010929*x_106 - 0.000399657702991392*x_107 + 0.0013023054730053*x_108 + 0.000572661798967524*x_109 - 0.00269340898872075*x_11 + 0.000286139815769576*x_110 - 0.00245728623240722*x_111 + 0.00114358935309089*x_112 + 0.00142768542414168*x_113 + 0.00178871943540698*x_114 + 0.000206476248679061*x_115 - 0.00186642098841176*x_116 - 0.000327585318644465*x_117 + 0.00234733185786892*x_118 - 0.00221324387386283*x_119 - 0.00086162603433776*x_12 - 0.00105177947198847*x_120 - 0.00360996914193554*x_13 - 0.00129766151660264*x_14 + 0.00104893266787698*x_15 + 0.00151000081080498*x_16 + 0.00551333531956256*x_17 + 0.000275673210977687*x_18 + 0.0031061431462399*x_19 - 0.00316883911815912*x_2 + 0.00816305548347912*x_20 + 0.00245512197148984*x_21 + 0.00424310177616772*x_22 + 0.00163457406869749*x_23 - 0.00174359218760885*x_24 + 0.00308043340831005*x_25 + 0.000547820304736015*x_26 - 0.000196130327568763*x_27 - 0.0015073839829669*x_28 + 0.00480279080530259*x_29 - 0.00462336843692552*x_3 + 0.00145151724030926*x_30 - 0.00322264260282626*x_31 + 0.00870758465856681*x_32 + 0.00104433894442686*x_33 + 8.15449358357702e-5*x_34 + 0.000248779930940301*x_35 - 0.000304130039699613*x_36 - 2.01928233391255e-5*x_37 + 0.000770045074202183*x_38 - 0.00161110261567585*x_39 + 0.00744213846591567*x_4 - 0.000146174309620336*x_40 - 6.8202947983538e-5*x_41 - 0.00225913143693032*x_42 - 0.000914386797169914*x_43 + 0.000634936000125743*x_44 + 0.00043094932616805*x_45 - 0.000395121683824829*x_46 - 0.000286229504610423*x_47 + 1.74478267025162e-5*x_48 + 0.000616474917655499*x_49 + 0.00321341301066139*x_5 + 0.000119177454971347*x_50 - 0.00091000948498647*x_51 - 0.00557552984447322*x_52 + 0.000184711489614133*x_53 + 0.000522169026357924*x_54 + 0.00080444213328964*x_55 - 0.000235393049595365*x_56 - 0.000993315873290296*x_57 + 4.08182186001509e-5*x_58 + 0.000295938332036452*x_59 - 0.00181609675476419*x_6 + 0.00122047633784157*x_60 + 0.00125393632222268*x_61 + 0.0018650185411904*x_62 + 0.000755075719570341*x_63 + 0.000180658154010348*x_64 + 0.000149550777282112*x_65 - 0.000581332140629208*x_66 - 0.000524438392301521*x_67 - 0.00147743115123412*x_68 + 0.00102002255198915*x_69 - 0.00112793332099787*x_7 + 0.000394837578161549*x_70 - 0.000205466763819287*x_71 - 0.000667028639771057*x_72 - 0.00138951618600772*x_73 + 0.000941001496537656*x_74 + 0.000251119807826318*x_75 - 0.000531266173508146*x_76 - 0.00161568688124534*x_77 + 0.00109591393212783*x_78 - 0.000865657558283066*x_79 - 0.00126453521006775*x_8 - 0.000410380274987619*x_80 - 0.000557538102334006*x_81 - 0.0016049337820409*x_82 + 0.00244072535645741*x_83 + 0.000123174724425393*x_84 + 0.000776715995138317*x_85 - 0.00104207975516038*x_86 + 5.47489055692368e-5*x_87 + 0.000431373828047514*x_88 + 0.00132754593569981*x_89 + 0.00348534425971002*x_9 - 0.00182651434171216*x_90 + 0.0086138269552232*x_91 + 0.00655729690009031*x_92 - 0.000711189666675775*x_93 - 0.00084271373058738*x_94 - 7.75889257276766e-5*x_95 + 0.000167242341007115*x_96 + 0.0025792442183167*x_97 + 0.000508109483747064*x_98 - 5.52501048806423e-5*x_99 + 2.9201958663643e-5*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 1.67224125170719e-5*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) - 1.36039884284422e-6*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 1.74828686205752e-7*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) - 6.069399966838e-7*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 8.72007847691705e-7*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 3.11038445625243e-7*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) + 0.000116037863890762*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) + 1.05805566089725e-5*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 1.58225074163837e-5*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 7.90418419012415e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) - 1.10043941136667e-6*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) - 7.7410526973387e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) - 6.11569690234841e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 7.67825155303243e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) - 8.25780606630692e-6*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 1.43264720156556e-5*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) + 1.04177554202496e-5*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) - 1.42121853235425e-7*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) + 8.84652328368672e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 6.95030150626424e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) - 4.23075329857478e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) - 1.27665037380733e-5*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) + 6.69279758390566e-8*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 1.80187780453448e-5*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) + 1.35935655321758e-5*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) + 9.87353988482349e-6*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 1.31667668044267e-7*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) - 6.57767522230921e-7*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) - 1.07682024585501e-6*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 1.69692448911136e-5*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) - 4.10198497081923e-7*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 3.84121617056983e-7*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) - 1.65981938457055e-7*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) - 2.46468076129398e-5*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) - 1.18425084276129e-5*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) + 1.37306573439335e-5*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 7.22372739406477e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 2.37728138210163e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 1.25674077374423e-5*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) - 2.31842088471919e-5*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) - 2.27783155592255e-5*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) + 4.84553825016251e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 1.67707712517749e-5*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 9.01879093725526e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 1.12445001972304e-5*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) + 0.000171542364484025*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 0.00208413122452779*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) - 8.95639100678134e-8*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 1.71551575763085e-5*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) - 6.60119944555385e-7*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) + 3.68796076511144e-7*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 3.37864837756334e-5*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) - 1.97965332242052e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 1.64794444728242e-6*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) - 2.02317009465454e-5*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) - 4.04074540962857e-7*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) - 1.07820622560225e-5*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 4.82793441862644e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) - 5.6603962231303e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) - 1.96787765151887e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) - 1.41462997155294e-5*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 9.95325917978496e-8*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) + 0.00126123300287873*std::pow(-0.116180626277321*x_1 - 0.00155727811401516*x_10 + 0.0501927743592881*x_101 - 0.0111947655746499*x_102 + 0.0280924160880962*x_103 - 0.0367681074139291*x_104 + 0.00274319907918765*x_105 + 0.000984830870767972*x_106 - 0.0478744677163821*x_107 + 0.00373985420709856*x_108 - 0.000256642295354727*x_11 - 0.00291939740843481*x_111 + 0.00135951462397583*x_112 + 0.00205267633107358*x_113 - 0.00141434161812401*x_114 + 0.00612661069094381*x_115 + 0.00775169410304814*x_116 + 0.00118371093215575*x_117 + 0.0980796742588289*x_119 - 0.00323378141661576*x_12 - 0.0327740908616293*x_120 + 0.00068891973186054*x_14 + 0.0620927585230298*x_15 - 0.0282631574396278*x_16 + 0.016730813638222*x_17 + 0.0604180208274507*x_18 + 0.00874095659013007*x_19 - 0.190655433390675*x_2 + 0.0227699492908964*x_20 - 0.0676325846051151*x_22 - 0.103121653602747*x_25 - 0.0106938647934926*x_26 - 0.00893309139069973*x_28 - 0.0007147567371348*x_29 + 0.0576335072394585*x_3 - 2.9448170750364e-5*x_30 + 0.398470460071317*x_31 + 0.0444313975857755*x_32 - 0.0446401266086331*x_33 + 0.00955701424911151*x_36 - 0.00311973095885303*x_38 + 0.145990591490777*x_39 + 0.113883616459939*x_4 + 0.00717170511227486*x_40 - 0.0522061814716095*x_41 + 0.0290587640355682*x_42 + 0.0115978263627637*x_44 + 0.0361021838965463*x_45 + 0.00680019467222319*x_47 - 0.0121105106486691*x_48 + 0.00469943607748733*x_49 - 0.0659736945130925*x_50 + 0.0231890557380901*x_51 + 0.00405695583129138*x_53 - 0.00466640016964407*x_54 + 0.0025077095364376*x_55 + 0.00282480002235014*x_56 + 0.105562526041165*x_6 + 0.00177181708441312*x_60 + 0.00639545361919513*x_61 - 0.000538522764002949*x_62 - 0.00193537219874928*x_63 - 0.00204598748434398*x_66 + 0.00090284260410388*x_67 - 0.00144824713138607*x_69 - 0.00357754593952323*x_70 - 0.00474279527309177*x_72 - 0.000338835301153045*x_73 + 0.00218636895883243*x_74 + 0.00258118113069253*x_75 - 0.0274746806883039*x_77 + 0.00162076247810789*x_78 + 0.00491271439744901*x_79 - 0.00190837134636297*x_8 - 0.0536984033210112*x_81 - 0.0112962803200927*x_82 - 0.0148287788612696*x_83 + 0.00213712995705379*x_84 + 0.00533649022192516*x_85 - 0.00627802182377249*x_86 - 0.0406324064663531*x_87 + 0.00288654942697695*x_89 + 0.154523077181546*x_9 + 0.00207488464487898*x_90 + 0.16530461933671*x_92 + 0.00793743057520023*x_93 + 0.0141594073037384*x_94 + 0.0444432454140287*x_97 - 0.0922689191561046*x_98 - 0.00159349276105718*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) - 0.00292750415023496*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 0.00287677484312021*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) + 0.00388715363388054*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 0.000731957670300973*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 0.000763495527880548*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) + 0.000957373630819415*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 0.580834367262515*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.593591784191254*std::sin(0.362399846315384*x_109 - 1.22647988796234) + 0.760765957551968*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.810348509672565*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.686433437715515*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.846855055128657*std::sin(0.382159858942032*x_23 + 5.17600011825562) + 0.342729865536828*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 0.405797397829897*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.488422376248412*std::sin(0.398559868335724*x_34 - 7.60168027877808) + 0.77477742755125*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.374234095868786*std::sin(0.413759857416153*x_37 + 5.19672012329102) - 1.16548059610388*std::sin(0.332159847021103*x_43 + 5.14351987838745) - 1.11044527285689*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.838440064712067*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 1.32611168095671*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.418985626657804*std::sin(0.333759844303131*x_57 - 7.44903993606567) - 0.290130463318059*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.820701578940906*std::sin(0.322079837322235*x_59 + 5.1165599822998) + 3.62668957575764*std::sin(0.125280052423477*x_65 + 4.9015998840332) + 1.31640011007619*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 3.50230032858875*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.73729829001234*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.857111924019804*std::sin(0.362479835748672*x_96 - 7.42711973190308) + 0.659955206887304*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 3.92300642866717, 2) + 2.95454430203303e-5*std::exp(0.759199857711792*x_22) + 0.00132284777945062*std::exp(0.627279818058014*x_38) + 0.000602064866398617*std::exp(0.757519841194153*x_72) + 0.00138433065799606*std::exp(0.511599838733673*x_73) + 0.0254933409147452*std::sin(0.144320040941238*x_1 + 8.1526403427124) - 0.0426530856450429*std::sin(0.358559846878052*x_1 + 8.25119972229004) + 0.0318142608419621*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.0248976112918884*std::sin(0.323119848966599*x_10 + 8.31192016601563) - 0.000508661049661043*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.0756371955956698*std::sin(0.140800043940544*x_100 + 1.73271989822388) - 0.000354915322307291*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.0155999378562991*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.00830115292743682*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.0118611758852862*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 0.0122554505398823*std::sin(0.385199844837189*x_104 + 1.99399983882904) + 0.00637890722172696*std::sin(0.409279853105545*x_105 - 1.17479979991913) + 0.0100036478509226*std::sin(0.300639927387238*x_106 - 7.50688028335571) + 0.0165021675482161*std::sin(0.369759827852249*x_107 + 5.16495990753174) + 0.000178692431417697*std::sin(0.226719990372658*x_109 + 5.01807975769043) - 0.000320364917080118*std::sin(0.330879837274551*x_109 + 1.928879737854) - 0.00145482216874185*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.0220507116324059*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.0216983648191261*std::sin(0.32423985004425*x_110 + 5.12512016296387) + 0.0105963020502135*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.0199643361465126*std::sin(0.24679996073246*x_111 + 1.84103989601135) - 0.00914926341245104*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.0115398482308231*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.00777456564961388*std::sin(0.310799926519394*x_113 - 7.49704027175903) + 0.0111202021026766*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 0.00142958177618974*std::sin(0.256479978561401*x_114 - 7.52464008331299) - 0.0153799450054151*std::sin(0.311999946832657*x_114 - 1.30423986911774) - 0.000359251457838197*std::sin(0.31687992811203*x_115 + 1.91471993923187) - 0.0133263511720369*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.0104231672906385*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.00820670744549512*std::sin(0.271519958972931*x_117 - 7.50487995147705) + 0.0129661480460232*std::sin(0.335359841585159*x_117 - 7.44863986968994) + 0.000275592364324841*std::sin(0.352479845285416*x_117 + 5.15328025817871) + 0.0138783002212435*std::sin(0.24967996776104*x_118 - 4.34711980819702) - 0.000351584601481594*std::sin(0.271039962768555*x_118 + 5.06983995437622) + 0.0130276847602821*std::sin(0.277119934558868*x_118 - 7.51272010803223) + 0.0102241136110878*std::sin(0.368079841136932*x_118 + 5.17296028137207) + 0.000174073981519549*std::sin(0.361119836568832*x_119 - 1.20559990406036) + 0.000639996306340834*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.0130050074965962*std::sin(0.296079933643341*x_12 + 5.11303997039795) - 0.0289468436360362*std::sin(0.310799926519394*x_12 + 5.12871980667114) - 0.0344178103463484*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.0096949680965803*std::sin(0.416159868240356*x_120 - 1.16447985172272) - 0.000221897554620035*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.104323612864205*std::sin(0.190880000591278*x_13 - 4.42511987686157) - 0.00141829585171686*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 0.00122179010279888*std::sin(0.126320049166679*x_14 - 4.50839996337891) + 0.100691340093521*std::sin(0.221919998526573*x_14 + 5.03495979309082) + 0.0167227025717509*std::sin(0.399439841508865*x_15 - 0.997359812259674) - 0.00104960003012872*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 0.00023448064889391*std::sin(0.207520008087158*x_16 - 1.18359982967377) - 0.00737765070159692*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.0758170578781333*std::sin(0.202480003237724*x_18 + 5.00679969787598) + 0.00239878182321291*std::sin(0.150320038199425*x_19 + 8.10863971710205) + 0.000290445958673003*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.0141143995874467*std::sin(0.288319945335388*x_21 - 1.0707198381424) + 8.64842026373761e-5*std::sin(0.292639940977097*x_21 + 5.07719993591309) - 0.0111518001986191*std::sin(0.349679857492447*x_21 - 4.02647972106934) - 0.0145349246431431*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.0978794717820982*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.0410079475139962*std::sin(0.295439928770065*x_23 + 5.13943958282471) + 0.000220943558193042*std::sin(0.193599998950958*x_24 - 7.59560012817383) + 0.000789582252797527*std::sin(0.258639991283417*x_24 + 5.07799959182739) - 0.00315484129912344*std::sin(0.568079829216003*x_24 + 2.35255980491638) - 0.0186272860822205*std::sin(0.345119833946228*x_26 + 1.93407988548279) + 0.0159173272682355*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.0175516255030121*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.0126183652364182*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.00711970843443525*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.0264962218576256*std::sin(0.278879970312119*x_28 + 5.09839963912964) - 0.00865751737871122*std::sin(0.309839934110641*x_28 + 1.91183984279633) + 0.000348028744292569*std::sin(0.312159925699234*x_28 + 5.14895963668823) - 0.0197598771592386*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.0358013905255169*std::sin(0.360399842262268*x_28 + 8.36839962005615) - 7.81009411284007e-5*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.0232496891824802*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.0254108861590332*std::sin(0.315519839525223*x_3 + 8.31960010528564) + 0.0114018009983842*std::sin(0.247039973735809*x_30 + 8.25191974639893) - 0.0222637083330342*std::sin(0.276239961385727*x_30 + 8.2806396484375) - 0.000260484394060924*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.0495562638528667*std::sin(0.263439953327179*x_32 + 5.1547999382019) - 0.000236159334183403*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.0114146656575285*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.0161407265178837*std::sin(0.361119836568832*x_34 + 1.98511981964111) + 0.0203293742310188*std::sin(0.361359834671021*x_34 + 2.00311970710754) + 8.37374913573805e-5*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.0205666709710087*std::sin(0.304399937391281*x_35 - 1.12567985057831) - 0.0259869815526935*std::sin(0.304399937391281*x_35 - 1.12175977230072) + 0.0133544179166532*std::sin(0.342639863491058*x_35 - 1.21223986148834) - 0.00311605523231909*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.0120538815515937*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.0146226883367736*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.0136138109158178*std::sin(0.343759834766388*x_38 - 4.26360034942627) + 0.000559840946623887*std::sin(0.346879839897156*x_38 - 4.25672006607056) - 0.0135970895771979*std::sin(0.319519847631454*x_39 + 1.94815981388092) - 0.000611324902170558*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.0112931472036021*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.0201343647375455*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.0141744795690194*std::sin(0.291759938001633*x_41 - 7.50631999969482) + 0.0182416876761655*std::sin(0.336239844560623*x_41 - 7.43887996673584) - 0.0274772874107019*std::sin(0.34775984287262*x_41 + 5.16032028198242) - 0.000253896731089713*std::sin(0.405519872903824*x_42 - 1.18847990036011) + 0.00705711922958235*std::sin(0.344799846410751*x_43 - 4.25375986099243) - 0.020587309270313*std::sin(0.347919851541519*x_43 - 7.45056009292603) + 0.00111657642469347*std::sin(0.386239856481552*x_43 + 1.97567975521088) - 0.0192447198409327*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.0100069936475133*std::sin(0.282239943742752*x_45 + 5.07999992370605) - 0.0142885007632669*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.0275078130741934*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.0389117705429871*std::sin(0.186160013079643*x_48 - 4.42583990097046) - 0.0300673736526258*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.00445913921671357*std::sin(0.475279867649078*x_48 + 2.04215979576111) + 0.000128444574780163*std::sin(0.293039947748184*x_49 + 1.90383982658386) + 0.180472105432773*std::sin(0.163760021328926*x_5 + 8.13551998138428) - 0.017482861373698*std::sin(0.342719823122025*x_51 + 5.15288019180298) - 0.000347772320789109*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.00874796933924595*std::sin(0.2811199426651*x_55 + 1.88439989089966) - 0.0148504537368278*std::sin(0.217999994754791*x_56 - 7.58768033981323) + 0.0149254628598742*std::sin(0.26335996389389*x_56 - 7.52920007705688) + 0.0189881644466008*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.0598458406355707*std::sin(0.140080034732819*x_57 + 4.9115195274353) + 0.00598707263016598*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.0291643432748976*std::sin(0.231359988451004*x_57 + 1.84351992607117) - 0.0204610804824964*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.0114336962798766*std::sin(0.284239947795868*x_58 - 7.50048017501831) + 0.0155099315628171*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.000184774102360889*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.011058478607962*std::sin(0.295199930667877*x_59 - 7.48152017593384) - 0.0176273316630513*std::sin(0.288639932870865*x_60 - 7.49160003662109) - 0.0124762918152309*std::sin(0.27167996764183*x_62 - 4.30463981628418) - 0.0313547192484098*std::sin(0.223439991474152*x_64 + 5.04335975646973) - 0.00999904000962804*std::sin(0.236399978399277*x_65 - 4.34391975402832) - 0.00835259710183229*std::sin(0.242479979991913*x_68 + 5.06775999069214) + 0.00998848994506063*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 0.00651721378055584*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.038950196492602*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.0533118804224943*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.0380399179644737*std::sin(0.180800005793571*x_74 - 7.61600017547607) - 0.0144330407853704*std::sin(0.317759841680527*x_74 - 4.29056024551392) - 0.0606388349611337*std::sin(0.170960023999214*x_75 - 7.64040040969849) - 0.0133729561703727*std::sin(0.243279978632927*x_76 - 7.53600025177002) - 0.0181927766387091*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.00875490975380291*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.0329387516389449*std::sin(0.174000009894371*x_87 + 4.95519971847534) + 0.0293616126409801*std::sin(0.206560000777245*x_88 + 5.00391960144043) - 0.012745063360401*std::sin(0.359999865293503*x_88 - 4.24480009078979) + 0.011187841348818*std::sin(0.338559836149216*x_93 + 1.98655986785889) - 7.23627441722836e-5*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.00353265603133829*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 0.000144640560186203*std::sin(0.358319848775864*x_94 - 1.20919990539551) + 0.000392602828466786*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.00812665270937408*std::sin(0.328879833221436*x_95 - 1.22527992725372) - 0.0100110422194927*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 0.00228335261100288*std::sin(0.367679834365845*x_95 + 1.98583984375) - 0.000150435673974919*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.000204033629589536*std::sin(0.386399865150452*x_96 - 7.41824007034302) + 0.00688603518075792*std::sin(0.472959846258163*x_97 - 1.13407981395721) + 0.0154145765035807*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.00744063236014438*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 0.000152727293831323*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.0108839675331676*std::sin(0.321679830551147*x_99 + 1.9223198890686) + 0.0197036649042082*std::sin(0.379759848117828*x_99 + 5.18016004562378) + 0.0118735977908285*std::sin(0.395599842071533*x_99 - 7.39767980575562) - 0.0121223651939358*std::sin(0.417999863624573*x_99 + 2.01671981811523) - 0.00224626816276488);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00126302394735177*x_1 - 0.00056762524220742*x_10 - 0.000536214086209619*x_100 + 0.00115006894027538*x_101 + 0.00057022873189814*x_102 - 0.00195856579649603*x_103 - 0.00155082917420456*x_104 + 0.000646069761486842*x_105 + 0.000570762105969853*x_106 - 0.00102964415628868*x_107 - 0.00102259322358257*x_108 - 0.00123667029353225*x_109 + 0.0018612974435762*x_11 - 9.73053022386533e-5*x_110 + 0.00105842625332227*x_111 - 0.000487356248234798*x_112 - 0.000260162406035808*x_113 - 0.00110764627733306*x_114 + 6.4123643099929e-5*x_115 + 0.00205949384770918*x_116 + 1.28485674822398e-6*x_117 - 0.00167699651614888*x_118 + 0.00224864877147888*x_119 + 0.0011896303261099*x_12 - 0.000637328532338263*x_120 + 0.00321355025944325*x_13 + 0.00141504382333655*x_14 + 0.00122995184816361*x_15 - 0.000737311473561526*x_16 + 0.00294545453145325*x_17 + 0.00128860523535313*x_18 - 0.00318592070118582*x_19 - 0.00139652882604053*x_2 - 0.00537522337167442*x_20 - 0.00272284693348576*x_21 - 0.000812610899591405*x_22 - 0.000145387665752455*x_23 - 0.000434611010199764*x_24 - 0.00226185298073384*x_25 - 0.000663572663852924*x_26 - 0.00125532936636672*x_27 - 0.000140728643058269*x_28 - 0.00194942967924229*x_29 + 0.00119971528792001*x_3 + 0.00162371833411987*x_30 + 0.013054581524568*x_31 - 0.0046658189832524*x_32 - 0.00107260660438012*x_33 + 0.00118802691004194*x_34 - 0.000139923392739049*x_35 + 0.00085286561396437*x_36 - 0.000575984272368454*x_37 + 0.000912686905862746*x_38 + 0.00272875145587595*x_39 + 0.00135180721396322*x_4 + 0.000160088942162942*x_40 - 0.000838622089536545*x_41 + 1.52530605614884e-5*x_42 + 7.38054151395544e-5*x_43 + 0.00115606299152813*x_44 + 0.00172492510266426*x_45 + 0.000508018049456584*x_46 + 9.03589551774319e-5*x_47 + 0.000971440555238353*x_48 - 0.000163311443164549*x_49 - 0.000578456739579591*x_5 - 0.00164663281909317*x_50 + 0.00125755886232926*x_51 + 0.00104322814119316*x_52 - 0.000285090520997437*x_53 + 0.000767900143817745*x_54 - 0.000397252019243017*x_55 - 0.000388988396393977*x_56 + 8.36127775334511e-5*x_57 - 2.00554861809704e-5*x_58 + 9.87405444634598e-5*x_59 + 0.00306519460410966*x_6 + 0.000689537383357776*x_60 + 0.000377482428086353*x_61 - 0.00149194533826897*x_62 + 0.00138248880448721*x_63 + 0.000385566520601581*x_64 + 0.000178994639119155*x_65 + 0.000710788055271251*x_66 + 0.000306461064788088*x_67 + 0.000893697855439905*x_68 + 5.97863495762234e-5*x_69 + 0.00207933309803357*x_7 + 5.90391361475192e-6*x_70 - 1.45505717652205e-5*x_71 + 0.000865977450741771*x_72 + 0.000872669113366264*x_73 - 0.000504446817937611*x_74 + 0.000574596289715704*x_75 + 0.000340558826827291*x_76 + 0.00081115877573361*x_77 - 0.000771051975884148*x_78 + 0.000419141311431094*x_79 - 0.00098002633228822*x_8 + 0.000199689186671177*x_80 - 0.00129869550475141*x_81 + 0.00101960499615659*x_82 - 0.000404702647963674*x_83 - 0.00022233696033287*x_84 - 0.000341828015330503*x_85 - 0.000799605408888789*x_86 - 0.000785799876390438*x_87 - 0.000133227194044093*x_88 + 0.000101670956848307*x_89 - 0.00121720977251992*x_9 + 0.00179907491429564*x_90 - 0.00385637591813083*x_91 - 0.000729830223822653*x_92 + 0.000488891725830545*x_93 + 4.54295311661503e-5*x_94 + 0.000120371787644159*x_95 - 8.79902248443553e-5*x_96 - 0.000906806184377842*x_97 - 0.00172419231638603*x_98 + 9.43302744999594e-5*x_99 - 1.80223878845603e-5*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 6.70770360614514e-7*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) - 3.0570399741552e-5*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 2.86479153434287e-5*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) + 8.22393766585453e-7*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 1.27812264285566e-5*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) + 4.10192305347005e-6*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) + 1.46312418403458e-6*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) - 7.16143535583732e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) - 5.50724542717168e-5*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 1.65069112108004e-5*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) - 4.87817529728861e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) + 2.31735680041406e-5*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) - 8.07589253652576e-6*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) + 3.77438592486442e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 8.01037492381624e-5*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) - 8.61499811283966e-6*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 5.74664259147084e-7*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) - 6.42946013426057e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 7.39753072790347e-7*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 2.94388948798632e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) - 5.61627729380843e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 4.41375486302892e-6*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 4.24835553444555e-6*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 3.48364270908897e-7*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 1.87981816973991e-5*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 5.51895553402328e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) - 8.38945474777608e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) + 1.03006206239041e-5*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) - 6.19364429319183e-7*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 1.38515762429872e-5*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 5.60491625728071e-6*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 1.77032509045877e-5*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 7.45731912617648e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) + 1.929572854342e-6*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) + 1.80690726638884e-6*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 3.49532532056145e-6*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) + 1.40422593198043e-5*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) + 1.5211114159598e-5*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 3.94087427947288e-6*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) - 7.53619028684309e-6*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) - 2.22393215729897e-5*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) + 1.17567328847196e-5*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 1.46472980979913e-5*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 9.29966301998404e-7*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 7.58002229559427e-6*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) + 5.05513238572717e-6*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) - 1.56889536805924e-5*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) + 8.43702362552766e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 4.51040030529455e-7*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) + 1.83667571710546e-5*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) + 0.00217428048346586*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 4.66185714409671e-7*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) - 1.05875399531304e-5*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) + 1.39011146529599e-5*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 7.76628033348728e-6*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 1.35524535607176e-6*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 7.75192716102206e-6*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 6.73257615796348e-6*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 8.5091907441914e-6*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) + 6.65429707684111e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 5.03676709908272e-6*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 1.8836304845135e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) - 2.05299835307422e-5*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) - 1.47581990148932e-5*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) + 4.68201099276766e-7*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) + 0.000817392021417618*std::pow(0.0357333408565297*x_10 + 0.0102726007046125*x_100 - 0.0651408066667241*x_101 + 0.0651180693264513*x_102 + 0.00203955564643423*x_103 - 0.0103240321368359*x_104 - 0.00354158315099477*x_105 + 0.00601183620891329*x_108 - 0.0767567680845374*x_109 - 0.00400971374390068*x_11 + 0.00359203855830334*x_110 + 0.00632274470602236*x_112 + 0.0424323411552183*x_113 - 0.000711241496642949*x_114 + 0.00569487447558453*x_115 + 0.00700385993066074*x_116 + 0.0014055428789555*x_119 + 0.0418411131022278*x_12 - 0.00623720665233056*x_120 - 0.098417701351153*x_13 + 0.0569493390235734*x_16 + 0.488502161189118*x_17 + 0.0265613923131133*x_18 - 0.023669168525384*x_19 - 0.049947947613017*x_2 + 0.00120136337177811*x_20 - 0.0223039540554055*x_21 + 0.389796308853498*x_22 + 0.0342000679778912*x_23 - 0.0859631185154328*x_24 + 0.00493365233085941*x_25 + 0.478875414855739*x_29 - 0.320976399435223*x_3 - 0.0104215813212237*x_30 + 0.380771401599415*x_31 + 0.157788660871621*x_32 - 0.00893972879397059*x_33 - 0.0106223801735313*x_34 - 0.00482962225875178*x_36 + 0.0402427163569487*x_37 - 0.00229255704357525*x_38 - 0.134177349166158*x_39 + 0.0186243796966967*x_4 - 0.00539517423570074*x_40 + 0.00774488415569951*x_41 - 0.135689751415586*x_42 - 0.0795086055131783*x_43 - 0.0136493689522085*x_44 - 0.0197496870528423*x_45 - 0.0128024558566113*x_46 - 0.00742137286554905*x_47 + 0.131868065959237*x_48 - 0.0141040636085881*x_49 + 5.39997396347067e-5*x_50 + 0.00914039798016168*x_51 + 0.0461462402721002*x_52 - 0.0100826167018402*x_53 + 0.000245768719409322*x_54 + 0.00334975413098013*x_55 - 0.0167153875372042*x_56 - 0.00482730680035633*x_59 + 0.0944358916921667*x_60 - 0.141239253564925*x_61 - 0.049059006936328*x_62 - 0.0187073873981226*x_63 - 0.00489015434592973*x_64 - 0.0480124200683939*x_65 + 0.0104420346653897*x_66 - 0.0192694601167674*x_67 - 0.00784515463411914*x_68 + 0.0030901758860912*x_69 + 0.0270576926993019*x_70 - 0.00325739692865242*x_71 - 0.00494059971094876*x_73 + 0.00442831234811918*x_74 + 0.00951622315401639*x_75 + 0.0093770233811257*x_76 - 5.71200618291632e-5*x_77 + 0.0228959436186523*x_78 + 0.00212804186113102*x_79 - 0.122235563149905*x_8 + 0.000724142736648251*x_81 + 0.0535233106690243*x_82 + 0.155181129550367*x_83 + 0.000777827281473315*x_85 - 0.0230925790153952*x_86 + 0.00168806952557386*x_87 + 0.00451839242085528*x_89 - 0.00855320115043335*x_9 + 0.018702174599885*x_90 + 0.0240346642613351*x_91 + 0.11081087704505*x_92 - 0.0139168376358456*x_93 - 0.00544160316124043*x_94 + 0.018562181129244*x_96 + 0.00657144281866827*x_97 + 0.000861552068584037*x_98 - 0.00563752779660798*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) + 0.00111372092811166*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) + 0.0139141423894047*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) - 0.00160573618608262*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 3.4596766157311*std::sin(0.358559846878052*x_1 + 8.25119972229004) + 0.81141577493041*std::sin(0.300639927387238*x_106 - 7.50688028335571) + 1.3385236334496*std::sin(0.369759827852249*x_107 + 5.16495990753174) - 0.742114953713781*std::sin(0.385039836168289*x_111 - 7.41479969024658) + 1.05171005831198*std::sin(0.335359841585159*x_117 - 7.44863986968994) + 1.05670142360503*std::sin(0.277119934558868*x_118 - 7.51272010803223) + 8.1672748749578*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.0851351461492449*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 1.51089622470681*std::sin(0.345119833946228*x_26 + 1.93407988548279) + 0.577493712563367*std::sin(0.540319859981537*x_27 + 5.33847999572754) + 2.90392199623153*std::sin(0.360399842262268*x_28 + 8.36839962005615) - 2.10785576310909*std::sin(0.304399937391281*x_35 - 1.12175977230072) + 14.6384514394467*std::sin(0.163760021328926*x_5 + 8.13551998138428) + 4.8542151702386*std::sin(0.140080034732819*x_57 + 4.9115195274353) - 1.65963893601943*std::sin(0.273039966821671*x_58 - 7.5079197883606) + 0.810186287036132*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 2.38157880298536*std::sin(0.206560000777245*x_88 + 5.00391960144043) + 0.659168965564788*std::sin(0.328879833221436*x_95 - 1.22527992725372) + 0.963091133977542*std::sin(0.395599842071533*x_99 - 7.39767980575562) - 4.70781861782887, 2) - 0.000622181763004809*std::exp(0.759199857711792*x_22) + 5.30621452589053e-5*std::exp(0.627279818058014*x_38) + 2.41500601145464e-5*std::exp(0.757519841194153*x_72) - 0.00129503284290672*std::exp(0.511599838733673*x_73) + 0.0265960573676598*std::sin(0.144320040941238*x_1 + 8.1526403427124) - 0.0105869464259948*std::sin(0.20160000026226*x_10 + 5.00271987915039) - 0.0232915627105994*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.0107116223788627*std::sin(0.348559856414795*x_10 - 4.24007987976074) + 0.0466805289750197*std::sin(0.140800043940544*x_100 + 1.73271989822388) + 0.0111430307214363*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.00747397291685971*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.00062574559327197*std::sin(0.344959855079651*x_102 - 7.43727970123291) - 0.00776567766734565*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.000475776160752118*std::sin(0.333679854869843*x_103 + 1.94599986076355) - 0.00756361879262546*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 0.00212273198325389*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.000930105203502019*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.00674639431795425*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.0113877756896673*std::sin(0.362399846315384*x_109 - 1.22647988796234) - 0.00151775061530762*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.000884499397343267*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.0145949325911583*std::sin(0.287039935588837*x_110 - 7.50984001159668) - 0.0133914423938234*std::sin(0.32423985004425*x_110 + 5.12512016296387) + 0.0110546459232233*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.000800810585359877*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.00712197504764585*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.00811085509416978*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.00370050979628578*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 5.73434653979365e-5*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.00511803981918426*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.00756528528768423*std::sin(0.31687992811203*x_115 + 1.91471993923187) - 0.0139027835330941*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.000418094678333603*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.0085616892171926*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.00580355295360794*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.00461833206360031*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.0074038330393164*std::sin(0.271039962768555*x_118 + 5.06983995437622) - 0.0155461502405735*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.0106663584440863*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 0.00366573134952061*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.0134773416638805*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.0135675401118675*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.00963274565135125*std::sin(0.310799926519394*x_12 + 5.12871980667114) + 0.0212414220341801*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.0101143246990097*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.00467282252782432*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.00418463468414575*std::sin(0.190880000591278*x_13 - 4.42511987686157) + 0.00738231799366818*std::sin(0.123040057718754*x_14 + 4.89599990844727) - 0.00574729803457473*std::sin(0.126320049166679*x_14 - 4.50839996337891) - 0.00556487410172544*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 0.0011029964716907*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 0.0024550874563928*std::sin(0.352719843387604*x_16 - 4.25216007232666) + 0.0709263927932321*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.0505146699883133*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.00611634689317211*std::sin(0.271839946508408*x_21 + 8.30095958709717) + 0.0087108946030851*std::sin(0.288319945335388*x_21 - 1.0707198381424) - 0.000450155645964199*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.0131688985979511*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.000447321642920371*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 0.00483683934281018*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.00392614693107286*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.0427817494874279*std::sin(0.295439928770065*x_23 + 5.13943958282471) - 0.0162465109294012*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.00115002494244*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.0166273925134524*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 0.00104984792770297*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.0065751092498708*std::sin(0.609839856624603*x_24 + 2.38503980636597) - 0.00529686645466766*std::sin(0.3503198325634*x_26 + 5.16328001022339) - 0.0164194380450285*std::sin(0.357919842004776*x_26 + 5.1561598777771) - 0.00778759655744989*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.00778502982185586*std::sin(0.288959950208664*x_27 - 4.27960014343262) + 0.0247870530933987*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 0.00288099331069928*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.00732895213489607*std::sin(0.312159925699234*x_28 + 5.14895963668823) - 0.0206145921894864*std::sin(0.316799849271774*x_28 - 4.29735994338989) + 0.000406520249154415*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.000932592852926365*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.0265100360250478*std::sin(0.315519839525223*x_3 + 8.31960010528564) - 0.00703677731149189*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.00740877459126504*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.00548540224699102*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.00198780367015584*std::sin(0.263439953327179*x_32 + 5.1547999382019) + 0.00111089300370783*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.0119084079123067*std::sin(0.312719941139221*x_34 - 1.1386399269104) + 0.00996146996146795*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.00676507924942636*std::sin(0.361359834671021*x_34 + 2.00311970710754) - 0.00937015068378896*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 0.000435858843163022*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.000824971474048958*std::sin(0.304399937391281*x_35 - 1.12567985057831) + 0.0148637359703219*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.0139320643069415*std::sin(0.342639863491058*x_35 - 1.21223986148834) - 0.00325084044483243*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.000483505981383536*std::sin(0.340399831533432*x_37 - 7.45648002624512) + 0.0136794352839975*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.00717950290532672*std::sin(0.413759857416153*x_37 + 5.19672012329102) - 0.0127356366423521*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.0117893925954351*std::sin(0.346879839897156*x_38 - 4.25672006607056) - 0.0141852327491215*std::sin(0.319519847631454*x_39 + 1.94815981388092) + 0.0128735658199302*std::sin(0.179680019617081*x_40 + 1.7875999212265) + 0.0105646699680955*std::sin(0.329919844865799*x_40 - 4.27824020385742) + 0.0124261983687086*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.000568567529495383*std::sin(0.291759938001633*x_41 - 7.50631999969482) + 0.0190307333017156*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.00914371612132738*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.00534667615787165*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.0223591901919154*std::sin(0.332159847021103*x_43 + 5.14351987838745) + 0.00736237547318984*std::sin(0.344799846410751*x_43 - 4.25375986099243) + 0.0127057392773768*std::sin(0.347919851541519*x_43 - 7.45056009292603) - 0.00104455039931473*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.0064041348925669*std::sin(0.206960007548332*x_45 - 7.57656002044678) - 0.00936148120207674*std::sin(0.282239943742752*x_45 + 5.07999992370605) - 0.0149065509800599*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.0213033637252487*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.0011033949603059*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.00156083114996849*std::sin(0.186160013079643*x_48 - 4.42583990097046) + 0.0185564905724043*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.00465201963189927*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 0.000668561988981938*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.016085073345784*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.00581783489033026*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.0073235522487834*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.0254408210564401*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.00912636343644329*std::sin(0.2811199426651*x_55 + 1.88439989089966) - 0.0154928112733943*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.00496680015498729*std::sin(0.26335996389389*x_56 - 7.52920007705688) - 0.0117188051943419*std::sin(0.314399927854538*x_56 + 5.12855958938599) + 0.00624604392451918*std::sin(0.221599996089935*x_57 - 7.57183980941772) - 0.0179991730333167*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.00803803971120403*std::sin(0.333759844303131*x_57 - 7.44903993606567) + 0.0106961527672117*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.00516129591512659*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.00556601476805611*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.000961760678473018*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.000443578321975844*std::sin(0.295199930667877*x_59 - 7.48152017593384) + 0.0157447689439777*std::sin(0.322079837322235*x_59 + 5.1165599822998) - 0.0183898032712581*std::sin(0.288639932870865*x_60 - 7.49160003662109) - 0.0130159547923992*std::sin(0.27167996764183*x_62 - 4.30463981628418) - 0.0327109700790627*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.0695763123491544*std::sin(0.125280052423477*x_65 + 4.9015998840332) - 0.0104315492664117*std::sin(0.236399978399277*x_65 - 4.34391975402832) - 0.00871388934201216*std::sin(0.242479979991913*x_68 + 5.06775999069214) - 0.00402218755367302*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.0015623724938418*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.0556178899751182*std::sin(0.145920038223267*x_73 - 7.66184043884277) + 0.0355861100243081*std::sin(0.180800005793571*x_74 - 7.61600017547607) - 0.0150573430921116*std::sin(0.317759841680527*x_74 - 4.29056024551392) + 0.0374240857308662*std::sin(0.170960023999214*x_75 - 7.64040040969849) - 0.0139514044342739*std::sin(0.243279978632927*x_76 - 7.53600025177002) - 0.0189797066135129*std::sin(0.244879975914955*x_79 - 7.55568027496338) + 0.00819016439632401*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.0343635199144016*std::sin(0.174000009894371*x_87 + 4.95519971847534) + 0.0252545091941012*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.000511230705353271*std::sin(0.359999865293503*x_88 - 4.24480009078979) - 0.0671899638809123*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.0116717723004025*std::sin(0.338559836149216*x_93 + 1.98655986785889) + 0.00037665257761813*std::sin(0.3711998462677*x_93 + 8.19575977325439) + 0.00330477805779304*std::sin(0.256959974765778*x_94 + 5.05655956268311) + 0.000680388886252743*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.00826761405500186*std::sin(0.359999865293503*x_94 + 1.97703981399536) + 0.0141447165655692*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.00333141065802629*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 0.00238211920657694*std::sin(0.367679834365845*x_95 + 1.98583984375) + 0.000707649089140067*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.0164432840743831*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.00429663563626161*std::sin(0.386399865150452*x_96 - 7.41824007034302) + 0.00718389117046771*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.00512956426784433*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.007762477494176*std::sin(0.375119835138321*x_98 - 7.40303993225098) - 0.000718428864051104*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.00043657832383254*std::sin(0.321679830551147*x_99 + 1.9223198890686) - 0.012160386080306*std::sin(0.379759848117828*x_99 + 5.18016004562378) + 0.0126609263494104*std::sin(0.382479846477509*x_99 - 7.39991998672485) + 0.00403400322585108*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.385792193564168);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00327333467845868*x_1 - 0.000527753278603114*x_10 + 0.00132461775041811*x_100 + 0.000787824038977109*x_101 + 0.000947789278872043*x_102 + 0.000596562348849799*x_103 + 8.25711236563479e-5*x_104 - 0.000935927609949953*x_105 + 7.7951070585451e-5*x_106 + 0.000112661604585165*x_107 + 0.00044544011265562*x_108 + 0.00171817550764152*x_109 + 0.00247059843559598*x_11 + 0.000172985427440935*x_110 - 0.000697665219980621*x_111 - 2.3123848639513e-5*x_112 + 0.00144086963471155*x_113 + 0.000574773343746018*x_114 - 1.35295720571929e-5*x_115 - 0.00163319319380251*x_116 + 0.000322824180928512*x_117 + 0.00035882822435398*x_118 - 0.00060196214606751*x_119 - 1.86973545149369e-5*x_12 - 0.000602457882234877*x_120 + 0.00141057158272449*x_13 - 0.00226124916765773*x_14 - 0.00187085495777863*x_15 - 0.000992069478770759*x_16 - 0.00445938731297822*x_17 - 0.000547652638204315*x_18 - 0.000736861491560072*x_19 - 0.00578836882972263*x_2 + 0.00242998904886223*x_20 - 0.000419502941463541*x_21 - 0.0036836207152412*x_22 - 0.00236086966102824*x_23 + 7.81919430183443e-5*x_24 + 0.000678953458058261*x_25 + 0.00179689242536093*x_26 + 0.00150917035912132*x_27 - 0.000769537502800934*x_28 - 0.00302623963442594*x_29 + 0.00295964611149488*x_3 - 2.08502483381408e-5*x_30 - 0.000348406896822955*x_31 - 0.00275898978550684*x_32 - 0.000715170857110469*x_33 - 0.00142201768344453*x_34 + 0.000112752236944022*x_35 - 0.00101796343228827*x_36 + 0.00193321261556038*x_37 + 3.58431582354758e-5*x_38 + 0.00241965963878484*x_39 + 0.00162384528907797*x_4 + 6.79799451701673e-5*x_40 - 0.000266434205847042*x_41 + 0.00087831382233962*x_42 + 0.000495922208227858*x_43 + 0.00012484456143978*x_44 - 0.000503027613239513*x_45 - 0.000608420257602967*x_46 + 0.000183294887684715*x_47 - 0.00248844768645335*x_48 + 0.000550309331189062*x_49 + 0.0011119493290886*x_5 + 0.000626121638163356*x_50 - 0.000252602093747975*x_51 - 0.000126877076245167*x_52 - 3.40732765779422e-6*x_53 - 0.00358582494835696*x_54 + 0.00190936479308123*x_55 + 0.00177835714752498*x_56 + 0.00101547912873989*x_57 - 2.81916707850396e-6*x_58 + 0.000119092336067716*x_59 - 0.000167112311799778*x_6 - 0.00283047717499235*x_60 + 0.00176220324439853*x_61 + 0.000925717783428494*x_62 - 0.00323929522985574*x_63 - 0.00149664961228672*x_64 + 0.000745211737017435*x_65 - 0.00282085656662152*x_66 + 0.000274327477139576*x_67 - 0.000315278835606085*x_68 + 0.0004758910198037*x_69 - 0.00559896482755627*x_7 + 4.47200871651638e-5*x_70 - 5.286196963675e-5*x_71 + 0.000286964995819567*x_72 - 0.000565828009735182*x_73 + 0.000331498967464567*x_74 - 0.00156410207878369*x_75 - 9.70270570538473e-5*x_76 - 0.000672398512902564*x_77 - 0.000749002912155632*x_78 + 0.000303749348599054*x_79 - 0.00105367675906362*x_8 + 5.77386136829902e-5*x_80 - 0.00051191403360428*x_81 - 0.00107436135903432*x_82 - 0.00168117854436374*x_83 + 0.000478551942999404*x_84 - 1.0021477076033e-5*x_85 + 0.00019846362559975*x_86 + 1.79489195265877e-5*x_87 - 0.00088811308021241*x_88 + 0.000438355837919154*x_89 - 0.000463865009575106*x_9 + 0.000233325726757223*x_90 + 0.0103564509858659*x_91 + 0.0032516562310267*x_92 + 0.000652165603986794*x_93 + 0.000112927736278791*x_94 + 4.32003317814057e-5*x_95 - 0.000153632546211996*x_96 - 0.000387590359420371*x_97 - 0.000120746806464171*x_98 + 4.68403380526616e-5*x_99 + 8.85363438183545e-6*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 8.43989783944323e-6*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) - 6.42057807896224e-6*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) - 8.72091147836008e-5*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 1.05020718537109e-6*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) - 3.89082217439205e-5*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 5.23820734011598e-6*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 1.86842798863026e-6*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) + 3.51810929250124e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) + 1.52304758225439e-7*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 6.24025863664571e-7*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 2.39644051661407e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) - 7.05442726911104e-5*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) - 3.05300352719557e-7*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) - 1.85419563760048e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 3.02823530476183e-6*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) - 3.25680653950326e-7*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 7.23065287908275e-6*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) + 3.15852092774546e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) - 2.04581245538792e-9*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 2.90382230359317e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) + 4.38594315013746e-5*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) - 1.17956412683039e-5*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 1.66857212426466e-7*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 4.19053419119849e-6*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) + 9.63413320811625e-10*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 7.1064485773497e-7*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 1.15912402912917e-5*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) + 4.12138310836135e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) + 3.89403783604721e-7*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 7.90936167640177e-7*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) - 4.216654817732e-5*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) - 1.5500587847914e-8*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 6.69252187421822e-7*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 1.56623073673042e-5*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) - 2.46408880838277e-6*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 2.30744330947407e-6*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) - 1.06403633015758e-5*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) + 2.94923923566796e-6*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) - 7.4725748980697e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 3.88723784472551e-6*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) - 8.66464317702365e-6*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 2.84897494899641e-7*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) - 4.97802944764469e-6*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) + 2.63161636096434e-6*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 3.07631309629755e-6*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 1.17012036366675e-5*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 7.47685600750461e-6*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) + 1.91103793596354e-7*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) - 3.51180107578361e-6*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) + 1.88853566960247e-6*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 5.67516396472927e-6*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) + 3.85749612275462e-6*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) - 0.000108250707942523*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 8.21963139691485e-5*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) - 1.28925255756729e-9*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 5.20120909329653e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) - 4.23173515020896e-5*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) + 2.36418749820158e-5*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 1.70522328120561e-5*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 1.24924752131854e-5*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 9.89930850130382e-6*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 6.64094385605036e-6*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) - 2.59034203162696e-5*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) - 3.26897377660702e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 1.90409513866283e-7*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 1.85799373073604e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) - 7.76113746550508e-7*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) - 5.5791769694482e-7*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 5.97898693591337e-7*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) + 0.00189402684752752*std::exp(0.759199857711792*x_22) + 0.000667648887641036*std::exp(0.627279818058014*x_38) + 0.000303865603120052*std::exp(0.757519841194153*x_72) - 0.000289878969846202*std::exp(0.511599838733673*x_73) + 0.00100543508455218*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 0.0269159558975239*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.0104428550338615*std::sin(0.20160000026226*x_10 + 5.00271987915039) - 0.00521356214372325*std::sin(0.323119848966599*x_10 + 8.31192016601563) - 0.0326079958823638*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.0229321629821078*std::sin(0.140800043940544*x_100 + 1.73271989822388) + 0.00234032591618393*std::sin(0.439679861068726*x_100 + 5.22295999526978) - 0.0227520416121815*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.00787337841800123*std::sin(0.344959855079651*x_102 - 7.43727970123291) - 0.00173826220292234*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.00598640373362899*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 0.00371568494821126*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 0.00209384098916687*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.00631273776088662*std::sin(0.300639927387238*x_106 - 7.50688028335571) - 0.0104135869005518*std::sin(0.369759827852249*x_107 + 5.16495990753174) + 2.57223779141344e-6*std::sin(0.226719990372658*x_109 + 5.01807975769043) - 0.0205371689142771*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.00239172871730021*std::sin(0.362399846315384*x_109 - 1.22647988796234) - 5.73769148237184e-5*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.0111291210687772*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.00306531497955365*std::sin(0.287039935588837*x_110 - 7.50984001159668) + 0.00657864737790356*std::sin(0.32423985004425*x_110 + 5.12512016296387) + 0.000417908891715118*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.0100761153533829*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.00577358394545557*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.00349872411759769*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.000306622074267042*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.0036501447914303*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 0.000721518150078737*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.00504838182216923*std::sin(0.311999946832657*x_114 - 1.30423986911774) - 0.0230300119612605*std::sin(0.31687992811203*x_115 + 1.91471993923187) - 0.000525579643022746*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.00526063251977585*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.000323665369005593*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.00818220449211715*std::sin(0.335359841585159*x_117 - 7.44863986968994) + 0.0176669998363422*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.00455547523316011*std::sin(0.24967996776104*x_118 - 4.34711980819702) - 0.0225385239248296*std::sin(0.271039962768555*x_118 + 5.06983995437622) - 0.00822103684063358*std::sin(0.277119934558868*x_118 - 7.51272010803223) - 0.00326509539589725*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.000403230104967901*std::sin(0.368079841136932*x_118 + 5.17296028137207) + 0.0111591081652479*std::sin(0.361119836568832*x_119 - 1.20559990406036) + 0.0410273146249284*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.00051290612931705*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.00950164120677206*std::sin(0.310799926519394*x_12 + 5.12871980667114) - 0.0104350092587902*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.000382361068347771*std::sin(0.416159868240356*x_120 - 1.16447985172272) - 0.014224864577656*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.0526527278236102*std::sin(0.190880000591278*x_13 - 4.42511987686157) - 2.04160532163967e-5*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 0.00733937188925949*std::sin(0.126320049166679*x_14 - 4.50839996337891) - 0.0635406238079466*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.00548913456134242*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 0.000662343361417926*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 0.00140854036967966*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 0.00242167300852781*std::sin(0.352719843387604*x_16 - 4.25216007232666) + 0.0158760990429107*std::sin(0.202480003237724*x_18 + 5.00679969787598) + 0.153775225891857*std::sin(0.150320038199425*x_19 + 8.10863971710205) + 0.0186191976577911*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.00427929286887063*std::sin(0.288319945335388*x_21 - 1.0707198381424) + 1.24492085433723e-6*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.00276581079661697*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.0056283777419162*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 0.00477100856532371*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.0494003327316688*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.0016173176090937*std::sin(0.295439928770065*x_23 + 5.13943958282471) - 0.00341218933395726*std::sin(0.382159858942032*x_23 + 5.17600011825562) + 3.18043336052124e-6*std::sin(0.193599998950958*x_24 - 7.59560012817383) + 0.0506166038566667*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 0.0010355591948291*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.00138094374536821*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 0.0117546293098698*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.00522477457560388*std::sin(0.3503198325634*x_26 + 5.16328001022339) - 0.00367531202935618*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.00382571571950073*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.00163505849582775*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.00449284630470245*std::sin(0.540319859981537*x_27 + 5.33847999572754) + 0.00554831134638265*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 0.00284178216140639*std::sin(0.309839934110641*x_28 + 1.91183984279633) + 0.0223105737472894*std::sin(0.312159925699234*x_28 + 5.14895963668823) - 0.000779312285070045*std::sin(0.316799849271774*x_28 - 4.29735994338989) - 0.0225922376747633*std::sin(0.360399842262268*x_28 + 8.36839962005615) - 1.12424567018082e-6*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.0117342519387448*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.00100218314105218*std::sin(0.315519839525223*x_3 + 8.31960010528564) + 0.00345687008521869*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.00730793903378679*std::sin(0.276239961385727*x_30 + 8.2806396484375) - 0.016698495107142*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.0250113315764515*std::sin(0.263439953327179*x_32 + 5.1547999382019) - 0.00141862434040131*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.000450184437139583*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.00489364747387499*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.00667300457107068*std::sin(0.361359834671021*x_34 + 2.00311970710754) - 0.00196797505382748*std::sin(0.398559868335724*x_34 - 7.60168027877808) + 1.20538255660155e-6*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.0103801172059084*std::sin(0.304399937391281*x_35 - 1.12567985057831) + 0.0163989178931386*std::sin(0.304399937391281*x_35 - 1.12175977230072) + 0.00312177067193581*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.000526686570900141*std::sin(0.342639863491058*x_35 - 1.21223986148834) - 0.000122894494937064*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.00608366339248843*std::sin(0.340399831533432*x_37 - 7.45648002624512) + 0.0030619923115638*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.00150788211346582*std::sin(0.413759857416153*x_37 + 5.19672012329102) - 0.00285073328482873*std::sin(0.343759834766388*x_38 - 4.26360034942627) + 0.035888911278847*std::sin(0.346879839897156*x_38 - 4.25672006607056) - 0.000536257329097509*std::sin(0.319519847631454*x_39 + 1.94815981388092) - 0.0391893185177979*std::sin(0.179680019617081*x_40 + 1.7875999212265) + 0.00236478608545777*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.00610446394880656*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.00715394141650722*std::sin(0.291759938001633*x_41 - 7.50631999969482) + 0.000719436218752*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.00901926750959556*std::sin(0.34775984287262*x_41 + 5.16032028198242) - 0.0162761893552414*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.00469601076934662*std::sin(0.332159847021103*x_43 + 5.14351987838745) + 0.000278326614507633*std::sin(0.344799846410751*x_43 - 4.25375986099243) - 0.00624179053482654*std::sin(0.347919851541519*x_43 - 7.45056009292603) - 0.000233811208236363*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.00631697277093626*std::sin(0.206960007548332*x_45 - 7.57656002044678) - 0.00209546540997498*std::sin(0.282239943742752*x_45 + 5.07999992370605) - 0.000563525981984175*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.00447425978393656*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.013883351573565*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.0196389945409727*std::sin(0.186160013079643*x_48 - 4.42583990097046) - 0.00911601636755319*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.000175864553429056*std::sin(0.475279867649078*x_48 + 2.04215979576111) + 1.8489310752019e-6*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.113885763646419*std::sin(0.163760021328926*x_5 + 8.13551998138428) - 0.00337828324770207*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.00573865248070823*std::sin(0.342719823122025*x_51 + 5.15288019180298) - 0.022294135577804*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.00534323330302279*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.00034501226503339*std::sin(0.2811199426651*x_55 + 1.88439989089966) - 0.000585688916115721*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.00489920057339093*std::sin(0.26335996389389*x_56 - 7.52920007705688) + 0.00575695170069794*std::sin(0.314399927854538*x_56 + 5.12855958938599) - 0.0377653335705261*std::sin(0.140080034732819*x_57 + 4.9115195274353) + 0.000236124911845088*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.00884222991054918*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.0016881971450781*std::sin(0.333759844303131*x_57 - 7.44903993606567) + 0.0129118334946669*std::sin(0.273039966821671*x_58 - 7.5079197883606) + 0.00239421707523464*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.00509104919017891*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.00116900769074297*std::sin(0.403839856386185*x_58 + 2.014399766922) - 2.65978209147644e-6*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.00558127779802017*std::sin(0.295199930667877*x_59 - 7.48152017593384) + 0.00330681048316893*std::sin(0.322079837322235*x_59 + 5.1165599822998) - 0.000695206554540616*std::sin(0.288639932870865*x_60 - 7.49160003662109) - 0.000492054044940376*std::sin(0.27167996764183*x_62 - 4.30463981628418) - 0.0012366027231998*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.014612832990758*std::sin(0.125280052423477*x_65 + 4.9015998840332) - 0.000394353398840173*std::sin(0.236399978399277*x_65 - 4.34391975402832) - 0.000329419129544284*std::sin(0.242479979991913*x_68 + 5.06775999069214) - 0.00630317246169407*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 0.00197593006229202*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.0196583883388952*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.00210257396939384*std::sin(0.145920038223267*x_73 - 7.66184043884277) + 0.00796556239571993*std::sin(0.180800005793571*x_74 - 7.61600017547607) - 0.000569226514128269*std::sin(0.317759841680527*x_74 - 4.29056024551392) - 0.0183848652164129*std::sin(0.170960023999214*x_75 - 7.64040040969849) - 0.000527417703424443*std::sin(0.243279978632927*x_76 - 7.53600025177002) - 0.000717507210182861*std::sin(0.244879975914955*x_79 - 7.55568027496338) + 0.00183327892499515*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.00129907557624159*std::sin(0.174000009894371*x_87 + 4.95519971847534) - 0.0185284571789626*std::sin(0.206560000777245*x_88 + 5.00391960144043) + 0.00530410297207203*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.00643250682933462*std::sin(0.359999865293503*x_88 - 4.24480009078979) - 0.0141116378217875*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.000441238684648001*std::sin(0.338559836149216*x_93 + 1.98655986785889) - 1.04164560173922e-6*std::sin(0.3711998462677*x_93 + 8.19575977325439) + 0.000739738504865381*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 0.000868865166811808*std::sin(0.358319848775864*x_94 - 1.20919990539551) + 0.0251680198878609*std::sin(0.359999865293503*x_94 + 1.97703981399536) - 0.00512827202562371*std::sin(0.328879833221436*x_95 - 1.22527992725372) + 0.00297075791883043*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.00328606919882099*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 9.00534313326609e-5*std::sin(0.367679834365845*x_95 + 1.98583984375) - 0.000903676788823253*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.00345351680601782*std::sin(0.362479835748672*x_96 - 7.42711973190308) + 0.013079687854914*std::sin(0.386399865150452*x_96 - 7.41824007034302) + 0.00027157920914909*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.00505974941976156*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.000293452037187344*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 0.000917442696990649*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.00549320105421227*std::sin(0.321679830551147*x_99 + 1.9223198890686) + 0.00597388165134465*std::sin(0.379759848117828*x_99 + 5.18016004562378) + 0.00265912342872926*std::sin(0.382479846477509*x_99 - 7.39991998672485) - 0.00749275766687746*std::sin(0.395599842071533*x_99 - 7.39767980575562) + 0.00397909927930271*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.154077213598116);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000841692929885705*x_1 - 0.000820750670846721*x_10 - 0.000435211432758287*x_100 + 0.000995082713362521*x_101 + 7.39409764643745e-5*x_102 + 0.00107850233746211*x_103 + 0.000331296876701652*x_104 + 4.63506594016112e-5*x_105 - 0.00046950239759556*x_106 + 0.000702617200956288*x_107 - 0.000642149346034291*x_108 + 0.00197389495789024*x_109 - 0.00131102877256218*x_11 + 0.000215284177152121*x_110 - 0.000945815731158081*x_111 + 0.000294990175409348*x_112 + 1.84119507955128e-5*x_113 + 0.00146310574421601*x_114 + 5.91416678040929e-5*x_115 - 0.000666780906932683*x_116 + 0.000807816916147661*x_117 + 0.000663121174973869*x_118 + 0.00039369162616882*x_119 - 0.000828420598394505*x_12 + 0.000198214409919176*x_120 + 0.000818164766268445*x_13 - 0.000969965831699247*x_14 + 0.000338239677982532*x_15 + 0.000214595449225231*x_16 - 0.00313340008140404*x_17 - 0.000306197875098096*x_18 + 4.81219451425757e-5*x_19 - 0.000392370488713507*x_2 + 0.000376958515956234*x_20 + 9.73060471820686e-5*x_21 - 0.00196664570910463*x_22 - 0.000796951039476598*x_23 - 2.84347190258732e-5*x_24 + 0.00133908388390949*x_25 + 0.000495080845984841*x_26 - 0.000241799798313349*x_27 - 0.000245492538708066*x_28 + 0.000470140926726618*x_29 + 0.00080653452672771*x_3 + 0.000113808543029219*x_30 + 0.00701631529311416*x_31 - 0.00492364175539934*x_32 - 0.00104631322478208*x_33 + 5.79123506417528e-5*x_34 + 2.9199099063505e-5*x_35 + 0.000687903143602813*x_36 + 0.000433038916210691*x_37 + 0.00090154562188514*x_38 + 0.0016921191619519*x_39 - 0.00124631094287808*x_4 + 0.000125173768129303*x_40 - 0.00012208565423055*x_41 + 0.000903800419644319*x_42 - 6.91745827741588e-5*x_43 + 4.56941060515129e-5*x_44 + 0.000545795662687821*x_45 + 0.000175349702840273*x_46 + 0.000195245383717273*x_47 + 0.00242995221284325*x_48 + 0.000693468587968197*x_49 - 0.000443186006321053*x_5 - 0.000102527603033011*x_50 + 4.52320930953679e-6*x_51 + 0.00256329594146464*x_52 + 4.30873355093796e-5*x_53 - 0.000765725375902886*x_54 - 6.2625330986663e-5*x_55 + 0.000144213321254593*x_56 + 0.000865725356944802*x_57 + 0.000131716594148051*x_58 + 8.59997939514941e-5*x_59 + 4.06349119986156e-5*x_6 + 0.000138452523861329*x_60 + 5.69537773409984e-5*x_61 + 0.000980917056253918*x_62 - 0.000144209305984995*x_63 + 3.85379154669485e-5*x_64 + 0.00123573350706212*x_65 + 0.000239027260955674*x_66 + 0.000136055149091791*x_67 - 0.000388806371602917*x_68 + 7.4817890231587e-5*x_69 - 2.75513140167951e-5*x_7 + 0.000159986541716951*x_70 - 0.000113368035554827*x_71 + 1.29296972348122e-5*x_72 - 0.000685674032462072*x_73 - 0.000639404204024033*x_74 + 4.17584050931032e-5*x_75 + 0.00023127433488563*x_76 - 0.000305110665748797*x_77 - 0.00110539272636079*x_78 + 0.00106919096385286*x_79 + 0.00106479677961195*x_8 + 0.000211821478993868*x_80 - 0.000321374410497179*x_81 - 0.0012746046908624*x_82 - 0.000176545180748342*x_83 + 0.000915195621833769*x_84 - 0.00068954467499702*x_85 - 3.66317585348789e-5*x_86 + 0.000149220985619856*x_87 + 0.000314089876832211*x_88 + 7.20355312736467e-5*x_89 + 0.0013083071575059*x_9 + 0.000218950379983373*x_90 + 1.92561276326603e-5*x_91 + 0.000432766226859659*x_92 + 0.000172932831546108*x_93 - 0.000288998819491627*x_94 - 0.000174488460282251*x_95 + 0.00101889164985163*x_96 - 0.000610634176977198*x_97 - 0.000160972252734868*x_98 + 3.29489838839139e-5*x_99 + 1.13129219291942e-5*std::pow(-5.67959976196289*x_108 - 7.30656003952026, 2) + 2.05048184898783e-6*std::pow(-6.65808010101318*x_116 - 8.61312007904053, 2) - 3.81921431390109e-6*std::pow(-5.90375995635986*x_13 - 8.55432033538818, 2) + 1.06885541104844e-6*std::pow(-3.81392002105713*x_13 - 5.81599998474121, 2) - 4.81684826409222e-6*std::pow(-5.79999971389771*x_15 - 9.99975967407227, 2) + 4.76868311855428e-7*std::pow(-5.74991989135742*x_17 - 9.11999988555908, 2) - 2.40254021155619e-5*std::pow(-4.17831993103027*x_17 - 6.16960000991821, 2) - 8.56967485938016e-6*std::pow(-5.95327997207642*x_18 - 8.5383996963501, 2) + 4.49533988506405e-5*std::pow(-4.61263990402222*x_2 - 8.82248020172119, 2) - 0.000967969312145404*std::pow(-0.834719836711884*x_2 - 1.46367990970612, 2) - 1.40295169176038e-6*std::pow(-5.71135950088501*x_22 - 9.16936016082764, 2) + 3.0621034597989e-5*std::pow(-5.68183994293213*x_27 - 7.63887977600098, 2) + 8.64607188955766e-7*std::pow(-3.92000007629395*x_4 - 6.5991997718811, 2) - 6.86384445394038e-7*std::pow(-6.13000011444092*x_40 - 8.77807998657227, 2) - 2.36923839238978e-5*std::pow(-5.12968015670776*x_5 - 7.89455986022949, 2) - 6.80815987163597e-6*std::pow(-3.93039989471436*x_5 - 5.99783992767334, 2) - 7.32203985504738e-7*std::pow(-6.70144033432007*x_53 - 8.1276798248291, 2) + 1.75669454381321e-6*std::pow(-6.68192005157471*x_53 - 9.9474401473999, 2) + 4.0358681109105e-6*std::pow(-6.19072008132935*x_55 - 8.58360004425049, 2) + 1.30021129890713e-5*std::pow(-5.18279981613159*x_55 - 9.17303943634033, 2) - 8.09119020102625e-6*std::pow(-6.66512012481689*x_59 - 9.49808025360107, 2) + 2.90591074923827e-6*std::pow(-4.46895980834961*x_6 - 8.32672023773193, 2) - 7.01651493362574e-6*std::pow(-3.40735983848572*x_64 - 5.40655994415283, 2) - 3.75132862412832e-7*std::pow(-8.32399940490723*x_66 - 9.96440029144287, 2) + 1.16764752247185e-5*std::pow(-5.26248025894165*x_66 - 9.10311985015869, 2) - 6.1229507227699e-6*std::pow(-8.15151977539063*x_67 - 9.98752021789551, 2) + 1.59769083855794e-6*std::pow(-3.90999984741211*x_67 - 6.25367975234985, 2) - 6.8949291312915e-6*std::pow(-3.22847986221313*x_68 - 4.64055967330933, 2) + 5.26618599033745e-6*std::pow(-6.70192003250122*x_69 - 9.99039936065674, 2) + 8.75468035536093e-7*std::pow(-5.96407985687256*x_69 - 9.73639965057373, 2) + 3.6276837172459e-6*std::pow(-4.45928001403809*x_69 - 5.61976003646851, 2) + 5.1680312655849e-7*std::pow(-4.19112014770508*x_69 - 5.99031972885132, 2) + 9.85136218448664e-5*std::pow(-2.07015991210938*x_69 - 3.01200008392334, 2) - 1.50463072643168e-6*std::pow(-5.91111993789673*x_7 - 9.9946403503418, 2) + 9.31656118035949e-6*std::pow(-4.79856014251709*x_7 - 8.01455974578857, 2) - 1.13017146183719e-5*std::pow(-4.61255979537964*x_7 - 8.02136039733887, 2) - 1.05832491479328e-5*std::pow(-3.41407990455627*x_70 - 5.21608018875122, 2) + 1.30410793856025e-7*std::pow(-7.09847974777222*x_71 - 9.73984050750732, 2) + 1.75432438722127e-6*std::pow(-5.95879983901978*x_71 - 6.75031995773315, 2) - 9.54824344286891e-6*std::pow(-4.71935987472534*x_71 - 5.74711990356445, 2) + 1.08313724016041e-5*std::pow(-7.29416036605835*x_72 - 9.92984008789063, 2) - 5.74076746654547e-7*std::pow(-5.54496002197266*x_72 - 7.33039999008179, 2) - 6.40514192954334e-7*std::pow(-6.1224799156189*x_75 - 7.89680004119873, 2) + 7.92204574276387e-7*std::pow(-5.73151969909668*x_75 - 7.78184032440186, 2) - 4.18795939401869e-7*std::pow(-5.80391979217529*x_76 - 8.20743942260742, 2) + 1.82991295595614e-6*std::pow(-4.4521598815918*x_76 - 6.26887989044189, 2) - 2.84281944221732e-6*std::pow(-5.6637601852417*x_77 - 7.02464008331299, 2) + 2.08334593985132e-5*std::pow(-5.33576011657715*x_77 - 7.38352012634277, 2) + 4.29644676830168e-7*std::pow(-7.91671991348267*x_78 - 9.55064010620117, 2) + 5.58868706070194e-7*std::pow(-6.51808023452759*x_78 - 8.55167961120605, 2) - 3.00541933686443e-7*std::pow(-6.62376022338867*x_79 - 9.44655990600586, 2) + 1.37878691437749e-6*std::pow(-6.11415958404541*x_80 - 7.95824003219604, 2) + 2.29459158142091e-6*std::pow(-5.32231998443604*x_80 - 6.70319986343384, 2) - 7.17216081136329e-6*std::pow(-1.66639983654022*x_80 - 2.21887969970703, 2) + 0.000184795958716016*std::pow(-0.513439834117889*x_80 - 0.770559847354889, 2) + 8.19381433561588e-6*std::pow(-7.26615953445435*x_81 - 8.24512004852295, 2) + 6.64595688868738e-6*std::pow(-5.92727994918823*x_81 - 7.15599966049194, 2) + 5.18651407556228e-7*std::pow(-5.31744003295898*x_81 - 7.35896015167236, 2) - 2.89760377278937e-7*std::pow(-6.04855966567993*x_84 - 9.48400020599365, 2) - 4.14285747659506e-6*std::pow(-4.589280128479*x_84 - 6.3866400718689, 2) + 8.27690117357096e-7*std::pow(-4.35976028442383*x_84 - 4.98799991607666, 2) - 4.5403866622156e-5*std::pow(-1.87999987602234*x_84 - 3.00363993644714, 2) + 1.85042796135118e-5*std::pow(-6.3010401725769*x_85 - 7.52167987823486, 2) + 3.17478408517376e-7*std::pow(-6.68864011764526*x_86 - 8.89504051208496, 2) - 4.17700161633191e-6*std::pow(-5.57927989959717*x_87 - 6.57136011123657, 2) - 4.28083778510764e-7*std::pow(-7.07895994186401*x_88 - 9.49880027770996, 2) + 5.1771007644295e-5*std::pow(-4.05200004577637*x_88 - 5.46799993515015, 2) - 1.74487975118096e-6*std::pow(-4.32488012313843*x_89 - 5.55807971954346, 2) - 1.25432553739876e-6*std::pow(-6.01503992080688*x_90 - 8.61599922180176, 2) - 2.74230392292622e-6*std::pow(-4.90007972717285*x_90 - 9.96728038787842, 2) - 2.32136382724927e-5*std::exp(0.759199857711792*x_22) + 0.000162205983016398*std::exp(0.627279818058014*x_38) + 7.38244603883156e-5*std::exp(0.757519841194153*x_72) + 4.61313956283127e-5*std::exp(0.511599838733673*x_73) + 0.00226044613687028*std::sin(0.144320040941238*x_1 + 8.1526403427124) + 0.00178331918338218*std::sin(0.358559846878052*x_1 + 8.25119972229004) - 0.0290978983859183*std::sin(0.20160000026226*x_10 + 5.00271987915039) + 0.00082968729332968*std::sin(0.323119848966599*x_10 + 8.31192016601563) + 0.000399651262701082*std::sin(0.348559856414795*x_10 - 4.24007987976074) - 0.0293020649256086*std::sin(0.140800043940544*x_100 + 1.73271989822388) + 0.001392118611184*std::sin(0.439679861068726*x_100 + 5.22295999526978) + 0.000278854370324974*std::sin(0.378879845142365*x_101 - 4.40639972686768) + 0.00191284537365787*std::sin(0.344959855079651*x_102 - 7.43727970123291) + 0.000276627384978281*std::sin(0.36847984790802*x_102 + 1.96815979480743) + 0.00145440293591622*std::sin(0.333679854869843*x_103 + 1.94599986076355) + 0.004747796432484*std::sin(0.385199844837189*x_104 + 1.99399983882904) - 0.00583426391934883*std::sin(0.409279853105545*x_105 - 1.17479979991913) - 0.000418251032640672*std::sin(0.300639927387238*x_106 - 7.50688028335571) - 0.000689953177151692*std::sin(0.369759827852249*x_107 + 5.16495990753174) - 0.0163477968425874*std::sin(0.226719990372658*x_109 + 5.01807975769043) + 0.000251708369888977*std::sin(0.330879837274551*x_109 + 1.928879737854) + 0.00142269503458132*std::sin(0.362399846315384*x_109 - 1.22647988796234) - 0.000128996319555107*std::sin(0.373039841651917*x_109 + 8.18727970123291) + 0.00270383139474365*std::sin(0.238639980554581*x_11 - 4.33599996566772) + 0.00182337084021864*std::sin(0.287039935588837*x_110 - 7.50984001159668) + 0.00840600830983179*std::sin(0.32423985004425*x_110 + 5.12512016296387) + 0.000939553984494114*std::sin(0.384959846735001*x_110 - 7.40488004684448) + 0.00244800257461199*std::sin(0.24679996073246*x_111 + 1.84103989601135) + 0.000382529346013138*std::sin(0.385039836168289*x_111 - 7.41479969024658) - 0.00447057006051408*std::sin(0.352639853954315*x_112 - 4.23967981338501) - 0.000689355975244084*std::sin(0.310799926519394*x_113 - 7.49704027175903) - 0.010170737972569*std::sin(0.345999836921692*x_113 + 1.96959984302521) + 0.000175293575656519*std::sin(0.256479978561401*x_114 - 7.52464008331299) + 0.0140667758767574*std::sin(0.311999946832657*x_114 - 1.30423986911774) + 0.000282261240265821*std::sin(0.31687992811203*x_115 + 1.91471993923187) - 0.00118162225681391*std::sin(0.334959834814072*x_115 - 4.27088022232056) + 0.00127807607404725*std::sin(0.368559837341309*x_115 + 1.98191976547241) + 0.000727673167813965*std::sin(0.271519958972931*x_117 - 7.50487995147705) - 0.000542112726321218*std::sin(0.335359841585159*x_117 - 7.44863986968994) - 0.000216530902978701*std::sin(0.352479845285416*x_117 + 5.15328025817871) - 0.0126933443971256*std::sin(0.24967996776104*x_118 - 4.34711980819702) + 0.000276237447357152*std::sin(0.271039962768555*x_118 + 5.06983995437622) - 0.000544685567215622*std::sin(0.277119934558868*x_118 - 7.51272010803223) - 0.00194220814993638*std::sin(0.303199917078018*x_118 + 5.1017599105835) + 0.000906552742239407*std::sin(0.368079841136932*x_118 + 5.17296028137207) - 0.000136768652846628*std::sin(0.361119836568832*x_119 - 1.20559990406036) - 0.000502840412340565*std::sin(0.248959973454475*x_12 - 4.32624006271362) - 0.00115312932322051*std::sin(0.296079933643341*x_12 + 5.11303997039795) + 0.026475306746825*std::sin(0.310799926519394*x_12 + 5.12871980667114) - 0.0133335577214833*std::sin(0.327679842710495*x_12 - 4.2513599395752) - 0.000859634414111651*std::sin(0.416159868240356*x_120 - 1.16447985172272) + 0.000174343284104954*std::sin(0.44463986158371*x_120 + 2.0079197883606) + 0.0127920343060849*std::sin(0.190880000591278*x_13 - 4.42511987686157) + 0.129753746493907*std::sin(0.123040057718754*x_14 + 4.89599990844727) + 0.033662539389135*std::sin(0.126320049166679*x_14 - 4.50839996337891) - 0.00420988999209965*std::sin(0.221919998526573*x_14 + 5.03495979309082) - 0.0152948862331869*std::sin(0.399439841508865*x_15 - 0.997359812259674) + 4.3883621555164e-5*std::sin(1.36559987068176*x_15 - 2.19623994827271) - 0.00646036832455869*std::sin(0.207520008087158*x_16 - 1.18359982967377) + 0.00674773277016442*std::sin(0.352719843387604*x_16 - 4.25216007232666) - 0.00252652548879749*std::sin(0.202480003237724*x_18 + 5.00679969787598) - 0.00188470531649766*std::sin(0.150320038199425*x_19 + 8.10863971710205) - 0.000228201263311674*std::sin(0.271839946508408*x_21 + 8.30095958709717) - 0.00546795858625176*std::sin(0.288319945335388*x_21 - 1.0707198381424) - 0.00791206523741424*std::sin(0.292639940977097*x_21 + 5.07719993591309) + 0.00164521388168977*std::sin(0.33943983912468*x_21 - 4.23839998245239) - 0.0013674201534894*std::sin(0.349679857492447*x_21 - 4.02647972106934) + 0.0132939049696644*std::sin(0.3503198325634*x_21 - 4.22424030303955) + 0.0120018615778563*std::sin(0.192800000309944*x_23 + 4.99607992172241) + 0.00363609684776062*std::sin(0.295439928770065*x_23 + 5.13943958282471) - 0.00202970545420056*std::sin(0.382159858942032*x_23 + 5.17600011825562) - 0.0202131694910752*std::sin(0.193599998950958*x_24 - 7.59560012817383) - 0.00062036899532051*std::sin(0.258639991283417*x_24 + 5.07799959182739) + 0.00288547491332918*std::sin(0.568079829216003*x_24 + 2.35255980491638) + 0.000821440071928059*std::sin(0.609839856624603*x_24 + 2.38503980636597) + 0.000778804067804467*std::sin(0.345119833946228*x_26 + 1.93407988548279) - 0.014558275413887*std::sin(0.3503198325634*x_26 + 5.16328001022339) + 0.00058488987101645*std::sin(0.357919842004776*x_26 + 5.1561598777771) + 0.00488839061920134*std::sin(0.371439844369888*x_26 + 5.18544006347656) + 0.000972597597059397*std::sin(0.288959950208664*x_27 - 4.27960014343262) - 0.000297673953459728*std::sin(0.540319859981537*x_27 + 5.33847999572754) - 0.000882959346532905*std::sin(0.278879970312119*x_28 + 5.09839963912964) + 0.00791832198181363*std::sin(0.309839934110641*x_28 + 1.91183984279633) - 0.000273443636396934*std::sin(0.312159925699234*x_28 + 5.14895963668823) - 0.00175207079130996*std::sin(0.316799849271774*x_28 - 4.29735994338989) - 0.00149685082685996*std::sin(0.360399842262268*x_28 + 8.36839962005615) + 0.00714511694005373*std::sin(0.407039850950241*x_28 - 4.18111991882324) - 0.00285084856115199*std::sin(0.310399949550629*x_3 - 4.25767993927002) - 0.00225313503023113*std::sin(0.315519839525223*x_3 + 8.31960010528564) + 0.00441709016962351*std::sin(0.247039973735809*x_30 + 8.25191974639893) + 0.0203627903218134*std::sin(0.276239961385727*x_30 + 8.2806396484375) + 0.00020466068135106*std::sin(0.258159965276718*x_32 + 1.97111988067627) + 0.00607652869645555*std::sin(0.263439953327179*x_32 + 5.1547999382019) - 0.0065066191572918*std::sin(0.312719941139221*x_34 - 1.14543986320496) + 0.0010121167317973*std::sin(0.312719941139221*x_34 - 1.1386399269104) - 0.00625296340839742*std::sin(0.361119836568832*x_34 + 1.98511981964111) - 0.0185936133660935*std::sin(0.361359834671021*x_34 + 2.00311970710754) - 0.00117062956053842*std::sin(0.398559868335724*x_34 - 7.60168027877808) - 0.00766078051519985*std::sin(0.270799964666367*x_35 + 8.24799919128418) + 0.00252186013693331*std::sin(0.304399937391281*x_35 - 1.12567985057831) + 0.00108651184363969*std::sin(0.304399937391281*x_35 - 1.12175977230072) + 0.00185695292360667*std::sin(0.324799835681915*x_35 - 7.42127990722656) + 0.0011841108817711*std::sin(0.342639863491058*x_35 - 1.21223986148834) - 0.000276294701260441*std::sin(0.355199843645096*x_36 - 4.24295997619629) - 0.0014780322699347*std::sin(0.340399831533432*x_37 - 7.45648002624512) - 0.000487286051866905*std::sin(0.386319845914841*x_37 + 5.17471981048584) + 0.000896948044334802*std::sin(0.413759857416153*x_37 + 5.19672012329102) + 0.000453666249272952*std::sin(0.343759834766388*x_38 - 4.26360034942627) - 0.000439862933045691*std::sin(0.346879839897156*x_38 - 4.25672006607056) - 0.00120562811717152*std::sin(0.319519847631454*x_39 + 1.94815981388092) + 0.000480313499993532*std::sin(0.179680019617081*x_40 + 1.7875999212265) - 0.000376332517472587*std::sin(0.329919844865799*x_40 - 4.27824020385742) - 0.00780011022525561*std::sin(0.263519942760468*x_41 + 8.27439975738525) - 0.00173805741518763*std::sin(0.291759938001633*x_41 - 7.50631999969482) + 0.00161745581230324*std::sin(0.336239844560623*x_41 - 7.43887996673584) + 0.0251312240434868*std::sin(0.34775984287262*x_41 + 5.16032028198242) + 0.000199484802784286*std::sin(0.405519872903824*x_42 - 1.18847990036011) - 0.0027933733268175*std::sin(0.332159847021103*x_43 + 5.14351987838745) + 0.000625741363334442*std::sin(0.344799846410751*x_43 - 4.25375986099243) - 0.00797558222685917*std::sin(0.347919851541519*x_43 - 7.45056009292603) + 3.72087611433423e-5*std::sin(0.386239856481552*x_43 + 1.97567975521088) + 0.0176015688429363*std::sin(0.206960007548332*x_45 - 7.57656002044678) + 0.000333472772806829*std::sin(0.282239943742752*x_45 + 5.07999992370605) - 0.0012669342343166*std::sin(0.296719938516617*x_46 + 5.10799980163574) - 0.00266146705183974*std::sin(0.315279841423035*x_46 + 5.10735988616943) - 0.00337297452484208*std::sin(0.22647999227047*x_47 - 4.37087965011597) - 0.0047713138955829*std::sin(0.186160013079643*x_48 - 4.42583990097046) - 0.0116481861599085*std::sin(0.261839956045151*x_48 + 5.08527946472168) - 0.000395383408157263*std::sin(0.475279867649078*x_48 + 2.04215979576111) - 0.0117508380034874*std::sin(0.293039947748184*x_49 + 1.90383982658386) - 0.00754551195573443*std::sin(0.163760021328926*x_5 + 8.13551998138428) - 0.00200953677026562*std::sin(0.211119994521141*x_5 - 4.36911964416504) + 0.0159901412223282*std::sin(0.342719823122025*x_51 + 5.15288019180298) + 0.000273242166327598*std::sin(0.215759992599487*x_52 + 1.79055988788605) + 0.00317836694179973*std::sin(0.297439932823181*x_52 + 5.10951995849609) + 0.000775665832284886*std::sin(0.2811199426651*x_55 + 1.88439989089966) - 0.00131676153754988*std::sin(0.217999994754791*x_56 - 7.58768033981323) - 0.0136510982862939*std::sin(0.26335996389389*x_56 - 7.52920007705688) + 0.0073560689691182*std::sin(0.314399927854538*x_56 + 5.12855958938599) - 0.00250214571905068*std::sin(0.140080034732819*x_57 + 4.9115195274353) + 0.000530862362970748*std::sin(0.221599996089935*x_57 - 7.57183980941772) + 0.0112983496204969*std::sin(0.231359988451004*x_57 + 1.84351992607117) + 0.00100420657172529*std::sin(0.333759844303131*x_57 - 7.44903993606567) + 0.000855474739642974*std::sin(0.273039966821671*x_58 - 7.5079197883606) - 0.000381016170908536*std::sin(0.284239947795868*x_58 - 7.50048017501831) - 0.0141856639332051*std::sin(0.359839856624603*x_58 + 5.1528000831604) - 0.000695372106785068*std::sin(0.403839856386185*x_58 + 2.014399766922) + 0.0169041825845798*std::sin(0.261439979076385*x_59 + 5.08079957962036) + 0.00135597717374196*std::sin(0.295199930667877*x_59 - 7.48152017593384) + 0.00196702193717707*std::sin(0.322079837322235*x_59 + 5.1165599822998) - 0.00156298203104596*std::sin(0.288639932870865*x_60 - 7.49160003662109) - 0.00110624910758139*std::sin(0.27167996764183*x_62 - 4.30463981628418) - 0.00278016342521533*std::sin(0.223439991474152*x_64 + 5.04335975646973) + 0.00869229222642978*std::sin(0.125280052423477*x_65 + 4.9015998840332) - 0.00088659589332609*std::sin(0.236399978399277*x_65 - 4.34391975402832) - 0.000740608926653088*std::sin(0.242479979991913*x_68 + 5.06775999069214) - 0.000417617282845205*std::sin(0.313759922981262*x_7 + 8.38703918457031) + 0.00252478717419358*std::sin(0.534639835357666*x_7 - 3.87391996383667) - 0.00477602563870818*std::sin(0.205680012702942*x_70 - 7.60304021835327) - 0.00472706321832522*std::sin(0.145920038223267*x_73 - 7.66184043884277) - 0.00126764114855909*std::sin(0.180800005793571*x_74 - 7.61600017547607) - 0.00127975032365066*std::sin(0.317759841680527*x_74 - 4.29056024551392) - 0.0234916573129283*std::sin(0.170960023999214*x_75 - 7.64040040969849) - 0.00118575463353139*std::sin(0.243279978632927*x_76 - 7.53600025177002) - 0.00161311896347521*std::sin(0.244879975914955*x_79 - 7.55568027496338) - 0.000291748364604957*std::sin(0.445039868354797*x_81 - 4.1593599319458) + 0.00292061656981637*std::sin(0.174000009894371*x_87 + 4.95519971847534) - 0.00122760466882615*std::sin(0.206560000777245*x_88 + 5.00391960144043) + 0.00315509067006269*std::sin(0.243199974298477*x_88 + 5.05599975585938) - 0.00156278414122499*std::sin(0.359999865293503*x_88 - 4.24480009078979) - 0.00839416147560814*std::sin(0.175840020179749*x_91 - 4.16767978668213) + 0.000992004650995978*std::sin(0.338559836149216*x_93 + 1.98655986785889) + 0.00662015414595486*std::sin(0.3711998462677*x_93 + 8.19575977325439) - 0.000117722129506486*std::sin(0.256959974765778*x_94 + 5.05655956268311) - 0.00398511048942103*std::sin(0.358319848775864*x_94 - 1.20919990539551) - 0.000308465167996103*std::sin(0.359999865293503*x_94 + 1.97703981399536) - 0.000339774144218236*std::sin(0.328879833221436*x_95 - 1.22527992725372) + 0.0017671245528356*std::sin(0.335519850254059*x_95 + 5.14463996887207) + 0.00915628028219719*std::sin(0.347519844770432*x_95 + 1.94063985347748) + 0.000202460540810044*std::sin(0.367679834365845*x_95 + 1.98583984375) - 0.00414477641381367*std::sin(0.280479967594147*x_96 - 7.50864028930664) + 0.00205428867255097*std::sin(0.362479835748672*x_96 - 7.42711973190308) - 0.000160307728994152*std::sin(0.386399865150452*x_96 - 7.41824007034302) + 0.000610571665547926*std::sin(0.472959846258163*x_97 - 1.13407981395721) - 0.0140984504713545*std::sin(0.228159993886948*x_98 + 1.83047986030579) - 0.000659746744477584*std::sin(0.375119835138321*x_98 - 7.40303993225098) + 0.00420791470860295*std::sin(0.316639840602875*x_99 + 1.92487978935242) + 0.00133457883836733*std::sin(0.321679830551147*x_99 + 1.9223198890686) + 0.0076332558835457*std::sin(0.379759848117828*x_99 + 5.18016004562378) + 0.00158175200683394*std::sin(0.382479846477509*x_99 - 7.39991998672485) - 0.000496433362227558*std::sin(0.395599842071533*x_99 - 7.39767980575562) + 0.0110873344618112*std::sin(0.417999863624573*x_99 + 2.01671981811523) + 0.15162664659182);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
