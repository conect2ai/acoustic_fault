
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000630712227119134*x_10 - 0.00443693361308005*x_100 - 0.0024450471326137*x_101 - 0.00101665163561781*x_102 - 0.00159666918590732*x_103 + 0.00166310400144248*x_104 + 0.00037687055004392*x_105 + 0.000695729379096131*x_106 + 0.00191672861347767*x_107 - 0.000943799745887945*x_108 + 0.00259814256547632*x_109 + 0.00319468589269347*x_11 + 0.000914725940454437*x_110 + 0.000608479654951074*x_111 - 0.00444429993092802*x_112 - 0.00166889273148068*x_113 - 0.00207297752121605*x_114 + 0.00164449137959039*x_115 + 0.000584368598999127*x_116 + 0.00238391448527057*x_117 + 0.00605579570254094*x_118 - 0.00449839478017243*x_119 + 0.00489314208979978*x_12 - 0.000230856330923419*x_120 + 0.0037572458827872*x_13 - 0.00197392019640482*x_14 + 0.000924283591338251*x_15 - 0.000283961199277725*x_16 - 0.00013488805252228*x_17 - 5.06966635065219e-6*x_18 - 0.00115854481606814*x_19 - 0.000772319670698865*x_2 + 0.00221828645867195*x_20 - 0.00021369000791571*x_21 + 0.00166855173700615*x_22 + 0.000116624086696777*x_23 + 0.00101171103854851*x_24 + 0.00257643342160078*x_25 + 0.0011022960923256*x_26 - 0.000708306477643851*x_27 + 0.00175821510609094*x_28 + 0.000517665496235472*x_29 - 0.000293417906777921*x_3 + 0.00314427561054645*x_30 - 0.00101025168047606*x_31 + 0.000457060896267583*x_32 - 0.00143353391165881*x_33 - 0.00117828590861534*x_34 - 0.00059079857178417*x_35 - 0.000888498445455989*x_36 + 0.000758338199649878*x_37 + 0.000722218159531724*x_38 - 0.0014017263580846*x_39 + 0.000931170373489688*x_4 - 0.000213398822569091*x_40 - 0.00162775139547304*x_41 + 0.000295177519759713*x_42 - 0.000707866780385274*x_43 + 0.000877965999319222*x_44 - 0.000954740936174514*x_45 + 0.00116477948953967*x_46 + 0.00192122074870738*x_47 + 0.00203735907314613*x_48 + 0.00116241376539078*x_49 + 0.000851432145092597*x_5 + 0.00057830113239906*x_50 + 0.00160954864878123*x_51 - 0.00262969069653638*x_52 - 0.000247470179305775*x_53 - 0.00138882364912669*x_54 + 0.00176470896109713*x_55 - 0.00194102985161008*x_56 + 0.000495266150298288*x_57 + 0.00311299438549562*x_58 + 0.00183867168687451*x_59 - 0.00818836905852914*x_6 + 0.00168063426947173*x_60 + 0.00137238842424895*x_61 - 0.000712844364113994*x_62 + 0.000317078161948874*x_63 + 0.00363344331347764*x_64 + 0.000191661507893267*x_65 + 0.000293135563778016*x_66 - 0.000224472259330583*x_67 - 0.000965862197712564*x_68 + 0.000101233438507752*x_69 - 0.000449550992847083*x_7 - 0.00055573933943392*x_70 - 0.0016591463593587*x_71 - 0.00172782618624499*x_72 - 0.000455032373776425*x_73 - 0.0014358475211106*x_74 - 0.0017404965574118*x_75 + 0.00082503678606537*x_76 + 0.000115446871661321*x_77 - 0.000389932627606439*x_78 + 0.000465211621789276*x_79 - 0.00164723999349723*x_8 + 0.000454393586630119*x_80 - 0.0006695219923626*x_81 - 7.85697428344942e-6*x_82 + 0.000973528365895256*x_83 + 0.000143496085577755*x_84 - 0.000928802436464889*x_85 + 0.00096160690008227*x_86 + 0.00159352747782168*x_87 + 0.000138801862843962*x_88 - 0.000271649957171667*x_89 + 8.31617000637585e-6*x_9 - 1.80077494916015e-5*x_90 - 5.28926218004571e-6*x_91 + 6.35338611516029e-5*x_92 - 0.000466499244918339*x_93 + 0.000700794041778461*x_94 - 0.000478903064370121*x_95 - 0.00154237759221935*x_96 - 0.000764568585612624*x_97 - 0.0015108998918897*x_98 - 0.00214758177230735*x_99 + 6.55774495970248e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.00385589372336102*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.000849511123896111*std::sin(0.328319847583771*x_1 - 4.26039981842041) + 0.0179008160234536*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.0716331572303988*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.01617805460903*std::sin(0.353999853134155*x_1 + 8.35127925872803) - 0.00103153857512491*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.000103225432489622*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.000253447096753229*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.000260587381958263*std::sin(0.207040011882782*x_11 - 7.38431978225708) + 0.00103831723259683*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.00319665905767071*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 0.00105078823655027*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.0187688650708988*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.000696265164635361*std::sin(0.25639995932579*x_116 - 7.43792009353638) + 0.00294384639661395*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.045856473979895*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.0833116891789365*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.000689964233161724*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.0188078817548302*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.0119836960463677*std::sin(0.235919982194901*x_15 - 7.38631963729858) - 0.00151783425487333*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.00554201406232748*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.0191042035002163*std::sin(0.251519978046417*x_17 - 1.1509598493576) + 0.010817763361731*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.00645175661537333*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.0155957287901073*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.000183288843242543*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.0355403009748425*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.00879803585494702*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.0109348666819549*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 4.91207750917776e-5*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.00491075018647023*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.0121316128613167*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.000895812563283468*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.0060629268907392*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.001218360303095*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.00219465366536469*std::sin(0.24551996588707*x_25 - 7.38503980636597) + 0.000721136156028815*std::sin(0.171760007739067*x_26 - 1.22095990180969) + 0.00192504965563042*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.00673696383486004*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.0234982053164122*std::sin(0.281919926404953*x_29 + 8.20503997802734) - 0.00320383333837015*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.0735189536712431*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.000844333815940905*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.00024808536788731*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.0245487769888298*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.0623990191557017*std::sin(0.37679985165596*x_31 - 7.4029598236084) + 0.009000531246634*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.00371284671602815*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.000277869791990521*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.000141740040412578*std::sin(0.289759933948517*x_32 + 2.03663969039917) + 0.00203439243147295*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.00664841509649546*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.0226110070537001*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.00961327476416581*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.000218320361203878*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.00594049840312242*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.00181802936194048*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.00919131018236132*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 9.57397321354688e-6*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.0250897484453132*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.015981167171894*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.000408426885721686*std::sin(0.221119984984398*x_48 + 5.18160009384155) - 0.000751981322243319*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.00977611501703474*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.0129262763364228*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.000460816840490897*std::sin(0.359839856624603*x_5 + 1.99495983123779) + 0.00400062578992407*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.0213029780974533*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.0217318885158505*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.0948568772502959*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.000709774193572164*std::sin(0.30839991569519*x_6 + 2.00783967971802) + 0.00638575548931193*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.0110253419773771*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.0183267889094767*std::sin(0.292799949645996*x_7 - 0.986879825592041) + 0.00528733232360319*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.010808332003269*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.00587903674802264*std::sin(0.272879958152771*x_8 + 1.97535979747772) + 0.000757519724830559*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.00745522605306776*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.00407898315241468*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.0122533168883573*std::sin(0.368399828672409*x_91 + 1.98135983943939) - 0.00414817100063529*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.00502986564162097*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 8.84833690709704e-5*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0263963320385023*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.000194745701593185*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 9.75358523168182e-5*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.00281374137219231*std::sin(0.292879939079285*x_97 - 1.23735988140106) - 0.181050317031195);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000478427158738443*x_10 + 0.00209107866864184*x_100 + 0.00267600411121336*x_101 + 0.000965569361756701*x_102 + 0.00249266404034472*x_103 - 0.00353206680740595*x_104 + 0.000205959322889923*x_105 + 0.00326379073844502*x_106 - 0.00107930832800245*x_107 - 0.00170878856810937*x_108 - 0.00227921427517058*x_109 - 0.0087983671341609*x_11 + 0.00065162409286447*x_110 + 0.00214881363900539*x_111 + 0.00200677889848376*x_112 + 0.00533084047947637*x_113 + 0.00503645122030033*x_114 + 0.000529281490405011*x_115 + 3.66356137686925e-6*x_116 + 0.000771266124804565*x_117 + 0.00152989461846157*x_118 + 0.00484654535043355*x_119 + 0.000662457481589335*x_12 + 0.00584679896916597*x_120 - 0.000936131380182598*x_13 + 0.00175695081796993*x_14 + 8.19856367777298e-5*x_15 + 0.00077047561262745*x_16 + 0.00150869373119208*x_17 + 0.00226781436827106*x_18 + 0.00353770896822378*x_19 + 0.00015323892533576*x_2 + 0.000823069706529142*x_20 + 0.000715876759833503*x_21 - 0.00978148865131965*x_22 - 8.17510808401719e-6*x_23 + 0.000635777934227138*x_24 - 0.000461768401168601*x_25 - 0.000542175184027055*x_26 - 0.000217986108146209*x_27 - 0.00166085252377351*x_28 - 0.000600749371264738*x_29 + 1.81869280099071e-5*x_3 - 0.0189901514413391*x_30 + 0.000262566947316175*x_31 - 0.00191235465693414*x_32 + 0.00080750726186001*x_33 + 0.00255967814503385*x_34 - 0.000139806183153938*x_35 + 0.00345999852340881*x_36 - 0.000471059916135913*x_37 + 0.00590116115171624*x_38 - 0.000845416847460955*x_39 - 0.000177937147158617*x_4 + 0.00204791699782122*x_40 + 0.00237688399668557*x_41 + 0.000159042478618322*x_42 + 0.000548712063195253*x_43 - 0.00141589861622287*x_44 + 0.00122999934293163*x_45 + 0.00224014521053029*x_46 + 0.00204346454173738*x_47 - 0.000475107824269918*x_48 - 0.000218369362359293*x_49 - 5.27743357525889e-5*x_5 - 0.00133668152359947*x_50 - 0.0142367525015015*x_51 - 0.00740160523699948*x_52 + 0.00119312203885274*x_53 + 0.00236022227573834*x_54 - 0.000362054171045629*x_55 - 0.00136198464772302*x_56 - 0.0027269319290729*x_57 + 0.00101260357249957*x_58 - 0.000619951276611592*x_59 + 0.0045390164551938*x_6 + 0.00396135761405185*x_60 - 0.000196045258766922*x_61 - 0.000748980651646103*x_62 + 2.14848361994594e-6*x_63 - 0.000914889949699746*x_64 - 9.63236793958906e-5*x_65 + 0.00242446171444898*x_66 + 0.00183547746902248*x_67 - 0.000964917200332581*x_68 - 0.0013499033695154*x_69 + 0.000673168732734137*x_7 - 0.000273708205245759*x_70 + 0.00108938467422283*x_71 + 0.0031878344796454*x_72 + 0.00102198490193949*x_73 + 0.0016161561666235*x_74 + 0.00152499779600063*x_75 - 0.000390494562560342*x_76 + 0.000580364741309841*x_77 + 0.00125123497681805*x_78 - 0.000177213201179796*x_79 + 0.00291642368599655*x_8 + 0.000186771424916232*x_80 + 3.24705439886671e-5*x_81 - 8.3279647729374e-5*x_82 + 0.000864648930685391*x_83 - 0.00196613405580566*x_84 - 0.000268813872451779*x_85 + 0.000748228651957879*x_86 - 2.27720257034801e-5*x_87 - 0.000685625112711677*x_88 + 0.00154616882416052*x_89 + 0.00253334800228509*x_9 + 0.00120432493345539*x_90 + 0.000198248074800326*x_91 - 0.00237185305913711*x_92 - 0.00287126530773605*x_93 + 0.00400391606318334*x_94 - 0.000207252995632128*x_95 + 0.00501156934479349*x_96 + 0.000425494515779657*x_97 + 0.00401521913720114*x_98 - 0.00387952948095157*x_99 - 4.06468837567259e-7*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) - 0.039616210112372*std::sin(0.272319942712784*x_1 - 4.31655979156494) + 0.0318407254360021*std::sin(0.328319847583771*x_1 - 4.26039981842041) - 0.0129332500772059*std::sin(0.332399845123291*x_1 - 4.25383996963501) - 0.018617637351261*std::sin(0.340559840202332*x_1 - 4.24952030181885) + 0.00100276468381143*std::sin(0.353999853134155*x_1 + 8.35127925872803) + 0.00074528146308501*std::sin(0.210800006985664*x_101 + 1.99727976322174) + 0.00386901661609855*std::sin(0.253119975328445*x_101 + 8.18896007537842) + 0.00949951000436612*std::sin(0.248879969120026*x_108 - 7.42855978012085) + 0.0097671367067753*std::sin(0.207040011882782*x_11 - 7.38431978225708) - 0.000750179009216828*std::sin(0.210720002651215*x_110 - 7.41519975662231) + 0.0328431035635271*std::sin(0.264079958200455*x_112 + 5.17264032363892) + 0.000759189247221195*std::sin(0.258399993181229*x_113 + 5.19055986404419) + 0.00487807513859596*std::sin(0.246719971299171*x_116 + 5.17600011825562) + 0.0260968777384938*std::sin(0.25639995932579*x_116 - 7.43792009353638) - 0.00212691430303546*std::sin(0.226079985499382*x_118 + 5.1831202507019) + 0.0119182126793502*std::sin(0.267919957637787*x_120 + 5.14832019805908) - 0.00516391010391833*std::sin(0.268559962511063*x_120 + 5.15359973907471) + 0.025860711049913*std::sin(0.105360068380833*x_13 + 4.9282398223877) - 0.004888215672675*std::sin(0.302639931440353*x_14 - 7.43607997894287) + 0.000742785672766912*std::sin(0.235919982194901*x_15 - 7.38631963729858) + 0.00109662766034277*std::sin(0.232479989528656*x_16 - 1.17375981807709) + 0.000343510768951566*std::sin(0.440719872713089*x_16 - 1.24711990356445) + 0.00496523043801818*std::sin(0.251519978046417*x_17 - 1.1509598493576) - 0.0078157799426571*std::sin(0.354079842567444*x_17 + 2.00215983390808) + 0.000399899359891644*std::sin(0.451679855585098*x_17 - 7.43752002716064) + 0.000966670370879556*std::sin(0.240239977836609*x_18 - 1.16775989532471) - 0.00686989206969105*std::sin(0.356399834156036*x_18 - 1.16319990158081) + 0.00923701342349172*std::sin(0.23735998570919*x_19 + 5.01391983032227) - 0.0903927499075238*std::sin(0.372239857912064*x_2 + 5.18247985839844) + 0.000677776061203944*std::sin(0.373279839754105*x_2 - 7.41351985931396) - 0.00184110727794563*std::sin(0.420479863882065*x_2 - 7.38711977005005) - 0.0504540127799471*std::sin(0.363279849290848*x_21 - 1.17143988609314) + 0.00315303663094776*std::sin(0.390079826116562*x_21 - 4.38703966140747) + 0.0335761605319701*std::sin(0.333519846200943*x_23 + 1.99015974998474) - 0.00157576991582174*std::sin(0.399759858846664*x_23 - 1.20783984661102) - 0.0125176732614696*std::sin(0.445679873228073*x_23 - 4.4159197807312) - 0.022548303186943*std::sin(0.24551996588707*x_25 - 7.38503980636597) - 0.000521017267224909*std::sin(0.171760007739067*x_26 - 1.22095990180969) - 0.00139083875141151*std::sin(0.147600039839745*x_28 - 1.2403998374939) - 0.000417577364706245*std::sin(0.367359846830368*x_28 - 1.16967988014221) + 0.00610724253824711*std::sin(0.281919926404953*x_29 + 8.20503997802734) + 0.00231475356858265*std::sin(0.333119839429855*x_3 - 7.41143989562988) + 0.0191077605792658*std::sin(0.351279854774475*x_3 - 7.4029598236084) - 0.00867485160564523*std::sin(0.38647985458374*x_3 + 8.20024013519287) + 0.009298545788737*std::sin(0.396959841251373*x_3 + 2.00959992408752) - 0.00638028875266524*std::sin(0.265279948711395*x_30 - 1.18247985839844) - 0.0038676796577807*std::sin(0.37679985165596*x_31 - 7.4029598236084) - 0.00650283882521939*std::sin(0.378239840269089*x_31 - 7.40263986587524) - 0.0381465170385947*std::sin(0.382639855146408*x_31 + 5.18423986434937) + 0.0104149027656655*std::sin(0.389679849147797*x_31 + 5.17935991287231) + 0.0053125916578541*std::sin(0.289759933948517*x_32 + 2.03663969039917) - 0.00146983836027038*std::sin(0.293599933385849*x_32 + 2.01647973060608) - 0.000412088846477453*std::sin(0.321439832448959*x_32 + 1.98871982097626) - 0.00587665748305102*std::sin(0.243759974837303*x_33 + 1.96831977367401) + 0.000595859802815879*std::sin(0.23879998922348*x_35 + 1.9826397895813) + 0.00818291660066783*std::sin(0.212640002369881*x_38 + 1.96959984302521) + 0.000368210031851693*std::sin(0.267919957637787*x_38 + 8.17575931549072) - 0.0186787910560761*std::sin(0.213679999113083*x_4 + 8.19799995422363) - 0.00664067565243396*std::sin(0.313759922981262*x_4 + 2.00783967971802) - 0.000358844332757042*std::sin(0.765919864177704*x_4 + 7.99975967407227) + 0.00652088859195194*std::sin(0.235519990324974*x_40 - 1.19175982475281) - 0.000990561005840416*std::sin(0.183520004153252*x_48 + 2.00439977645874) - 0.0153083437793052*std::sin(0.221119984984398*x_48 + 5.18160009384155) + 0.000543302745596537*std::sin(0.477759838104248*x_49 + 1.8414398431778) + 0.100441727491383*std::sin(0.342879861593246*x_5 + 2.02063989639282) - 0.00335957166259845*std::sin(0.352879852056503*x_5 + 1.99839973449707) - 0.0172719839465586*std::sin(0.359839856624603*x_5 + 1.99495983123779) - 0.00289043213106131*std::sin(0.365119844675064*x_5 + 2.01319980621338) - 0.00553669747439155*std::sin(0.209360003471375*x_50 + 5.17960023880005) - 0.00564817236862543*std::sin(0.182720005512238*x_51 - 1.16575992107391) - 0.0246535404720323*std::sin(0.229759991168976*x_53 + 1.99935972690582) - 0.0266032128166162*std::sin(0.30839991569519*x_6 + 2.00783967971802) - 0.00461367641379892*std::sin(0.36303985118866*x_6 + 2.00039982795715) - 0.00286551405165949*std::sin(0.497679859399796*x_60 - 1.34559988975525) + 0.00476317843470613*std::sin(0.292799949645996*x_7 - 0.986879825592041) - 0.00382007116842383*std::sin(0.341839849948883*x_7 + 2.0046398639679) + 0.111046927723036*std::sin(0.358079850673676*x_7 + 2.00367975234985) - 0.00036440045284902*std::sin(0.272879958152771*x_8 + 1.97535979747772) - 0.000547304213775148*std::sin(0.362319827079773*x_9 + 8.23831939697266) - 0.000462097426205652*std::sin(0.33247983455658*x_91 + 5.20344018936157) + 0.0419082747617927*std::sin(0.345519840717316*x_91 - 7.40391969680786) - 0.00318466781303209*std::sin(0.368399828672409*x_91 + 1.98135983943939) + 0.00299703280810989*std::sin(0.368799835443497*x_91 + 2.00087976455688) + 0.00130727470436731*std::sin(0.22095999121666*x_92 - 7.40327978134155) + 0.00331646588371896*std::sin(0.293599933385849*x_92 - 1.18903994560242) - 0.00163612437898412*std::sin(0.297119915485382*x_92 + 1.99895977973938) + 0.00729930926134467*std::sin(0.278479963541031*x_94 + 1.98743987083435) - 0.00365576412883564*std::sin(0.273839950561523*x_95 + 1.95871984958649) + 0.0289089319882709*std::sin(0.292879939079285*x_97 - 1.23735988140106) - 0.071942174259936);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000927466063690651*x_10 + 3.97555743669696e-5*x_100 - 0.00164774584843728*x_101 - 0.000396307010461546*x_102 - 0.00152965472377426*x_103 + 0.00279236326482011*x_104 + 0.00038294130411636*x_105 - 0.00265193796479185*x_106 + 0.000436014722814176*x_107 + 0.000787256211814463*x_108 + 0.000603554594847937*x_109 + 0.00580821366697363*x_11 - 0.000553672497486409*x_110 - 0.00166207150531846*x_111 + 0.000996990160403242*x_112 - 0.000913154725498034*x_113 - 0.000169529590211422*x_114 - 0.00096031738787625*x_115 + 0.000337520999772898*x_116 + 0.00334719492059341*x_117 + 0.00144664202523812*x_118 - 0.00139875119317245*x_119 - 0.00159583845846882*x_12 - 0.00397734004500995*x_120 - 0.00130696744284988*x_13 - 0.00203968515572912*x_14 - 0.000338844209690693*x_15 - 0.000472610878975937*x_16 - 0.00101429152347605*x_17 - 0.00166004550589012*x_18 - 0.00278921288157679*x_19 + 0.000168774928128596*x_2 - 0.00114434149987909*x_20 - 0.000478131213030127*x_21 + 0.00638082008231373*x_22 + 5.99521670878242e-5*x_23 - 0.0012860375541371*x_24 - 0.00076808755169261*x_25 - 0.000470540684570181*x_26 + 0.000640823581162016*x_27 + 0.000682538571653289*x_28 + 0.0006346606156197*x_29 - 0.000150555009613704*x_3 + 0.013775073817078*x_30 + 0.000124830692004515*x_31 + 0.00123181205960052*x_32 - 0.00113386208852612*x_33 - 0.0021041867635988*x_34 + 0.000342228065044527*x_35 - 0.00156801614892507*x_36 + 0.00109598330019233*x_37 - 0.00440941849554594*x_38 + 0.00046569681343401*x_39 + 9.10631710328833e-5*x_4 - 0.00132067080628788*x_40 - 0.00107621510705903*x_41 + 0.000114871986083844*x_42 + 1.11248598299982e-5*x_43 + 0.00084585378597819*x_44 - 0.000268163235160695*x_45 - 0.00197421867600668*x_46 - 0.00128865854524356*x_47 - 0.000292284555346746*x_48 - 0.000586964620238226*x_49 + 0.00043687645446552*x_5 + 0.0011153703469415*x_50 + 0.00990388480655407*x_51 + 0.00627126861720772*x_52 - 0.000839769616515431*x_53 - 0.00116449095581588*x_54 - 0.000583381398336861*x_55 + 0.00110882987379301*x_56 + 0.00175405193316759*x_57 - 0.00110437597748301*x_58 - 0.000865129147206218*x_59 - 0.000468134830866841*x_6 - 0.00184467631811596*x_60 - 0.000654960711853624*x_61 - 0.000356907583732335*x_62 - 0.000289356212980461*x_63 - 0.000104386359591579*x_64 - 0.000302853430412591*x_65 - 0.00232577633587186*x_66 - 0.00210882696299119*x_67 - 0.000219078385233508*x_68 + 0.000789973246383397*x_69 - 0.000575583458830777*x_7 - 0.000161864516167331*x_70 - 0.000994269389949196*x_71 - 0.00254142829649319*x_72 - 0.000427671250403564*x_73 - 0.00114586143099435*x_74 - 0.00181728427087949*x_75 - 0.000478127493660483*x_76 - 0.00091818784922898*x_77 - 0.000642827992214874*x_78 + 0.000245032895167075*x_79 - 0.00160235260813192*x_8 - 3.36015668568629e-5*x_80 + 0.000192337230830925*x_81 - 0.000379603997107669*x_82 - 0.00123115157856375*x_83 + 0.00139450137352873*x_84 - 0.000767847153636366*x_85 - 0.000723845307128907*x_86 - 0.000595221382577522*x_87 + 0.00011451349582206*x_88 - 0.00181677241607876*x_89 - 0.00196377974441592*x_9 - 0.00123793571874213*x_90 - 0.000108502401766829*x_91 + 0.00161517017752394*x_92 + 0.00240525721781612*x_93 - 0.00291630716579583*x_94 + 0.000804390216562955*x_95 - 0.00262915048643935*x_96 + 0.000725609523247479*x_97 - 0.0027727366367094*x_98 + 0.00244113976353746*x_99 + 3.36482993248086e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.0272594167041109*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.017426626650897*std::sin(0.328319847583771*x_1 - 4.26039981842041) + 0.0105773303978841*std::sin(0.332399845123291*x_1 - 4.25383996963501) - 0.00885127613281979*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.00830108562200684*std::sin(0.353999853134155*x_1 + 8.35127925872803) - 0.000609521058311715*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.00211753680708011*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.00519914078419109*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.00534561453944737*std::sin(0.207040011882782*x_11 - 7.38431978225708) + 0.000613526467877438*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.0225989271400512*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 0.000620895401731406*std::sin(0.258399993181229*x_113 + 5.19055986404419) + 0.00231915517708972*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.014282983156804*std::sin(0.25639995932579*x_116 - 7.43792009353638) + 0.00173947578349553*std::sin(0.226079985499382*x_118 + 5.1831202507019) + 0.00566620723372599*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.0427478755574454*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.0141537276623728*std::sin(0.105360068380833*x_13 + 4.9282398223877) - 0.00232397623282168*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.00614892762776793*std::sin(0.235919982194901*x_15 - 7.38631963729858) - 0.000896866063646861*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.00284365051061629*std::sin(0.440719872713089*x_16 - 1.24711990356445) + 0.00236059091928783*std::sin(0.251519978046417*x_17 - 1.1509598493576) + 0.00639205816613266*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.00331044648882998*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.00800228971609582*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.00375993456779406*std::sin(0.356399834156036*x_18 - 1.16319990158081) + 0.00439150010881217*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.0621981161188905*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.0056107651250894*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.00100764944006992*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.0347167726256985*std::sin(0.363279849290848*x_21 - 1.17143988609314) + 0.00149903005149706*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.0183764410499151*std::sin(0.333519846200943*x_23 + 1.99015974998474) - 0.000749159218410907*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.00861325378254052*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.0155152042762303*std::sin(0.24551996588707*x_25 - 7.38503980636597) + 0.000426108808346117*std::sin(0.171760007739067*x_26 - 1.22095990180969) + 0.00113748368863508*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.00345678853094746*std::sin(0.367359846830368*x_28 - 1.16967988014221) + 0.00290353115683967*std::sin(0.281919926404953*x_29 + 8.20503997802734) - 0.00189309826520183*std::sin(0.333119839429855*x_3 - 7.41143989562988) + 0.00908429259717184*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.00596905645678509*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.00508915182169091*std::sin(0.396959841251373*x_3 + 2.00959992408752) - 0.00303334394646694*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.0320174219495839*std::sin(0.37679985165596*x_31 - 7.4029598236084) + 0.00531828228542178*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.0262481393554801*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.00570014092384434*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.0029076143869955*std::sin(0.289759933948517*x_32 + 2.03663969039917) + 0.00120209273579768*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.00341135348472907*std::sin(0.321439832448959*x_32 + 1.98871982097626) - 0.00279390543166656*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.00493264603524555*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.00447856104289721*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.00304811592453085*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.0128526415697595*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.00543101076849767*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 0.000196397730488781*std::sin(0.765919864177704*x_4 + 7.99975967407227) + 0.00310018851854001*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.00820006114699665*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.00837835156179875*std::sin(0.221119984984398*x_48 + 5.18160009384155) - 0.000444334765967323*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.069112691405918*std::sin(0.342879861593246*x_5 + 2.02063989639282) - 0.00159722181244664*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.0094530640126884*std::sin(0.359839856624603*x_5 + 1.99495983123779) + 0.0023639112721387*std::sin(0.365119844675064*x_5 + 2.01319980621338) - 0.00263228020210664*std::sin(0.209360003471375*x_50 + 5.17960023880005) - 0.00268527806924332*std::sin(0.182720005512238*x_51 - 1.16575992107391) - 0.0117208908011535*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.0145601034876339*std::sin(0.30839991569519*x_6 + 2.00783967971802) + 0.00377324953019226*std::sin(0.36303985118866*x_6 + 2.00039982795715) - 0.00136233484706884*std::sin(0.497679859399796*x_60 - 1.34559988975525) + 0.00226453049868976*std::sin(0.292799949645996*x_7 - 0.986879825592041) + 0.00312420734545785*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.076409996512215*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.00301657947136739*std::sin(0.272879958152771*x_8 + 1.97535979747772) + 0.000447607327059788*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.00382533446038616*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.0288365576071426*std::sin(0.345519840717316*x_91 - 7.40391969680786) - 0.00151406828227541*std::sin(0.368399828672409*x_91 + 1.98135983943939) - 0.00245109357937393*std::sin(0.368799835443497*x_91 + 2.00087976455688) + 0.000621510085919776*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.00181512236183725*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0135441632293802*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.00399495726196808*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.00200082239724748*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.0198918730818468*std::sin(0.292879939079285*x_97 - 1.23735988140106) + 0.265343741577081);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0005149881594834*x_10 - 0.00218219594818224*x_100 - 0.00197363473697051*x_101 - 0.00110332590846927*x_102 - 0.0020604675162267*x_103 + 0.00241627165122226*x_104 - 0.00128453913819916*x_105 - 0.00263918196969262*x_106 + 0.00124071880680485*x_107 + 0.00269496477067316*x_108 + 0.00334065472594198*x_109 + 0.00771739114388365*x_11 - 0.000732740994396045*x_110 - 0.00156310142548706*x_111 - 0.0040633450713949*x_112 - 0.00772846410487716*x_113 - 0.00616397877970119*x_114 - 0.00015911152012539*x_115 - 0.000951115341689678*x_116 - 0.00593382802446936*x_117 - 0.00680109972057867*x_118 - 0.00466514602896516*x_119 + 0.00105285153588538*x_12 - 0.00534256469143131*x_120 + 0.00308571883687598*x_13 + 0.00104376509612374*x_14 + 1.07536064781725e-5*x_15 - 0.000788032982178013*x_16 - 0.00124604031162196*x_17 - 0.00203502217992259*x_18 - 0.00208363109544711*x_19 - 0.000303577612905682*x_2 - 0.000126778637390815*x_20 + 0.000151026965871365*x_21 + 0.00927660990608311*x_22 - 0.000137873863311906*x_23 + 0.00032709787822281*x_24 + 0.00182664176965287*x_25 + 0.00222825870854572*x_26 - 0.000625154091683489*x_27 + 0.00201055684749007*x_28 + 9.3914921889649e-5*x_29 + 0.000353426718120469*x_3 + 0.0156379908247815*x_30 - 0.00042297163961704*x_31 + 0.00181538021136388*x_32 + 0.00132557293485571*x_33 - 0.00150057229628625*x_34 + 0.000255960123407286*x_35 - 0.00387583076901491*x_36 - 0.00134075314259721*x_37 - 0.00524249434153079*x_38 + 0.00134138677696921*x_39 - 0.000135647253239934*x_4 - 0.00142994831595397*x_40 - 0.00247452887823041*x_41 - 0.000154734291940616*x_42 - 0.000333320657672225*x_43 + 0.00185005992126735*x_44 - 0.0017264636233794*x_45 - 0.00173923007136101*x_46 - 0.00289205647063453*x_47 + 0.000804601246024224*x_48 + 0.000999707259988438*x_49 - 0.00102556409064053*x_5 + 0.00103287061203149*x_50 + 0.0131454576114692*x_51 + 0.00591795636550128*x_52 - 0.000975721552639555*x_53 - 0.00264955272634155*x_54 + 0.00102154190145312*x_55 + 0.0021195921903403*x_56 + 0.00304502612524776*x_57 - 0.000967773625287568*x_58 + 0.00207177314513612*x_59 - 0.00607798951409704*x_6 - 0.00629708789752825*x_60 + 0.000911240629717923*x_61 + 0.0027530337509051*x_62 + 0.000400264313534057*x_63 + 0.000325386152419125*x_64 + 0.000948599663975219*x_65 - 0.000769082506902339*x_66 + 0.000140286768414898*x_67 + 0.00309965130292594*x_68 + 0.00137626659648738*x_69 + 0.000485289850759296*x_7 + 0.00112352624641747*x_70 - 8.92799099466532e-5*x_71 - 0.00186135437766532*x_72 - 0.00111164144913734*x_73 - 0.0010107546359912*x_74 + 0.000376697720079516*x_75 + 0.00138154122599162*x_76 + 4.65399706483347e-5*x_77 - 0.0011644506835955*x_78 - 0.000827662462434495*x_79 - 0.00282892568642356*x_8 - 0.000617089572300069*x_80 - 0.000330909700153939*x_81 + 0.000578031080545989*x_82 + 8.35085425322443e-5*x_83 + 0.00157746773751176*x_84 + 0.00211980916875276*x_85 - 0.000723537877175697*x_86 + 0.000847531292345453*x_87 + 0.00120532137873143*x_88 - 0.000253245993311694*x_89 - 0.00100274327250423*x_9 - 0.000391700510223735*x_90 - 1.08665459986178e-5*x_91 + 0.00220000490210451*x_92 + 0.00273907226719729*x_93 - 0.00380231829275256*x_94 - 0.000890222678703532*x_95 - 0.00487186590767875*x_96 - 0.00199937440801222*x_97 - 0.00353131127125549*x_98 + 0.00514793410966634*x_99 - 7.89891218579539e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.0365782584739704*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.00174528155155184*std::sin(0.328319847583771*x_1 - 4.26039981842041) + 0.0109432411979935*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.0299913324077909*std::sin(0.340559840202332*x_1 - 4.24952030181885) + 0.0194867341561768*std::sin(0.353999853134155*x_1 + 8.35127925872803) - 0.000630606750990368*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.000212071905720128*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.000520695409177335*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.000535364796888246*std::sin(0.207040011882782*x_11 - 7.38431978225708) + 0.000634750723176698*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.0303245446201553*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 0.000642374576975589*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.00785813850767175*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.0014304447730515*std::sin(0.25639995932579*x_116 - 7.43792009353638) + 0.00179965098383125*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.0191991642886378*std::sin(0.267919957637787*x_120 + 5.14832019805908) - 0.100350306533506*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.00141749979899619*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.00787447399227804*std::sin(0.302639931440353*x_14 - 7.43607997894287) + 0.0144345599460178*std::sin(0.235919982194901*x_15 - 7.38631963729858) - 0.000927892132285658*std::sin(0.232479989528656*x_16 - 1.17375981807709) + 0.00667544753261554*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.00799853782401654*std::sin(0.251519978046417*x_17 - 1.1509598493576) + 0.0066131841998229*std::sin(0.354079842567444*x_17 + 2.00215983390808) + 0.00777124747334952*std::sin(0.451679855585098*x_17 - 7.43752002716064) + 0.0187853130830094*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.000376558502553059*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.0148799944274563*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.083461021660368*std::sin(0.372239857912064*x_2 + 5.18247985839844) + 0.0131712276422626*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.00010091637431706*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.046584969013418*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.00507925726065828*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.00184040573027057*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.00253842302607777*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.0115577609961169*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.0208191964799752*std::sin(0.24551996588707*x_25 - 7.38503980636597) + 0.000440849561365118*std::sin(0.171760007739067*x_26 - 1.22095990180969) + 0.00117683365228027*std::sin(0.147600039839745*x_28 - 1.2403998374939) - 0.0081147842829272*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.00983821618198851*std::sin(0.281919926404953*x_29 + 8.20503997802734) - 0.00195858786180593*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.0307808766649131*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.00800962442784331*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.000509679983703925*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.0102780689745207*std::sin(0.265279948711395*x_30 - 1.18247985839844) - 0.0751606498604993*std::sin(0.37679985165596*x_31 - 7.4029598236084) + 0.00550226225513659*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.0352212681667819*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.000570870713817645*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.000291198397160173*std::sin(0.289759933948517*x_32 + 2.03663969039917) + 0.00124367777646629*std::sin(0.293599933385849*x_32 + 2.01647973060608) - 0.0080081258640953*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.00946676448228149*std::sin(0.243759974837303*x_33 + 1.96831977367401) + 0.0115793483349364*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.00044852914578651*std::sin(0.212640002369881*x_38 + 1.96959984302521) + 0.00715542850697424*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.0172464161839919*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.00561889045277994*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 1.96692878464276e-5*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.0105045626179928*std::sin(0.235519990324974*x_40 - 1.19175982475281) - 0.0192495799841283*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.000839094261107052*std::sin(0.221119984984398*x_48 + 5.18160009384155) - 0.00045970602540761*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.0927393978205035*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.00541196654439938*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.000946727014785414*std::sin(0.359839856624603*x_5 + 1.99495983123779) + 0.00244568811302748*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.00891911961023381*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.00909869559750939*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.0397146272309127*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.00145819845198468*std::sin(0.30839991569519*x_6 + 2.00783967971802) + 0.00390378083654922*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.00461608435168572*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.0076730502940652*std::sin(0.292799949645996*x_7 - 0.986879825592041) + 0.00323228577039887*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.102531342939465*std::sin(0.358079850673676*x_7 + 2.00367975234985) - 0.00708139692761119*std::sin(0.272879958152771*x_8 + 1.97535979747772) + 0.000463091797055358*std::sin(0.362319827079773*x_9 + 8.23831939697266) - 0.00897994299569526*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.0386945571544284*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.00513021223837345*std::sin(0.368399828672409*x_91 + 1.98135983943939) - 0.00253588639372632*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.00210590148831754*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.000181785014127257*std::sin(0.293599933385849*x_92 - 1.18903994560242) - 0.0317948182005368*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.000400096091356387*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.000200382924808227*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.0266920632608208*std::sin(0.292879939079285*x_97 - 1.23735988140106) + 0.131466149320784);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00137348173250653*x_10 - 0.00221743958221805*x_100 + 0.000166498200066267*x_101 - 0.000747548195676099*x_102 - 0.000613032609266419*x_103 - 0.000816833479923949*x_104 - 0.00204317281770937*x_105 - 0.000549844292235394*x_106 + 0.000376761372858718*x_107 + 0.00293218907290797*x_108 + 0.00307409045481673*x_109 + 0.00241243716215593*x_11 - 0.000662048511786859*x_110 - 0.00033212839186489*x_111 - 0.00577723805899711*x_112 - 0.00994521353081489*x_113 - 0.00980202967864329*x_114 + 0.000504821696712664*x_115 - 0.00210959472021138*x_116 - 0.0142478159366488*x_117 - 0.0140945619785551*x_118 - 0.00396700950880886*x_119 + 0.000972392535889962*x_12 - 0.00197242376498551*x_120 + 0.00462086119208537*x_13 + 0.00439771619621589*x_14 + 0.000235867903202007*x_15 - 0.000364413923123427*x_16 - 0.000522933471847722*x_17 - 0.000824654361922528*x_18 + 0.000816320022095121*x_19 - 0.000243942934515072*x_2 + 0.000280537259906058*x_20 + 0.000355919528175425*x_21 + 0.00378496289816544*x_22 - 0.000299097785086665*x_23 + 0.00190435746648423*x_24 + 0.00236509928865878*x_25 + 0.00288753186085022*x_26 - 0.00131360456863785*x_27 + 0.00115053076991809*x_28 - 0.000875955781576864*x_29 + 0.000765079809469476*x_3 + 0.00298270668207975*x_30 - 0.000385935035817024*x_31 + 0.000802935724982281*x_32 + 0.00332755301622826*x_33 + 0.00101543439699571*x_34 - 3.6588657357732e-5*x_35 - 0.00311837419415499*x_36 - 0.00327747250998732*x_37 - 0.00181031259676896*x_38 + 0.00176905043027193*x_39 - 0.000612123057670944*x_4 - 0.000761731893202407*x_40 - 0.00154850356631565*x_41 - 0.000837109278189344*x_42 - 0.000709748637741675*x_43 + 0.000900308811380535*x_44 - 0.0016222097088308*x_45 - 0.000456278969046067*x_46 - 0.00325481972499467*x_47 + 0.000757966080512116*x_48 + 0.00175948602780789*x_49 - 0.00222008789612376*x_5 - 0.000191875987114765*x_50 + 0.00509858978591224*x_51 + 0.00136726640045998*x_52 - 0.000379308643878584*x_53 - 0.00169153517056455*x_54 + 0.00167032280498757*x_55 + 0.00168721655910313*x_56 + 0.00140156246099334*x_57 - 0.00105245083255822*x_58 + 0.0034984944269219*x_59 - 0.00491658012883395*x_6 - 0.00647175470809816*x_60 + 0.00149287083381686*x_61 + 0.00411532898963992*x_62 + 0.000542895816992837*x_63 - 0.000400195037699011*x_64 + 0.00123099974188902*x_65 + 0.00138897897349635*x_66 + 0.00249485437511729*x_67 + 0.00465273255240646*x_68 + 0.000844101375882851*x_69 + 0.00106708294197837*x_7 + 0.00163885042042587*x_70 + 0.00147941625247514*x_71 + 0.000951169790578016*x_72 - 0.00128416297029744*x_73 + 0.000367049758773665*x_74 + 0.00330984251099861*x_75 + 0.00211160681142454*x_76 + 0.001170967756232*x_77 - 0.000915885453597771*x_78 - 0.00133330699497213*x_79 - 0.0015041210071755*x_8 - 0.000976685272863628*x_80 - 0.000584969100934531*x_81 + 0.00131486309926687*x_82 + 0.00108851948419111*x_83 + 0.000238925251303423*x_84 + 0.00411238546237425*x_85 - 0.000451969994097928*x_86 + 0.00138415606086703*x_87 + 0.00138479615847684*x_88 + 0.0021900380860748*x_89 + 0.000422354314632216*x_9 + 0.000984220125788073*x_90 - 1.84464916041354e-5*x_91 + 0.000788989221633185*x_92 + 0.000647113602264611*x_93 - 0.00177866981487148*x_94 - 0.00215149050453587*x_95 - 0.00320090789264612*x_96 - 0.00338881545583796*x_97 - 0.000526378688762819*x_98 + 0.0046699412367283*x_99 - 1.70991549882331e-5*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.0150004880412425*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.00296270052062985*std::sin(0.328319847583771*x_1 - 4.26039981842041) + 0.0157484944857613*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.0273652057558299*std::sin(0.340559840202332*x_1 - 4.24952030181885) + 0.0421838703499157*std::sin(0.353999853134155*x_1 + 8.35127925872803) - 0.000907510559346583*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.000360002398999361*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.000883905842290939*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.000908807843099803*std::sin(0.207040011882782*x_11 - 7.38431978225708) + 0.000913474178528944*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.0124358837164012*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 0.00092444571953218*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.00717005747515193*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.00242824974003975*std::sin(0.25639995932579*x_116 - 7.43792009353638) + 0.00258989024205717*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.017518030674825*std::sin(0.267919957637787*x_120 + 5.14832019805908) - 0.217233133395106*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.00240627501548078*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.00718496257810949*std::sin(0.302639931440353*x_14 - 7.43607997894287) + 0.0312471859286845*std::sin(0.235919982194901*x_15 - 7.38631963729858) - 0.00133533601830519*std::sin(0.232479989528656*x_16 - 1.17375981807709) + 0.0144506622293228*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.00729816302669972*std::sin(0.251519978046417*x_17 - 1.1509598493576) + 0.00951707935701267*std::sin(0.354079842567444*x_17 + 2.00215983390808) + 0.016822793047083*std::sin(0.451679855585098*x_17 - 7.43752002716064) + 0.0406654704285101*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.000639226416259067*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.0135770596523137*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.0342267814148981*std::sin(0.372239857912064*x_2 + 5.18247985839844) + 0.0285123897497374*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.000171310465330585*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.0191041700655241*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.00463450300022682*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.00312417845154816*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.00231615146201073*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.0047397569714579*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.00853780690648192*std::sin(0.24551996588707*x_25 - 7.38503980636597) + 0.000634429668559423*std::sin(0.171760007739067*x_26 - 1.22095990180969) + 0.00169358949037807*std::sin(0.147600039839745*x_28 - 1.2403998374939) - 0.0175664636960232*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.00897675389775327*std::sin(0.281919926404953*x_29 + 8.20503997802734) - 0.00281861740808429*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.0280856152646742*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.0032846909737435*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.000865206620520095*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.00937809192456236*std::sin(0.265279948711395*x_30 - 1.18247985839844) - 0.162703872476534*std::sin(0.37679985165596*x_31 - 7.4029598236084) + 0.00791834386325316*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.0144439958044798*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.000969080868090319*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.000494323475834551*std::sin(0.289759933948517*x_32 + 2.03663969039917) + 0.00178978533419646*std::sin(0.293599933385849*x_32 + 2.01647973060608) - 0.0173355750886418*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.00863782756888517*std::sin(0.243759974837303*x_33 + 1.96831977367401) + 0.0250663720756226*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.000761400091897945*std::sin(0.212640002369881*x_38 + 1.96959984302521) + 0.0154897001219989*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.00707263468834524*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.0080861843132843*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 3.33895750466246e-5*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.00958475313826661*std::sin(0.235519990324974*x_40 - 1.19175982475281) - 0.0416704913113114*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.00142440341618746*std::sin(0.221119984984398*x_48 + 5.18160009384155) - 0.000661566137053656*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.0380317786028125*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.00493807930963029*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.00160711526292426*std::sin(0.359839856624603*x_5 + 1.99495983123779) + 0.00351960676595224*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.00813813604464943*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.00830198784602275*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.0362371011368502*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.00247536296309057*std::sin(0.30839991569519*x_6 + 2.00783967971802) + 0.0056179581410751*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.0042118868329215*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.00700117611371544*std::sin(0.292799949645996*x_7 - 0.986879825592041) + 0.00465160492312503*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.0420473868298145*std::sin(0.358079850673676*x_7 + 2.00367975234985) - 0.0153294404027139*std::sin(0.272879958152771*x_8 + 1.97535979747772) + 0.000666438624569912*std::sin(0.362319827079773*x_9 + 8.23831939697266) - 0.019439314358377*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.015868367332721*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.00468099621468291*std::sin(0.368399828672409*x_91 + 1.98135983943939) - 0.00364941173876698*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.00192150274438449*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.000308588923958229*std::sin(0.293599933385849*x_92 - 1.18903994560242) - 0.0688277716533354*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.000679182620769443*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.000340159784034155*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.0109462285096202*std::sin(0.292879939079285*x_97 - 1.23735988140106) - 0.108861409742557);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00059715319220793*x_10 - 0.000928448364751486*x_100 - 0.00112193482787351*x_101 - 8.1823828598791e-5*x_102 - 0.000688118638400866*x_103 + 0.00124020280193782*x_104 + 0.000742962273025241*x_105 - 0.000516151392011789*x_106 + 0.000198990710468163*x_107 - 0.000780369700196286*x_108 - 0.000380684376928535*x_109 + 0.00179289462341895*x_11 + 0.000191183139145958*x_110 - 0.000566524028281145*x_111 + 0.000588915394511909*x_112 + 0.000920620542104215*x_113 - 0.000437938470326181*x_114 + 1.18265074099474e-5*x_115 + 0.000923344290697318*x_116 + 0.0036308396062797*x_117 + 0.00474223642512272*x_118 - 0.00159421001101847*x_119 - 0.000668995494127304*x_12 - 0.000941726620605658*x_120 - 0.000895822875376481*x_13 - 0.00263627179140895*x_14 + 8.45325794746471e-5*x_15 - 7.19579522492744e-5*x_16 - 0.00032813597312798*x_17 - 0.000240578990724665*x_18 - 0.00150036367070328*x_19 - 0.000101225316703932*x_2 - 0.0002421929680314*x_20 - 0.000829193379737896*x_21 + 0.00139547760388779*x_22 + 0.000130535956124068*x_23 - 0.000552795850631006*x_24 - 0.000580685268038696*x_25 - 0.00110933295664855*x_26 + 0.00055137009304927*x_27 + 0.000117849660444553*x_28 + 0.000476288804552725*x_29 - 0.000333505182727739*x_3 + 0.00420759566460564*x_30 - 8.43687558700716e-5*x_31 + 0.000256231426752981*x_32 - 0.00194835964972345*x_33 - 0.00111943522263821*x_34 - 0.000259467363406113*x_35 - 0.00023439672429593*x_36 + 0.00148902521949536*x_37 - 0.000737771449881205*x_38 - 0.000518408427245932*x_39 + 0.000418708217099678*x_4 - 0.000650727948893657*x_40 - 0.000413553316041433*x_41 - 1.22617654066979e-5*x_42 - 0.000383579152592643*x_43 - 0.000204701046099321*x_44 + 4.35743125140013e-5*x_45 - 0.000250931789040383*x_46 + 0.000965989049361201*x_47 + 0.000165112822142567*x_48 - 0.000333927756092467*x_49 + 0.000967756318104661*x_5 + 0.000290598584782903*x_50 + 0.00176858214214395*x_51 + 0.000961159095864589*x_52 - 0.000224070610180589*x_53 - 0.000144468187956277*x_54 - 0.000133518882383795*x_55 - 0.000819041115755577*x_56 + 3.07498732482475e-6*x_57 + 0.000340664224242102*x_58 - 0.000718580517892825*x_59 - 0.000628763081770279*x_6 + 0.00178448606647826*x_60 - 0.000158041225268405*x_61 - 0.00152942851245806*x_62 - 0.000147377459698888*x_63 + 0.00125937246660743*x_64 - 0.000553346038032789*x_65 - 0.00135722188652426*x_66 - 0.00157157724002331*x_67 - 0.00172516823757772*x_68 + 0.000128946227443745*x_69 - 0.00109687960708115*x_7 - 0.000621900957129585*x_70 - 0.000994601507998387*x_71 - 0.00135393075849679*x_72 + 1.70485887978189e-5*x_73 - 0.000719695308472544*x_74 - 0.00171893738519873*x_75 - 0.000516059040386345*x_76 - 0.000366938169907598*x_77 - 0.000218079385905302*x_78 + 0.000973284959618392*x_79 - 0.000488833582065204*x_8 + 0.000437006794096684*x_80 + 0.000201187154633028*x_81 - 0.000271140376860611*x_82 - 0.000536422693718298*x_83 + 0.000537378390104937*x_84 - 0.00143202154022194*x_85 + 0.000141131941408369*x_86 - 0.000446176062460048*x_87 - 0.00027910006068741*x_88 - 0.00107216250128069*x_89 - 0.00142545367151236*x_9 - 0.000668252750008631*x_90 - 0.000185715467184257*x_91 + 0.00036617865165019*x_92 + 4.11734822668361e-5*x_93 - 0.000250278211353931*x_94 + 0.000799538693777267*x_95 - 0.00085344394339355*x_96 + 0.00102243965203073*x_97 - 0.000878272187188858*x_98 - 0.00118616490253835*x_99 + 7.4536757319409e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.00501670468343415*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.0298278568696752*std::sin(0.328319847583771*x_1 - 4.26039981842041) - 0.00490923456700308*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.00598227201337197*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.0183883291848563*std::sin(0.353999853134155*x_1 + 8.35127925872803) + 0.000282895753107869*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.00362442979144237*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.0088989814416068*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.00914968964202167*std::sin(0.207040011882782*x_11 - 7.38431978225708) - 0.000284754775597984*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.00415900842100502*std::sin(0.264079958200455*x_112 + 5.17264032363892) + 0.000288174903686741*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.00156743693252633*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.0244471168062352*std::sin(0.25639995932579*x_116 - 7.43792009353638) - 0.000807339311865431*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.00382959388540578*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.0946938802341308*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.0242258798184494*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.00157069531768429*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.0136209299002411*std::sin(0.235919982194901*x_15 - 7.38631963729858) + 0.00041626059846896*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.00629917387398971*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.00159544192041569*std::sin(0.251519978046417*x_17 - 1.1509598493576) - 0.00296673278824211*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.00733320707162408*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.0177264449775169*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.0064355995210199*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.00296806333950602*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.0114466712116904*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.0124288076038557*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.00172471837925483*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.00638912408565202*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.00101314266888853*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.0314535833234643*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.000506330856546382*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.00158514582536763*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.00285535082433602*std::sin(0.24551996588707*x_25 - 7.38503980636597) - 0.000197769003382527*std::sin(0.171760007739067*x_26 - 1.22095990180969) - 0.00052793796105363*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.00765737980836906*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.00196239648598354*std::sin(0.281919926404953*x_29 + 8.20503997802734) + 0.000878639797819071*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.00613975979845863*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.00109851923126149*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.00871072153930777*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.00205013246966678*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.0709240840617977*std::sin(0.37679985165596*x_31 - 7.4029598236084) - 0.00246836340083463*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.00483059359139592*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.00975650600769918*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.00497674664781127*std::sin(0.289759933948517*x_32 + 2.03663969039917) - 0.000557924825010834*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.00755673338398113*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.00188830424235586*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.010926657449239*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.00766561885129761*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.00675209985369668*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.00236534434530982*std::sin(0.213679999113083*x_4 + 8.19799995422363) - 0.00252068383945048*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 0.000336159344657038*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.00209531040861683*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.0181645426361078*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.0143405993710372*std::sin(0.221119984984398*x_48 + 5.18160009384155) + 0.000206228179545603*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.0127191996228049*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.00107950709077051*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.0161801045032335*std::sin(0.359839856624603*x_5 + 1.99495983123779) - 0.00109715726879752*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.00177906732861119*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.00181488675764974*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.00792174551549006*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.0249214430042575*std::sin(0.30839991569519*x_6 + 2.00783967971802) - 0.0017512705311024*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.000920755098605765*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.00153051799790855*std::sin(0.292799949645996*x_7 - 0.986879825592041) - 0.00145003191900621*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.0140621639679549*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.00668224119803421*std::sin(0.272879958152771*x_8 + 1.97535979747772) - 0.000207747066583581*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.00847377228747942*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.00530695484691185*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.001023306489988*std::sin(0.368399828672409*x_91 + 1.98135983943939) + 0.00113762101344862*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.000420057214037205*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.00310680954463677*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0300026458388777*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.00683787033472252*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.00342465844264049*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.00366081394679766*std::sin(0.292879939079285*x_97 - 1.23735988140106) + 0.150527242216578);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000150226585948873*x_10 - 0.00283150312829895*x_100 - 0.000618373005883265*x_101 - 0.000162488014329398*x_102 - 0.000467382674512673*x_103 - 0.000327234498187559*x_104 - 0.00011419008921906*x_105 + 0.000326723864812283*x_106 - 0.000113107391221472*x_107 - 0.000122302120721143*x_108 + 0.000169917536084639*x_109 + 0.0005614867675495*x_11 + 0.000185502208403552*x_110 - 0.000440055168750198*x_111 - 0.00254617533310268*x_112 - 0.0040614055736572*x_113 - 0.00788426835492583*x_114 + 0.000767983866900916*x_115 + 0.000251015713194609*x_116 - 0.00525625704576361*x_117 - 0.00178077182463228*x_118 - 0.00460082561576998*x_119 - 0.000958022411396175*x_12 - 0.00043962998138396*x_120 + 0.00133950072326689*x_13 - 0.000987970580338465*x_14 + 0.000423019404251724*x_15 + 1.87570982743144e-5*x_16 - 0.000331536874513375*x_17 + 0.0001633060753243*x_18 - 0.000470504797093534*x_19 - 0.000363217144386386*x_2 - 4.71533404199122e-5*x_20 - 0.00135171142202281*x_21 + 0.000535536525275444*x_22 + 1.61524485711528e-5*x_23 + 0.000873022168348687*x_24 + 0.000278005410003936*x_25 - 0.000491852856707846*x_26 + 3.74327559957188e-5*x_27 + 0.00010813610954031*x_28 - 0.000152743267396903*x_29 - 4.38890141555328e-5*x_3 + 0.00034127118535433*x_30 - 0.000330220083021104*x_31 + 9.08567268125995e-5*x_32 - 0.000997286302803536*x_33 + 6.85247655027326e-5*x_34 - 0.000803335108338719*x_35 - 0.00139519590563978*x_36 + 0.000101978074277176*x_37 + 0.000286269927053497*x_38 + 4.65358607760679e-5*x_39 + 0.00024697306771716*x_4 - 0.00104979021939484*x_40 - 0.000858969592302527*x_41 - 0.000854041263288551*x_42 - 0.00132320672660389*x_43 - 0.000784184055663582*x_44 - 0.000633417818917561*x_45 + 0.000358274690366543*x_46 + 0.000481536206401912*x_47 + 0.000671792217308957*x_48 + 0.000677389022865133*x_49 + 0.000127355954102446*x_5 - 0.000514916161666676*x_50 - 0.000461018432677558*x_51 - 0.0010928766559478*x_52 - 7.99556487526245e-5*x_53 - 0.000286820438481377*x_54 + 0.000943367090158944*x_55 - 0.00117052115766013*x_56 - 0.00054567001440215*x_57 + 0.000119485133462195*x_58 + 0.00109058589781336*x_59 - 0.00265722906291339*x_6 + 0.00063079016091075*x_60 + 0.000907941431840838*x_61 - 0.000202923296199902*x_62 + 0.000192583938606865*x_63 + 0.00193173415720206*x_64 - 0.000254476801672249*x_65 - 0.000470321773756183*x_66 - 0.000206176142481605*x_67 - 0.000324435417518775*x_68 + 0.000271776959062037*x_69 - 0.00133111167435388*x_7 - 2.61754989748742e-5*x_70 - 7.32216580043084e-5*x_71 - 5.62939281999899e-5*x_72 - 0.000462069820908048*x_73 - 0.000165686153253588*x_74 + 0.000226813567638849*x_75 + 0.000487905224272843*x_76 + 0.000711692204714517*x_77 - 0.000600373627464283*x_78 + 0.00108776946041447*x_79 - 0.000570762603747312*x_8 + 0.000250473166898088*x_80 + 7.64520964676664e-5*x_81 + 0.000643664202056672*x_82 + 0.000246828332407148*x_83 + 0.000308919112130465*x_84 + 0.000448998788533009*x_85 + 0.00034990033304702*x_86 + 7.13402871831115e-7*x_87 + 0.000219286441990188*x_88 + 0.000592007269739078*x_89 - 0.00160727397511574*x_9 + 0.000122859649329774*x_90 - 0.000388430267190681*x_91 + 0.000135369500323947*x_92 - 0.00130032171785966*x_93 + 0.0002776959782512*x_94 - 0.000185657615645061*x_95 - 0.0019396439271513*x_96 - 0.000422372751095328*x_97 + 0.000159046528903879*x_98 - 0.000868433294937315*x_99 + 9.8089773908241e-7*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) - 0.0623859853423961*std::sin(0.328319847583771*x_1 - 4.26039981842041) - 0.0134640233707035*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.0234146674386517*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.00241988935011423*std::sin(0.353999853134155*x_1 + 8.35127925872803) + 0.00077586739426108*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.00758061917862252*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.0186125248020336*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.0191368895991639*std::sin(0.207040011882782*x_11 - 7.38431978225708) - 0.000780965932925705*std::sin(0.210720002651215*x_110 - 7.41519975662231) + 0.000790345946019258*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.00613496250657405*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.0511319830117665*std::sin(0.25639995932579*x_116 - 7.43792009353638) - 0.00221420166722235*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.0149890655342046*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.012461638574987*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.0506692582663212*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.00614771585591862*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.00179250343372094*std::sin(0.235919982194901*x_15 - 7.38631963729858) + 0.00114163264142224*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.000828966221941419*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.00624457428560837*std::sin(0.251519978046417*x_17 - 1.1509598493576) - 0.00813653514623332*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.000965044160152396*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.00233278592009359*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.0134602770538322*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.0116170270887122*std::sin(0.23735998570919*x_19 + 5.01391983032227) - 0.001635621097101*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.00360730762515304*std::sin(0.420479863882065*x_2 - 7.38711977005005) - 0.00396544968314832*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.0657862479613289*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.00198178360887984*std::sin(0.399759858846664*x_23 - 1.20783984661102) - 0.000542399522206698*std::sin(0.171760007739067*x_26 - 1.22095990180969) - 0.00144791798983989*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.00100770503191298*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.007680837815361*std::sin(0.281919926404953*x_29 + 8.20503997802734) + 0.00240974975035425*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.0240310760715609*std::sin(0.351279854774475*x_3 - 7.4029598236084) - 0.01821877276156*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.00802423725887579*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.00933355249203908*std::sin(0.37679985165596*x_31 - 7.4029598236084) - 0.00676971166535945*std::sin(0.378239840269089*x_31 - 7.40263986587524) - 0.0204060668337232*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.0104090362502317*std::sin(0.289759933948517*x_32 + 2.03663969039917) - 0.00153015969811915*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.000994460043308796*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.00739084009535633*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.00143793934337087*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.0160329046564402*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.000888570917053447*std::sin(0.267919957637787*x_38 + 8.17575931549072) - 0.00691320523827284*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 0.000703088795152578*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.00820106412561046*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.00239043922005776*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.0299938552766846*std::sin(0.221119984984398*x_48 + 5.18160009384155) + 0.000565599584049756*std::sin(0.477759838104248*x_49 + 1.8414398431778) + 0.00422520063807843*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.0338412433312764*std::sin(0.359839856624603*x_5 + 1.99495983123779) - 0.00300905383656274*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.00696328581470194*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.00710348338794924*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.0310057844852627*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.0521240525180211*std::sin(0.30839991569519*x_6 + 2.00783967971802) - 0.00480301909337797*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.00360384388708946*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.0059904614584217*std::sin(0.292799949645996*x_7 - 0.986879825592041) - 0.00397684473603874*std::sin(0.341839849948883*x_7 + 2.0046398639679) + 0.000879377574082942*std::sin(0.272879958152771*x_8 + 1.97535979747772) - 0.000569765270227038*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.00111514162638832*std::sin(0.33247983455658*x_91 + 5.20344018936157) + 0.00400523097199945*std::sin(0.368399828672409*x_91 + 1.98135983943939) + 0.0031200293453132*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.00164410778211066*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.00649799868492652*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0039483240924652*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.0143016402532392*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.00716279055309847*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.448537558317184*std::sin(0.00227590010862408*x_10 + 0.000323044974421579*x_100 + 0.00940856194772273*x_101 + 0.00297587475791563*x_102 + 0.00851949762850237*x_103 - 0.0152803887499133*x_104 + 0.00144005663242156*x_105 + 0.0151131355330331*x_106 - 0.0038712817025772*x_107 - 0.00788020545514201*x_108 - 0.00695158053450491*x_109 - 0.0349063700905958*x_11 + 0.00344469242715795*x_110 + 0.00912248567314205*x_111 + 0.0120266732938343*x_113 + 0.00245817078537088*x_114 + 0.00473391897347633*x_115 - 0.00034466304280582*x_116 - 0.00804816254147997*x_117 + 0.00261122974248485*x_118 + 0.00942229501418928*x_119 + 0.0030554639824929*x_12 + 0.025506242459141*x_120 + 0.0012796003820803*x_13 + 0.00561943343288596*x_14 + 0.00187433361111741*x_15 + 0.00322303071830062*x_16 + 0.00567755654099604*x_17 + 0.009684108378355*x_18 + 0.0138900979481325*x_19 + 0.0045221078520527*x_20 - 0.0415897267333569*x_22 + 0.00556843843899456*x_24 - 0.00259541184536395*x_26 - 0.00143347295138602*x_27 - 0.00616574777732922*x_28 - 0.00280663022403413*x_29 - 0.0810681548391651*x_30 - 0.00779953125120292*x_32 + 0.00111145093005037*x_33 + 0.0109636115789888*x_34 - 0.00244822911036775*x_35 + 0.0120327544352578*x_36 - 0.00173125797485355*x_37 + 0.02675905367912*x_38 - 0.00408294578408298*x_39 + 0.00595532613694293*x_40 + 0.00781936369418417*x_41 - 0.00141762597349413*x_42 - 0.0011880931290618*x_43 - 0.0071707449265311*x_44 + 0.00385987523814126*x_45 + 0.0105903772566557*x_46 + 0.00938236991739228*x_47 + 0.000228906105738189*x_48 + 0.00122241394077189*x_49 - 0.00622600372479245*x_50 - 0.0610517888276217*x_51 - 0.0348762315617929*x_52 + 0.00441073856259225*x_53 + 0.00875099835419669*x_54 + 0.00154974887833678*x_55 - 0.00971547450911925*x_56 - 0.013185149549239*x_57 + 0.00632706888305487*x_58 + 0.00127188519646747*x_59 + 0.0102056294982663*x_6 + 0.0189825803190091*x_60 + 0.0012197429874072*x_61 - 0.0039903418244968*x_62 - 0.000148337217216062*x_63 + 0.00137586893375605*x_64 - 0.00138221471903516*x_65 + 0.00965537653096217*x_66 + 0.0071673940710321*x_67 - 0.00470308642391517*x_68 - 0.00541514410023262*x_69 - 0.00203954727428388*x_70 + 0.00338596110128586*x_71 + 0.0123358259879208*x_72 + 0.00204745335613016*x_73 + 0.00558009133388782*x_74 + 0.00646025793930689*x_75 - 0.000332923941950162*x_76 + 0.00378572491172961*x_77 + 0.00358367019024087*x_78 + 0.00125912699006449*x_79 + 0.0101638587844848*x_8 + 0.0011359581779035*x_80 - 0.000704123785421897*x_81 + 0.000858055333659591*x_82 + 0.00438262235237628*x_83 - 0.00853245578695919*x_84 - 0.000442572992153083*x_85 + 0.00415506636547207*x_86 + 0.00138652457043883*x_87 - 0.00254345265832595*x_88 + 0.00840144831836811*x_89 + 0.00750868911142799*x_9 + 0.00561008919672136*x_90 - 0.0106045385068177*x_92 - 0.0151362559385282*x_93 + 0.0181234630360457*x_94 - 0.00225598663103676*x_95 + 0.0170116565972587*x_96 + 0.0177243328675504*x_98 - 0.0186486256561408*x_99 - 0.167917967720477*std::sin(0.272319942712784*x_1 - 4.31655979156494) + 0.139209358703859*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 0.383140305902117*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.213855269479851*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.0530576309216038*std::sin(0.445679873228073*x_23 - 4.4159197807312) - 0.0955736360433477*std::sin(0.24551996588707*x_25 - 7.38503980636597) - 0.0367693791951531*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.161688500706305*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.0791722535980846*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.425734079732678*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.470685468699884*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.177633153416508*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.122533909595859*std::sin(0.292879939079285*x_97 - 1.23735988140106) - 2.34086017368404) - 0.466026329556346);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000605806162764049*x_10 - 0.00064596650726176*x_100 - 0.00138729282432691*x_101 - 0.000378423904100358*x_102 - 0.000585185281449302*x_103 + 0.00146572984699705*x_104 - 0.000460359610577734*x_105 - 0.000376687996176473*x_106 + 0.00111287782220693*x_107 + 9.28288976361582e-5*x_108 + 0.000993180443814759*x_109 + 0.00248803502919388*x_11 + 0.000290632902003218*x_110 - 0.00011581642835623*x_111 - 0.000889322605572337*x_112 + 0.000644017475758905*x_113 + 0.00277061088674914*x_114 + 0.000307831238232145*x_115 + 0.000653568057008625*x_116 + 0.00323421443376244*x_117 + 0.00404344695084078*x_118 - 0.000902426371159568*x_119 + 0.00303825813984514*x_12 - 0.00179859355896751*x_120 + 0.00128382599437808*x_13 - 0.000764791284319523*x_14 + 9.14682021530725e-5*x_15 - 0.000296480606867451*x_16 - 9.79864498914392e-5*x_17 - 0.000212864432817801*x_18 - 0.000775138419329148*x_19 - 0.00053432302796191*x_2 + 0.00101523860404961*x_20 + 0.000727976019851758*x_21 + 0.00320350994056113*x_22 + 4.60320928592395e-5*x_23 - 0.000200569574342925*x_24 + 0.00133187208113852*x_25 + 0.00109552695685591*x_26 - 0.000346334681174877*x_27 + 0.00120624390449139*x_28 + 0.000401570229711723*x_29 - 0.000123576463319353*x_3 + 0.00520402626834633*x_30 - 0.00041160122546017*x_31 + 0.000503370266360137*x_32 - 6.78237357969683e-5*x_33 - 0.0010534825036708*x_34 + 0.000109449877306708*x_35 - 0.000808385766240411*x_36 + 0.000131538766244439*x_37 - 0.00109260249714168*x_38 - 0.000451032140600583*x_39 + 0.000383829088605831*x_4 + 0.000516349976196581*x_40 - 0.000911494792800194*x_41 + 0.000812017452965432*x_42 + 0.000554406076004669*x_43 + 0.00107400349914518*x_44 - 0.000702418852196347*x_45 + 0.000251530985250308*x_46 + 0.000872682627331755*x_47 + 0.000828940527184276*x_48 + 0.000300810967495267*x_49 + 0.000358590838583648*x_5 + 0.000498437765703552*x_50 + 0.00325077741028184*x_51 + 0.000132514282909136*x_52 + 2.14075848422019e-5*x_53 - 0.000931644457556062*x_54 + 0.000377002871439466*x_55 + 0.000452502733437164*x_56 + 0.00145320405460771*x_57 + 0.00100915163700674*x_58 + 0.00026758902417918*x_59 - 0.00374669295390138*x_6 - 0.000772794586444084*x_60 + 0.000694762577195055*x_61 + 0.000404796674241171*x_62 + 0.000595939404887213*x_63 + 0.001026483151556*x_64 + 0.000768054090245739*x_65 + 0.000235842429342627*x_66 + 0.000229585882150457*x_67 + 4.85511028348853e-5*x_68 + 0.000327205442273005*x_69 + 0.000528426871036064*x_7 + 0.000362322427868002*x_70 - 0.000464171377127782*x_71 - 0.00078831848480113*x_72 + 0.000538519072099134*x_73 - 0.000525118367168802*x_74 - 0.000907597443889247*x_75 + 0.000488804318755859*x_76 - 0.000100611518928163*x_77 + 0.000119556221796989*x_78 - 0.000226257114153119*x_79 - 0.000762053622172254*x_8 + 0.000202197115363364*x_80 + 1.69740631943259e-5*x_81 - 0.000105161308757956*x_82 + 0.000575839114699698*x_83 + 0.000708818605088294*x_84 - 0.000284541833042593*x_85 + 0.000282625180575019*x_86 + 0.000461607731720922*x_87 + 0.000289341500261502*x_88 - 0.000817198576137186*x_89 + 0.000678378840389537*x_9 - 0.000226967331279357*x_90 + 0.000217915596603561*x_91 + 0.000842202213003671*x_92 + 0.000861459351372713*x_93 - 0.000550220755723326*x_94 + 0.00012888705390471*x_95 - 0.000854271023319329*x_96 - 0.000227060418442667*x_97 - 0.00196933898506694*x_98 - 3.73444872492387e-5*x_99 + 2.76187277855438e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.0083990368337619*std::sin(0.272319942712784*x_1 - 4.31655979156494) + 0.0349995362460143*std::sin(0.328319847583771*x_1 - 4.26039981842041) - 0.0310097470162733*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.0291850989901043*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.00681358133157306*std::sin(0.353999853134155*x_1 + 8.35127925872803) + 0.00178694369073679*std::sin(0.210800006985664*x_101 + 1.99727976322174) + 0.00425284868473698*std::sin(0.253119975328445*x_101 + 8.18896007537842) + 0.0104419243018017*std::sin(0.248879969120026*x_108 - 7.42855978012085) + 0.0107361013452927*std::sin(0.207040011882782*x_11 - 7.38431978225708) - 0.00179868642095863*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.00696306980861286*std::sin(0.264079958200455*x_112 + 5.17264032363892) + 0.00182029005495657*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.00764689434620697*std::sin(0.246719971299171*x_116 + 5.17600011825562) + 0.0286858608216089*std::sin(0.25639995932579*x_116 - 7.43792009353638) - 0.00509965198760555*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.0186830482444858*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.0350877150442165*std::sin(0.268559962511063*x_120 + 5.15359973907471) + 0.0284262648336437*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.00766279069681933*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.00504707702118904*std::sin(0.235919982194901*x_15 - 7.38631963729858) + 0.0026293581362206*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.00233408555397712*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.00778351941807611*std::sin(0.251519978046417*x_17 - 1.1509598493576) - 0.0187397102282754*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.00271723451877979*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.00656832784315361*std::sin(0.240239977836609*x_18 - 1.16775989532471) - 0.00755143085488532*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.0144799872320678*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.0191641763264281*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.00460534998106768*std::sin(0.373279839754105*x_2 - 7.41351985931396) - 0.00202375731158434*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.0106967605065667*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.00494271557971894*std::sin(0.390079826116562*x_21 - 4.38703966140747) + 0.036907137995416*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.00247018459491966*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.00265387321245165*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.00478046810809955*std::sin(0.24551996588707*x_25 - 7.38503980636597) - 0.00124923074643315*std::sin(0.171760007739067*x_26 - 1.22095990180969) - 0.0033347810924737*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.00283735295287382*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.00957374314863024*std::sin(0.281919926404953*x_29 + 8.20503997802734) + 0.00555002974026394*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.0299534185494978*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.0018391561927949*std::sin(0.38647985458374*x_3 + 8.20024013519287) + 0.0102210231052131*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.0100017717242393*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.0262800937629701*std::sin(0.37679985165596*x_31 - 7.4029598236084) - 0.0155917024455478*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.00808744705205471*std::sin(0.382639855146408*x_31 + 5.18423986434937) + 0.0114481300866803*std::sin(0.389679849147797*x_31 + 5.17935991287231) + 0.00583963592987422*std::sin(0.289759933948517*x_32 + 2.03663969039917) - 0.00352419658126995*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.00280005959188353*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.00921227689302715*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.00404874572693322*std::sin(0.23879998922348*x_35 + 1.9826397895813) + 0.00899471611407939*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.00250191200350889*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.003960092438048*std::sin(0.213679999113083*x_4 + 8.19799995422363) - 0.0159221905375536*std::sin(0.313759922981262*x_4 + 2.00783967971802) - 0.000394444066805277*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.0102221767171047*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.00673065983090373*std::sin(0.183520004153252*x_48 + 2.00439977645874) - 0.0168270328528518*std::sin(0.221119984984398*x_48 + 5.18160009384155) + 0.00130266410945601*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.0212946611110422*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.00526648090127525*std::sin(0.352879852056503*x_5 + 1.99839973449707) - 0.0189854791277663*std::sin(0.359839856624603*x_5 + 1.99495983123779) - 0.00693032057811125*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.00867935392765791*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.00885410251480377*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.0386470101204367*std::sin(0.229759991168976*x_53 + 1.99935972690582) - 0.0292424276923918*std::sin(0.30839991569519*x_6 + 2.00783967971802) - 0.0110621025305157*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.00449199378403149*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.00746678171357831*std::sin(0.292799949645996*x_7 - 0.986879825592041) - 0.00915929405291251*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.0235430707171709*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.00247602669183726*std::sin(0.272879958152771*x_8 + 1.97535979747772) - 0.00131225833481867*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.00313985768285679*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.00888497769890882*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.00499230077481583*std::sin(0.368399828672409*x_91 + 1.98135983943939) + 0.00718591449358544*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.00204929019372242*std::sin(0.22095999121666*x_92 - 7.40327978134155) + 0.00364548126075817*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0111171311721964*std::sin(0.297119915485382*x_92 + 1.99895977973938) + 0.0080234490755176*std::sin(0.278479963541031*x_94 + 1.98743987083435) - 0.00401844013859652*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.00612898568301911*std::sin(0.292879939079285*x_97 - 1.23735988140106) + 0.0400214683017888);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00265767134089745*x_10 + 0.00903207722400885*x_100 - 0.000970753695242923*x_101 + 0.00121438225667558*x_102 + 0.000117283227996869*x_103 + 0.00488263214212864*x_104 + 0.00123538844613178*x_105 - 0.00502421620274038*x_106 - 0.000783149299035544*x_107 - 0.00026525036968428*x_108 - 0.00479792996214241*x_109 + 0.00490467037161668*x_11 - 0.00105163293158857*x_110 - 0.00307057233804583*x_111 + 0.0136135706518912*x_112 + 0.0140807690811017*x_113 + 0.0204942700225441*x_114 - 0.00413567000146145*x_115 + 0.00292521433493018*x_116 + 0.0231192651301639*x_117 + 0.0150873052124607*x_118 + 0.00889319338143626*x_119 - 0.00525621622368486*x_12 - 0.0063692837856019*x_120 - 0.010689650750226*x_13 - 0.00549501976900127*x_14 - 0.00214636367391626*x_15 - 0.000374363675710351*x_16 - 0.000749502661789378*x_17 - 0.00186823710846332*x_18 - 0.00421560600836971*x_19 + 0.000821861090269834*x_2 - 0.00356955074043898*x_20 + 0.000984178739268483*x_21 + 0.00808942364953811*x_22 + 0.000292996634891686*x_23 - 0.00602152665219738*x_24 - 0.00530669248479463*x_25 - 0.00332016373718665*x_26 + 0.00276938703601126*x_27 - 0.000873474511146125*x_28 + 0.00175873825267358*x_29 - 0.000763972392187093*x_3 + 0.020642739410821*x_30 + 0.00152195073250706*x_31 + 0.00105147170859011*x_32 - 0.00266552316326002*x_33 - 0.00408743474305375*x_34 + 0.0018628167032177*x_35 + 0.00134658054821207*x_36 + 0.00397960776480451*x_37 - 0.00752248802819773*x_38 + 0.000196765594057993*x_39 - 7.2136009648522e-5*x_4 + 0.000525245839585313*x_40 + 0.00125921651874689*x_41 + 0.00228878582985189*x_42 + 0.00326055120256782*x_43 + 0.001000795637253*x_44 + 0.00171048823286559*x_45 - 0.00376456644079251*x_46 + 6.04328690099027e-5*x_47 - 0.00310764208620717*x_48 - 0.00415078134818097*x_49 + 0.00221687442260878*x_5 + 0.00187028771996421*x_50 + 0.0120117022018826*x_51 + 0.0120523889958277*x_52 - 0.000306576257441524*x_53 + 0.000732287437733355*x_54 - 0.00494718023486682*x_55 + 0.00403398500165562*x_56 + 0.0030191204050539*x_57 - 0.00360965720068366*x_58 - 0.00763069120626983*x_59 + 0.0113875629921842*x_6 - 6.19236731793076e-5*x_60 - 0.00361346789216234*x_61 - 0.00287576710467502*x_62 - 0.000410400285351183*x_63 - 0.0041288798996505*x_64 - 0.000526903472086341*x_65 - 0.00462900108459582*x_66 - 0.00472499451157176*x_67 - 0.00348538890786969*x_68 + 0.00059889298007378*x_69 + 9.95474581560348e-5*x_7 - 0.000363187520313552*x_70 - 0.00110741315578612*x_71 - 0.00320546571647154*x_72 + 0.00262226607781493*x_73 - 0.000600392277741054*x_74 - 0.00495843725524655*x_75 - 0.00342528720041568*x_76 - 0.00305223020639613*x_77 + 0.00106829110532038*x_78 + 0.00032144922714891*x_79 + 0.000729354361290793*x_8 + 0.000571497668339459*x_80 + 0.00198944974375682*x_81 - 0.0022477735675307*x_82 - 0.00341489659069264*x_83 + 0.00272247371599991*x_84 - 0.00454068420101572*x_85 - 0.00163865749683618*x_86 - 0.00401127670751948*x_87 - 0.00103283506961303*x_88 - 0.00607502096537379*x_89 - 0.00155000060224177*x_9 - 0.00318878009156753*x_90 + 0.000375761425850254*x_91 + 0.00286906695484599*x_92 + 0.00533925563278196*x_93 - 0.00441834138048591*x_94 + 0.00445621233467759*x_95 + 0.00105689599535783*x_96 + 0.00550001109959689*x_97 - 0.00459632919832321*x_98 + 0.00207934362049033*x_99 + 1.70744047601997e-5*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) + 0.0316527407675822*std::sin(0.272319942712784*x_1 - 4.31655979156494) + 0.0603512362074092*std::sin(0.328319847583771*x_1 - 4.26039981842041) - 0.0865411151382627*std::sin(0.332399845123291*x_1 - 4.25383996963501) - 0.107915817637862*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.0421228111682655*std::sin(0.353999853134155*x_1 + 8.35127925872803) + 0.00498695134805487*std::sin(0.210800006985664*x_101 + 1.99727976322174) + 0.00733337361166207*std::sin(0.253119975328445*x_101 + 8.18896007537842) + 0.0180054682887316*std::sin(0.248879969120026*x_108 - 7.42855978012085) + 0.0185127306739738*std::sin(0.207040011882782*x_11 - 7.38431978225708) - 0.00501972262373256*std::sin(0.210720002651215*x_110 - 7.41519975662231) - 0.0262411331157223*std::sin(0.264079958200455*x_112 + 5.17264032363892) + 0.00508001342766075*std::sin(0.258399993181229*x_113 + 5.19055986404419) + 0.028275417398484*std::sin(0.246719971299171*x_116 + 5.17600011825562) + 0.0494642886148223*std::sin(0.25639995932579*x_116 - 7.43792009353638) - 0.0142319629242006*std::sin(0.226079985499382*x_118 + 5.1831202507019) + 0.069083076536932*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.216918698582881*std::sin(0.268559962511063*x_120 + 5.15359973907471) + 0.0490166558611179*std::sin(0.105360068380833*x_13 + 4.9282398223877) - 0.0283341962867917*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.0312019570868108*std::sin(0.235919982194901*x_15 - 7.38631963729858) + 0.00733793749065358*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.0144297455708297*std::sin(0.440719872713089*x_16 - 1.24711990356445) + 0.0287806069250156*std::sin(0.251519978046417*x_17 - 1.1509598493576) - 0.0522982473759557*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.0167984428400488*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.0406066090598119*std::sin(0.240239977836609*x_18 - 1.16775989532471) - 0.013021263596857*std::sin(0.356399834156036*x_18 - 1.16319990158081) + 0.0535416947554036*std::sin(0.23735998570919*x_19 + 5.01391983032227) + 0.0722224127945597*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.0284711193975727*std::sin(0.373279839754105*x_2 - 7.41351985931396) - 0.00348965353938959*std::sin(0.420479863882065*x_2 - 7.38711977005005) + 0.04031197791707*std::sin(0.363279849290848*x_21 - 1.17143988609314) + 0.018276353741943*std::sin(0.390079826116562*x_21 - 4.38703966140747) + 0.0636405976137598*std::sin(0.333519846200943*x_23 + 1.99015974998474) - 0.00913383882534002*std::sin(0.399759858846664*x_23 - 1.20783984661102) + 0.0100014278406418*std::sin(0.445679873228073*x_23 - 4.4159197807312) + 0.0180157464204852*std::sin(0.24551996588707*x_25 - 7.38503980636597) - 0.0034863174409193*std::sin(0.171760007739067*x_26 - 1.22095990180969) - 0.0093066117028694*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.0175410370604663*std::sin(0.367359846830368*x_28 - 1.16967988014221) + 0.0354001992622888*std::sin(0.281919926404953*x_29 + 8.20503997802734) + 0.0154888642761552*std::sin(0.333119839429855*x_3 - 7.41143989562988) + 0.110756782250908*std::sin(0.351279854774475*x_3 - 7.4029598236084) + 0.00693107261628193*std::sin(0.38647985458374*x_3 + 8.20024013519287) + 0.0176245586618123*std::sin(0.396959841251373*x_3 + 2.00959992408752) - 0.0369828923251042*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.162468366222074*std::sin(0.37679985165596*x_31 - 7.4029598236084) - 0.0435128772844742*std::sin(0.378239840269089*x_31 - 7.40263986587524) + 0.030478478672843*std::sin(0.382639855146408*x_31 + 5.18423986434937) + 0.0197405130781718*std::sin(0.389679849147797*x_31 + 5.17935991287231) + 0.0100695404902471*std::sin(0.289759933948517*x_32 + 2.03663969039917) - 0.00983522703198781*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.0173104826535577*std::sin(0.321439832448959*x_32 + 1.98871982097626) - 0.0340636293046152*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.0250300896730554*std::sin(0.23879998922348*x_35 + 1.9826397895813) + 0.0155099837038902*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.0154672795046964*std::sin(0.267919957637787*x_38 + 8.17575931549072) + 0.0149240659182885*std::sin(0.213679999113083*x_4 + 8.19799995422363) - 0.0444351940001536*std::sin(0.313759922981262*x_4 + 2.00783967971802) - 0.000680157213485573*std::sin(0.765919864177704*x_4 + 7.99975967407227) + 0.0377978693455557*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.0416101752218363*std::sin(0.183520004153252*x_48 + 2.00439977645874) - 0.0290155911562382*std::sin(0.221119984984398*x_48 + 5.18160009384155) + 0.00363543774232516*std::sin(0.477759838104248*x_49 + 1.8414398431778) - 0.0802513908704262*std::sin(0.342879861593246*x_5 + 2.02063989639282) - 0.0194735194397665*std::sin(0.352879852056503*x_5 + 1.99839973449707) - 0.0327374947855529*std::sin(0.359839856624603*x_5 + 1.99495983123779) - 0.0193409404720605*std::sin(0.365119844675064*x_5 + 2.01319980621338) - 0.0320930751678854*std::sin(0.209360003471375*x_50 + 5.17960023880005) - 0.0327392315050389*std::sin(0.182720005512238*x_51 - 1.16575992107391) - 0.142902503014288*std::sin(0.229759991168976*x_53 + 1.99935972690582) - 0.0504240012935199*std::sin(0.30839991569519*x_6 + 2.00783967971802) - 0.0308717993817311*std::sin(0.36303985118866*x_6 + 2.00039982795715) - 0.0166097494544157*std::sin(0.497679859399796*x_60 - 1.34559988975525) + 0.0276094267837658*std::sin(0.292799949645996*x_7 - 0.986879825592041) - 0.025561495900058*std::sin(0.341839849948883*x_7 + 2.0046398639679) - 0.0887247822616931*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.0153072517538683*std::sin(0.272879958152771*x_8 + 1.97535979747772) - 0.00366221303208605*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.0194111768589793*std::sin(0.33247983455658*x_91 + 5.20344018936157) - 0.0334840650655113*std::sin(0.345519840717316*x_91 - 7.40391969680786) - 0.0184597016508683*std::sin(0.368399828672409*x_91 + 1.98135983943939) + 0.0200542446617426*std::sin(0.368799835443497*x_91 + 2.00087976455688) + 0.00757752532920285*std::sin(0.22095999121666*x_92 - 7.40327978134155) + 0.00628606330984613*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0687281466692573*std::sin(0.297119915485382*x_92 + 1.99895977973938) + 0.0138351853279149*std::sin(0.278479963541031*x_94 + 1.98743987083435) - 0.00692917266917759*std::sin(0.273839950561523*x_95 + 1.95871984958649) - 0.0230977907148831*std::sin(0.292879939079285*x_97 - 1.23735988140106) + 1.03308439979027);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00174863152964544*x_10 - 0.00180728847395341*x_100 + 0.00393471906066526*x_101 + 0.000955211556186542*x_102 + 0.00350090409329636*x_103 - 0.00724226865279968*x_104 - 1.23922532795014e-5*x_105 + 0.00719267327465922*x_106 - 0.00133015504196339*x_107 - 0.00295842891856122*x_108 - 0.00177761842094832*x_109 - 0.0150910811013558*x_11 + 0.00163901865789999*x_110 + 0.00427395845160065*x_111 - 0.00313325758378213*x_112 + 0.00160276343245706*x_113 - 0.00339405641805923*x_114 + 0.00285787461150205*x_115 - 0.000656464058296581*x_116 - 0.00876058580962549*x_117 - 0.00234291553890249*x_118 + 0.00163741307011217*x_119 + 0.00273818099617173*x_12 + 0.0112642811180036*x_120 + 0.00310457637902032*x_13 + 0.00361006179869098*x_14 + 0.00120031590901381*x_15 + 0.00135136783788241*x_16 + 0.00246565534327778*x_17 + 0.00438068352590494*x_18 + 0.00659927462071259*x_19 - 0.000326004852817905*x_2 + 0.00271615322300513*x_20 - 5.19204724429127e-5*x_21 - 0.0179837456677103*x_22 - 7.3927372341286e-5*x_23 + 0.00358569474722828*x_24 + 0.0013866984937519*x_25 - 6.64892972965038e-5*x_26 - 0.0012695516566323*x_27 - 0.00214844347097686*x_28 - 0.00154011311299876*x_29 + 0.000188635557394902*x_3 - 0.0367907210306336*x_30 - 0.000386993776012887*x_31 - 0.00333442766570476*x_32 + 0.00125309457641298*x_33 + 0.00531289636024466*x_34 - 0.00140031705714899*x_35 + 0.00427027664447462*x_36 - 0.00177957625693697*x_37 + 0.0122762710653813*x_38 - 0.00162893001143773*x_39 + 2.45470839782755e-5*x_4 + 0.00246317443978249*x_40 + 0.00273851892831934*x_41 - 0.000960149834127304*x_42 - 0.00106867315300627*x_43 - 0.00301506438165616*x_44 + 0.000975035061005569*x_45 + 0.005204512821788*x_46 + 0.00390237718753038*x_47 + 0.00088456680421265*x_48 + 0.00150077376038709*x_49 - 0.000547377557958792*x_5 - 0.00299675917685128*x_50 - 0.0270761040973842*x_51 - 0.016869005230052*x_52 + 0.00194652922939653*x_53 + 0.00326968951241096*x_54 + 0.00177257019247544*x_55 - 0.00453703080887944*x_56 - 0.00570604827677644*x_57 + 0.00329883426752996*x_58 + 0.00227100744560628*x_59 + 0.00112385599446027*x_6 + 0.00722404592391672*x_60 + 0.00153159848675435*x_61 - 0.000633570373050876*x_62 + 0.00026594895246971*x_63 + 0.00152660521222505*x_64 - 0.000171006551922493*x_65 + 0.0050977088522247*x_66 + 0.00423892017818327*x_67 - 0.00090075840488259*x_68 - 0.00221822298608694*x_69 + 0.000128558225506645*x_7 - 0.000473724840117636*x_70 + 0.0018050123441166*x_71 + 0.00588277804771883*x_72 + 0.000478516583321157*x_73 + 0.00249795510071969*x_74 + 0.00387639456363551*x_75 + 0.000812330621039187*x_76 + 0.00233712684700644*x_77 + 0.00127202082777237*x_78 + 0.000387145653550343*x_79 + 0.00394630690178612*x_8 + 0.000356199671706772*x_80 - 0.000616878799585385*x_81 + 0.00094719407837325*x_82 + 0.00272963592260704*x_83 - 0.00385725450688395*x_84 + 0.00106305968205072*x_85 + 0.00208476300619993*x_86 + 0.00142215803280386*x_87 - 0.000665622462831425*x_88 + 0.00472671238392319*x_89 + 0.00356246967935315*x_9 + 0.00301479919046466*x_90 - 4.58121134034824e-5*x_91 - 0.00469446172854037*x_92 - 0.007242922920045*x_93 + 0.00820007845885297*x_94 - 0.00188818159756599*x_95 + 0.00644061546294039*x_96 - 0.00134471971750271*x_97 + 0.00789809171793431*x_98 - 0.00787796398326352*x_99 - 4.21591132358309e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) - 0.0740800662505476*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.00735790713726958*std::sin(0.328319847583771*x_1 - 4.26039981842041) + 0.00159900381967776*std::sin(0.332399845123291*x_1 - 4.25383996963501) + 0.027440277051807*std::sin(0.340559840202332*x_1 - 4.24952030181885) + 0.0104007161057465*std::sin(0.353999853134155*x_1 + 8.35127925872803) - 9.21429570366288e-5*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.000894070866288045*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.00219519221074837*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.00225703666927801*std::sin(0.207040011882782*x_11 - 7.38431978225708) + 9.27484657003503e-5*std::sin(0.210720002651215*x_110 - 7.41519975662231) + 0.0614147411112367*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 9.38624474836748e-5*std::sin(0.258399993181229*x_113 + 5.19055986404419) - 0.00718972717950909*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.00603059133682306*std::sin(0.25639995932579*x_116 - 7.43792009353638) + 0.000262961287717997*std::sin(0.226079985499382*x_118 + 5.1831202507019) - 0.017566088097724*std::sin(0.267919957637787*x_120 + 5.14832019805908) - 0.0535602857315525*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.00597601680877133*std::sin(0.105360068380833*x_13 + 4.9282398223877) + 0.00720467317181371*std::sin(0.302639931440353*x_14 - 7.43607997894287) + 0.00770420322393135*std::sin(0.235919982194901*x_15 - 7.38631963729858) - 0.000135581683427187*std::sin(0.232479989528656*x_16 - 1.17375981807709) + 0.00356290767396407*std::sin(0.440719872713089*x_16 - 1.24711990356445) - 0.00731818416454736*std::sin(0.251519978046417*x_17 - 1.1509598493576) + 0.000966304827283558*std::sin(0.354079842567444*x_17 + 2.00215983390808) + 0.00414777243380148*std::sin(0.451679855585098*x_17 - 7.43752002716064) + 0.0100263444232401*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.00158752752017067*std::sin(0.356399834156036*x_18 - 1.16319990158081) - 0.0136143057623101*std::sin(0.23735998570919*x_19 + 5.01391983032227) - 0.169029316098748*std::sin(0.372239857912064*x_2 + 5.18247985839844) + 0.00702992088738027*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.000425451876343181*std::sin(0.420479863882065*x_2 - 7.38711977005005) - 0.0943461426204725*std::sin(0.363279849290848*x_21 - 1.17143988609314) - 0.00464721688769184*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.00775893978034037*std::sin(0.333519846200943*x_23 + 1.99015974998474) + 0.00232250538799556*std::sin(0.399759858846664*x_23 - 1.20783984661102) - 0.0234073391140155*std::sin(0.445679873228073*x_23 - 4.4159197807312) - 0.0421640482314718*std::sin(0.24551996588707*x_25 - 7.38503980636597) + 6.44160281010108e-5*std::sin(0.171760007739067*x_26 - 1.22095990180969) + 0.000171956504574395*std::sin(0.147600039839745*x_28 - 1.2403998374939) - 0.00433112941910519*std::sin(0.367359846830368*x_28 - 1.16967988014221) - 0.00900137993399743*std::sin(0.281919926404953*x_29 + 8.20503997802734) - 0.000286184816320818*std::sin(0.333119839429855*x_3 - 7.41143989562988) - 0.0281626628686662*std::sin(0.351279854774475*x_3 - 7.4029598236084) - 0.0162214805463982*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.00214875243853007*std::sin(0.396959841251373*x_3 + 2.00959992408752) + 0.00940381895621165*std::sin(0.265279948711395*x_30 - 1.18247985839844) - 0.0401157307970294*std::sin(0.37679985165596*x_31 - 7.4029598236084) + 0.00080397920539715*std::sin(0.378239840269089*x_31 - 7.40263986587524) - 0.0713318235497802*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.00240672554862119*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.00122765909197927*std::sin(0.289759933948517*x_32 + 2.03663969039917) + 0.000181723630050535*std::sin(0.293599933385849*x_32 + 2.01647973060608) - 0.00427420228469325*std::sin(0.321439832448959*x_32 + 1.98871982097626) + 0.00866152382448102*std::sin(0.243759974837303*x_33 + 1.96831977367401) + 0.00618028212198129*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.00189094750936979*std::sin(0.212640002369881*x_38 + 1.96959984302521) + 0.00381908943384516*std::sin(0.267919957637787*x_38 + 8.17575931549072) - 0.0349282799891582*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.000821020676944724*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 8.29234648710725e-5*std::sin(0.765919864177704*x_4 + 7.99975967407227) - 0.00961104710609315*std::sin(0.235519990324974*x_40 - 1.19175982475281) - 0.0102741390612298*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.00353752530481507*std::sin(0.221119984984398*x_48 + 5.18160009384155) - 6.71712957117704e-5*std::sin(0.477759838104248*x_49 + 1.8414398431778) + 0.18782033429688*std::sin(0.342879861593246*x_5 + 2.02063989639282) + 0.00495162600161278*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.00399129266733021*std::sin(0.359839856624603*x_5 + 1.99495983123779) + 0.000357358899773541*std::sin(0.365119844675064*x_5 + 2.01319980621338) + 0.00816046149051528*std::sin(0.209360003471375*x_50 + 5.17960023880005) + 0.00832476278849342*std::sin(0.182720005512238*x_51 - 1.16575992107391) + 0.0363365108094494*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.00614759766862459*std::sin(0.30839991569519*x_6 + 2.00783967971802) + 0.000570412399387814*std::sin(0.36303985118866*x_6 + 2.00039982795715) + 0.00422344135240429*std::sin(0.497679859399796*x_60 - 1.34559988975525) - 0.00702038252381556*std::sin(0.292799949645996*x_7 - 0.986879825592041) + 0.000472294926123489*std::sin(0.341839849948883*x_7 + 2.0046398639679) + 0.207651457302656*std::sin(0.358079850673676*x_7 + 2.00367975234985) - 0.00377957632540718*std::sin(0.272879958152771*x_8 + 1.97535979747772) + 6.76660176775348e-5*std::sin(0.362319827079773*x_9 + 8.23831939697266) - 0.00479289330862084*std::sin(0.33247983455658*x_91 + 5.20344018936157) + 0.0783660971605714*std::sin(0.345519840717316*x_91 - 7.40391969680786) + 0.00469383764753877*std::sin(0.368399828672409*x_91 + 1.98135983943939) - 0.000370538486402066*std::sin(0.368799835443497*x_91 + 2.00087976455688) - 0.00192677402582603*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.000766384800037734*std::sin(0.293599933385849*x_92 - 1.18903994560242) - 0.0169699486372263*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.00168675929884622*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.000844791461482208*std::sin(0.273839950561523*x_95 + 1.95871984958649) + 0.054058063374792*std::sin(0.292879939079285*x_97 - 1.23735988140106) - 0.39482746214345);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000843106341221336*x_10 + 0.000853427979407588*x_100 + 0.00159331455141647*x_101 + 9.68696349601223e-5*x_102 + 0.000893560306115572*x_103 - 0.00155506529166369*x_104 + 0.00278268414822749*x_105 + 0.0033511356940086*x_106 + 0.000278987087596253*x_107 - 0.0033691215267475*x_108 - 2.87663756178112e-5*x_109 - 0.00663225561135501*x_11 + 0.00106261520612008*x_110 + 0.00348300467867247*x_111 + 0.00179476680261053*x_112 + 0.00883507322263921*x_113 + 0.0102290536355182*x_114 + 0.000808327006332349*x_115 - 0.000564526686551294*x_116 + 0.0110195826103335*x_117 + 0.0089357108511997*x_118 + 0.00686487098936886*x_119 + 0.00324732861006508*x_12 + 0.00854876941504938*x_120 - 0.000786648283017981*x_13 + 3.20503231394534e-5*x_14 + 0.000591665992447171*x_15 + 0.000678723146985505*x_16 + 0.00156458512694882*x_17 + 0.00153967113270987*x_18 + 0.00234206855865066*x_19 + 0.000839306103687428*x_2 + 0.00191728132879934*x_20 + 0.00074344106657709*x_21 - 0.0121354261446671*x_22 + 0.000140117550668086*x_23 + 0.00041511632121007*x_24 - 9.43774125087905e-5*x_25 - 0.000821625858234317*x_26 - 0.000251967432323011*x_27 - 0.00120639291327004*x_28 + 0.000173190756664083*x_29 - 0.000330138434814216*x_3 - 0.0184907231797203*x_30 + 9.95986985027684e-5*x_31 - 0.00179672757364195*x_32 - 0.000935895171180135*x_33 + 0.00138854984989476*x_34 + 0.000208119663411501*x_35 + 0.00584715356527814*x_36 + 0.00150522004026012*x_37 + 0.0069764458262753*x_38 - 0.00242076277724076*x_39 + 0.000304381750738318*x_4 + 0.00162440061090854*x_40 + 0.00268428814696583*x_41 + 0.000494621522054669*x_42 + 0.000417889242868961*x_43 - 0.00047988820157646*x_44 + 0.00238826661930698*x_45 + 0.00199826233087125*x_46 + 0.0021876233634579*x_47 - 0.000177864994465223*x_48 - 0.000586746225573857*x_49 + 0.000957986780077909*x_5 + 0.000236384171252589*x_50 - 0.0128502333707955*x_51 - 0.00698907940834693*x_52 + 0.00033303397333061*x_53 + 0.00203465204114978*x_54 - 0.000256229219768947*x_55 - 0.00350566134142169*x_56 - 0.00344782637283239*x_57 + 0.00370684141190924*x_58 - 0.000750503760148038*x_59 + 0.00349487072690742*x_6 + 0.0075150431056242*x_60 - 0.00161368655270511*x_61 - 0.00343060234199862*x_62 - 0.0015010275103337*x_63 - 0.000216052384159244*x_64 - 0.00149481150484868*x_65 + 0.00171728750748422*x_66 - 0.000358725542474797*x_67 - 0.00297362976478002*x_68 - 0.00210921899738329*x_69 + 0.000570304323660446*x_7 - 0.0024972618107017*x_70 - 0.00159502382523441*x_71 + 0.000255093554099116*x_72 - 0.000456627519412678*x_73 - 0.000274818235071076*x_74 - 0.00148442225020661*x_75 - 0.00149365234629855*x_76 - 0.00101568957340903*x_77 + 0.00105455857060487*x_78 - 0.000513250607610418*x_79 + 0.00191800582798002*x_8 + 0.000157184314721989*x_80 - 0.00127788501655795*x_81 - 0.00145718685891461*x_82 - 5.94957750277214e-5*x_83 - 0.00324108930815155*x_84 - 0.00314377329799244*x_85 + 0.000823781072980697*x_86 + 0.00138697204716434*x_87 - 0.00165141831995284*x_88 + 0.000576312778570107*x_89 + 0.00268504658948497*x_9 + 0.000631950717480514*x_90 + 0.000324102484816574*x_91 - 0.00372585766479975*x_92 - 0.00201608760743538*x_93 + 0.00460383835263307*x_94 - 0.000373903411465927*x_95 + 0.00665010253525409*x_96 + 0.00114777707195973*x_97 + 0.0040916461340824*x_98 - 0.00526581002113336*x_99 + 7.37843058278507e-6*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) - 0.0380921981141766*std::sin(0.272319942712784*x_1 - 4.31655979156494) + 0.052054267072023*std::sin(0.328319847583771*x_1 - 4.26039981842041) + 0.131310533782602*std::sin(0.332399845123291*x_1 - 4.25383996963501) - 0.00706217011827176*std::sin(0.340559840202332*x_1 - 4.24952030181885) - 0.0182026982797833*std::sin(0.353999853134155*x_1 + 8.35127925872803) - 0.00756679923080196*std::sin(0.210800006985664*x_101 + 1.99727976322174) + 0.00632519584534242*std::sin(0.253119975328445*x_101 + 8.18896007537842) + 0.015530111957233*std::sin(0.248879969120026*x_108 - 7.42855978012085) + 0.0159676369084409*std::sin(0.207040011882782*x_11 - 7.38431978225708) + 0.00761652373105943*std::sin(0.210720002651215*x_110 - 7.41519975662231) + 0.0315796489385942*std::sin(0.264079958200455*x_112 + 5.17264032363892) - 0.00770800415205175*std::sin(0.258399993181229*x_113 + 5.19055986404419) + 0.0018503849778846*std::sin(0.246719971299171*x_116 + 5.17600011825562) + 0.042664035600442*std::sin(0.25639995932579*x_116 - 7.43792009353638) + 0.0215944368796875*std::sin(0.226079985499382*x_118 + 5.1831202507019) + 0.00452089832126918*std::sin(0.267919957637787*x_120 + 5.14832019805908) + 0.0937379417953512*std::sin(0.268559962511063*x_120 + 5.15359973907471) + 0.0422779425164257*std::sin(0.105360068380833*x_13 + 4.9282398223877) - 0.00185423155494512*std::sin(0.302639931440353*x_14 - 7.43607997894287) - 0.0134834260781211*std::sin(0.235919982194901*x_15 - 7.38631963729858) - 0.011133996681481*std::sin(0.232479989528656*x_16 - 1.17375981807709) - 0.00623558346641728*std::sin(0.440719872713089*x_16 - 1.24711990356445) + 0.00188344532488868*std::sin(0.251519978046417*x_17 - 1.1509598493576) + 0.0793531579511046*std::sin(0.354079842567444*x_17 + 2.00215983390808) - 0.00725917805832392*std::sin(0.451679855585098*x_17 - 7.43752002716064) - 0.0175474958195034*std::sin(0.240239977836609*x_18 - 1.16775989532471) - 0.0112311259135863*std::sin(0.356399834156036*x_18 - 1.16319990158081) + 0.00350384739753457*std::sin(0.23735998570919*x_19 + 5.01391983032227) - 0.0869153946779806*std::sin(0.372239857912064*x_2 + 5.18247985839844) - 0.0123033383031221*std::sin(0.373279839754105*x_2 - 7.41351985931396) - 0.00300990284116028*std::sin(0.420479863882065*x_2 - 7.38711977005005) - 0.0485130769707004*std::sin(0.363279849290848*x_21 - 1.17143988609314) + 0.00119603151875699*std::sin(0.390079826116562*x_21 - 4.38703966140747) + 0.0548914135482631*std::sin(0.333519846200943*x_23 + 1.99015974998474) - 0.000597731871280334*std::sin(0.399759858846664*x_23 - 1.20783984661102) - 0.0120361258296013*std::sin(0.445679873228073*x_23 - 4.4159197807312) - 0.0216808833984682*std::sin(0.24551996588707*x_25 - 7.38503980636597) + 0.00528985792904699*std::sin(0.171760007739067*x_26 - 1.22095990180969) + 0.0141211047310722*std::sin(0.147600039839745*x_28 - 1.2403998374939) + 0.00758007825856398*std::sin(0.367359846830368*x_28 - 1.16967988014221) + 0.00231664120129215*std::sin(0.281919926404953*x_29 + 8.20503997802734) - 0.0235015579882327*std::sin(0.333119839429855*x_3 - 7.41143989562988) + 0.0072480870286606*std::sin(0.351279854774475*x_3 - 7.4029598236084) - 0.00834113523317882*std::sin(0.38647985458374*x_3 + 8.20024013519287) + 0.0152015690358946*std::sin(0.396959841251373*x_3 + 2.00959992408752) - 0.00242021496739305*std::sin(0.265279948711395*x_30 - 1.18247985839844) + 0.0702081026486137*std::sin(0.37679985165596*x_31 - 7.4029598236084) + 0.066022943354874*std::sin(0.378239840269089*x_31 - 7.40263986587524) - 0.0366790432572491*std::sin(0.382639855146408*x_31 + 5.18423986434937) + 0.0170266262049453*std::sin(0.389679849147797*x_31 + 5.17935991287231) + 0.00868519988837483*std::sin(0.289759933948517*x_32 + 2.03663969039917) + 0.0149231831526561*std::sin(0.293599933385849*x_32 + 2.01647973060608) + 0.00748044786378177*std::sin(0.321439832448959*x_32 + 1.98871982097626) - 0.00222917409384978*std::sin(0.243759974837303*x_33 + 1.96831977367401) - 0.0108163524132928*std::sin(0.23879998922348*x_35 + 1.9826397895813) + 0.0133777016800512*std::sin(0.212640002369881*x_38 + 1.96959984302521) - 0.00668393714057659*std::sin(0.267919957637787*x_38 + 8.17575931549072) - 0.0179602290936749*std::sin(0.213679999113083*x_4 + 8.19799995422363) + 0.067422392623109*std::sin(0.313759922981262*x_4 + 2.00783967971802) - 0.000586650538856641*std::sin(0.765919864177704*x_4 + 7.99975967407227) + 0.00247354826446563*std::sin(0.235519990324974*x_40 - 1.19175982475281) + 0.0179811708650306*std::sin(0.183520004153252*x_48 + 2.00439977645874) - 0.025026584809443*std::sin(0.221119984984398*x_48 + 5.18160009384155) - 0.00551612109129238*std::sin(0.477759838104248*x_49 + 1.8414398431778) + 0.0965777940817478*std::sin(0.342879861593246*x_5 + 2.02063989639282) - 0.00127437580602505*std::sin(0.352879852056503*x_5 + 1.99839973449707) - 0.0282368084554152*std::sin(0.359839856624603*x_5 + 1.99495983123779) + 0.0293463888602114*std::sin(0.365119844675064*x_5 + 2.01319980621338) - 0.00210021812756549*std::sin(0.209360003471375*x_50 + 5.17960023880005) - 0.00214250355036876*std::sin(0.182720005512238*x_51 - 1.16575992107391) - 0.00935175036156762*std::sin(0.229759991168976*x_53 + 1.99935972690582) - 0.0434918088695369*std::sin(0.30839991569519*x_6 + 2.00783967971802) + 0.0468423875653549*std::sin(0.36303985118866*x_6 + 2.00039982795715) - 0.00108696647846924*std::sin(0.497679859399796*x_60 - 1.34559988975525) + 0.00180680157073205*std::sin(0.292799949645996*x_7 - 0.986879825592041) + 0.0387849597911454*std::sin(0.341839849948883*x_7 + 2.0046398639679) + 0.106775018579466*std::sin(0.358079850673676*x_7 + 2.00367975234985) + 0.00661478371078578*std::sin(0.272879958152771*x_8 + 1.97535979747772) + 0.0055567477643491*std::sin(0.362319827079773*x_9 + 8.23831939697266) + 0.00838822922354499*std::sin(0.33247983455658*x_91 + 5.20344018936157) + 0.0402960884022324*std::sin(0.345519840717316*x_91 - 7.40391969680786) - 0.00120803007607696*std::sin(0.368399828672409*x_91 + 1.98135983943939) - 0.030428699317465*std::sin(0.368799835443497*x_91 + 2.00087976455688) + 0.000495884422892687*std::sin(0.22095999121666*x_92 - 7.40327978134155) + 0.0054218677018948*std::sin(0.293599933385849*x_92 - 1.18903994560242) + 0.0296997679511878*std::sin(0.297119915485382*x_92 + 1.99895977973938) + 0.0119331512874926*std::sin(0.278479963541031*x_94 + 1.98743987083435) - 0.00597656365264729*std::sin(0.273839950561523*x_95 + 1.95871984958649) + 0.0277968225997108*std::sin(0.292879939079285*x_97 - 1.23735988140106) - 0.28308688230854);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000115270109775798*x_10 + 0.00389019661976098*x_100 + 0.00405911045286078*x_101 + 0.00106418135880531*x_102 + 0.00208668512792921*x_103 - 0.00392944075412866*x_104 - 0.00157162226563386*x_105 - 0.000536475880778586*x_106 - 0.00292222995650288*x_107 + 0.00279924584599514*x_108 - 0.00202874962062326*x_109 - 0.00467629840646475*x_11 - 0.00159917684040376*x_110 - 0.000792079588787*x_111 + 0.00179053394270316*x_112 - 0.00527135906572613*x_113 - 0.00697971463320386*x_114 - 0.0016085293443052*x_115 - 0.00237231485496057*x_116 - 0.0154583281492078*x_117 - 0.0192624531617149*x_118 + 0.00276605448380363*x_119 - 0.00733883783651963*x_12 + 0.000536235088071146*x_120 - 0.00211652636104407*x_13 + 0.00566249831707254*x_14 - 0.000921737619052174*x_15 + 0.000377056926379123*x_16 - 3.3375718671024e-5*x_17 - 8.89597445861777e-5*x_18 + 0.00268958767621878*x_19 + 0.00100335482167612*x_2 - 0.00305967613939353*x_20 - 0.000202834756545385*x_21 - 0.0023621901246345*x_22 - 0.000361576755098001*x_23 + 0.000409694579549147*x_24 - 0.00238206488700907*x_25 - 0.000303718363378392*x_26 + 0.000205706455270845*x_27 - 0.0022726728281423*x_28 - 0.00155246626588459*x_29 + 0.000920641184797154*x_3 - 0.00698417378686944*x_30 + 0.00117067555748309*x_31 - 0.000525985308102046*x_32 + 0.00380155760690715*x_33 + 0.0030328565128219*x_34 + 0.000402602511574466*x_35 - 0.000480920134444694*x_36 - 0.00318159719386431*x_37 - 0.000702023213523906*x_38 + 0.0030632796754683*x_39 - 0.00171968814268908*x_4 - 0.000562654487479957*x_40 + 0.00155520111890173*x_41 - 0.00158086834449583*x_42 - 0.000192923830816976*x_43 - 0.00149708917909374*x_44 + 0.000476370144913137*x_45 - 0.00151220071841333*x_46 - 0.00459580324215072*x_47 - 0.00236502655525348*x_48 - 0.000301310772166015*x_49 - 0.0026714916871986*x_5 - 0.00143610445627803*x_50 - 0.00231141261792124*x_51 + 0.00289182994670239*x_52 + 0.000177278739680255*x_53 + 0.00134350580696847*x_54 - 0.00109562014647298*x_55 + 0.00278425252257721*x_56 - 0.00097571613865323*x_57 - 0.00497711366710599*x_58 + 6.89259242833068e-5*x_59 + 0.00884423580501207*x_6 - 0.00524062380746652*x_60 - 0.000872313505927767*x_61 + 0.00320721412597741*x_62 - 0.000299814121195128*x_63 - 0.00490484337057859*x_64 + 6.7270370707484e-5*x_65 + 0.000564859429234564*x_66 + 0.0019473848703072*x_67 + 0.00399806962151117*x_68 + 0.000166085274770626*x_69 + 0.000661991266029894*x_7 + 0.00153476104019581*x_70 + 0.00340868965491235*x_71 + 0.00358525144006353*x_72 - 0.000556290286268419*x_73 + 0.00247295072179409*x_74 + 0.005077131660221*x_75 + 0.000175949799814103*x_76 + 0.000955793842127995*x_77 - 0.000194121585549611*x_78 - 0.00102554565611818*x_79 + 0.00168475578261334*x_8 - 0.00121412642178612*x_80 + 0.000483039667531223*x_81 + 0.00110472527858393*x_82 - 0.000640225619231846*x_83 - 0.000544391445113452*x_84 + 0.00409554613661589*x_85 - 0.00145571219659464*x_86 - 0.00135492853280691*x_87 + 0.000555601709180565*x_88 + 0.00256315320179879*x_89 - 0.00026769094835568*x_9 + 0.000966489637106316*x_90 - 0.000212987719792865*x_91 - 0.000258686810347866*x_92 - 0.000190830015663238*x_93 - 0.00117421502654188*x_94 - 0.000942915188159636*x_95 + 0.000339796892622366*x_96 - 0.00119445470557431*x_97 + 0.00313628770114487*x_98 + 0.00502021691028923*x_99 - 2.05758747160156e-5*std::pow(-3.42847990989685*x_44 - 9.07087993621826, 2) - 0.00438950449479927*std::sin(0.272319942712784*x_1 - 4.31655979156494) - 0.0342080674124841*std::sin(0.328319847583771*x_1 - 4.26039981842041) - 0.0018424168673143*std::sin(0.332399845123291*x_1 - 4.25383996963501) - 0.0830082126024811*std::sin(0.340559840202332*x_1 - 4.24952030181885) + 0.0507609897655067*std::sin(0.353999853134155*x_1 + 8.35127925872803) + 0.00010616968900219*std::sin(0.210800006985664*x_101 + 1.99727976322174) - 0.00415667606221909*std::sin(0.253119975328445*x_101 + 8.18896007537842) - 0.0102057938117042*std::sin(0.248879969120026*x_108 - 7.42855978012085) - 0.0104933184252937*std::sin(0.207040011882782*x_11 - 7.38431978225708) - 0.000106867372998699*std::sin(0.210720002651215*x_110 - 7.41519975662231) + 0.00363903943124125*std::sin(0.264079958200455*x_112 + 5.17264032363892) + 0.00010815093392721*std::sin(0.258399993181229*x_113 + 5.19055986404419) + 0.0217492848612192*std::sin(0.246719971299171*x_116 + 5.17600011825562) - 0.0280371675176834*std::sin(0.25639995932579*x_116 - 7.43792009353638) - 0.000302991341221413*std::sin(0.226079985499382*x_118 + 5.1831202507019) + 0.0531382964048376*std::sin(0.267919957637787*x_120 + 5.14832019805908) - 0.261402492695172*std::sin(0.268559962511063*x_120 + 5.15359973907471) - 0.0277834419541816*std::sin(0.105360068380833*x_13 + 4.9282398223877) - 0.0217944972366057*std::sin(0.302639931440353*x_14 - 7.43607997894287) + 0.0376005822123434*std::sin(0.235919982194901*x_15 - 7.38631963729858) + 0.000156221002958866*std::sin(0.232479989528656*x_16 - 1.17375981807709) + 0.0173888718944661*std::sin(0.440719872713089*x_16 - 1.24711990356445) + 0.0221378736755449*std::sin(0.251519978046417*x_17 - 1.1509598493576) - 0.00111340341457924*std::sin(0.354079842567444*x_17 + 2.00215983390808) + 0.0202433209330193*std::sin(0.451679855585098*x_17 - 7.43752002716064) + 0.0489338581573572*std::sin(0.240239977836609*x_18 - 1.16775989532471) + 0.0073806651016425*std::sin(0.356399834156036*x_18 - 1.16319990158081) + 0.0411839568900636*std::sin(0.23735998570919*x_19 + 5.01391983032227) - 0.0100155815230905*std::sin(0.372239857912064*x_2 + 5.18247985839844) + 0.0343097281560711*std::sin(0.373279839754105*x_2 - 7.41351985931396) + 0.00197799268123355*std::sin(0.420479863882065*x_2 - 7.38711977005005) - 0.00559034080367707*std::sin(0.363279849290848*x_21 - 1.17143988609314) + 0.0140580638706766*std::sin(0.390079826116562*x_21 - 4.38703966140747) - 0.0360725312379766*std::sin(0.333519846200943*x_23 + 1.99015974998474) - 0.00702569513613741*std::sin(0.399759858846664*x_23 - 1.20783984661102) - 0.00138696717555247*std::sin(0.445679873228073*x_23 - 4.4159197807312) - 0.00249836816566846*std::sin(0.24551996588707*x_25 - 7.38503980636597) - 7.42219469635862e-5*std::sin(0.171760007739067*x_26 - 1.22095990180969) - 0.00019813308797231*std::sin(0.147600039839745*x_28 - 1.2403998374939) - 0.0211381998971026*std::sin(0.367359846830368*x_28 - 1.16967988014221) + 0.0272296251916947*std::sin(0.281919926404953*x_29 + 8.20503997802734) + 0.000329750139599403*std::sin(0.333119839429855*x_3 - 7.41143989562988) + 0.0851934658837671*std::sin(0.351279854774475*x_3 - 7.4029598236084) - 0.000961179779859979*std::sin(0.38647985458374*x_3 + 8.20024013519287) - 0.00998988800737337*std::sin(0.396959841251373*x_3 + 2.00959992408752) - 0.0284470233926102*std::sin(0.265279948711395*x_30 - 1.18247985839844) - 0.195785961247299*std::sin(0.37679985165596*x_31 - 7.4029598236084) - 0.000926367298667349*std::sin(0.378239840269089*x_31 - 7.40263986587524) - 0.00422666144810142*std::sin(0.382639855146408*x_31 + 5.18423986434937) - 0.0111892455659793*std::sin(0.389679849147797*x_31 + 5.17935991287231) - 0.00570758018475889*std::sin(0.289759933948517*x_32 + 2.03663969039917) - 0.000209387042779024*std::sin(0.293599933385849*x_32 + 2.01647973060608) - 0.0208603654039885*std::sin(0.321439832448959*x_32 + 1.98871982097626) - 0.0262015434365532*std::sin(0.243759974837303*x_33 + 1.96831977367401) + 0.0301630420782763*std::sin(0.23879998922348*x_35 + 1.9826397895813) - 0.0087913123483636*std::sin(0.212640002369881*x_38 + 1.96959984302521) + 0.0186391742351144*std::sin(0.267919957637787*x_38 + 8.17575931549072) - 0.00206962344619777*std::sin(0.213679999113083*x_4 + 8.19799995422363) - 0.000946002958217827*std::sin(0.313759922981262*x_4 + 2.00783967971802) + 0.000385524229032203*std::sin(0.765919864177704*x_4 + 7.99975967407227) + 0.0290738989263413*std::sin(0.235519990324974*x_40 - 1.19175982475281) - 0.0501432269118791*std::sin(0.183520004153252*x_48 + 2.00439977645874) + 0.0164465114662195*std::sin(0.221119984984398*x_48 + 5.18160009384155) + 7.73966432698472e-5*std::sin(0.477759838104248*x_49 + 1.8414398431778) + 0.0111290154469153*std::sin(0.342879861593246*x_5 + 2.02063989639282) - 0.0149789166885536*std::sin(0.352879852056503*x_5 + 1.99839973449707) + 0.0185561472956631*std::sin(0.359839856624603*x_5 + 1.99495983123779) - 0.00041175890671752*std::sin(0.365119844675064*x_5 + 2.01319980621338) - 0.0246858047774137*std::sin(0.209360003471375*x_50 + 5.17960023880005) - 0.0251828244338728*std::sin(0.182720005512238*x_51 - 1.16575992107391) - 0.109919765343787*std::sin(0.229759991168976*x_53 + 1.99935972690582) + 0.0285811483550713*std::sin(0.30839991569519*x_6 + 2.00783967971802) - 0.000657245100370756*std::sin(0.36303985118866*x_6 + 2.00039982795715) - 0.0127761216489394*std::sin(0.497679859399796*x_60 - 1.34559988975525) + 0.0212370087950424*std::sin(0.292799949645996*x_7 - 0.986879825592041) - 0.000544191406879965*std::sin(0.341839849948883*x_7 + 2.0046398639679) + 0.012304079239061*std::sin(0.358079850673676*x_7 + 2.00367975234985) - 0.018446329389372*std::sin(0.272879958152771*x_8 + 1.97535979747772) - 7.79666757382743e-5*std::sin(0.362319827079773*x_9 + 8.23831939697266) - 0.0233918516487194*std::sin(0.33247983455658*x_91 + 5.20344018936157) + 0.00464346690191657*std::sin(0.345519840717316*x_91 - 7.40391969680786) - 0.0141990940045108*std::sin(0.368399828672409*x_91 + 1.98135983943939) + 0.00042694479458708*std::sin(0.368799835443497*x_91 + 2.00087976455688) + 0.00582858794285289*std::sin(0.22095999121666*x_92 - 7.40327978134155) - 0.00356304345984482*std::sin(0.293599933385849*x_92 - 1.18903994560242) - 0.0828223153422567*std::sin(0.297119915485382*x_92 + 1.99895977973938) - 0.00784200924625666*std::sin(0.278479963541031*x_94 + 1.98743987083435) + 0.00392756835941779*std::sin(0.273839950561523*x_95 + 1.95871984958649) + 0.00320313039895586*std::sin(0.292879939079285*x_97 - 1.23735988140106) + 0.212446702465192);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
