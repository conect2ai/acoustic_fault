
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00171132553882905*x_1 + 0.000254181781690504*x_10 - 0.000151514954237091*x_100 - 0.00146201238262385*x_101 + 0.000412973608149297*x_102 - 0.00239405031543916*x_103 + 0.00651551560403976*x_104 - 0.00018104021943911*x_105 + 0.00370981308413644*x_106 + 0.000213773972557701*x_107 - 0.00331668730795418*x_108 + 0.000408776855234995*x_109 - 0.000146017870440715*x_11 - 0.000266463037827836*x_110 + 0.00380273032879761*x_111 - 0.00557883050552854*x_112 - 0.00107965586070446*x_113 + 0.000765681921330203*x_114 - 0.000650565042876149*x_115 - 0.00694665344352213*x_116 - 0.00374773765275406*x_117 + 0.00451019713610473*x_118 - 0.00709971215418646*x_119 - 0.000700214940925967*x_12 - 0.00497881828614105*x_120 - 0.000303694933348487*x_13 - 0.000548213575737254*x_14 - 0.000486500534916573*x_15 - 0.000613515882553954*x_16 - 0.000584912368307616*x_17 - 0.000491526610305076*x_18 - 0.00115157214173896*x_19 + 0.00243687367374198*x_2 - 0.000110490266269116*x_20 - 0.000783086154408361*x_21 + 0.000222045713075083*x_22 - 0.00265950264230628*x_23 + 0.000243736226011503*x_24 + 0.000348073728392856*x_25 - 0.00101156354486117*x_26 + 0.000652547083942303*x_27 + 6.75790966396843e-5*x_28 - 0.00168465477233856*x_29 - 3.95196455874177e-7*x_3 + 0.00236224861440731*x_30 + 0.00124076672925939*x_31 + 0.000215730385059452*x_32 - 0.00171038599421802*x_33 + 0.000923158305803372*x_34 + 0.00591438224506426*x_35 - 0.000684772828748078*x_36 - 0.00230974262762096*x_37 - 0.00361447143345749*x_38 + 0.00267755884288184*x_39 + 0.000379505028769943*x_4 - 0.00134999335040835*x_40 - 0.000759677226565028*x_41 - 0.00274613143010814*x_42 - 0.00565634613402411*x_43 - 0.000655465625441395*x_44 + 0.0038487555302629*x_45 + 0.000695969288779814*x_46 - 0.0026095926646181*x_47 - 0.000406190453419779*x_48 - 0.00190670846973654*x_49 + 0.00055126527954578*x_5 - 0.0053663798989656*x_50 - 0.00392337763055314*x_51 + 0.000361207243078911*x_52 - 0.00205440063815392*x_53 + 0.00546252767822441*x_54 - 0.00174797258180311*x_55 + 0.00371535491893292*x_56 + 0.003838842541859*x_57 - 0.002466454282132*x_58 - 0.00144737957419989*x_59 - 0.00529759197772839*x_6 - 0.00070023763488262*x_60 + 0.000832514915467053*x_61 - 0.00265558108837909*x_62 - 0.000813063392645199*x_63 + 0.000642831262301938*x_64 + 0.000104922511284848*x_65 - 0.00064926243101957*x_66 - 4.88416669133639e-5*x_67 + 0.000996614130453972*x_68 - 0.00042125110157721*x_69 - 0.000110794577748166*x_7 - 0.000322123626854075*x_70 - 0.00022982206588292*x_71 + 4.72346122348547e-5*x_72 - 0.000384959781086964*x_73 + 0.00039158040386044*x_74 + 0.00052060627296386*x_75 - 0.000615295715505054*x_76 + 0.00033447824288399*x_77 - 0.000130171968034823*x_78 - 0.00016518242615834*x_79 + 0.000503159712826162*x_8 + 0.00155825909303764*x_80 + 0.000453016362098822*x_81 + 2.9411420700837e-5*x_82 + 0.000148547408772135*x_83 - 0.000265665907657023*x_84 + 0.000760376756136924*x_85 + 0.00255390278927167*x_86 - 0.00249646244193467*x_87 + 0.00102596707443247*x_88 - 0.00125841879939633*x_89 - 0.0047180405592914*x_9 - 0.00065483129158891*x_90 + 3.93625074483108e-5*x_91 + 0.00190060253193414*x_92 - 0.00289278792723272*x_93 - 0.000624955396356764*x_94 + 5.29740982233128e-5*x_95 + 0.00023894050816963*x_96 + 0.000310357926770448*x_97 - 1.70464713055273e-5*x_98 + 0.000852577314302012*x_99 - 2.33313691167558e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.000274282137629665*std::exp(0.237919852137566*x_28) - 0.000872480060835641*std::exp(0.200159847736359*x_49) + 0.0033339455786381*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.000963428918088336*std::sin(0.323359847068787*x_1 + 8.33455944061279) + 0.000208061084156578*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.00333635729480898*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.00316024193759765*std::sin(0.121440060436726*x_10 - 4.46895980834961) + 0.0218717865893812*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.00125210085324429*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.0022525512834719*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.0010503788977969*std::sin(0.239199981093407*x_100 - 1.19463992118835) + 0.0231729814199367*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.00317763894823936*std::sin(0.262639969587326*x_100 - 1.2196798324585) - 0.019201891592394*std::sin(0.240559980273247*x_101 + 1.96103990077972) - 0.0230990359344082*std::sin(0.224239990115166*x_102 - 1.20831990242004) + 0.00330833090832452*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.000888396272096951*std::sin(0.238879978656769*x_102 - 1.21063983440399) + 7.01788560380388e-5*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 0.00338549457987674*std::sin(0.237279981374741*x_104 - 1.20263981819153) - 0.00234252093684545*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.00214669172619918*std::sin(0.238159984350204*x_106 + 8.17735958099365) - 0.00659008174376122*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 0.000845407469839485*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.00367907363887278*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 0.00396648128695249*std::sin(0.249039977788925*x_109 + 1.95839989185333) + 0.0291317006507301*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00315689173305573*std::sin(0.253679990768433*x_109 + 8.17984008789063) - 0.021169597531144*std::sin(0.267999976873398*x_11 - 1.19399988651276) - 0.00471238612824563*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.000718252938581424*std::sin(0.199520006775856*x_110 - 7.39160013198853) + 0.00601997078453937*std::sin(0.213839992880821*x_110 - 7.42335987091064) + 0.0271833348857444*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.00345262207082311*std::sin(0.242079973220825*x_110 + 8.17360019683838) - 0.000270417005826434*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.00351298908983165*std::sin(0.220319986343384*x_111 - 1.18911993503571) - 0.00919021078252845*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 0.00106919226014611*std::sin(0.28519994020462*x_112 + 8.17903995513916) - 0.00341242407654665*std::sin(0.301439940929413*x_112 - 1.24199986457825) - 0.00728196519709249*std::sin(0.299759924411774*x_113 - 1.20455992221832) + 0.0128705566585729*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.00250238270235914*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.000795317180000893*std::sin(0.203199997544289*x_117 - 4.20279979705811) - 0.000426992171390111*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.00126540435018093*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.000504669590074676*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.00314639415124272*std::sin(0.279679954051971*x_12 + 5.15056037902832) + 0.00502283689735839*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.00380144815462384*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00415692112160662*std::sin(0.287439942359924*x_13 + 1.95335984230042) + 0.0191899947156354*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.00137099241283662*std::sin(0.225679993629456*x_14 - 4.19647979736328) - 0.0257308535994106*std::sin(0.261919975280762*x_14 + 1.97167980670929) + 0.00636911386711572*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.00328284076946941*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.00153134200258308*std::sin(0.369119822978973*x_14 + 4.83024024963379) - 0.000271757954314463*std::sin(0.25231996178627*x_15 + 1.56383979320526) - 0.00491213363664241*std::sin(0.26463994383812*x_15 - 1.01159977912903) - 0.00191235092038527*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.000589367355900075*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.000923825710586519*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00249867598571408*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.00103789111400252*std::sin(0.308079928159714*x_16 - 1.1775997877121) + 0.0120714173535904*std::sin(0.308479934930801*x_16 - 1.17567980289459) + 0.00473392825627281*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.00111685056185772*std::sin(0.352959841489792*x_16 + 2.01791977882385) - 0.00167870185020456*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 0.00118535904529036*std::sin(0.291759938001633*x_17 - 1.14455986022949) + 0.0160512452708604*std::sin(0.358159840106964*x_17 + 1.98871982097626) - 0.00325326731177013*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.00149724986662135*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.000302504761715272*std::sin(0.166160017251968*x_18 + 7.98320007324219) + 0.0479037069704036*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.00471318953454784*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.000678055929873575*std::sin(0.337039858102798*x_18 - 4.15015983581543) + 0.000190485702673319*std::sin(0.350399851799011*x_18 + 2.01143980026245) + 0.00338300503743241*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.00101687596797633*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.00175406120937247*std::sin(0.254959970712662*x_19 + 1.82567989826202) + 0.00588749427355502*std::sin(0.262319952249527*x_19 - 7.57184028625488) - 0.00676466106627028*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.000392652935135048*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.00252386680770923*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.00185449431577173*std::sin(0.258719980716705*x_20 - 4.39888000488281) + 0.0001646312809388*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00392482452382048*std::sin(0.283439934253693*x_20 + 1.97463977336884) - 0.00531294129643585*std::sin(0.289999932050705*x_20 + 1.97943985462189) - 0.00182220073604757*std::sin(0.341759830713272*x_20 + 8.23559951782227) + 0.024798445041396*std::sin(0.346559852361679*x_20 - 4.35752010345459) + 0.000160784647097555*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00277246828250314*std::sin(0.316399931907654*x_21 + 1.97503972053528) - 0.00923442998989204*std::sin(0.356479853391647*x_21 + 8.22696018218994) - 0.000123588735050416*std::sin(0.356319844722748*x_22 - 7.38351964950562) - 0.0258226584892252*std::sin(0.370719850063324*x_22 + 1.98679983615875) + 0.000348513567787685*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 0.00348270952708643*std::sin(0.3435198366642*x_23 - 1.15847992897034) + 0.00303021946148448*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.00221716424496321*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 0.000902900426742981*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 0.000274801217868913*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 0.00277742490014167*std::sin(0.377839833498001*x_24 - 4.59847974777222) - 0.0154367879296869*std::sin(0.42087984085083*x_24 + 1.98071980476379) - 0.00410170062471285*std::sin(0.424319863319397*x_25 + 1.77583980560303) + 0.00405489768901263*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.00114742270038142*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.0109116423462065*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.00390735852295284*std::sin(0.186720013618469*x_27 - 4.40975952148438) - 0.00413585668885828*std::sin(0.342079848051071*x_27 - 1.15599977970123) - 0.00585974448789216*std::sin(0.183280006051064*x_28 - 1.20519983768463) + 0.00240225414957992*std::sin(0.221039995551109*x_28 + 8.60432052612305) - 0.0117273286534253*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.00469520623312367*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.00174891008390083*std::sin(0.347279846668243*x_28 - 4.38199949264526) + 0.00457814464967469*std::sin(0.223119989037514*x_29 + 8.21144008636475) + 0.006757396969848*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00146530342690799*std::sin(0.398559868335724*x_29 - 4.39160013198853) - 0.00371254932017096*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.00180977494415702*std::sin(0.287599951028824*x_3 + 5.06271982192993) - 0.0192195171168198*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.00422227577562818*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.000722985772980297*std::sin(0.371919840574265*x_3 - 1.20223987102509) - 0.0030078371437497*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 0.000821948896497813*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00181067841362351*std::sin(0.399679869413376*x_3 + 8.18696022033691) - 0.000172477724377133*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.00544101063334361*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.002204847928423*std::sin(0.322319835424423*x_31 - 1.04135990142822) + 0.00212041167363227*std::sin(0.376239836215973*x_31 + 5.19583988189697) - 0.000575743101292905*std::sin(0.396399825811386*x_31 + 5.1989598274231) + 0.000231162914695733*std::sin(0.405279844999313*x_31 - 7.38151979446411) - 0.00182511503127203*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000863076290960116*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.00306496505289531*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.000169828770270815*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.00408238299832242*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 0.000207995191378647*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 0.0025895518485315*std::sin(0.266639977693558*x_33 - 1.23087990283966) - 0.0345071080114096*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.000608514730359018*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.00550705385505478*std::sin(0.243759974837303*x_34 + 1.95839989185333) - 0.0378795541577432*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.00492757106759457*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00238247304650284*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.00246806526687803*std::sin(0.241119980812073*x_36 + 1.96823978424072) - 0.00802658702229441*std::sin(0.247599974274635*x_36 + 5.15607976913452) - 0.0344894768513246*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00296273822159812*std::sin(0.224559992551804*x_37 - 1.2190397977829) - 0.00359075841035665*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.00250212828037949*std::sin(0.229519993066788*x_39 - 1.18871986865997) - 0.00748935157515244*std::sin(0.334719836711884*x_4 - 7.37951993942261) - 0.000786728811671846*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 0.00139655128098856*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.0021691550000842*std::sin(0.236879989504814*x_41 + 1.98095989227295) + 0.00921229365665144*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.00176184896788996*std::sin(0.276719957590103*x_41 - 1.2247998714447) - 0.00484431913332146*std::sin(0.23335999250412*x_42 - 1.1956799030304) - 0.00510767186036318*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.00474990683392012*std::sin(0.254719972610474*x_44 + 8.17759990692139) + 0.0140358264316565*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.00378738555417899*std::sin(0.262559950351715*x_48 + 8.17479991912842) - 0.00198055936926621*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.00667859085030032*std::sin(0.0756000876426697*x_49 + 8.10095977783203) + 0.0002915016243585*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.00131887606819249*std::sin(0.303839921951294*x_5 - 4.58752012252808) - 0.00238302704300439*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.000343579328637667*std::sin(0.389279842376709*x_5 - 1.38399982452393) + 0.0198516901529676*std::sin(0.393919855356216*x_5 + 1.97943985462189) + 0.00447037182255435*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.00212342420155091*std::sin(0.193999990820885*x_50 + 2.01047992706299) - 0.0345264355049406*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.00366855808306387*std::sin(0.244319975376129*x_53 - 1.22295987606049) + 0.00442451433939359*std::sin(0.24975997209549*x_53 - 1.19007992744446) - 0.0389838277814292*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.00235223640755374*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.00515671614636467*std::sin(0.246639966964722*x_6 - 7.37775993347168) - 1.0634616793902e-5*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.00149860448491916*std::sin(0.291599929332733*x_60 - 4.26775979995728) - 0.00510965537351848*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00121328877841372*std::sin(0.418079853057861*x_60 - 4.41295957565308) - 0.0136687054964354*std::sin(0.472959846258163*x_60 - 4.67736005783081) - 0.00176366389213349*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.00443996254886064*std::sin(0.28519994020462*x_7 + 5.22079992294312) - 0.00251059113227156*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.000849441235934103*std::sin(0.338559836149216*x_7 + 2.02039980888367) + 0.000175196642997531*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.00295556454514114*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.00115165672676815*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.0024690194066646*std::sin(0.383679836988449*x_7 - 1.19735991954803) - 0.00318458684431145*std::sin(0.442559868097305*x_7 - 1.41695988178253) - 0.000352124181682067*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.00205090017291984*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.00239258799950031*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 0.000922580960835808*std::sin(0.357119828462601*x_8 + 8.24271965026855) - 0.00135446176181296*std::sin(0.369919836521149*x_8 + 1.81647992134094) - 0.000268179204444281*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.00332598510520263*std::sin(0.339039832353592*x_9 - 4.36039972305298) + 0.0031126259401584*std::sin(0.463119864463806*x_9 + 4.93391990661621) + 0.0149691479664758*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00159607510468298*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.00182160004334793*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.00105695846082939*std::sin(0.356319844722748*x_91 + 5.19551992416382) + 0.00581288030797145*std::sin(0.36303985118866*x_91 + 5.18800020217896) - 0.000443881248995222*std::sin(0.405119866132736*x_91 - 1.19711995124817) + 0.000707708333856445*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.00129776199887895*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 0.00105837691345895*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.00264299435062002*std::sin(0.300319939851761*x_92 + 2.00071978569031) + 0.00526701787132155*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.00236217075442653*std::sin(0.314959913492203*x_92 + 8.21815967559814) - 5.82120306228329e-5*std::sin(0.273039966821671*x_94 - 7.60464000701904) - 0.00199925131132893*std::sin(0.288959950208664*x_94 - 1.20831990242004) + 0.00345703247219029*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.00214654784511572*std::sin(0.281839966773987*x_95 + 1.94663977622986) + 0.0213516673668727*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.001344918443942*std::sin(0.286399960517883*x_95 - 1.2111998796463) + 8.44254131735743e-5*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00269628065367685*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.00123270737230261*std::sin(0.275439947843552*x_97 + 1.9748797416687) + 0.00542937075320551*std::sin(0.277199953794479*x_97 + 1.97303986549377) - 0.0284314220809919*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.00312415856172162*std::sin(0.294079929590225*x_97 - 4.4256796836853) - 0.0108504444650104*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.000457067819006421*std::sin(0.264959961175919*x_98 + 1.95287978649139) - 0.0262446172071561*std::sin(0.265839964151382*x_98 + 1.95631980895996) - 0.00452739488384498*std::sin(0.251759976148605*x_99 + 1.95271980762482) + 0.174044539104094);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00228929544759246*x_1 + 0.00151922761011437*x_10 - 0.00019731160890284*x_100 + 0.00126893199134559*x_101 + 0.000914434455102616*x_102 + 0.000963611447825905*x_103 - 0.00820053064579694*x_104 + 0.0028802259862105*x_105 - 0.00451912306435119*x_106 - 0.001174522309726*x_107 + 0.00389418919897854*x_108 - 0.00031300977601256*x_109 + 0.000772373205356431*x_11 + 8.40976123177078e-5*x_110 - 0.00416955915954791*x_111 + 0.00766652103423696*x_112 + 0.00166082229189126*x_113 - 0.000304928945189511*x_114 - 0.00154481317116294*x_115 + 0.0114128837875677*x_116 + 0.00444640588530768*x_117 - 0.00619392058523449*x_118 + 0.00954203623274911*x_119 + 0.00144222168325559*x_12 + 0.0067662085502583*x_120 + 0.00089411203300428*x_13 - 0.000356847575320706*x_14 - 0.000419449723009645*x_15 + 3.84991034337603e-5*x_16 + 0.001409696169954*x_17 + 0.000256511702327109*x_18 - 0.00213245448480678*x_19 - 0.00321791848827354*x_2 - 2.91052408431346e-5*x_20 + 0.000315448767126226*x_21 + 0.000245526744402564*x_22 + 0.00306429141916595*x_23 - 0.000401875956185894*x_24 - 0.00310677915693683*x_25 - 0.00148813545999645*x_26 - 0.00135306045869848*x_27 - 3.315073858543e-5*x_28 + 0.00225314449083659*x_29 + 8.36228043425123e-7*x_3 - 0.005714923554523*x_30 - 0.00102615880202525*x_31 - 0.000158006725342781*x_32 + 0.00168653432388999*x_33 + 0.00153226677023281*x_34 - 0.00894784753571234*x_35 + 0.00206306708558639*x_36 + 0.00289633070925411*x_37 + 0.0034287362539258*x_38 - 0.00633925302643478*x_39 + 0.00135683747681611*x_4 - 0.000352126266865842*x_40 - 0.0007774723182163*x_41 + 0.00665378025769504*x_42 + 0.0073481520435897*x_43 + 0.000460357534019622*x_44 - 0.00749031118223018*x_45 - 0.00169054857559924*x_46 + 0.00314461042004198*x_47 - 0.00359205499428343*x_48 + 0.00366679504200868*x_49 + 0.00143801925557419*x_5 + 0.00748870463722702*x_50 + 0.00253478425139018*x_51 - 0.00182747472117653*x_52 + 0.00166620537584706*x_53 - 0.0063407326685033*x_54 + 0.00297815558386489*x_55 - 0.00546572843493065*x_56 - 0.00749126576172652*x_57 - 0.000987143079430845*x_58 - 2.88177917731635e-8*x_59 + 0.00772625968714531*x_6 + 0.000158032890753899*x_60 - 0.000925891883962546*x_61 + 0.00346168980601474*x_62 + 0.000347540219449865*x_63 - 0.000430379686100676*x_64 - 0.000805482592135451*x_65 + 0.00136167413351727*x_66 - 0.000538705409568311*x_67 - 0.00139349199819393*x_68 + 0.000348913267702487*x_69 + 0.000443674663892494*x_7 + 0.00043059149355054*x_70 + 0.000345737834448948*x_71 + 0.0003966005280995*x_72 + 1.03366090088114e-5*x_73 - 0.000225236339351734*x_74 - 0.000222162462637326*x_75 + 0.000666232989380985*x_76 - 0.000227070188855624*x_77 + 0.000570283559055748*x_78 - 1.85325202557612e-5*x_79 - 4.39190796195139e-5*x_8 - 0.00257851214412805*x_80 - 5.11554872200205e-5*x_81 - 0.000882815009388333*x_82 - 2.73355715993011e-5*x_83 - 0.000191453051243484*x_84 - 0.00165690445244292*x_85 - 0.00118553686245718*x_86 + 0.00127474424540693*x_87 + 0.000509853586790297*x_88 + 0.00122133504122889*x_89 + 0.00540024887225065*x_9 + 0.00092944829131746*x_90 - 4.17372569562087e-5*x_91 - 0.00169045567884771*x_92 + 0.00453803053463235*x_93 + 0.00114521944212439*x_94 - 0.000199985107759467*x_95 + 0.00113027923934583*x_96 - 0.000549241027081807*x_97 - 0.00042757564763693*x_98 + 0.000781260620207454*x_99 - 4.60240557680257e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) - 0.000260604587144842*std::exp(0.237919852137566*x_28) + 0.000570708381029235*std::exp(0.200159847736359*x_49) - 0.00241471880352125*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.00196194308384806*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.000440253222747926*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.000704747602556628*std::sin(0.366799831390381*x_1 - 4.22656011581421) - 0.00300265103860843*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.0289564646791453*std::sin(0.341759830713272*x_10 - 7.55480003356934) + 0.000906874873305242*std::sin(0.370639860630035*x_10 + 8.21944046020508) + 0.0022459383613734*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.00213900950579898*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.0306791406936397*std::sin(0.252879977226257*x_100 + 1.95943987369537) + 0.00230150862937886*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.0254217410816309*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.0305812428913209*std::sin(0.224239990115166*x_102 - 1.20831990242004) - 0.00329861848369148*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.0018091453235756*std::sin(0.238879978656769*x_102 - 1.21063983440399) - 0.000148497099612621*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 0.00071512700164003*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.00233564388655003*std::sin(0.229439988732338*x_106 - 1.21535992622375) - 0.00155481148517552*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.00431071728932128*std::sin(0.252239972352982*x_107 - 7.43511962890625) - 0.000803249772481197*std::sin(0.215519994497299*x_109 + 4.98439979553223) - 0.00266468905558876*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 0.000837850365101722*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.0385679998060079*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00622736541729271*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.0280268235371273*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.00308247532380264*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.00146266253674375*std::sin(0.199520006775856*x_110 - 7.39160013198853) - 0.00600229766955838*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.0359885221659301*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.000729306519638208*std::sin(0.242079973220825*x_110 + 8.17360019683838) - 0.00922185936082776*std::sin(0.213199988007545*x_111 + 1.97535979747772) + 0.00254439690501689*std::sin(0.220319986343384*x_111 - 1.18911993503571) + 0.00601151883286681*std::sin(0.268079966306686*x_112 - 1.21143984794617) + 0.000774397360201917*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.00340240606064139*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.00476329346067059*std::sin(0.299759924411774*x_113 - 1.20455992221832) - 0.0170395691162168*std::sin(0.162400022149086*x_115 + 8.4596004486084) + 0.00181243227355298*std::sin(0.250879973173141*x_116 + 5.16208028793335) + 0.000755657321087308*std::sin(0.203199997544289*x_117 - 4.20279979705811) - 0.0145614427639268*std::sin(0.239599987864494*x_118 + 1.96927976608276) + 0.000916510364781567*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.00102771776234421*std::sin(0.292079925537109*x_119 - 1.4268798828125) + 0.00227887856627783*std::sin(0.279679954051971*x_12 + 5.15056037902832) - 0.00328554799420835*std::sin(0.284559935331345*x_12 + 5.14287996292114) - 0.00275332278918935*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00820004897983927*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.0254059905854267*std::sin(0.324719846248627*x_13 - 4.29655981063843) + 0.00130262551843024*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.0340655552014816*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00416617734531496*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.000693443164932725*std::sin(0.310879945755005*x_14 + 8.31400012969971) - 0.00110912438161926*std::sin(0.369119822978973*x_14 + 4.83024024963379) - 0.00926758887524542*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.00489771285194602*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.00125091076200359*std::sin(0.317439913749695*x_15 - 1.2267199754715) - 0.000559977539143894*std::sin(0.36959981918335*x_15 + 8.21647930145264) - 0.000877757552794979*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00492895219038572*std::sin(0.291199922561646*x_16 - 4.3842396736145) + 0.000751726484393688*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.015981573741039*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00309656650314551*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.00227437353642697*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 0.00167377360522143*std::sin(0.482319831848145*x_16 + 7.94760036468506) + 0.000858534942479738*std::sin(0.291759938001633*x_17 - 1.14455986022949) - 0.0212505418724057*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.00212803364099506*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.000316268061448749*std::sin(0.379279851913452*x_17 + 1.78831994533539) - 0.000287419841545056*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.0634206077871146*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.00929735828608191*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.00138080466249369*std::sin(0.337039858102798*x_18 - 4.15015983581543) + 0.00649601290766932*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.00221289793840974*std::sin(0.396079838275909*x_18 - 1.19023990631104) - 0.000736505579591483*std::sin(0.419119864702225*x_18 - 1.2196798324585) - 0.00166659193065096*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.00385113938530734*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.00442491346065258*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.000799605135342443*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.000533123081473553*std::sin(0.255439966917038*x_20 - 7.40359973907471) - 0.00176201676748154*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.000348356600621579*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00774220929170856*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.00347531165685111*std::sin(0.289999932050705*x_20 + 1.97943985462189) + 0.00131978830407957*std::sin(0.341759830713272*x_20 + 8.23559951782227) - 0.0328311221858546*std::sin(0.346559852361679*x_20 - 4.35752010345459) + 0.00548313667767503*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00546904188136001*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.0122256334543869*std::sin(0.356479853391647*x_21 + 8.22696018218994) + 0.000261511368749468*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.0341870974009919*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.000737447956747345*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 0.000735661972845092*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.00198213314052213*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.00451507109086167*std::sin(0.112400062382221*x_24 + 2.09047985076904) - 0.000653955077171435*std::sin(0.277679949998856*x_24 - 7.55751991271973) - 0.000581474052546979*std::sin(0.336079835891724*x_24 + 2.01231980323792) + 0.00276927108156545*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.0204370503808067*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.00268301251578682*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.00265239768702466*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.00226343538124933*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.00230489516078183*std::sin(0.131920039653778*x_27 - 7.64504051208496) - 0.00283003182713243*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.00270535474794294*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.00383298764068822*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.0023952017376466*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.0155260283171611*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.009261883965501*std::sin(0.325759828090668*x_28 - 1.14023983478546) + 0.00126670515929309*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.00299466502263792*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.00673755895768902*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00289049503694406*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 0.00370165021229215*std::sin(0.138640031218529*x_3 - 7.64983987808228) + 0.00131078851910436*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 0.0254450758409291*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.000891882513553529*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.00147230056145064*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.00196749237462788*std::sin(0.377199828624725*x_3 - 4.3931999206543) - 0.000780961001241679*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00357179057386396*std::sin(0.399679869413376*x_3 + 8.18696022033691) - 0.00588189826383342*std::sin(0.421359837055206*x_3 + 8.18671989440918) + 0.00516968528102886*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.000465735877262217*std::sin(0.322319835424423*x_31 - 1.04135990142822) - 0.00211418668008058*std::sin(0.376239836215973*x_31 + 5.19583988189697) - 0.0196342012288155*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.000489136248554835*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.00119384784987723*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000182309894633882*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.00604602849561014*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.00034584220487421*std::sin(0.375919848680496*x_32 - 7.99271965026855) - 0.00295679901087392*std::sin(0.245119974017143*x_33 + 1.98655986785889) + 0.000440113794906541*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 0.000546997906905274*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.0456846014946466*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.00123918977750477*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.0108633553596534*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.0501494456133269*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.00972025278418025*std::sin(0.198479995131493*x_36 - 1.18119990825653) + 0.00226366693082253*std::sin(0.232639983296394*x_36 - 1.21487987041473) + 0.00178757675183246*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.00525036696001567*std::sin(0.247599974274635*x_36 + 5.15607976913452) + 0.0456612592741943*std::sin(0.265039950609207*x_36 + 8.17183971405029) + 0.00281499618506078*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.00234879398513589*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.000528531194674563*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.0048989494479911*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 0.000569813996661568*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 0.000294997232057673*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00427893066171029*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.00602596372611415*std::sin(0.240399971604347*x_41 + 1.98135983943939) + 0.00167399133919711*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00483009743489267*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.00334104040780547*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.00936978777041712*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.0185822914214149*std::sin(0.293119937181473*x_44 + 8.14287948608398) - 0.00274313749224324*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00129552740733537*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.0131743592160351*std::sin(0.0756000876426697*x_49 + 8.10095977783203) + 0.00994089471211856*std::sin(0.348799854516983*x_49 - 1.33007991313934) + 0.000955239000235726*std::sin(0.303839921951294*x_5 - 4.58752012252808) + 0.00155879035717943*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.000699670805928646*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.0262820214702912*std::sin(0.393919855356216*x_5 + 1.97943985462189) - 0.00445724793905799*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.00432417726735332*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.0457101895224686*std::sin(0.218479990959167*x_52 + 5.18767976760864) + 0.00265707282138747*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.00441152508189487*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.0516114139829295*std::sin(0.20040000975132*x_55 + 8.20783996582031) + 0.00223493809387357*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.0101722702303707*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 2.25026430828417e-5*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.00295618555614894*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.0050946547148506*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00247076196575303*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.01809625319357*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.00115365130934361*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.00875838374225343*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.00250322067029775*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.00172981662340288*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.000370712702026657*std::sin(0.347919851541519*x_7 - 7.36895990371704) + 0.00214066400120677*std::sin(0.358479827642441*x_7 - 1.18127989768982) + 0.0010942273835463*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.000521537519443729*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.00208310823793871*std::sin(0.442559868097305*x_7 - 1.41695988178253) + 0.000466183747170431*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.000433217084452277*std::sin(0.332879841327667*x_8 - 4.35008001327515) - 0.00173290987966059*std::sin(0.33383983373642*x_8 + 8.25695991516113) - 0.000876574874631224*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00088598320345558*std::sin(0.369919836521149*x_8 + 1.81647992134094) - 0.00914554504190906*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.000702556657429224*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.00203603702915114*std::sin(0.463119864463806*x_9 + 4.93391990661621) - 0.0198179331439984*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00314845859496226*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.00038478140976205*std::sin(0.35183984041214*x_91 - 7.39383983612061) - 0.00100425140949426*std::sin(0.356319844722748*x_91 + 5.19551992416382) - 0.00579581515836684*std::sin(0.36303985118866*x_91 + 5.18800020217896) - 0.0151374002483033*std::sin(0.405119866132736*x_91 - 1.19711995124817) + 0.0241345277208594*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.00264278467293*std::sin(0.289599925279617*x_92 + 1.99127984046936) + 0.000766563992681039*std::sin(0.294319927692413*x_92 + 7.99768018722534) - 0.00251119689208294*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.00344527213529093*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.000498967595167829*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.000123175528899564*std::sin(0.273039966821671*x_94 - 7.60464000701904) + 0.00199338201402407*std::sin(0.288959950208664*x_94 - 1.20831990242004) - 0.0022613209102791*std::sin(0.265439957380295*x_95 + 1.96335983276367) - 0.00203950654533083*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.028267869175803*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.00273881486209422*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.000178642538474517*std::sin(0.288799941539764*x_95 + 8.17711925506592) + 0.00195286918770393*std::sin(0.273919969797134*x_97 + 1.96983981132507) + 0.00117123629925575*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.00355147072312649*std::sin(0.277199953794479*x_97 + 1.97303986549377) + 0.0376408879952136*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.000659924301214907*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.00709751416914074*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.000930780703706199*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.0347457363883416*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.00451410359503141*std::sin(0.251759976148605*x_99 + 1.95271980762482) - 0.0469572394137178);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00164339665079729*x_1 + 6.25843168854381e-6*x_10 + 3.2211724245088e-5*x_100 + 7.67810502176723e-5*x_101 - 7.14713625334784e-5*x_102 - 0.00160520652090978*x_103 + 0.00541028998582763*x_104 - 0.00215999998353784*x_105 + 0.00394597750801349*x_106 + 0.000297117528294577*x_107 - 0.00353831960906423*x_108 - 9.13283884695611e-5*x_109 - 0.000313903347349028*x_11 + 8.8977667015176e-5*x_110 + 0.00301421834723755*x_111 - 0.00560827560202174*x_112 - 0.00161384721115201*x_113 + 0.0001936567961064*x_114 + 0.000122999296716491*x_115 - 0.00677351016536904*x_116 - 0.00142922907954702*x_117 + 0.00428242948994262*x_118 - 0.00713685389562961*x_119 - 0.00189482738573577*x_12 - 0.00635636682633709*x_120 + 2.20716412637567e-5*x_13 - 4.46722146690972e-5*x_14 + 0.000142867576448912*x_15 + 0.000188833622667635*x_16 + 0.000347078126367139*x_17 + 7.99510164349928e-5*x_18 + 0.000646310963374311*x_19 + 0.0026028382485336*x_2 + 1.77180806193528e-5*x_20 + 0.000135677312718427*x_21 + 7.8457214102285e-5*x_22 - 0.00205683189900618*x_23 - 9.91070072399966e-5*x_24 + 0.000135233983604533*x_25 - 6.92079812615553e-5*x_26 + 0.00122528442976995*x_27 - 3.09352704523962e-6*x_28 - 0.00185445641841405*x_29 + 4.17179592989615e-6*x_3 + 0.00370324557679416*x_30 + 0.00104692415854193*x_31 + 0.000297403149465646*x_32 + 0.000265215340018189*x_33 - 0.000524079531512801*x_34 + 0.00626683487743953*x_35 + 0.000272687712412398*x_36 - 0.00239017172668494*x_37 - 0.00255924199191697*x_38 + 0.00288930982385306*x_39 - 2.1440587489142e-5*x_4 + 0.000683141271748685*x_40 + 0.000633567065127195*x_41 - 0.00512101164747552*x_42 - 0.00544897523248266*x_43 - 0.00027590954900893*x_44 + 0.00335051170154976*x_45 + 0.000557212524300899*x_46 - 0.00370745205828549*x_47 + 0.00224819339298704*x_48 - 0.00177651677000833*x_49 - 9.52118127561648e-5*x_5 - 0.00402588603761938*x_50 - 0.00328639783722858*x_51 - 0.000228496273735688*x_52 - 0.00125573096239507*x_53 + 0.00709841107417766*x_54 + 0.000119744308090148*x_55 + 0.00632951216239214*x_56 + 0.00312402002762643*x_57 - 0.00102380142803337*x_58 + 0.00174467975417358*x_59 - 0.00537829508902429*x_6 + 0.000155570619083069*x_60 + 0.000586437385400906*x_61 - 0.00244801656764687*x_62 + 0.000280186009783677*x_63 - 0.000146713632819154*x_64 - 4.35112540999909e-5*x_65 - 0.00159039928898942*x_66 + 2.02208999929766e-5*x_67 + 0.00137718162741942*x_68 + 1.38849391119424e-5*x_69 - 0.000133421807478664*x_7 - 0.000139038446250985*x_70 - 6.84623364951639e-5*x_71 + 0.000111777763034112*x_72 + 9.82002845683765e-5*x_73 - 0.000121034858256376*x_74 + 6.25309717693833e-5*x_75 - 2.10354347380471e-7*x_76 - 5.54615790298949e-5*x_77 - 2.47912832414919e-5*x_78 - 0.000168580009518413*x_79 + 0.000764983882590886*x_8 + 0.00213499022488604*x_80 - 0.000213966916169691*x_81 + 4.13870203090336e-5*x_82 - 0.000222328071752468*x_83 + 1.73857702095679e-5*x_84 + 0.00112347881808798*x_85 + 0.0011666300880861*x_86 - 0.00172753825003961*x_87 + 0.000190852699240859*x_88 - 0.000752381323002823*x_89 - 0.00458155040803718*x_9 - 3.47392237425191e-5*x_90 - 2.75129655842718e-5*x_91 + 0.00172951364754561*x_92 - 0.00552795799136771*x_93 - 0.00100693431468392*x_94 + 1.85393022266448e-6*x_95 - 0.00115536530122638*x_96 - 6.03292948321505e-6*x_97 + 6.55429330222615e-5*x_98 + 0.000346387980642339*x_99 + 3.09914937793412e-7*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.000340562727846011*std::exp(0.237919852137566*x_28) + 0.000215698860250402*std::exp(0.200159847736359*x_49) + 0.00339255248335091*std::exp(-0.0025728766008114*x_1 - 0.0022732776036552*x_100 - 0.0215452447484323*x_101 + 0.0745863938429842*x_103 - 0.0025075483002188*x_104 - 0.00262431574819143*x_105 + 0.000321424526867302*x_107 - 0.0715584586776345*x_108 - 0.00455379233915551*x_109 + 0.0512897180169571*x_11 - 0.00313173482623698*x_111 - 0.0463163961527424*x_113 + 0.0523827207907704*x_114 - 0.00254147489479432*x_115 + 0.0594711758456958*x_116 - 0.00661052464913052*x_117 - 0.00900276675467228*x_118 - 0.00278828155856729*x_119 - 0.152510462742564*x_12 + 0.00721239749240508*x_120 - 0.0501809941739386*x_13 + 0.059748442847932*x_14 + 0.103837180894876*x_17 + 0.0388122725274424*x_18 - 0.0256983458841154*x_19 + 5.85521913332842e-5*x_2 + 0.00850330759892242*x_20 + 0.0307876219166489*x_21 + 0.05177143600341*x_22 + 0.0876503067777026*x_23 - 0.088139437854168*x_25 + 0.00054755020994511*x_26 + 0.0640014630658078*x_27 + 0.0485173414445372*x_30 - 0.000558389620222679*x_32 + 0.0770248941660312*x_33 + 0.0779048665472851*x_34 + 0.0240634098397895*x_35 + 0.07985467605921*x_36 - 0.0913887612000759*x_37 - 0.00216638737342371*x_38 - 0.0015600234981836*x_39 + 0.0291434494451834*x_4 - 0.00172396362809249*x_40 - 0.0235222061706271*x_41 - 0.0556269678150665*x_43 + 0.0441852651565577*x_44 - 0.0715872585802513*x_45 + 0.0147381606700403*x_46 - 0.110634254623742*x_47 + 0.103119075992966*x_48 + 0.0774639694789945*x_49 - 0.00438950691330179*x_50 - 0.14992999042416*x_51 - 0.0234224859136837*x_52 + 0.00539139689378632*x_54 - 0.00854984961764679*x_55 + 0.0506467699601015*x_56 - 0.132877070816055*x_57 - 0.172496117637198*x_58 + 0.100245238726171*x_59 - 0.00500026895277523*x_6 - 0.00413943068066498*x_61 + 0.0272150236273896*x_62 - 0.000292027076510545*x_63 + 0.00107447773050934*x_64 - 2.51548001505776e-5*x_65 + 0.0122205855714011*x_66 - 0.0387494527681562*x_67 + 0.00104843725564187*x_68 + 8.96816565663004e-5*x_69 + 0.0264309111759075*x_70 + 0.0358369991296938*x_71 - 0.0165678768784401*x_72 - 0.0115959620521113*x_73 + 0.00508958330840355*x_74 - 0.0262599871731614*x_75 + 0.013257174345299*x_76 - 0.00748599924827208*x_77 + 0.0402347560309107*x_78 - 0.00117997224168798*x_79 + 0.0487036182448333*x_8 - 0.000261361227184168*x_80 - 0.0164185121620533*x_81 - 0.024216031860191*x_82 + 0.00182495151716799*x_83 + 0.0343516866852327*x_84 + 0.00422806551019557*x_85 - 0.0408513513281019*x_86 + 0.00945760104080604*x_87 - 0.0358373256918226*x_88 + 0.000799448689317778*x_89 + 0.00330816598825606*x_9 - 0.0181771633648011*x_90 + 0.00190522955306972*x_92 - 0.00344733444784506*x_93 - 0.00576008000249348*x_95 + 0.0158650205571419*x_96 - 0.0552873193646954*x_97 - 0.046533575733013*x_98 + 0.296600331538013*std::sin(0.527119874954224*x_10 - 4.52896022796631) - 0.435618070694527*std::sin(0.227439999580383*x_102 - 7.42063999176025) + 0.308446911553641*std::sin(0.229439988732338*x_106 - 1.21535992622375) - 0.792668004340157*std::sin(0.213839992880821*x_110 - 7.42335987091064) + 0.449324337198675*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.646795691568698*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.221039817817919*std::sin(0.482319831848145*x_16 + 7.94760036468506) + 0.365712049376402*std::sin(0.377839833498001*x_24 - 4.59847974777222) - 0.316312166755985*std::sin(0.221039995551109*x_28 + 8.60432052612305) - 0.889767170362354*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.488842747907039*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.279201104104075*std::sin(0.376239836215973*x_31 + 5.19583988189697) + 0.637866348065771*std::sin(0.23335999250412*x_42 - 1.1956799030304) - 0.588627559512943*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.582589364152518*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.672803984064977*std::sin(0.334559857845306*x_60 + 1.88487982749939) + 0.330577229318575*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.765399766560577*std::sin(0.36303985118866*x_91 + 5.18800020217896) + 0.263247547844504*std::sin(0.288959950208664*x_94 - 1.20831990242004) + 0.596135960768095*std::sin(0.251759976148605*x_99 + 1.95271980762482)) - 0.000158255818345332*std::sin(0.304559946060181*x_1 + 5.10119962692261) + 0.000371806140731164*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.00219634657940997*std::sin(0.352879852056503*x_1 + 8.36448001861572) + 0.00104386723747633*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.00392391799270131*std::sin(0.121440060436726*x_10 - 4.46895980834961) + 0.0231146703173926*std::sin(0.341759830713272*x_10 - 7.55480003356934) + 5.94347569590528e-5*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.000405361845552899*std::sin(0.239199981093407*x_100 - 1.19463992118835) + 0.0244898067016141*std::sin(0.252879977226257*x_100 + 1.95943987369537) + 0.000150836251011945*std::sin(0.262639969587326*x_100 - 1.2196798324585) - 0.020293056162316*std::sin(0.240559980273247*x_101 + 1.96103990077972) - 0.0244116591980956*std::sin(0.224239990115166*x_102 - 1.20831990242004) + 0.000342849569041101*std::sin(0.238879978656769*x_102 - 1.21063983440399) - 0.000740826142624799*std::sin(0.254799962043762*x_102 + 7.98680019378662) - 0.00105924113106398*std::sin(0.237279981374741*x_104 - 1.20263981819153) - 0.000101899220563637*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.00162923278696458*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 0.00104970114553602*std::sin(0.215519994497299*x_109 + 4.98439979553223) - 0.00017463836638581*std::sin(0.237919986248016*x_109 + 1.9521598815918) - 0.00124101812175657*std::sin(0.249039977788925*x_109 + 1.95839989185333) + 0.0307871354530097*std::sin(0.25095996260643*x_109 - 1.24199986457825) + 0.000419335830732655*std::sin(0.253679990768433*x_109 + 8.17984008789063) - 0.0223725787413203*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.00116501953746525*std::sin(0.28383994102478*x_11 - 7.43631982803345) - 0.000277187915111233*std::sin(0.199520006775856*x_110 - 7.39160013198853) + 0.028728052070347*std::sin(0.220159992575645*x_110 + 1.96663987636566) + 0.00108024373430492*std::sin(0.242079973220825*x_110 + 8.17360019683838) + 0.00024100228791719*std::sin(0.213199988007545*x_111 + 1.97535979747772) + 0.000166754660547469*std::sin(0.220319986343384*x_111 - 1.18911993503571) + 0.00227204962065692*std::sin(0.268079966306686*x_112 - 1.21143984794617) + 5.0752446945171e-5*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.001800283655642*std::sin(0.299759924411774*x_113 - 1.20455992221832) + 0.0136019374891246*std::sin(0.162400022149086*x_115 + 8.4596004486084) + 0.000118783169381193*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.000987506480241921*std::sin(0.203199997544289*x_117 - 4.20279979705811) + 0.000380545927255018*std::sin(0.239599987864494*x_118 + 1.96927976608276) + 6.00662477092476e-5*std::sin(0.251519978046417*x_118 - 1.22175991535187) + 0.000194761906257042*std::sin(0.292079925537109*x_119 - 1.4268798828125) + 0.000149353122148229*std::sin(0.279679954051971*x_12 + 5.15056037902832) - 0.00124177072074999*std::sin(0.284559935331345*x_12 + 5.14287996292114) - 0.000180447243188985*std::sin(0.254559963941574*x_13 + 1.98231983184814) + 0.000552171603975708*std::sin(0.287439942359924*x_13 + 1.95335984230042) + 0.0202804832349531*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.001702294287214*std::sin(0.225679993629456*x_14 - 4.19647979736328) - 0.0271930322429275*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00157460400943271*std::sin(0.294079929590225*x_14 + 1.97463977336884) - 0.00102712318324915*std::sin(0.310879945755005*x_14 + 8.31400012969971) - 7.26897833420426e-5*std::sin(0.369119822978973*x_14 + 4.83024024963379) + 0.000242197374197383*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.000472780906340525*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.000731788647132856*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.00114706924326375*std::sin(0.259519964456558*x_16 + 8.21255970001221) - 0.000331903802474385*std::sin(0.291199922561646*x_16 - 4.3842396736145) + 4.92666432986326e-5*std::sin(0.308079928159714*x_16 - 1.1775997877121) + 0.0127573863822978*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00117034528950407*std::sin(0.330239832401276*x_16 - 4.33816003799438) - 0.000431014566182742*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 5.62666550250341e-5*std::sin(0.291759938001633*x_17 - 1.14455986022949) + 0.0169633715610446*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.000804288926175125*std::sin(0.36695984005928*x_17 - 7.37695980072021) + 0.000468454048525795*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.000375605381110382*std::sin(0.166160017251968*x_18 + 7.98320007324219) + 0.0506258777295975*std::sin(0.170800015330315*x_18 - 7.62080001831055) - 0.000626061777214324*std::sin(0.257679969072342*x_18 - 1.18119990825653) - 0.000261675100002613*std::sin(0.337039858102798*x_18 - 4.15015983581543) - 0.000169765544217471*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.000836363332013157*std::sin(0.396079838275909*x_18 - 1.19023990631104) - 4.82690957821613e-5*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.00217793209370173*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.00145553561799485*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.00167239315541177*std::sin(0.387439846992493*x_2 + 5.19392013549805) - 0.000151532479167229*std::sin(0.436879843473434*x_2 + 2.02287983894348) + 0.000789658192910205*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.00230263497438134*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.00173789035186272*std::sin(0.277519941329956*x_20 + 2.00039982795715) + 0.000521341778985585*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.00131349177323422*std::sin(0.289999932050705*x_20 + 1.97943985462189) + 8.64962735205998e-5*std::sin(0.341759830713272*x_20 + 8.23559951782227) + 0.0262076387392214*std::sin(0.346559852361679*x_20 - 4.35752010345459) - 0.000143295232835098*std::sin(0.43343985080719*x_20 + 4.7992000579834) - 0.000368272145113464*std::sin(0.316399931907654*x_21 + 1.97503972053528) - 0.00975918468814198*std::sin(0.356479853391647*x_21 + 8.22696018218994) + 0.00130463462969033*std::sin(0.356319844722748*x_22 - 7.38351964950562) - 0.0272900540272668*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.00367899929768892*std::sin(0.151280030608177*x_23 + 8.14335918426514) + 0.0010896573873034*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.000749145927214397*std::sin(0.343919843435287*x_23 + 2.00119972229004) - 0.000855647226079333*std::sin(0.112400062382221*x_24 + 2.09047985076904) - 4.28589017271631e-5*std::sin(0.277679949998856*x_24 - 7.55751991271973) - 0.00290087268039932*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 0.0163139971348959*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.00101404282980582*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.00100247197524985*std::sin(0.330559849739075*x_26 + 5.04143953323364) + 0.000152414302406314*std::sin(0.432159870862961*x_26 - 4.42119979858398) - 0.00341399464919012*std::sin(0.131920039653778*x_27 - 7.64504051208496) - 0.000185474599399762*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.00102248706187199*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.00144867517795919*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.012393744535677*std::sin(0.29911994934082*x_28 + 1.9845597743988) - 0.000623673021666245*std::sin(0.325759828090668*x_28 - 1.14023983478546) + 8.30173108743995e-5*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.00113183169143201*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.000194638993591049*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 8.59064456971257e-5*std::sin(0.287599951028824*x_3 + 5.06271982192993) - 0.0203116832728452*std::sin(0.289759933948517*x_3 - 1.13751995563507) - 0.00132105016348993*std::sin(0.295359939336777*x_3 - 4.13687992095947) - 0.000279014408856155*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.000743612459297054*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 0.0010205737812911*std::sin(0.393519848585129*x_3 + 1.98551976680756) - 0.000240515798757391*std::sin(0.399679869413376*x_3 + 8.18696022033691) + 0.000153716390959227*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.00675583703533977*std::sin(0.103840067982674*x_30 - 7.68088006973267) + 0.000689844735658056*std::sin(0.322319835424423*x_31 - 1.04135990142822) + 0.000513116415293749*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.00244021547343437*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.000451214015933155*std::sin(0.457759857177734*x_31 + 8.22959995269775) - 0.000270036145402537*std::sin(0.295679926872253*x_32 - 7.37351989746094) - 0.000407125037949385*std::sin(0.320079833269119*x_32 + 1.98847985267639) + 6.55402577958756e-5*std::sin(0.375919848680496*x_32 - 7.99271965026855) - 0.000193782665901372*std::sin(0.245119974017143*x_33 + 1.98655986785889) + 0.00219565099821561*std::sin(0.262479960918427*x_33 - 1.20239984989166) + 0.000810209487645136*std::sin(0.266639977693558*x_33 - 1.23087990283966) - 0.0364680051184131*std::sin(0.270159959793091*x_33 + 8.16936016082764) + 0.0002348377853571*std::sin(0.226719990372658*x_34 - 7.41680002212524) - 0.000731512259042082*std::sin(0.243759974837303*x_34 + 1.95839989185333) - 0.0400320935168208*std::sin(0.244799971580505*x_34 + 1.96495985984802) + 0.000654538477036676*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00295820036531918*std::sin(0.232639983296394*x_36 - 1.21487987041473) + 0.000117154188431302*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.00198437276692759*std::sin(0.247599974274635*x_36 + 5.15607976913452) - 0.0364493720519732*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00367868727931324*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.000887725154207712*std::sin(0.249839976429939*x_38 - 4.424880027771) + 0.000782856722184691*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.00185155474754082*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 3.73444643802009e-5*std::sin(0.345279842615128*x_4 - 4.37623977661133) - 0.000436947844269487*std::sin(0.410959869623184*x_4 - 1.20031988620758) + 0.000288132913911414*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.00227750905863515*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.00218760177291395*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00126274404226291*std::sin(0.223600000143051*x_44 - 1.18495988845825) - 0.000630939004733189*std::sin(0.254719972610474*x_44 + 8.17759990692139) + 0.0148334247535772*std::sin(0.293119937181473*x_44 + 8.14287948608398) - 0.000179779719293057*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00048964373833347*std::sin(0.299679934978485*x_48 + 7.96231985092163) - 0.000887129708317038*std::sin(0.0756000876426697*x_49 + 8.10095977783203) - 0.000259793418639755*std::sin(0.348799854516983*x_49 - 1.33007991313934) + 6.26044446571731e-5*std::sin(0.303839921951294*x_5 - 4.58752012252808) + 0.0005891437984607*std::sin(0.366399854421616*x_5 + 8.22288036346436) - 0.000132594010639882*std::sin(0.389279842376709*x_5 - 1.38399982452393) + 0.0209797801040934*std::sin(0.393919855356216*x_5 + 1.97943985462189) + 0.000819471102321021*std::sin(0.193999990820885*x_50 + 2.01047992706299) - 0.0364884309139559*std::sin(0.218479990959167*x_52 + 5.18767976760864) + 0.000174139213700008*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.04119911847143*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.0029206570082111*std::sin(0.226319998502731*x_57 - 1.19551992416382) - 0.000684976246238012*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 0.000112261763478291*std::sin(0.933999836444855*x_6 - 8.37304019927979) - 0.00019906243538323*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.000468231967947916*std::sin(0.418079853057861*x_60 - 4.41295957565308) - 0.0144454418446562*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.000436021759664771*std::sin(0.516559839248657*x_60 + 1.67543983459473) - 0.00058976852590576*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.000327816055529289*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.00184942104445711*std::sin(0.347919851541519*x_7 - 7.36895990371704) + 0.00014029481727618*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.00142995588338287*std::sin(0.367679834365845*x_7 - 1.17919993400574) - 0.000772497739172144*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.000787309399401628*std::sin(0.442559868097305*x_7 - 1.41695988178253) - 0.000372133951522472*std::sin(1.39911985397339*x_78 - 6.79120016098022) + 0.000641678126373494*std::sin(0.332879841327667*x_8 - 4.35008001327515) - 0.00011357143147454*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 0.00114552369832141*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.000334856773684876*std::sin(0.369919836521149*x_8 + 1.81647992134094) + 0.000239007904274953*std::sin(0.16176001727581*x_9 + 8.17623996734619) - 0.00104062202482245*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.00076951886675205*std::sin(0.463119864463806*x_9 + 4.93391990661621) + 0.0158197831148071*std::sin(0.31007993221283*x_91 - 4.15040016174316) + 0.000212009640028454*std::sin(0.340319842100143*x_91 + 5.19456005096436) + 0.000569935542573606*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.00131237367387735*std::sin(0.356319844722748*x_91 + 5.19551992416382) + 0.000395597888692144*std::sin(0.405119866132736*x_91 - 1.19711995124817) - 0.000630727076931466*std::sin(0.28519994020462*x_92 + 5.19591999053955) + 0.000500831842735388*std::sin(0.289599925279617*x_92 + 1.99127984046936) + 5.02390637779018e-5*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.00328167693859842*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.00130213835565988*std::sin(0.302559942007065*x_92 - 1.19743990898132) + 0.000739067324625908*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.000614501240620039*std::sin(0.273039966821671*x_94 - 7.60464000701904) - 0.000854664762637535*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.0026652635709425*std::sin(0.281839966773987*x_95 + 1.94663977622986) + 0.0225649948574163*std::sin(0.283279925584793*x_95 + 4.98383951187134) - 0.000519030441013176*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.000891216481884274*std::sin(0.288799941539764*x_95 + 8.17711925506592) + 0.00012798712254644*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.00153059250950602*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.00134227604264289*std::sin(0.277199953794479*x_97 + 1.97303986549377) - 0.0300470629306446*std::sin(0.287119954824448*x_97 - 4.41831970214844) + 0.000977475275905392*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.00268250084944225*std::sin(0.257279962301254*x_98 - 7.43447971343994) + 0.000176391447927875*std::sin(0.264959961175919*x_98 + 1.95287978649139) - 0.0277359909246786*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.187636562205789);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00190445305434912*x_1 + 0.00219521983108776*x_10 - 0.000364828103669222*x_100 - 0.000401847772231303*x_101 + 0.00150613507894288*x_102 - 0.00448070513405882*x_103 + 0.00733734369515059*x_104 + 0.000214153626675138*x_105 + 0.00622545431841125*x_106 - 0.000864047608542387*x_107 - 0.00402149836386943*x_108 - 7.81762538215671e-5*x_109 + 0.000225224454530771*x_11 - 0.000172779271601144*x_110 + 0.003745642396887*x_111 - 0.00618959196129313*x_112 - 0.00246650135189737*x_113 + 0.00132153599846891*x_114 - 0.00101442978916236*x_115 - 0.00674684309966932*x_116 - 8.044438010225e-5*x_117 + 0.00405739852987783*x_118 - 0.00623967949523172*x_119 - 0.00343738392887047*x_12 - 0.00770644902563746*x_120 - 0.000538231832176938*x_13 + 0.000340204768066892*x_14 - 0.00130402106145983*x_15 - 9.12425182863448e-5*x_16 + 0.00196546343951163*x_17 + 0.000290150747556748*x_18 - 0.00408164418110286*x_19 + 0.00308910873544702*x_2 - 0.000284983902414001*x_20 - 0.000264945140746543*x_21 + 0.000510067685183944*x_22 - 0.00185912271284159*x_23 - 0.000311901714619676*x_24 - 0.00256103598951946*x_25 - 0.00196055522930502*x_26 + 0.00169571513941795*x_27 - 8.7124659825416e-5*x_28 - 0.00216228036019911*x_29 + 0.001423452625974*x_30 + 0.00172488031880271*x_31 + 0.000306455186825885*x_32 + 0.000749121205010937*x_33 + 0.00142963699184665*x_34 + 0.00558258779545072*x_35 + 0.00123293452229955*x_36 - 0.00256934480404893*x_37 - 0.00392897523309221*x_38 - 4.42589496768277e-5*x_39 + 0.00273872401456016*x_4 - 0.00111586325331746*x_40 - 0.00105388773547143*x_41 - 0.00164244562119093*x_42 - 0.00705868143885625*x_43 - 0.000595056200171017*x_44 - 0.000565922546000902*x_45 - 0.000571807195692099*x_46 - 0.00455712115217317*x_47 - 0.00079514728499972*x_48 + 0.000801099925146206*x_49 + 0.00217357980024899*x_5 - 0.00169533800849556*x_50 - 0.00801253899725892*x_51 - 0.00116872969012573*x_52 - 0.00126871407024162*x_53 + 0.00772218449042013*x_54 + 0.00301529645104016*x_55 + 0.00784466013437292*x_56 + 0.00138427625214038*x_57 - 0.00402091817594141*x_58 + 0.00187447819508309*x_59 - 0.00565027548167907*x_6 - 0.000132530879799991*x_60 + 0.000662510139384425*x_61 - 0.00247506834576822*x_62 + 0.000175143308400015*x_63 + 0.000492215439782955*x_64 - 0.000603854466174344*x_65 - 0.00163433001269544*x_66 - 0.00117526967637429*x_67 + 0.00146245311163723*x_68 - 0.000392675168482583*x_69 - 5.08495367371521e-5*x_7 - 3.44299453443133e-6*x_70 + 0.000514214621402229*x_71 + 0.000829371170797002*x_72 - 0.000740910158033211*x_73 + 5.20219796287485e-5*x_74 - 0.000164707026896851*x_75 + 0.000433361409876942*x_76 + 0.000487227878335624*x_77 + 0.000521611553699089*x_78 - 0.00103283175659016*x_79 + 0.00186492290819225*x_8 + 0.00240329481061608*x_80 - 5.97982217771778e-5*x_81 - 0.0014207706286865*x_82 - 0.000143612967082301*x_83 - 0.000375272168698154*x_84 + 0.00122063542997914*x_85 + 0.00308639466785599*x_86 - 0.0038399107350048*x_87 + 0.00131008481517259*x_88 - 0.000986225158443271*x_89 - 0.00706552316811705*x_9 + 0.000169674173088986*x_90 - 3.23651866816281e-5*x_91 + 0.00296794222253132*x_92 - 0.00416695494871748*x_93 - 0.000866547654391604*x_94 - 0.000132287503759526*x_95 + 0.000310698849618352*x_96 - 0.000549626609205277*x_97 - 0.000637990121805044*x_98 + 0.00115616951465346*x_99 - 9.18376755269342e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 2.51782009121069e-5*std::exp(0.237919852137566*x_28) - 0.000190441318038584*std::exp(0.200159847736359*x_49) + 0.000269385634431844*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.00752327827224225*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.000778133135305547*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.000290099848000798*std::sin(0.121440060436726*x_10 - 4.46895980834961) + 0.0257700220916861*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.000101170812410697*std::sin(0.370639860630035*x_10 + 8.21944046020508) + 0.00256480500740116*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.00820225819575477*std::sin(0.239199981093407*x_100 - 1.19463992118835) + 0.0273031304818934*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.000256755925937002*std::sin(0.262639969587326*x_100 - 1.2196798324585) - 0.0226242684161155*std::sin(0.240559980273247*x_101 + 1.96103990077972) - 0.0272160056012687*std::sin(0.224239990115166*x_102 - 1.20831990242004) - 0.00376693917784298*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.00693735909886317*std::sin(0.238879978656769*x_102 - 1.21063983440399) + 0.000789593343644044*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.00266724645642823*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.000173454514763851*std::sin(0.238159984350204*x_106 + 8.17735958099365) - 0.00143845562735481*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 7.76056337906868e-5*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.000297272274832414*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 0.000925095919657441*std::sin(0.249039977788925*x_109 + 1.95839989185333) + 0.0343238795911707*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.0124262574220653*std::sin(0.253679990768433*x_109 + 8.17984008789063) - 0.024942681011461*std::sin(0.267999976873398*x_11 - 1.19399988651276) - 0.00102860003987976*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.00560873420482935*std::sin(0.199520006775856*x_110 - 7.39160013198853) - 0.00685447267100496*std::sin(0.213839992880821*x_110 - 7.42335987091064) + 0.0320282541926153*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.000805249378169054*std::sin(0.242079973220825*x_110 + 8.17360019683838) - 0.00288919052595811*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.000283852502206417*std::sin(0.220319986343384*x_111 - 1.18911993503571) - 0.00200600097703188*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 8.63916427354321e-5*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.00388546197510461*std::sin(0.301439940929413*x_112 - 1.24199986457825) - 0.00158947706921481*std::sin(0.299759924411774*x_113 - 1.20455992221832) + 0.0151644918474447*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.000202194647742768*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 7.30075094206464e-5*std::sin(0.203199997544289*x_117 - 4.20279979705811) - 0.00456207157707535*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.000102245746262467*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.00394089246272977*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.000254231319801987*std::sin(0.279679954051971*x_12 + 5.15056037902832) + 0.00109636394224253*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.000307160239643572*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.0163626048367217*std::sin(0.287439942359924*x_13 + 1.95335984230042) + 0.0226102511443376*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.00012585260825837*std::sin(0.225679993629456*x_14 - 4.19647979736328) - 0.030316895375007*std::sin(0.261919975280762*x_14 + 1.97167980670929) + 0.0013902236784983*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.00076565156394689*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.000123733734450004*std::sin(0.369119822978973*x_14 + 4.83024024963379) - 0.002903517493508*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.00559306464661954*std::sin(0.26463994383812*x_15 - 1.01159977912903) - 0.000417420003251029*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 5.41019908409974e-5*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 8.48041711718146e-5*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00983536770922509*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 8.38624835414839e-5*std::sin(0.308079928159714*x_16 - 1.1775997877121) + 0.0142229209584104*std::sin(0.308479934930801*x_16 - 1.17567980289459) + 0.00103330216596723*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.00872132588882428*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 0.00191140727535492*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 9.57780176410404e-5*std::sin(0.291759938001633*x_17 - 1.14455986022949) + 0.0189120785144259*std::sin(0.358159840106964*x_17 + 1.98871982097626) - 0.000710109654760417*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.000349201128686846*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 2.77689452662061e-5*std::sin(0.166160017251968*x_18 + 7.98320007324219) + 0.0564416437521524*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.0185522062166463*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.00529484152780555*std::sin(0.337039858102798*x_18 - 4.15015983581543) + 0.00203518815620445*std::sin(0.350399851799011*x_18 + 2.01143980026245) + 0.000738428265790667*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 8.21644418934091e-5*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.000161017067765979*std::sin(0.254959970712662*x_19 + 1.82567989826202) + 0.00128509775722159*std::sin(0.262319952249527*x_19 - 7.57184028625488) - 0.00147656207559739*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.00306617046672747*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.000588637312685909*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.000170236497631156*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.0154490188430442*std::sin(0.283439934253693*x_20 + 1.97463977336884) - 0.00115968672359777*std::sin(0.289999932050705*x_20 + 1.97943985462189) - 0.000147235367154034*std::sin(0.341759830713272*x_20 + 8.23559951782227) + 0.0292183024895873*std::sin(0.346559852361679*x_20 - 4.35752010345459) + 0.00171785601165904*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.0109130776365105*std::sin(0.316399931907654*x_21 + 1.97503972053528) - 0.010880293837504*std::sin(0.356479853391647*x_21 + 8.22696018218994) - 0.0304250627635732*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.000812266626205399*std::sin(0.3435198366642*x_23 - 1.15847992897034) + 0.000661423697910714*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.0173135176627475*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 7.29551213569293e-5*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 0.00316243778502764*std::sin(0.377839833498001*x_24 - 4.59847974777222) - 0.0181881056834123*std::sin(0.42087984085083*x_24 + 1.98071980476379) - 0.000895302148706813*std::sin(0.424319863319397*x_25 + 1.77583980560303) + 0.00088508619860901*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.00451652164613816*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.0025449044331664*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.000315717887359247*std::sin(0.186720013618469*x_27 - 4.40975952148438) - 0.000902757592294413*std::sin(0.342079848051071*x_27 - 1.15599977970123) - 0.00127904064945014*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.00273526002142612*std::sin(0.221039995551109*x_28 + 8.60432052612305) - 0.0138175049047872*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.0184814197748892*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.000141313420211354*std::sin(0.347279846668243*x_28 - 4.38199949264526) + 0.000999298368400863*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.00769412253227388*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00576777384968108*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 0.00422719125485209*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.000146231352615463*std::sin(0.287599951028824*x_3 + 5.06271982192993) - 0.0226450353595005*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.000984754448369812*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.0056456922299941*std::sin(0.371919840574265*x_3 - 1.20223987102509) - 0.000656538178709177*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 7.54522136744068e-5*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00712724983269659*std::sin(0.399679869413376*x_3 + 8.18696022033691) - 0.00184278723775632*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.000499466936035791*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.000514233063132994*std::sin(0.322319835424423*x_31 - 1.04135990142822) - 0.00241434790772069*std::sin(0.376239836215973*x_31 + 5.19583988189697) - 0.00615135689620376*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.000398378516289044*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000201293866618422*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.0120644127063698*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.00132616851476207*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.000329860013625685*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 0.000603956926936225*std::sin(0.266639977693558*x_33 - 1.23087990283966) - 0.0406573524362184*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.00475180427252818*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.0216770401479207*std::sin(0.243759974837303*x_34 + 1.95839989185333) - 0.0446308738190684*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.0193960616103177*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.000218703213964015*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.000199421769808471*std::sin(0.241119980812073*x_36 + 1.96823978424072) - 0.00175201002348763*std::sin(0.247599974274635*x_36 + 5.15607976913452) - 0.0406365788527236*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.000271969654451562*std::sin(0.224559992551804*x_37 - 1.2190397977829) - 0.000783775807749115*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.000583567271640145*std::sin(0.229519993066788*x_39 - 1.18871986865997) - 0.00163474450506103*std::sin(0.334719836711884*x_4 - 7.37951993942261) - 6.35683561891267e-5*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 0.000325715362854393*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00853829674840184*std::sin(0.236879989504814*x_41 + 1.98095989227295) + 0.00201082113492756*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.000161731958463211*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00551584954436272*std::sin(0.23335999250412*x_42 - 1.1956799030304) - 0.00111488136504175*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.018696734015641*std::sin(0.254719972610474*x_44 + 8.17759990692139) + 0.0165374490895256*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.000306023969583595*std::sin(0.262559950351715*x_48 + 8.17479991912842) - 0.000432308259715953*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.0262884812467584*std::sin(0.0756000876426697*x_49 + 8.10095977783203) + 0.00311446289712469*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.000106566306493863*std::sin(0.303839921951294*x_5 - 4.58752012252808) - 0.000520157229216999*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.00268296171040855*std::sin(0.389279842376709*x_5 - 1.38399982452393) + 0.0233898813756557*std::sin(0.393919855356216*x_5 + 1.97943985462189) - 0.00509006481653118*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.0165815151054212*std::sin(0.193999990820885*x_50 + 2.01047992706299) - 0.0406801246927615*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.000296422608991694*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.00503785046594101*std::sin(0.24975997209549*x_53 - 1.19007992744446) - 0.0459319634928068*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.000215927589649044*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.0202980297411793*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 0.00589885453101739*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.00581796729080239*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00947439809333016*std::sin(0.418079853057861*x_60 - 4.41295957565308) - 0.0161048957371825*std::sin(0.472959846258163*x_60 - 4.67736005783081) - 0.000384965217283326*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.0174767214848599*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.00285861492026154*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.00663316480735291*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.000238812125548356*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.00010571831143995*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.000575845343371166*std::sin(0.383679836988449*x_7 - 1.19735991954803) - 0.00069511836804401*std::sin(0.442559868097305*x_7 - 1.41695988178253) - 0.000414883708922495*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.000478328080819107*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.000193323142497933*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 8.46899072260122e-5*std::sin(0.357119828462601*x_8 + 8.24271965026855) - 0.000295646278615776*std::sin(0.369919836521149*x_8 + 1.81647992134094) - 0.00286528139889515*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.000775714046549396*std::sin(0.339039832353592*x_9 - 4.36039972305298) + 0.000679411041253034*std::sin(0.463119864463806*x_9 + 4.93391990661621) + 0.0176371176727321*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00628252147771406*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.000424848787990555*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 9.70253211255246e-5*std::sin(0.356319844722748*x_91 + 5.19551992416382) - 0.00661867484691821*std::sin(0.36303985118866*x_91 + 5.18800020217896) - 0.00474251793199201*std::sin(0.405119866132736*x_91 - 1.19711995124817) + 0.00756130039629249*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.0101340373590618*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 8.55177535371237e-5*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.000242618215478999*std::sin(0.300319939851761*x_92 + 2.00071978569031) + 0.00114966274941177*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.000550925207599573*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.00227639202355756*std::sin(0.288959950208664*x_94 - 1.20831990242004) + 0.000754586666285006*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.000197046054033408*std::sin(0.281839966773987*x_95 + 1.94663977622986) + 0.0251572013785917*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.0105022752766478*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.000217861766895953*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.000113158494949376*std::sin(0.275439947843552*x_97 + 1.9748797416687) + 0.00118510046105842*std::sin(0.277199953794479*x_97 + 1.97303986549377) - 0.0334987895081662*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.000728642373107494*std::sin(0.294079929590225*x_97 - 4.4256796836853) - 0.0023683898784368*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.00356917705822577*std::sin(0.264959961175919*x_98 + 1.95287978649139) - 0.0309222277042798*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.00515499254279813*std::sin(0.251759976148605*x_99 + 1.95271980762482) + 0.0176511537283659*std::sin(0.0157654139059157*x_10 + 0.0104332952343203*x_100 + 0.0285385147829933*x_101 + 0.0667214557945332*x_103 - 0.0074667499448572*x_104 + 0.0136298977075615*x_105 - 0.155413048140688*x_106 + 0.0191897710792371*x_107 + 0.00961338562623412*x_108 - 0.000765789817911863*x_109 - 0.274156652693913*x_11 + 4.31992590018054e-5*x_110 + 0.341866159630982*x_111 + 0.152502055252333*x_112 + 0.000375571547969296*x_113 - 0.00115374783108765*x_114 + 0.0179924743378933*x_115 + 0.0647220464946213*x_116 + 0.0292089006826408*x_117 - 0.089721751516582*x_118 - 0.000693956168541612*x_119 + 0.0677066069341159*x_12 + 0.00226230187847205*x_120 - 0.0137334208534489*x_13 - 0.042040288684116*x_14 + 0.001193463515527*x_15 - 0.000218428741033659*x_16 + 0.337409860052118*x_17 + 0.0159700239046106*x_18 + 0.188497559255722*x_19 - 0.00594313057590843*x_2 + 0.0177933456093597*x_21 + 0.00112972439002404*x_25 + 0.0147657211975439*x_26 - 0.04258954062227*x_27 + 0.0144638228545453*x_28 + 0.0567878165735874*x_29 + 0.0035157961370077*x_3 - 0.0187356746434165*x_30 + 0.00901298230846755*x_32 + 0.00161511280659047*x_34 + 0.229967030444829*x_35 + 0.237104785420976*x_36 - 0.00626483305697561*x_37 + 0.00317023531599086*x_38 + 0.165049689087585*x_39 + 0.0245371688202031*x_4 + 0.0791275436228824*x_40 + 0.0897646229825893*x_41 + 0.0241796138287855*x_42 + 0.179337284776266*x_43 - 0.175009435029389*x_44 - 0.0403023698973877*x_45 + 0.0333185062466449*x_46 - 0.159070589761862*x_47 + 0.055739395956483*x_48 + 0.101550504239274*x_49 + 0.00868280600655111*x_5 - 0.002353032347759*x_50 - 0.0680440993295288*x_51 - 0.0715727257996403*x_52 + 0.0390785659413883*x_53 - 0.0143070572395456*x_54 + 0.0267637411953636*x_55 + 0.331933333891383*x_56 + 0.0438480800551721*x_57 + 0.0517492597457398*x_58 + 0.434187212516499*x_59 + 0.0656705842735825*x_60 + 0.0922422425611066*x_61 + 0.000456396585353295*x_62 + 0.000888566886792391*x_63 + 0.00269168330676034*x_64 + 0.00111513625829557*x_65 - 0.00149231876403086*x_66 - 0.000573595497016091*x_67 - 0.0146851456872561*x_68 - 0.0627157194354728*x_69 + 0.00161072083411478*x_70 - 0.0277581897904446*x_71 - 0.00172745558790851*x_72 - 0.0037560437924475*x_73 - 0.00445526856632808*x_74 + 0.00558262428043812*x_75 - 0.0443250550956873*x_76 + 0.000373114879647159*x_77 + 0.0014166308586041*x_78 + 0.0509429863679643*x_79 - 0.00134140514228867*x_8 - 0.00618884456659327*x_80 + 0.00121006491402548*x_81 - 0.00117130729351349*x_82 + 0.00862464728553878*x_83 - 0.0199513114441488*x_84 - 0.00184564824094287*x_85 - 0.00417908113248371*x_86 + 0.00184266281406855*x_87 - 0.00441403366672086*x_88 + 0.0466860684925513*x_89 + 0.0043847656223661*x_9 - 0.00270020718026721*x_90 - 0.0123771819416434*x_91 + 0.00398737437849532*x_92 - 0.0608580434214243*x_93 - 0.0168095273323693*x_96 + 0.0030759122696776*x_97 - 0.000408233497406706*x_98 - 0.00297032910263249*x_99 - 1.85097903856766*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.62433391618449*std::sin(0.254799962043762*x_102 + 7.98680019378662) - 1.46461339152177*std::sin(0.277519941329956*x_20 + 2.00039982795715) + 1.0994855616981*std::sin(0.356319844722748*x_22 - 7.38351964950562) - 3.10048998949733*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 2.44472096312558*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 2.05650043269986*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 1.85039283499557*std::sin(0.262479960918427*x_33 - 1.20239984989166) + 0.0946090079675761*std::sin(0.933999836444855*x_6 - 8.37304019927979) - 1.55860628685279*std::sin(0.347919851541519*x_7 - 7.36895990371704) + 0.517873147263977*std::sin(0.273039966821671*x_94 - 7.60464000701904) - 0.751075919555902*std::sin(0.288799941539764*x_95 + 8.17711925506592) + 13.1780734273697) + 0.28675266090194);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000334561918012276*x_1 + 0.0011031108787358*x_10 - 1.61008262508496e-5*x_100 + 0.00187268190907092*x_101 + 0.000661180665445745*x_102 - 0.00193533461190086*x_103 - 0.000458951846637988*x_104 + 0.000252508296332041*x_105 + 0.000257815972713397*x_106 - 2.90923966032652e-6*x_107 + 0.00211727184747582*x_108 - 0.000375270944672294*x_109 - 0.00100356285285313*x_11 + 0.000323004257634148*x_110 - 0.0013935646627765*x_111 + 0.000750952165101948*x_112 + 0.000842973185390548*x_113 - 0.00150612012220268*x_114 - 0.000956301948130327*x_115 - 0.000494516068174409*x_116 + 0.00128091316517912*x_117 - 0.00103031011835863*x_118 + 0.000715632730993871*x_119 + 0.00326772670904538*x_12 - 0.000339899945007368*x_120 + 0.00158027323482614*x_13 - 0.0010481042239914*x_14 - 0.000414454342769167*x_15 - 1.1127050791685e-5*x_16 - 0.00199403608293492*x_17 - 0.000793304782953225*x_18 - 0.000860022211878715*x_19 - 0.000184744740751877*x_2 - 0.000318540454962433*x_20 - 0.000848259469582211*x_21 - 0.0012280275047758*x_22 - 0.00161644406412656*x_23 - 0.000477413432734122*x_24 + 0.00105219464782693*x_25 - 0.00057534207359218*x_26 - 0.00146354926849626*x_27 - 4.63123203829736e-5*x_28 + 0.000329798231128035*x_29 - 1.92086544862949e-6*x_3 - 0.00123440641677032*x_30 + 0.000100847921596518*x_31 + 0.000295686600435346*x_32 - 0.000209215462746699*x_33 - 0.00228299204705014*x_34 - 0.00261408794431146*x_35 - 0.00170695759141887*x_36 + 0.00157291762557175*x_37 - 0.000642224828471732*x_38 - 0.0029126998705616*x_39 + 3.1311589204026e-5*x_4 - 0.000497830475374107*x_40 - 7.17057018606595e-5*x_41 + 4.68920524741877e-5*x_42 + 0.00282110284713907*x_43 - 0.00175074207062925*x_44 - 0.00130879044139176*x_45 - 0.00138226095219749*x_46 + 0.0027226462778418*x_47 - 0.00322337896662835*x_48 - 0.000981640453018313*x_49 + 0.000489212346448135*x_5 + 0.00233503163674536*x_50 + 0.00266767873356038*x_51 - 0.00115882050931534*x_52 + 4.950527859171e-5*x_53 - 0.00068583382840086*x_54 + 0.00370494234809128*x_55 - 0.000931534169419061*x_56 + 0.00174573646271009*x_57 + 0.00425536914829122*x_58 - 0.00269124597008951*x_59 + 0.000952259853479208*x_6 - 0.000477805525846574*x_60 - 0.000410293677122366*x_61 - 0.000222197649588759*x_62 + 0.000715579466329776*x_63 - 0.000116003040390669*x_64 - 0.000248012292013877*x_65 - 0.000490018905208086*x_66 + 0.000783611643996724*x_67 - 0.000312239477931552*x_68 + 0.000207317853767139*x_69 + 9.20869131761341e-6*x_7 - 0.000102393535875875*x_70 - 0.000645501411995433*x_71 + 0.000406096943208532*x_72 + 0.000598990312230412*x_73 - 0.000471722868440716*x_74 + 0.000499665919578193*x_75 + 0.000324828368903232*x_76 + 0.000245382475773394*x_77 - 0.000604449849702605*x_78 - 0.000299311598709716*x_79 - 0.000961528576115375*x_8 - 0.000170854653127029*x_80 + 0.000146449291363588*x_81 + 2.9329767172984e-5*x_82 - 0.000558835606439591*x_83 - 0.000721959460850602*x_84 - 0.000253243449102667*x_85 + 0.000345776802607291*x_86 + 0.000283298468332619*x_87 + 0.00094606625520247*x_88 + 0.000232964879368043*x_89 - 0.000312126192983045*x_9 + 0.00138068285765859*x_90 - 0.000104053583894963*x_91 + 9.08203539311188e-6*x_92 - 0.000152355117876143*x_93 + 0.000297875995844509*x_94 + 0.000126677614788138*x_95 - 0.000229207379643035*x_96 + 0.00120327804890705*x_97 + 0.000847289718048859*x_98 + 0.00101522444519976*x_99 - 2.22399700060012e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) - 0.000100872396251903*std::exp(0.237919852137566*x_28) + 0.000928390636105207*std::exp(0.200159847736359*x_49) + 0.00366976706807709*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.00308985076315942*std::sin(0.323359847068787*x_1 + 8.33455944061279) + 0.0010112877831273*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 4.65199641315966e-5*std::sin(0.366799831390381*x_1 - 4.22656011581421) - 0.00116223819653779*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.00250319239495983*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.00137822240008613*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.00597492017259129*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.00336871146176945*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.00265211214556626*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.00349771599188835*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.00219762701169826*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.00264364919827752*std::sin(0.224239990115166*x_102 - 1.20831990242004) + 0.00877538870115677*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.00284921061407777*std::sin(0.238879978656769*x_102 - 1.21063983440399) + 0.000341106651600971*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 4.72051020040999e-5*std::sin(0.237279981374741*x_104 - 1.20263981819153) - 0.00621356579225245*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.00236292357397669*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.00701238968855741*std::sin(0.252239972352982*x_107 - 7.43511962890625) - 0.000310914440250971*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.00404965916884616*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 5.53059971978343e-5*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.00333407841298881*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00300921806620129*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.00242282793532961*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.00501436691972663*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.00230353723948924*std::sin(0.199520006775856*x_110 - 7.39160013198853) + 0.0159680470508601*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.00311109094255144*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 4.8141083433885e-5*std::sin(0.242079973220825*x_110 + 8.17360019683838) + 0.000142929274339515*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.00386684526435629*std::sin(0.220319986343384*x_111 - 1.18911993503571) + 0.00977914111430887*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 0.00117688980014182*std::sin(0.28519994020462*x_112 + 8.17903995513916) - 0.00905149711884425*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.00774861066160024*std::sin(0.299759924411774*x_113 - 1.20455992221832) - 0.00147301544914859*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.00275444257149351*std::sin(0.250879973173141*x_116 + 5.16208028793335) + 0.000292492797454117*std::sin(0.203199997544289*x_117 - 4.20279979705811) + 0.000225687289965092*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.00139286593094073*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.00161854568485416*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.0034633239706743*std::sin(0.279679954051971*x_12 + 5.15056037902832) - 0.00534471210462392*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.0041843602181832*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00396246789458445*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.00219626543241875*std::sin(0.324719846248627*x_13 - 4.29655981063843) + 0.000504208152675014*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.00294485668935432*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00677726167043257*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 4.57737650230306e-5*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.00168559093677174*std::sin(0.369119822978973*x_14 + 4.83024024963379) + 0.000143638034477343*std::sin(0.25231996178627*x_15 + 1.56383979320526) - 0.0130294952977949*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.00203489886718147*std::sin(0.317439913749695*x_15 - 1.2267199754715) - 0.000216750890072758*std::sin(0.36959981918335*x_15 + 8.21647930145264) - 0.000339754217869637*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00238179245713822*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.001142435753847*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.00138155518262803*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00503728951800705*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.00358189534910214*std::sin(0.352959841489792*x_16 + 2.01791977882385) - 0.00445277744491303*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 0.00130475782692015*std::sin(0.291759938001633*x_17 - 1.14455986022949) - 0.00183704037744954*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.00346174433614193*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 2.08766639591133e-5*std::sin(0.379279851913452*x_17 + 1.78831994533539) - 0.000111251795160758*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.00548250571523573*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.00449271508055923*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.00217461983240215*std::sin(0.337039858102798*x_18 - 4.15015983581543) - 0.000100681475900317*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.00359979596054133*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.00111930379533157*std::sin(0.419119864702225*x_18 - 1.2196798324585) - 0.000645088881437881*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.00626477876005144*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.00719815646484313*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.00125929266654271*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 3.51911330211062e-5*std::sin(0.255439966917038*x_20 - 7.40359973907471) - 0.000682025038466066*std::sin(0.258719980716705*x_20 - 4.39888000488281) + 0.000800195787736612*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00374122835448598*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.00565340707621843*std::sin(0.289999932050705*x_20 + 1.97943985462189) - 0.00200574727296684*std::sin(0.341759830713272*x_20 + 8.23559951782227) - 0.00283814396143521*std::sin(0.346559852361679*x_20 - 4.35752010345459) - 8.49829427862933e-5*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00264277724710024*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.00105686633453663*std::sin(0.356479853391647*x_21 + 8.22696018218994) - 0.000600707135576515*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.00295536361804371*std::sin(0.370719850063324*x_22 + 1.98679983615875) + 0.00169396172660792*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 4.85606030663771e-5*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.00322440305477183*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.0071107546241634*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 0.000993847731961981*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 0.00133568041109599*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 0.00736715394028047*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.00176671667814098*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.00436454725216654*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.00431474507421796*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.00109374834854252*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.000152144739219664*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.00430093872034952*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.00440089211727263*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.00623525070282724*std::sin(0.183280006051064*x_28 - 1.20519983768463) + 0.00637200887870274*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.00134217475918044*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.00447557300534362*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.00192507420398535*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.00487152293133472*std::sin(0.223119989037514*x_29 + 8.21144008636475) + 0.0179240791388871*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00139675919150071*std::sin(0.398559868335724*x_29 - 4.39160013198853) - 0.00984758304398724*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.00199206985658461*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 0.00219964422590796*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 5.88726267242244e-5*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.00231871609877476*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.00320058642545036*std::sin(0.377199828624725*x_3 - 4.3931999206543) - 0.000302287110283095*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00172597816304662*std::sin(0.399679869413376*x_3 + 8.18696022033691) + 9.11633346046931e-5*std::sin(0.421359837055206*x_3 + 8.18671989440918) + 0.0020010336267632*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 3.07429443199775e-5*std::sin(0.322319835424423*x_31 - 1.04135990142822) + 0.00562441822121631*std::sin(0.376239836215973*x_31 + 5.19583988189697) + 0.000304309795244884*std::sin(0.396399825811386*x_31 + 5.1989598274231) + 0.00112357499477397*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.00194207269702523*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 1.20341661730192e-5*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.0029215915493309*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.000544664526438462*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.00449359305158222*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 0.00101096750910014*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 3.61070018783741e-5*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.00394928553244731*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.00195159151722823*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.00524944386867947*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.00433525681611063*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.00469706823450148*std::sin(0.198479995131493*x_36 - 1.18119990825653) + 0.000876199111189658*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.00271666841123236*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.00854094960547813*std::sin(0.247599974274635*x_36 + 5.15607976913452) + 0.00394726767324505*std::sin(0.265039950609207*x_36 + 8.17183971405029) + 0.00108960250369355*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.00382086265845234*std::sin(0.249839976429939*x_38 - 4.424880027771) - 3.48880253433923e-5*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.00796928684675252*std::sin(0.334719836711884*x_4 - 7.37951993942261) - 0.000865974388748163*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 1.94725893418567e-5*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00206768586527545*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.00980263911096732*std::sin(0.240399971604347*x_41 + 1.98135983943939) + 0.000647952975577874*std::sin(0.276719957590103*x_41 - 1.2247998714447) - 0.0128496164879939*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.00543498349167721*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.00452771481129318*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.00160637878561583*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.00416888112088337*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00210747827396318*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.00636617848912958*std::sin(0.0756000876426697*x_49 + 8.10095977783203) - 0.000154073577994914*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.00145172374526428*std::sin(0.303839921951294*x_5 - 4.58752012252808) + 0.00253573702325276*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.00110190677367602*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.00227199545930708*std::sin(0.393919855356216*x_5 + 1.97943985462189) + 0.0118577166156212*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.00681011724527838*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.00395149753440803*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.004038084402702*std::sin(0.244319975376129*x_53 - 1.22295987606049) + 0.0117360790736874*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.00446163923692794*std::sin(0.20040000975132*x_55 + 8.20783996582031) + 0.000865079020571446*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.00491549432228772*std::sin(0.246639966964722*x_6 - 7.37775993347168) - 5.16899067670916e-5*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.0014285024864454*std::sin(0.291599929332733*x_60 - 4.26775979995728) - 0.0135534241507563*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00389118614516266*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.00156436235822795*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.00187668362429437*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.00423226915747152*std::sin(0.28519994020462*x_7 + 5.22079992294312) - 0.00665937406682145*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.00272427638597145*std::sin(0.338559836149216*x_7 + 2.02039980888367) + 0.000851549079572151*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.00325327249035836*std::sin(0.358479827642441*x_7 - 1.18127989768982) + 0.000423543343699543*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 3.44263770600833e-5*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.00338866266272135*std::sin(0.442559868097305*x_7 - 1.41695988178253) + 4.03000719701582e-5*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 2.85963984223635e-5*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.00263358847375948*std::sin(0.33383983373642*x_8 + 8.25695991516113) - 0.000339296437821788*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00144125885859826*std::sin(0.369919836521149*x_8 + 1.81647992134094) + 0.000141746481390937*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 4.63753411653441e-5*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.00331209033450404*std::sin(0.463119864463806*x_9 + 4.93391990661621) - 0.00171319600232854*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00152141360748445*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 2.53991887531075e-5*std::sin(0.35183984041214*x_91 - 7.39383983612061) - 0.000388716281723523*std::sin(0.356319844722748*x_91 + 5.19551992416382) + 0.015418736997377*std::sin(0.36303985118866*x_91 + 5.18800020217896) + 0.000234614034786428*std::sin(0.405119866132736*x_91 - 1.19711995124817) - 0.000374060197482746*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.00416210353182252*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 0.0011649850458001*std::sin(0.294319927692413*x_92 + 7.99768018722534) - 0.000972010703034742*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.00560454076996364*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 3.29365499731109e-5*std::sin(0.314959913492203*x_92 + 8.21815967559814) - 0.000282941500754657*std::sin(0.273039966821671*x_94 - 7.60464000701904) - 0.00530303885988655*std::sin(0.288959950208664*x_94 - 1.20831990242004) - 0.00367856724750723*std::sin(0.265439957380295*x_95 + 1.96335983276367) - 0.000789433197062708*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.00244366554849326*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.00431334082087448*std::sin(0.286399960517883*x_95 - 1.2111998796463) + 0.000410352513897592*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00296787146513611*std::sin(0.273919969797134*x_97 + 1.96983981132507) + 0.000453351237510926*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.00577729760653982*std::sin(0.277199953794479*x_97 + 1.97303986549377) + 0.00325393260583407*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 4.35612050480437e-5*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.011545766477743*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.00146588017326164*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.00300365614546917*std::sin(0.265839964151382*x_98 + 1.95631980895996) - 0.0120089709918071*std::sin(0.251759976148605*x_99 + 1.95271980762482) + 0.149886543144974);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00185138366609568*x_1 + 0.000510273178642095*x_10 - 9.0734381222383e-5*x_100 - 0.000131033075662755*x_101 + 0.000322018458429043*x_102 + 0.00304866036641125*x_103 - 0.00812640866382856*x_104 + 0.00170785381411793*x_105 - 0.00446993531526409*x_106 - 0.000310886699644627*x_107 + 0.00368175903384056*x_108 - 0.000191680751791422*x_109 + 8.09021321892204e-5*x_11 + 0.000109576386245082*x_110 - 0.00292251808844142*x_111 + 0.00773406925452916*x_112 + 0.00169528631307447*x_113 - 0.000229744835929335*x_114 - 0.000840491564798552*x_115 + 0.0101411028805129*x_116 + 0.00273613808587648*x_117 - 0.00583005106067456*x_118 + 0.00840836408556588*x_119 + 0.00129366784327822*x_12 + 0.00825397120908933*x_120 - 7.52912236164849e-5*x_13 + 0.000257318694135932*x_14 - 0.000305264312803095*x_15 - 0.000173455890458636*x_16 + 0.0011912391694279*x_17 + 0.000241711966612371*x_18 - 0.000761899616216097*x_19 - 0.00328118589512515*x_2 + 3.49980023791061e-6*x_20 + 0.000123140720612563*x_21 + 0.000803475085791742*x_22 + 0.00306489807586742*x_23 - 0.000197450048272833*x_24 - 0.00182474290079403*x_25 - 0.000270384177065657*x_26 - 0.00120902705463766*x_27 + 1.58155890147826e-5*x_28 + 0.00237273805150627*x_29 + 2.87282047776632e-6*x_3 - 0.00412896296371308*x_30 - 0.000954724776347141*x_31 - 0.000206304007485423*x_32 + 0.00106875907456446*x_33 + 0.00087656157482946*x_34 - 0.00765091565642498*x_35 + 0.00128088489797061*x_36 + 0.00220871437213261*x_37 + 0.0029386650466435*x_38 - 0.00557955288369855*x_39 + 0.000366062709235996*x_4 - 0.00141967222428054*x_40 - 0.000849324800526602*x_41 + 0.00562877118154012*x_42 + 0.00624456227695166*x_43 + 7.84261304582575e-5*x_44 - 0.00582407923387992*x_45 - 0.000865935407561094*x_46 + 0.00199821911716117*x_47 - 0.00221846428013308*x_48 + 0.00359437448411769*x_49 + 0.000343871208588699*x_5 + 0.00474693395045975*x_50 + 0.00205098986265961*x_51 - 0.00121166685314079*x_52 + 0.000823139676130117*x_53 - 0.00858898517042177*x_54 + 0.000623560566653001*x_55 - 0.00600569972516734*x_56 - 0.00586380486205016*x_57 - 0.00112952172679167*x_58 + 6.62778894726663e-5*x_59 + 0.00684702686884731*x_6 - 0.000124597022957496*x_60 - 0.00081609451452832*x_61 + 0.00305442039102263*x_62 + 8.57933743507547e-5*x_63 - 0.000227268628030441*x_64 - 0.000217046273419075*x_65 + 0.00174343118166373*x_66 - 0.00026919063460319*x_67 - 0.00143421277522792*x_68 + 1.57562503590132e-5*x_69 + 0.000252815174461485*x_7 + 0.000542831478871522*x_70 + 0.000352025407078523*x_71 - 0.000120775861734267*x_72 + 7.45808109040575e-6*x_73 - 7.39230838377059e-5*x_74 + 0.000143649841163653*x_75 + 0.000461851578914026*x_76 - 0.000132109307104302*x_77 + 0.000438613235943397*x_78 + 0.000430879872416282*x_79 - 0.000415239292217886*x_8 - 0.00263601206732321*x_80 - 0.000136159771186178*x_81 - 0.000179296037291323*x_82 - 0.000192876180364347*x_83 + 0.000206809872225412*x_84 - 0.00154840033011996*x_85 - 0.00158860851530409*x_86 + 0.00220744747651019*x_87 + 2.31100304969554e-5*x_88 + 0.00089006626656536*x_89 + 0.0055272227800609*x_9 + 0.000240618932986931*x_90 - 4.07255108506346e-5*x_91 - 0.00201981549579408*x_92 + 0.00496504772202521*x_93 + 0.00125690768504283*x_94 - 8.9221282035928e-5*x_95 + 0.00122853079334604*x_96 - 0.000359166316358794*x_97 - 0.000507636871133431*x_98 - 0.000282376541252482*x_99 - 9.46236315026223e-7*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.00050671853626735*std::exp(0.237919852137566*x_28) + 0.000306210175265801*std::exp(0.200159847736359*x_49) + 8.46388293500405e-6*std::exp(0.0392926087403145*x_101 + 0.00679473268793491*x_102 + 0.0707136927553414*x_103 + 0.122102321027135*x_104 + 0.061511085502635*x_105 + 0.0828233569448928*x_107 - 0.0300531721952929*x_108 + 0.0611646565245844*x_11 + 0.0123829351957016*x_110 - 0.0493753517766133*x_113 + 0.0123964493625906*x_114 - 0.00232126281142274*x_115 - 0.153077230391406*x_117 - 0.0129283339542608*x_119 + 0.121604116733764*x_120 + 0.0181416765414759*x_15 - 0.06817051807807*x_19 + 0.0117911314671123*x_2 - 0.0389732816416675*x_21 + 0.00348008290461141*x_22 + 0.00753206508918748*x_23 - 0.0647944417570099*x_25 - 0.0623532616597657*x_26 + 0.0436612096154826*x_29 + 0.00339091521508809*x_30 + 0.0238822311320398*x_31 + 0.039685401908797*x_32 + 0.0424713250470176*x_34 - 0.0139307413030831*x_35 - 0.199806479686253*x_37 - 0.206121921735679*x_38 - 0.104937390065348*x_39 - 0.0588344225002694*x_40 - 0.0327526830576958*x_41 - 0.035488431645133*x_42 + 0.0205520875403474*x_43 - 0.15608049977162*x_44 - 0.0217961546526807*x_45 - 0.00732602104427108*x_46 - 0.0228545836950196*x_47 - 0.106705295672012*x_49 - 0.012485726141074*x_50 - 0.062917279804587*x_51 - 0.0499627674374366*x_52 + 0.109550178629625*x_54 + 0.0380145404940393*x_55 - 0.159044984797741*x_56 + 0.098302291780637*x_57 - 0.112624508015798*x_58 - 0.0992341372134943*x_59 - 0.00864492788210482*x_6 - 0.124034588292929*x_60 - 0.0120787288100807*x_61 - 0.00423387119053001*x_62 - 0.0128486864208162*x_63 - 0.00399592489531818*x_64 + 0.000133242994555549*x_65 + 0.0469844494977093*x_66 + 0.00205076916097951*x_67 - 0.0651443960249293*x_68 - 0.00303687292717618*x_69 + 0.0448096813958693*x_70 - 0.00706348068193431*x_71 - 0.043351122040747*x_72 + 0.022894492324424*x_73 + 0.017763510308073*x_74 + 0.00127398494218317*x_75 - 0.0274923427314555*x_76 - 0.0177582036494261*x_77 + 0.0506839082045432*x_78 - 0.0368549279008329*x_79 - 0.00211924097950951*x_80 - 0.0158265141848809*x_81 - 0.00239663012553936*x_82 - 0.0238472472214709*x_83 + 0.0396204549349016*x_84 - 0.0129690276805068*x_85 - 0.03130748067935*x_86 + 0.0554288812436309*x_87 + 0.0376973190669881*x_88 - 0.0220251691899312*x_89 - 0.00294960560968532*x_9 - 0.00265271860619899*x_90 - 0.0064618363274644*x_91 - 0.0160286897767905*x_93 + 0.0302977902816208*x_94 + 0.0056049979119548*x_95 + 0.0701749694001792*x_96 - 0.0141854497752687*x_98 + 0.12001544171735*x_99 + 1.01616132393836*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.381630842713641*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.968520248599873*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.654295355196883*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 1.12135373885463*std::sin(0.237919986248016*x_109 + 1.9521598815918) - 1.07073242808078*std::sin(0.220319986343384*x_111 - 1.18911993503571) - 0.325881690923863*std::sin(0.28519994020462*x_112 + 8.17903995513916) - 0.762707266766022*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.385685647671096*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.95899707147133*std::sin(0.279679954051971*x_12 + 5.15056037902832) + 1.15865256302821*std::sin(0.254559963941574*x_13 + 1.98231983184814) + 0.466741426950016*std::sin(0.369119822978973*x_14 + 4.83024024963379) - 0.316341339002745*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.361288445894971*std::sin(0.291759938001633*x_17 - 1.14455986022949) + 0.309936081896703*std::sin(0.419119864702225*x_18 - 1.2196798324585) - 0.555392962706954*std::sin(0.341759830713272*x_20 + 8.23559951782227) + 0.275197201448757*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 1.19093323995035*std::sin(0.186720013618469*x_27 - 4.40975952148438) - 0.533054527852187*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.551605675590032*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 1.24427937245855*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 0.752247572733793*std::sin(0.241119980812073*x_36 + 1.96823978424072) - 0.239788974352571*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 1.15436638907936*std::sin(0.262559950351715*x_48 + 8.17479991912842) - 0.401983421730765*std::sin(0.303839921951294*x_5 - 4.58752012252808) - 1.11814867720599*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.900833655000078*std::sin(0.358479827642441*x_7 - 1.18127989768982) + 0.729242674142398*std::sin(0.33383983373642*x_8 + 8.25695991516113) - 0.322585255289493*std::sin(0.294319927692413*x_92 + 7.99768018722534) - 0.821805891585335*std::sin(0.273919969797134*x_97 + 1.96983981132507)) - 0.00131430417022349*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.00151246837947753*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.00125240184091146*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.00583834289286574*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.0281338885334461*std::sin(0.341759830713272*x_10 - 7.55480003356934) + 0.00230671438303791*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.00143292083076402*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.0298076279041895*std::sin(0.252879977226257*x_100 + 1.95943987369537) + 0.0246995770319929*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.0297125111180546*std::sin(0.224239990115166*x_102 - 1.20831990242004) - 0.00338788046517577*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.00121194506756643*std::sin(0.238879978656769*x_102 - 1.21063983440399) - 0.000510154511093291*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 0.00127084699556321*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.00239884737685541*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.00231288963078461*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 0.00156183570453629*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.00148893779255875*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.0374723855112628*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.0012803216071354*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.0272306560236958*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.00165388373559869*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.000979836513861301*std::sin(0.199520006775856*x_110 - 7.39160013198853) - 0.00616472232887931*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.0349661839702738*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.00129604531391113*std::sin(0.242079973220825*x_110 + 8.17360019683838) - 0.00321000561210708*std::sin(0.213199988007545*x_111 + 1.97535979747772) + 0.00322544454683856*std::sin(0.268079966306686*x_112 - 1.21143984794617) + 0.00349447657691618*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.00255571667408134*std::sin(0.299759924411774*x_113 - 1.20455992221832) - 0.016555520277959*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.00146929712886539*std::sin(0.203199997544289*x_117 - 4.20279979705811) - 0.00506864301044658*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.000688467342392258*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.00176284116475801*std::sin(0.284559935331345*x_12 + 5.14287996292114) - 0.00168589751603512*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.0246842739654941*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.00253281994471038*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.0330978433827485*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00223533758659127*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.00123231280699452*std::sin(0.310879945755005*x_14 + 8.31400012969971) - 0.00322592344301037*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.00503024698890889*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.000671168702629185*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.00108881812897591*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.00170670834010561*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00101337300238785*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.0155275797374278*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00166144427376444*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.0015236010912758*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 0.00171906661176246*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 0.0206468704981163*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.0011417837477793*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.000562037672697277*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.000558858011662542*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.0616189970003876*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.00191149995307727*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.000924999986554165*std::sin(0.337039858102798*x_18 - 4.15015983581543) + 0.00226117500539141*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.00118731717999961*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.00324051480791882*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.00206630584962021*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.00237416090487204*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.000535654868158284*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.000947409152223713*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.0034260584860716*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.0011967620360251*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00159176749378043*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.001864657725244*std::sin(0.289999932050705*x_20 + 1.97943985462189) - 0.03189847732586*std::sin(0.346559852361679*x_20 - 4.35752010345459) + 0.00190860636869517*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00112441329869442*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.0118783357246028*std::sin(0.356479853391647*x_21 + 8.22696018218994) + 0.000898409496331897*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.0332159328916377*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.00253346632905693*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 0.00130733954360025*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.00106350170513501*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.00302464266799014*std::sin(0.112400062382221*x_24 + 2.09047985076904) - 0.00199762562207866*std::sin(0.336079835891724*x_24 + 2.01231980323792) + 0.00284420870324853*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.0198564881361411*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.00143955435036328*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.00142312814673177*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.000465353328539392*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.00409601243338623*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.00145154194166519*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.00205656663939313*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.00246001688805396*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.015084975147423*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.00190420657359899*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.00160676964265108*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.00691988009179531*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.000594274304321456*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 0.00380181839916933*std::sin(0.138640031218529*x_3 - 7.64983987808228) + 0.0247222489128432*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.00158495793075284*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.000986293019235624*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.00105564628958562*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 0.0015184975052305*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.000734345961966795*std::sin(0.399679869413376*x_3 + 8.18696022033691) - 0.00204740993090285*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.0100519157673532*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.000827655841532071*std::sin(0.322319835424423*x_31 - 1.04135990142822) - 0.00217139744671659*std::sin(0.376239836215973*x_31 + 5.19583988189697) - 0.00683440222494136*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.00168040361993905*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.00064055193773802*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000323981588341057*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.0012430394559456*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.000231679428342001*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.00151198938195879*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 0.00097206600362693*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.0443868234740329*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.00083013228349032*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.00223346273439035*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.0487248332464977*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.00199844538299382*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00440146509449459*std::sin(0.232639983296394*x_36 - 1.21487987041473) + 0.00281705305279863*std::sin(0.247599974274635*x_36 + 5.15607976913452) + 0.0443641443439801*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00547346753224793*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.00126023139270295*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.000939248943576746*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.00262850208434351*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 0.000524237436427646*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.000879731156679664*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.00323319486808842*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.00325490218885032*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00496080187068369*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.00179261528803767*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.00192639116751131*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.0180544179456623*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.00069510749736386*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.00270859595256995*std::sin(0.0756000876426697*x_49 + 8.10095977783203) + 0.00346029217825784*std::sin(0.348799854516983*x_49 - 1.33007991313934) + 0.000836359661678251*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.000468708937372448*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.0255354191429088*std::sin(0.393919855356216*x_5 + 1.97943985462189) - 0.00457786291316734*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.00289676304172961*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.0444116846140413*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.00453090277656446*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.0501452709831337*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.00434560485670318*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.00209137837541992*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 7.73067279440539e-5*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.000607780014278414*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.00523251818013894*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00165516154976812*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.0175821867711491*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.000618984723849062*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.00180068892659674*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.00257095885773225*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.00115880283203791*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.00127356532721403*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.00212761142928795*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.000926820534168812*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.00111767929093049*std::sin(0.442559868097305*x_7 - 1.41695988178253) + 0.000452940706827483*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.000769866931244696*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.00170440874532649*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00047536899935379*std::sin(0.369919836521149*x_8 + 1.81647992134094) - 0.00318344162078731*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.00124850832825396*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.00109242351482498*std::sin(0.463119864463806*x_9 + 4.93391990661621) - 0.0192549583733574*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.000647310587733874*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.000683792245885331*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.00195266249853279*std::sin(0.356319844722748*x_91 + 5.19551992416382) - 0.00595265231547073*std::sin(0.36303985118866*x_91 + 5.18800020217896) - 0.00526912608927526*std::sin(0.405119866132736*x_91 - 1.19711995124817) + 0.00840090554390744*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.00177039942964197*std::sin(0.289599925279617*x_92 + 1.99127984046936) + 0.00488276137951538*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.00184854019925769*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.000886711685823921*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.000423163495370206*std::sin(0.273039966821671*x_94 - 7.60464000701904) + 0.0020473237563949*std::sin(0.288959950208664*x_94 - 1.20831990242004) - 0.00121329823651795*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.00396560852086356*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.0274648541968885*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.0018347299798628*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.000613717689528436*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00227734726270265*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.0019055204176583*std::sin(0.277199953794479*x_97 + 1.97303986549377) + 0.0365716104811634*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.00117274667796738*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.00380812886217762*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.000623529281005049*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.0337587024311753*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.00463625710672427*std::sin(0.251759976148605*x_99 + 1.95271980762482) - 0.176113002664788);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000826700116350708*x_1 + 0.00080740559724147*x_10 - 5.11211173242707e-5*x_100 - 0.000432170489052639*x_101 + 0.000598511363026488*x_102 - 0.00141988660125714*x_103 + 0.00252862654892234*x_104 - 0.00171649565567038*x_105 + 0.000447627032197323*x_106 + 0.000207939096696108*x_107 - 0.00172949622452235*x_108 + 2.30274444480669e-5*x_109 + 6.57079034759508e-5*x_11 + 2.18638377564121e-5*x_110 + 0.00123248858292603*x_111 - 0.00269449281520777*x_112 - 0.00117882916025427*x_113 + 5.53677421395327e-6*x_114 - 0.000947653961633767*x_115 - 0.00396008046635031*x_116 - 0.00247255523436626*x_117 + 0.00127335545901554*x_118 - 0.00140109545368216*x_119 - 0.000613786976302062*x_12 - 0.00159707694811095*x_120 - 0.000857481101007258*x_13 + 0.000138831677238705*x_14 + 0.000355919234123428*x_15 - 0.000155845506115898*x_16 + 0.00106892588114507*x_17 + 4.42141704295724e-5*x_18 - 0.00120649277339001*x_19 + 0.000898346870471538*x_2 + 9.89797692335149e-5*x_20 - 5.97036818349529e-5*x_21 - 1.31857803873312e-5*x_22 - 0.000562205961142601*x_23 - 0.000156813614668818*x_24 + 0.00293687118000238*x_25 + 0.0017178077726327*x_26 + 0.000326028317847305*x_27 + 8.86719822502509e-5*x_28 - 0.000206176085581834*x_29 + 8.47339485111948e-6*x_3 + 0.00113755797223368*x_30 + 0.000624515246944927*x_31 + 0.000105367019676747*x_32 - 3.23455278807842e-6*x_33 - 0.00126400865615947*x_34 + 0.00353836735261697*x_35 - 0.000887648892153812*x_36 - 0.00185654022809762*x_37 - 0.0019382068988401*x_38 + 0.00103308850276422*x_39 + 0.000608760069018273*x_4 - 0.00155305863505202*x_40 + 0.000443899205057971*x_41 - 0.00114060991768867*x_42 - 0.00342326216730126*x_43 - 0.000747768419920055*x_44 - 0.000238028871337701*x_45 - 0.000261920504107724*x_46 - 0.00124959836964696*x_47 - 0.000647037418038435*x_48 - 0.00132660634560654*x_49 + 0.000333999598231161*x_5 - 3.58246148959956e-5*x_50 - 0.0015703707322595*x_51 - 0.000299192960755544*x_52 - 0.000586566484779142*x_53 - 7.69343991334126e-5*x_54 + 3.57139840976741e-5*x_55 + 0.0016093206790188*x_56 + 0.00309018697506432*x_57 - 0.000366623847396938*x_58 + 0.00109403511473472*x_59 - 0.00254219785063669*x_6 - 0.000219127098342774*x_60 + 0.000387198782591783*x_61 - 0.000404376381967653*x_62 - 0.000145891020760073*x_63 + 0.000819971464853173*x_64 + 0.000335756586062292*x_65 - 0.000485965215155415*x_66 - 0.000256117593224666*x_67 + 0.000211278387617988*x_68 - 0.000299399026148045*x_69 - 0.000331374013268091*x_7 + 0.000171873222797511*x_70 - 0.000173913103136375*x_71 + 6.77788033413092e-5*x_72 + 0.000117932269244111*x_73 - 5.52878015135375e-5*x_74 - 9.00717483666247e-6*x_75 + 0.000210042093632213*x_76 + 0.000681642889046539*x_77 - 0.000155924936260938*x_78 - 0.000435380531340127*x_79 + 2.92457910553951e-5*x_8 + 0.000650119052259642*x_80 - 4.97214583248199e-5*x_81 - 0.000428848272052783*x_82 - 9.50534302907903e-5*x_83 - 0.00020226894652751*x_84 + 0.000680299320930954*x_85 + 4.4431825333306e-5*x_86 - 1.57840300853408e-5*x_87 - 0.000538102870378108*x_88 - 0.000163926796218031*x_89 - 0.00101343141010919*x_9 + 0.000127793394638525*x_90 - 4.37781441985965e-5*x_91 + 0.00089112105159565*x_92 - 0.000112739259518937*x_93 - 0.000311370313466972*x_94 + 0.00012945870620653*x_95 - 0.000137952532348165*x_96 - 0.000544051916310675*x_97 - 0.000128404570165468*x_98 + 0.000482910053911735*x_99 - 3.22039300686208e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 2.45703339142174e-6*std::exp(0.237919852137566*x_28) - 4.12046083074738e-5*std::exp(-0.0132389310109497*x_1 - 0.0562053648957509*x_10 - 0.00168062111182513*x_100 - 0.125145773662125*x_101 - 0.0267653019477198*x_102 + 0.00820172451290849*x_103 + 0.0699948016027748*x_104 + 0.0813605668319302*x_105 + 0.007455525890048*x_106 + 0.00051447219614834*x_108 + 0.0418561229131336*x_109 - 0.0311981239139605*x_110 + 0.121218695805364*x_111 + 0.0547693186148327*x_114 + 0.0965025757544372*x_115 - 0.0163074733582115*x_116 - 0.0673234154844213*x_117 + 0.0446557696542729*x_118 + 0.0595658187299793*x_119 + 0.105887060498864*x_120 - 0.0648799919076155*x_13 - 0.0113986312287115*x_21 + 0.0113394700566973*x_22 + 0.0391481060379336*x_24 - 0.0830974159101178*x_30 - 0.0177010244193454*x_32 - 0.128619704663262*x_33 + 0.0888474703043844*x_34 + 0.0812697216075088*x_35 + 0.0229233552473273*x_37 + 0.119813995417913*x_39 - 0.0148732626672387*x_40 + 0.133917520122529*x_42 - 0.100430494357142*x_43 + 0.122294283553093*x_45 + 0.0593703822744487*x_46 - 0.00101141498618306*x_47 - 0.0922743707881035*x_50 - 0.0317306868026825*x_51 + 0.129478734083954*x_52 + 0.0241676305401275*x_53 - 0.0109494581249906*x_54 - 0.216965776696221*x_55 - 0.0983052399192353*x_56 + 0.0930060935795632*x_57 - 0.0778384062654733*x_58 + 0.00861184226608593*x_59 - 0.0223212544115284*x_6 + 0.0345549665905696*x_61 - 0.0121925507450585*x_62 - 0.0637474076071025*x_63 + 0.0218930933698992*x_64 + 0.01398415903843*x_65 + 0.0492363010800149*x_66 - 0.0180509138380044*x_67 - 0.0109356484443391*x_68 - 0.0350070641789448*x_69 - 0.0261304907788045*x_70 + 0.000893304167814836*x_71 - 0.000214489985260293*x_72 - 0.0472623675290847*x_73 + 0.0419118781656807*x_74 + 0.000188175974671706*x_75 - 0.0513948640561482*x_76 + 0.00266209593298334*x_77 - 0.000963987262152347*x_78 - 0.00304602602448011*x_79 + 0.00273167247871241*x_80 + 0.0158722447116042*x_81 + 0.0146038631825323*x_82 + 0.03911245395876*x_83 + 0.000790486744580443*x_84 + 0.00539529724873468*x_85 + 0.0697835006578506*x_86 - 0.0472112211417533*x_87 + 0.0187011876584417*x_88 - 0.0238173376398251*x_89 - 0.0839557776528902*x_90 + 0.00696500557086341*x_91 + 0.126240697210974*x_93 - 0.000148653230931386*x_94 + 0.0595772710929924*x_96 - 0.0668959700413541*x_99 - 0.0936167611542824*std::exp(0.200159847736359*x_49) - 0.707113132192383*std::sin(0.252239972352982*x_107 - 7.43511962890625) - 0.50563714454654*std::sin(0.28383994102478*x_11 - 7.43631982803345) - 0.986105936863986*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 0.781351949679028*std::sin(0.299759924411774*x_113 - 1.20455992221832) + 0.538948387756335*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.683403367512057*std::sin(0.294079929590225*x_14 + 1.97463977336884) - 0.205194487981091*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.507948606257589*std::sin(0.330239832401276*x_16 - 4.33816003799438) - 0.34907427982402*std::sin(0.36695984005928*x_17 - 7.37695980072021) + 0.362995085835784*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.631725777981345*std::sin(0.262319952249527*x_19 - 7.57184028625488) - 0.725845423589568*std::sin(0.387439846992493*x_2 + 5.19392013549805) - 0.570076473608783*std::sin(0.289999932050705*x_20 + 1.97943985462189) + 0.325141334805004*std::sin(0.343919843435287*x_23 + 2.00119972229004) - 0.440110834558602*std::sin(0.424319863319397*x_25 + 1.77583980560303) + 0.4350888982996*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.443775766564052*std::sin(0.342079848051071*x_27 - 1.15599977970123) - 0.628748237091763*std::sin(0.183280006051064*x_28 - 1.20519983768463) + 0.491233087651146*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.322739721074772*std::sin(0.377199828624725*x_3 - 4.3931999206543) - 0.195834112011726*std::sin(0.457759857177734*x_31 + 8.22959995269775) - 0.861249573348992*std::sin(0.247599974274635*x_36 + 5.15607976913452) - 0.385286939558398*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.803604424999662*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 0.988475420414581*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.548051145315682*std::sin(0.223600000143051*x_44 - 1.18495988845825) - 0.212513227232822*std::sin(0.299679934978485*x_48 + 7.96231985092163) - 0.255697847461942*std::sin(0.366399854421616*x_5 + 8.22288036346436) - 0.189240429389477*std::sin(0.516559839248657*x_60 + 1.67543983459473) - 0.341704893167911*std::sin(0.442559868097305*x_7 - 1.41695988178253) - 0.145333204665796*std::sin(0.369919836521149*x_8 + 1.81647992134094) + 0.333983516968104*std::sin(0.463119864463806*x_9 + 4.93391990661621) + 0.565148908483462*std::sin(0.302559942007065*x_92 - 1.19743990898132) + 0.370938199941975*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.582569307697494*std::sin(0.277199953794479*x_97 + 1.97303986549377) - 1.16424834617515*std::sin(0.257279962301254*x_98 - 7.43447971343994)) + 0.00276980947226179*std::exp(-0.00251933804525034*x_1 - 0.00222597335313241*x_100 - 0.0210969133816357*x_101 + 0.0730343381440818*x_103 - 0.00245536915025453*x_104 - 0.00256970680408194*x_105 + 0.000314736058059685*x_107 - 0.0700694107712683*x_108 - 0.00445903324185308*x_109 + 0.0502224389189638*x_11 - 0.00306656708405139*x_111 - 0.0453526060712321*x_113 + 0.0512926975822684*x_114 - 0.00248858977204142*x_115 + 0.0582336501706236*x_116 - 0.00647296735582557*x_117 - 0.00881542969857472*x_118 - 0.00273026067754402*x_119 - 0.149336898227029*x_12 + 0.00706231592854235*x_120 - 0.0491367863235335*x_13 + 0.05850514757054*x_14 + 0.101676450498054*x_17 + 0.0380046344897276*x_18 - 0.0251635933357382*x_19 + 5.73337886520478e-5*x_2 + 0.00832636370421945*x_20 + 0.0301469674810425*x_21 + 0.0506941329170239*x_22 + 0.085826406316296*x_23 - 0.086305359146628*x_25 + 0.000536156329908899*x_26 + 0.0626696674074939*x_27 + 0.047507752263391*x_30 - 0.000546770184724845*x_32 + 0.0754220961248843*x_33 + 0.0762837573091647*x_34 + 0.0235626784000112*x_35 + 0.0781929935635712*x_36 - 0.0894870678706624*x_37 - 0.00212130738368683*x_38 - 0.00152756123213177*x_39 + 0.0285370083174317*x_4 - 0.00168808995950738*x_40 - 0.0230327365467875*x_41 - 0.0544694356170119*x_43 + 0.0432658214207724*x_44 - 0.0700976113815655*x_45 + 0.0144314767685846*x_46 - 0.108332085065256*x_47 + 0.100973288520021*x_48 + 0.0758520347936607*x_49 - 0.00429816640373776*x_50 - 0.146810122522193*x_51 - 0.0229350913518643*x_52 + 0.00527920822447405*x_54 - 0.00837193723792024*x_55 + 0.0495928698598627*x_56 - 0.130112054244163*x_57 - 0.168906674997285*x_58 + 0.0981592524485627*x_59 - 0.00489621919886787*x_6 - 0.00405329396527876*x_61 + 0.0266487107874691*x_62 - 0.000285950334292841*x_63 + 0.00105211910450456*x_64 - 2.46313581537619e-5*x_65 + 0.0119662894658681*x_66 - 0.037943121936225*x_67 + 0.00102662050148982*x_68 + 8.78154860895007e-5*x_69 + 0.0258809147998378*x_70 + 0.0350912730546688*x_71 - 0.016223118720779*x_72 - 0.011354663632119*x_73 + 0.00498367502712271*x_74 - 0.0257135475258578*x_75 + 0.0129813080386737*x_76 - 0.00733022435158357*x_77 + 0.0393975177737136*x_78 - 0.00115541839817982*x_79 + 0.0476901528611443*x_8 - 0.000255922605456762*x_80 - 0.016076862109602*x_81 - 0.0237121245345127*x_82 + 0.00178697640861932*x_83 + 0.0336368682265341*x_84 + 0.00414008440757991*x_85 - 0.0400012824432847*x_86 + 0.00926079941470478*x_87 - 0.0350915928214213*x_88 + 0.000782813096278546*x_89 + 0.00323932691975522*x_9 - 0.0177989178358697*x_90 + 0.0018655839524018*x_92 - 0.00337559944632368*x_93 - 0.00564021946850891*x_95 + 0.0155348880182133*x_96 - 0.0541368548540012*x_97 - 0.0455652663982197*x_98 + 0.290428425227205*std::sin(0.527119874954224*x_10 - 4.52896022796631) - 0.426553367679261*std::sin(0.227439999580383*x_102 - 7.42063999176025) + 0.302028491755877*std::sin(0.229439988732338*x_106 - 1.21535992622375) - 0.776173509431828*std::sin(0.213839992880821*x_110 - 7.42335987091064) + 0.439974422793739*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.63333662903193*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.216440237502361*std::sin(0.482319831848145*x_16 + 7.94760036468506) + 0.358102008976985*std::sin(0.377839833498001*x_24 - 4.59847974777222) - 0.309730080188302*std::sin(0.221039995551109*x_28 + 8.60432052612305) - 0.871252155273083*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.478670501553992*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.273391255384524*std::sin(0.376239836215973*x_31 + 5.19583988189697) + 0.624593094733029*std::sin(0.23335999250412*x_42 - 1.1956799030304) - 0.576378907832634*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.570466360261804*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.658803719353017*std::sin(0.334559857845306*x_60 + 1.88487982749939) + 0.32369830346822*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.749472691816493*std::sin(0.36303985118866*x_91 + 5.18800020217896) + 0.257769673988392*std::sin(0.288959950208664*x_94 - 1.20831990242004) + 0.583731068031511*std::sin(0.251759976148605*x_99 + 1.95271980762482)) + 0.00413932508012168*std::sin(0.304559946060181*x_1 + 5.10119962692261) + 0.00207704698944522*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.00446103119854897*std::sin(0.352879852056503*x_1 + 8.36448001861572) + 9.79663990200237e-5*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 2.8309608612329e-5*std::sin(0.121440060436726*x_10 - 4.46895980834961) + 0.00701915749176126*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.00155457020590991*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.00226450160098455*std::sin(0.239199981093407*x_100 - 1.19463992118835) + 0.00743674072876892*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.0039452595382171*std::sin(0.262639969587326*x_100 - 1.2196798324585) - 0.00616232700863023*std::sin(0.240559980273247*x_101 + 1.96103990077972) - 0.00741300992805871*std::sin(0.224239990115166*x_102 - 1.20831990242004) + 0.00191528484120522*std::sin(0.238879978656769*x_102 - 1.21063983440399) - 0.00150470265755495*std::sin(0.254799962043762*x_102 + 7.98680019378662) - 9.94092309622735e-5*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.0026652669313144*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 7.5732032742052e-6*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.00456782554657703*std::sin(0.237919986248016*x_109 + 1.9521598815918) - 0.000116468907292285*std::sin(0.249039977788925*x_109 + 1.95839989185333) + 0.0093490302694154*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00435740912146137*std::sin(0.253679990768433*x_109 + 8.17984008789063) - 0.00679380893284879*std::sin(0.267999976873398*x_11 - 1.19399988651276) - 0.0015484744911964*std::sin(0.199520006775856*x_110 - 7.39160013198853) + 0.00872375505012308*std::sin(0.220159992575645*x_110 + 1.96663987636566) + 0.00010138031438715*std::sin(0.242079973220825*x_110 + 8.17360019683838) + 0.00945521202476904*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.00436162003930313*std::sin(0.220319986343384*x_111 - 1.18911993503571) - 0.001327476478996*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.00413045655067887*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.00310688199180778*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 7.12449190064289e-6*std::sin(0.203199997544289*x_117 - 4.20279979705811) + 0.0149299098297145*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.00157108742169052*std::sin(0.251519978046417*x_118 - 1.22175991535187) + 0.0010880122373834*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.00390646695184131*std::sin(0.279679954051971*x_12 + 5.15056037902832) + 0.00471976201052586*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00573773431087899*std::sin(0.287439942359924*x_13 + 1.95335984230042) + 0.00615850902827056*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 1.22814200255128e-5*std::sin(0.225679993629456*x_14 - 4.19647979736328) - 0.00825762052284293*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 9.63949782121449e-5*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.00190126749463176*std::sin(0.369119822978973*x_14 + 4.83024024963379) + 0.00950209869238029*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 5.27958286228481e-6*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 8.27567787819185e-6*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00344888404556977*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.0012886139312391*std::sin(0.308079928159714*x_16 - 1.1775997877121) + 0.00387399443604522*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00240780721194223*std::sin(0.352959841489792*x_16 + 2.01791977882385) - 0.00147170561408018*std::sin(0.291759938001633*x_17 - 1.14455986022949) + 0.00515121240940403*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 4.39641695733019e-5*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 2.70985309879003e-6*std::sin(0.166160017251968*x_18 + 7.98320007324219) + 0.015373397243538*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.00650554304855297*std::sin(0.257679969072342*x_18 - 1.18119990825653) - 0.00146181415294642*std::sin(0.337039858102798*x_18 - 4.15015983581543) - 0.00666038994463007*std::sin(0.350399851799011*x_18 + 2.01143980026245) + 0.0012625221673045*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 1.57129698611465e-5*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.000846516625676275*std::sin(0.436879843473434*x_2 + 2.02287983894348) + 7.41090119880558e-5*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 1.66126547555393e-5*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.00352985414596978*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00541737494547418*std::sin(0.283439934253693*x_20 + 1.97463977336884) - 0.00226238882124137*std::sin(0.341759830713272*x_20 + 8.23559951782227) + 0.00795838925114848*std::sin(0.346559852361679*x_20 - 4.35752010345459) - 0.00562188359415097*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00382679534323082*std::sin(0.316399931907654*x_21 + 1.97503972053528) - 0.00296354018364302*std::sin(0.356479853391647*x_21 + 8.22696018218994) + 0.00264986220313164*std::sin(0.356319844722748*x_22 - 7.38351964950562) - 0.00828708281562315*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.00747246850760638*std::sin(0.151280030608177*x_23 + 8.14335918426514) + 0.000102263780840332*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.00477996272858834*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 0.00112101361378445*std::sin(0.277679949998856*x_24 - 7.55751991271973) - 0.00589200431826026*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 0.00495401896880237*std::sin(0.42087984085083*x_24 + 1.98071980476379) - 0.00158376991154342*std::sin(0.432159870862961*x_26 - 4.42119979858398) - 0.000320401627761949*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.00485125709151283*std::sin(0.186720013618469*x_27 - 4.40975952148438) - 0.00376356848763334*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.00648072097409309*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.00217139338432922*std::sin(0.347279846668243*x_28 - 4.38199949264526) + 0.00202253579090505*std::sin(0.398559868335724*x_29 - 4.39160013198853) - 0.00224696133725887*std::sin(0.287599951028824*x_3 + 5.06271982192993) - 0.00616798344329383*std::sin(0.289759933948517*x_3 - 1.13751995563507) - 0.000123979872914496*std::sin(0.295359939336777*x_3 - 4.13687992095947) - 0.00155867796262554*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 7.36306017661338e-6*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00249925157487719*std::sin(0.399679869413376*x_3 + 8.18696022033691) + 0.00603073556173534*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 4.87408510256561e-5*std::sin(0.103840067982674*x_30 - 7.68088006973267) + 6.47415707755387e-5*std::sin(0.322319835424423*x_31 - 1.04135990142822) + 0.0201310308790882*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.00495635682465791*std::sin(0.405279844999313*x_31 - 7.38151979446411) - 2.53427522395385e-5*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.0042305241382222*std::sin(0.320079833269119*x_32 + 1.98847985267639) + 0.000366132186183597*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.00506856213847414*std::sin(0.245119974017143*x_33 + 1.98655986785889) + 0.00445961839355805*std::sin(0.262479960918427*x_33 - 1.20239984989166) + 7.60377403436346e-5*std::sin(0.266639977693558*x_33 - 1.23087990283966) - 0.0110741216647978*std::sin(0.270159959793091*x_33 + 8.16936016082764) + 0.00131189096050092*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.00760130176436782*std::sin(0.243759974837303*x_34 + 1.95839989185333) - 0.0121564169101753*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.00680145058246972*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 2.13423151795745e-5*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.00306427451126503*std::sin(0.241119980812073*x_36 + 1.96823978424072) - 0.011068463421522*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 2.65403602415293e-5*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 7.34706974868462e-5*std::sin(0.229519993066788*x_39 - 1.18871986865997) - 0.000976778482010459*std::sin(0.345279842615128*x_4 - 4.37623977661133) - 4.10073286389682e-5*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00299405129553854*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 1.57827329995235e-5*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00655622337234265*std::sin(0.254719972610474*x_44 + 8.17759990692139) + 0.00450441832212527*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.00470230231499691*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00921835626635136*std::sin(0.0756000876426697*x_49 + 8.10095977783203) - 0.0101924420598136*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.00163747627484415*std::sin(0.303839921951294*x_5 - 4.58752012252808) - 0.000740719316997961*std::sin(0.389279842376709*x_5 - 1.38399982452393) + 0.00637086225635434*std::sin(0.393919855356216*x_5 + 1.97943985462189) + 0.00457786948506569*std::sin(0.193999990820885*x_50 + 2.01047992706299) - 0.0110803243003466*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.00455476975341408*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.0125108036196*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 2.10714538242405e-5*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.00711773601155674*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 0.000228016486093609*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.0020685007292692*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.00261571742057759*std::sin(0.418079853057861*x_60 - 4.41295957565308) - 0.00438660080171792*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.00612841204111408*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.00183130205942789*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.00375638574345245*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.00366953873692765*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 1.03165997522792e-5*std::sin(0.367679834365845*x_7 - 1.17919993400574) - 7.24985123019732e-5*std::sin(0.383679836988449*x_7 - 1.19735991954803) - 0.000113004718557557*std::sin(1.39911985397339*x_78 - 6.79120016098022) + 6.02211594672759e-5*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.00297056423961647*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 8.26452734637854e-6*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00937696662569398*std::sin(0.16176001727581*x_9 + 8.17623996734619) - 9.76618374950131e-5*std::sin(0.339039832353592*x_9 - 4.36039972305298) + 0.00480394258899654*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00220303792710406*std::sin(0.340319842100143*x_91 + 5.19456005096436) + 5.34881551742595e-5*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 9.46828785150407e-6*std::sin(0.356319844722748*x_91 + 5.19551992416382) + 0.0155204415130717*std::sin(0.405119866132736*x_91 - 1.19711995124817) - 0.0247452349672256*std::sin(0.28519994020462*x_92 + 5.19591999053955) + 0.00279783241106822*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 0.00131404847462808*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 2.36760783218792e-5*std::sin(0.300319939851761*x_92 + 2.00071978569031) + 6.93610852295811e-5*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.00124812232807514*std::sin(0.273039966821671*x_94 - 7.60464000701904) + 1.92288851811955e-5*std::sin(0.281839966773987*x_95 + 1.94663977622986) + 0.00685223931512488*std::sin(0.283279925584793*x_95 + 4.98383951187134) - 0.00289949653014562*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.00181016264355457*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00334761977049746*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 1.104265557274e-5*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.00912429483003961*std::sin(0.287119954824448*x_97 - 4.41831970214844) + 9.17355478490403e-5*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.000985388044323302*std::sin(0.264959961175919*x_98 + 1.95287978649139) - 0.00842249903706783*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.0322380516503146);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000186714312044727*x_1 + 0.00292245638131475*x_10 - 0.000470032672342059*x_100 - 0.00111538439096257*x_101 + 0.00204001357142742*x_102 - 0.00379252735800238*x_103 - 0.00227928010799101*x_104 - 0.00193854320759178*x_105 - 0.00197848033526825*x_106 - 0.00172051755738503*x_107 - 0.00280827234360672*x_108 + 0.00017063122904467*x_109 + 0.00343340892099244*x_11 - 0.000216213299276904*x_110 - 0.00144104934786259*x_111 - 0.00179871124316836*x_112 - 0.00102846428069455*x_113 + 0.000187514109041351*x_114 - 0.00445934462478285*x_115 + 0.00247344211774745*x_116 - 0.00185999771134466*x_117 - 3.2307246410792e-5*x_118 + 0.00329124586772565*x_119 - 0.00119719409647675*x_12 + 0.000597405448132099*x_120 - 0.000373100231709903*x_13 - 0.00117521098432319*x_14 + 0.000971822759931583*x_15 - 0.000300509655837819*x_16 + 0.00213713394809656*x_17 + 0.000247810781668351*x_18 - 0.00491004797245946*x_19 - 0.000241353457358894*x_2 + 0.000495841522121043*x_20 + 0.000801887447926018*x_21 + 0.000885274618103387*x_22 + 0.000956420649838017*x_23 - 0.000483590499116833*x_24 + 0.00228649363253465*x_25 + 0.00131808851536635*x_26 + 5.41942364873889e-5*x_27 + 0.000164217864127262*x_28 + 0.000164720187998019*x_29 + 2.16595618026701e-6*x_3 - 0.00269128827917186*x_30 + 0.000763872020820992*x_31 - 0.000200655888944913*x_32 + 0.000983066712652987*x_33 + 0.000788463886173349*x_34 + 0.00123315840093521*x_35 + 0.000570150417369047*x_36 - 0.00113645024138766*x_37 + 8.75314553467428e-6*x_38 - 0.00211279772345812*x_39 + 0.00246869750773489*x_4 - 0.00319826553880741*x_40 + 0.000502891913732686*x_41 + 0.00238954173036549*x_42 - 0.00524160128179537*x_43 + 0.00209121980985232*x_44 - 0.0047326021621782*x_45 - 0.00150814074319332*x_46 - 0.00124169165549324*x_47 - 0.00466985312526609*x_48 - 0.000827704114366425*x_49 + 0.0026645150304267*x_5 + 0.00410169184731556*x_50 - 0.00121658573855097*x_51 - 0.00155165124482881*x_52 - 0.000994854934592293*x_53 - 0.00104340067231908*x_54 - 0.00092616823241462*x_55 - 0.00112968825742199*x_56 - 0.00245966385081804*x_57 - 0.00642527633497427*x_58 + 0.00145994558777213*x_59 + 0.000365753154294332*x_6 + 0.000310109789982514*x_60 + 3.97509911471912e-5*x_61 + 0.00165469550894054*x_62 - 0.000697022617425651*x_63 + 0.000913203111685884*x_64 - 0.000563475192462394*x_65 - 0.000300704406321995*x_66 - 0.00133224771821206*x_67 + 0.000529870680898461*x_68 + 0.000345581638742474*x_69 + 6.91239911317723e-6*x_7 + 0.000127843602246788*x_70 + 1.35003621117253e-5*x_71 + 0.00102434675397062*x_72 - 1.81847878598924e-6*x_73 - 0.000115424283333498*x_74 + 5.00960740928976e-6*x_75 + 0.00101570649480063*x_76 + 0.000814356210012188*x_77 + 0.000144682953588127*x_78 - 0.000810160824740061*x_79 + 0.000873471104244008*x_8 - 0.000439867947238902*x_80 + 5.10702726520585e-5*x_81 - 0.00165465566667322*x_82 + 0.000287284655362688*x_83 - 0.000846769801351687*x_84 - 7.58406667955831e-5*x_85 + 0.000648614214213492*x_86 - 0.00112538141570504*x_87 + 5.64446496373069e-5*x_88 + 3.24503835514793e-5*x_89 + 0.0025398993968229*x_9 + 0.000458257735953329*x_90 + 7.69615484175906e-5*x_91 + 0.00107929511062465*x_92 + 0.000981718255151874*x_93 - 0.000454904670035858*x_94 - 0.000122969505016485*x_95 - 1.69208041042815e-5*x_96 - 0.0023143669849778*x_97 - 0.000724393934527948*x_98 + 0.00196045320242852*x_99 - 1.20047403272415e-5*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.000327344500568685*std::exp(0.237919852137566*x_28) - 0.000134677172338907*std::exp(0.200159847736359*x_49) - 0.00340277611327028*std::sin(0.304559946060181*x_1 + 5.10119962692261) + 0.00888414657388886*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.00114032194470254*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.00158859413885305*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.00377161935399483*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.00309121734218321*std::sin(0.341759830713272*x_10 - 7.55480003356934) + 0.00127795093660931*std::sin(0.370639860630035*x_10 + 8.21944046020508) + 0.00252799351257395*std::sin(0.527119874954224*x_10 - 4.52896022796631) - 0.00968594559592812*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.00327511983269695*std::sin(0.252879977226257*x_100 + 1.95943987369537) + 0.00324324247490662*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.00271387159208789*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.00326466885438718*std::sin(0.224239990115166*x_102 - 1.20831990242004) - 0.00371287399095374*std::sin(0.227439999580383*x_102 - 7.42063999176025) + 0.0081922418445427*std::sin(0.238879978656769*x_102 - 1.21063983440399) - 0.000384629782732804*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 0.00161199067470347*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.00262896466547321*std::sin(0.229439988732338*x_106 - 1.21535992622375) - 0.00219101096768636*std::sin(0.238159984350204*x_106 + 8.17735958099365) - 0.0010172537053534*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 0.0010089591993967*std::sin(0.215519994497299*x_109 + 4.98439979553223) - 0.00375502946944703*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 0.0018886253382175*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.00411728680191802*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.0162432240075155*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.00299197446664383*std::sin(0.267999976873398*x_11 - 1.19399988651276) - 0.000727410134866987*std::sin(0.28383994102478*x_11 - 7.43631982803345) - 0.00662328508484597*std::sin(0.199520006775856*x_110 - 7.39160013198853) - 0.00675609350200621*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.00384191734286506*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.0016439531802898*std::sin(0.242079973220825*x_110 + 8.17360019683838) + 0.00032035221272178*std::sin(0.213199988007545*x_111 + 1.97535979747772) + 0.0035855160437086*std::sin(0.220319986343384*x_111 - 1.18911993503571) - 0.00141861305140201*std::sin(0.268079966306686*x_112 - 1.21143984794617) + 0.00109126612822662*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.00382969568371592*std::sin(0.301439940929413*x_112 - 1.24199986457825) - 0.00112405374728615*std::sin(0.299759924411774*x_113 - 1.20455992221832) - 0.0018190415210913*std::sin(0.162400022149086*x_115 + 8.4596004486084) + 0.00255404531507884*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.000949178489459643*std::sin(0.203199997544289*x_117 - 4.20279979705811) + 0.000505840549863556*std::sin(0.239599987864494*x_118 + 1.96927976608276) + 0.00129152908914096*std::sin(0.251519978046417*x_118 - 1.22175991535187) + 0.00465375133072011*std::sin(0.292079925537109*x_119 - 1.4268798828125) + 0.003211352617566*std::sin(0.279679954051971*x_12 + 5.15056037902832) + 0.000775331724839485*std::sin(0.284559935331345*x_12 + 5.14287996292114) - 0.00387993045215618*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.0213886970695922*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.002712190164208*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.00163622330838551*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.00363663299980679*std::sin(0.261919975280762*x_14 + 1.97167980670929) + 0.000983144812623121*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.00156311244400625*std::sin(0.310879945755005*x_14 + 8.31400012969971) - 0.00156295712234324*std::sin(0.369119822978973*x_14 + 4.83024024963379) + 0.000321940780770499*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.00551278990069805*std::sin(0.26463994383812*x_15 - 1.01159977912903) - 0.000295193009030509*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.000703385807168694*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.00110254815883332*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.0128564921416762*std::sin(0.291199922561646*x_16 - 4.3842396736145) + 0.00105931875839015*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.00170609632256868*std::sin(0.308479934930801*x_16 - 1.17567980289459) + 0.000730735406147209*std::sin(0.330239832401276*x_16 - 4.33816003799438) - 0.0102989062362402*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 0.00188397370483928*std::sin(0.482319831848145*x_16 + 7.94760036468506) + 0.00120983121944377*std::sin(0.291759938001633*x_17 - 1.14455986022949) - 0.00226857954845854*std::sin(0.358159840106964*x_17 + 1.98871982097626) - 0.000502178630869978*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.000712909965072964*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.000361027046817886*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.00677040118038038*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.0242508770883424*std::sin(0.257679969072342*x_18 - 1.18119990825653) - 0.00625261309183479*std::sin(0.337039858102798*x_18 - 4.15015983581543) - 0.000225660794360056*std::sin(0.350399851799011*x_18 + 2.01143980026245) + 0.000522205117230184*std::sin(0.396079838275909*x_18 - 1.19023990631104) - 0.00103786974693268*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.00209340023200561*std::sin(0.254959970712662*x_19 + 1.82567989826202) + 0.000908801377265246*std::sin(0.262319952249527*x_19 - 7.57184028625488) - 0.00104420199971538*std::sin(0.387439846992493*x_2 + 5.19392013549805) - 0.00362080290814729*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.00120172980999693*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.00221326303218262*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.000902295896419164*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.0201944853740352*std::sin(0.283439934253693*x_20 + 1.97463977336884) - 0.000820112622311696*std::sin(0.289999932050705*x_20 + 1.97943985462189) + 0.00185982074150686*std::sin(0.341759830713272*x_20 + 8.23559951782227) - 0.00350485238404612*std::sin(0.346559852361679*x_20 - 4.35752010345459) - 0.000190475141576164*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.0142652416283024*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.0013051348143544*std::sin(0.356479853391647*x_21 + 8.22696018218994) + 0.000677353707288955*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.00364960811120579*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.00191010092534072*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 0.00165827921088228*std::sin(0.3435198366642*x_23 - 1.15847992897034) + 0.00046774867066668*std::sin(0.343919843435287*x_23 + 2.00119972229004) - 0.0204453195880018*std::sin(0.112400062382221*x_24 + 2.09047985076904) - 0.00092154113866418*std::sin(0.277679949998856*x_24 - 7.55751991271973) - 0.00150610509618936*std::sin(0.336079835891724*x_24 + 2.01231980323792) + 0.00311704873524452*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.00218173610833512*std::sin(0.42087984085083*x_24 + 1.98071980476379) - 0.000633143915504468*std::sin(0.424319863319397*x_25 + 1.77583980560303) + 0.000625919352651733*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.00590385908976458*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.00519553799091437*std::sin(0.131920039653778*x_27 - 7.64504051208496) - 0.00398802737905466*std::sin(0.186720013618469*x_27 - 4.40975952148438) - 0.000638416290592246*std::sin(0.342079848051071*x_27 - 1.15599977970123) - 0.000904517883769125*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.00269600206230672*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.00165746504350726*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.024158347214616*std::sin(0.325759828090668*x_28 - 1.14023983478546) + 0.00178501697684768*std::sin(0.347279846668243*x_28 - 4.38199949264526) + 0.00070668844327072*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.0075836922457689*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00753945773718637*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 0.00416652027652719*std::sin(0.138640031218529*x_3 - 7.64983987808228) + 0.00184713841456529*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 0.0027163626701051*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.0020104209342987*std::sin(0.295359939336777*x_3 - 4.13687992095947) - 0.00666692836118956*std::sin(0.371919840574265*x_3 - 1.20223987102509) - 0.00046429370659561*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 0.000980962352642676*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00931652320226734*std::sin(0.399679869413376*x_3 + 8.18696022033691) + 0.000204327462618591*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.00649362340454553*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.00104983015506306*std::sin(0.322319835424423*x_31 - 1.04135990142822) - 0.00237969585609896*std::sin(0.376239836215973*x_31 + 5.19583988189697) + 0.000682059827912098*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.00126693632063636*std::sin(0.405279844999313*x_31 - 7.38151979446411) - 0.00028172716218813*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000410950571551651*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.0157702316516239*std::sin(0.320079833269119*x_32 + 1.98847985267639) + 0.00156605605169397*std::sin(0.375919848680496*x_32 - 7.99271965026855) - 0.00416666529919388*std::sin(0.245119974017143*x_33 + 1.98655986785889) + 0.00113996080566024*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 0.00123300549831212*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.00487701223114744*std::sin(0.270159959793091*x_33 + 8.16936016082764) + 0.00561134709097895*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.0283355645214101*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.00535365203240569*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.0253539390742477*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00284338402881645*std::sin(0.232639983296394*x_36 - 1.21487987041473) + 0.00251901938350034*std::sin(0.241119980812073*x_36 + 1.96823978424072) - 0.0012389945538233*std::sin(0.247599974274635*x_36 + 5.15607976913452) + 0.00487452035662247*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00353590675589039*std::sin(0.224559992551804*x_37 - 1.2190397977829) - 0.000554274201746005*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.00119137909091865*std::sin(0.229519993066788*x_39 - 1.18871986865997) - 0.00115606618199092*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 0.000802971117804521*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 0.000664962707392877*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.0111610006147677*std::sin(0.236879989504814*x_41 + 1.98095989227295) + 0.00142202179296242*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.00210269460292049*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00543668303213896*std::sin(0.23335999250412*x_42 - 1.1956799030304) - 0.000788426961562737*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.0244397994110213*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.00198373324008542*std::sin(0.293119937181473*x_44 + 8.14287948608398) - 0.00386557752414475*std::sin(0.262559950351715*x_48 + 8.17479991912842) - 0.000305721755115674*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.0343634994194008*std::sin(0.0756000876426697*x_49 + 8.10095977783203) - 0.000345330317114658*std::sin(0.348799854516983*x_49 - 1.33007991313934) + 0.00134610475046881*std::sin(0.303839921951294*x_5 - 4.58752012252808) - 0.000367847195787591*std::sin(0.366399854421616*x_5 + 8.22288036346436) - 0.00316827641154061*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.00280570993236988*std::sin(0.393919855356216*x_5 + 1.97943985462189) - 0.00501700940135411*std::sin(0.417199850082397*x_5 - 1.20159983634949) + 0.0195809067912901*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.00487974385450796*std::sin(0.218479990959167*x_52 + 5.18767976760864) + 0.00374429681611471*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.00496554445989685*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.00550972294879397*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.00280729783829306*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.0265329642545252*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 5.82852240376796e-5*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.0077108023985502*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.00573446461819678*std::sin(0.334559857845306*x_60 + 1.88487982749939) + 0.0111881999195853*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.00193184673337522*std::sin(0.472959846258163*x_60 - 4.67736005783081) - 0.000272241483342638*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.0228450363092797*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.00281758650365812*std::sin(0.338319838047028*x_7 - 1.38855981826782) + 0.00783302255543459*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.00096020155551028*std::sin(0.347919851541519*x_7 - 7.36895990371704) + 0.00301658326394851*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.00137445514793055*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.00117561442362437*std::sin(0.383679836988449*x_7 - 1.19735991954803) - 0.000491577023374915*std::sin(0.442559868097305*x_7 - 1.41695988178253) + 4.97669622264028e-5*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.000976528502850205*std::sin(0.332879841327667*x_8 - 4.35008001327515) - 0.00244198386013323*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 0.00110106260097308*std::sin(0.357119828462601*x_8 + 8.24271965026855) - 0.000209076503074959*std::sin(0.369919836521149*x_8 + 1.81647992134094) + 0.000317701178914888*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.00158365545928137*std::sin(0.339039832353592*x_9 - 4.36039972305298) + 0.000480469043347265*std::sin(0.463119864463806*x_9 + 4.93391990661621) - 0.0021156428901031*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00821232010801011*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.00086734809748926*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.0012614366450257*std::sin(0.356319844722748*x_91 + 5.19551992416382) - 0.00652367997822946*std::sin(0.36303985118866*x_91 + 5.18800020217896) + 0.000525848364701576*std::sin(0.405119866132736*x_91 - 1.19711995124817) - 0.000838393761589363*std::sin(0.28519994020462*x_92 + 5.19591999053955) + 0.0119671597972591*std::sin(0.289599925279617*x_92 + 1.99127984046936) + 0.00108022749472294*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.00315430553803586*std::sin(0.300319939851761*x_92 + 2.00071978569031) + 0.00081302382187242*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.00112473883456386*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.00031904311291081*std::sin(0.273039966821671*x_94 - 7.60464000701904) + 0.00224371999080728*std::sin(0.288959950208664*x_94 - 1.20831990242004) + 0.000533632089646203*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.00256181696109909*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.00301770704369659*std::sin(0.283279925584793*x_95 + 4.98383951187134) - 0.0124020074149484*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.000462710995295764*std::sin(0.288799941539764*x_95 + 8.17711925506592) + 0.00275194636102976*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.00147118577469513*std::sin(0.275439947843552*x_97 + 1.9748797416687) + 0.000838084826741989*std::sin(0.277199953794479*x_97 + 1.97303986549377) + 0.00401831394250904*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.00148755649993497*std::sin(0.294079929590225*x_97 - 4.4256796836853) - 0.0016748889112358*std::sin(0.257279962301254*x_98 - 7.43447971343994) + 0.00421479719159564*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.00370924503666786*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.00508100524911463*std::sin(0.251759976148605*x_99 + 1.95271980762482) - 0.0445968272639557);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00299880060358241*x_1 + 0.0012624285828631*x_10 - 0.000176674019693304*x_100 + 0.000845069030403241*x_101 + 0.000679440244163514*x_102 + 0.00173858092373085*x_103 - 0.0109720140296384*x_104 + 0.00472505500353538*x_105 - 0.00507640861360543*x_106 - 0.00111160395775536*x_107 + 0.0073405498830942*x_108 - 0.00014339976596794*x_109 - 0.000683805081745609*x_11 - 4.73751998764603e-5*x_110 - 0.00351918018750506*x_111 + 0.0121011464308681*x_112 + 0.00260254603558014*x_113 - 0.000655011921685631*x_114 + 0.000501458887503872*x_115 + 0.0152584750502282*x_116 + 0.00744131854831402*x_117 - 0.00890550045086876*x_118 + 0.0150706327892756*x_119 + 0.00370738257561805*x_12 + 0.011823872964402*x_120 + 0.000747901237396936*x_13 - 0.000538515390430322*x_14 - 0.000821101217650855*x_15 + 0.000590576726262307*x_16 + 0.00133003673437315*x_17 + 0.000178799821126252*x_18 - 0.00209385120950297*x_19 - 0.00459852332609622*x_2 - 0.0003286240448157*x_20 - 0.000124329611985809*x_21 - 8.68858231281337e-5*x_22 + 0.00343464562147603*x_23 - 0.000248234671950353*x_24 - 0.00424846149954893*x_25 - 0.00192971060446809*x_26 - 0.00264693114652345*x_27 - 0.000153263963110396*x_28 + 0.00347356682261999*x_29 + 5.80574981156563e-6*x_3 - 0.009712354464517*x_30 - 0.00132764911578619*x_31 - 0.000268694485566138*x_32 + 0.000471188904564561*x_33 + 0.00122726228810832*x_34 - 0.0124667613142439*x_35 + 0.00231061909341184*x_36 + 0.00556695887331431*x_37 + 0.00441657756684818*x_38 - 0.0091675063273104*x_39 + 0.00148356292215596*x_4 - 0.000507981482444816*x_40 - 0.000488310753876347*x_41 + 0.0108708342645015*x_42 + 0.0103074771987673*x_43 - 0.00142789096710811*x_44 - 0.00904076429526594*x_45 - 0.00196107099229373*x_46 + 0.00477284613697101*x_47 - 0.00528455488954*x_48 + 0.00529729084736593*x_49 + 0.00164249003517186*x_5 + 0.0101155112250228*x_50 + 0.00422426390770887*x_51 - 0.000942799985253683*x_52 + 0.00318070144554313*x_53 - 0.00954854707446709*x_54 + 0.00322448503980643*x_55 - 0.00870922284897629*x_56 - 0.00689456421283481*x_57 + 0.00100865924162841*x_58 + 0.000771583443895935*x_59 + 0.0108669298685502*x_6 + 0.000150183511404779*x_60 - 0.000967753855437581*x_61 + 0.00421382200541268*x_62 + 0.000413977512569696*x_63 - 0.00079186067406731*x_64 - 0.000961479257389735*x_65 + 0.00223087910324298*x_66 - 0.00045495919103817*x_67 - 0.00232178780271514*x_68 - 0.00016501052332243*x_69 + 0.000569298569651666*x_7 + 0.000189606665552628*x_70 + 0.000211689264190517*x_71 + 0.000732473245707055*x_72 - 0.00037663558188893*x_73 - 4.46744558761311e-6*x_74 + 1.69513913288137e-5*x_75 + 0.000377784479952561*x_76 - 0.000349539584605485*x_77 + 0.000478541054918919*x_78 - 0.000198577861269504*x_79 - 0.000702786027470382*x_8 - 0.00326152430966962*x_80 - 0.000211672385308562*x_81 - 0.000602361271291825*x_82 - 0.000101746780850587*x_83 - 0.000392375136463331*x_84 - 0.00216221147279966*x_85 - 0.000625778798890031*x_86 + 0.00175815296162399*x_87 + 0.00152661986064672*x_88 + 0.00150467135278505*x_89 + 0.00687198841069808*x_9 + 0.000608533287329483*x_90 - 6.59181231262418e-5*x_91 - 0.00258442841551916*x_92 + 0.00738818713172314*x_93 + 0.00177990633257416*x_94 - 0.000182040939987819*x_95 + 0.00218239711810949*x_96 + 0.000248962884342305*x_97 + 3.60156069542645e-5*x_98 - 0.000582567634693132*x_99 - 5.33849371900003e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.000185887878353954*std::exp(0.237919852137566*x_28) + 7.09772455273994e-5*std::exp(0.200159847736359*x_49) - 0.000268474097018217*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.00703399884271659*std::sin(0.323359847068787*x_1 + 8.33455944061279) - 0.00305658257350562*std::sin(0.352879852056503*x_1 + 8.36448001861572) + 0.0020948551822444*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.0021417751587542*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.0416573958800072*std::sin(0.341759830713272*x_10 - 7.55480003356934) + 0.000100828474257165*std::sin(0.370639860630035*x_10 + 8.21944046020508) + 0.000229330018760895*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.00766882103370694*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.0441356748240687*std::sin(0.252879977226257*x_100 + 1.95943987369537) + 0.000255887124476391*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.0365722661219498*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.0439948369299347*std::sin(0.224239990115166*x_102 - 1.20831990242004) - 0.000336817898371626*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.00648618515853053*std::sin(0.238879978656769*x_102 - 1.21063983440399) - 0.00103098313297743*std::sin(0.254799962043762*x_102 + 7.98680019378662) - 0.00212570784194777*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.000238489740205402*std::sin(0.229439988732338*x_106 - 1.21535992622375) - 0.000172867585620048*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.00053611064707264*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 0.00057295382875144*std::sin(0.215519994497299*x_109 + 4.98439979553223) - 0.00029626637560874*std::sin(0.237919986248016*x_109 + 1.9521598815918) - 0.00249050180931644*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.0554847580331874*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00722334236115523*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.0403199940421621*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.000383357972586848*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.00524396791906998*std::sin(0.199520006775856*x_110 - 7.39160013198853) - 0.000612887272795216*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.0517738657537946*std::sin(0.220159992575645*x_110 + 1.96663987636566) + 0.00216785631702233*std::sin(0.242079973220825*x_110 + 8.17360019683838) - 0.0110416777461385*std::sin(0.213199988007545*x_111 + 1.97535979747772) + 0.000282892012326329*std::sin(0.220319986343384*x_111 - 1.18911993503571) + 0.000747634102417563*std::sin(0.268079966306686*x_112 - 1.21143984794617) + 8.60993138042917e-5*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.000347415520896991*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.000592396153123523*std::sin(0.299759924411774*x_113 - 1.20455992221832) - 0.0245134923812095*std::sin(0.162400022149086*x_115 + 8.4596004486084) + 0.000201510468771453*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.000539006384033759*std::sin(0.203199997544289*x_117 - 4.20279979705811) - 0.0174349610232712*std::sin(0.239599987864494*x_118 + 1.96927976608276) + 0.000101899770786459*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.003684594935746*std::sin(0.292079925537109*x_119 - 1.4268798828125) + 0.000253371061012746*std::sin(0.279679954051971*x_12 + 5.15056037902832) - 0.000408613495839015*std::sin(0.284559935331345*x_12 + 5.14287996292114) - 0.000306120881880474*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00951152810065404*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.0365496071177186*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.000929155916108783*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.0490074439205417*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00051813465892305*std::sin(0.294079929590225*x_14 + 1.97463977336884) - 0.00206125285475455*std::sin(0.310879945755005*x_14 + 8.31400012969971) - 0.000123315048692997*std::sin(0.369119822978973*x_14 + 4.83024024963379) - 0.0110964314071879*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.000500099468239824*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.000155571922962608*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.000399429027008923*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.000626099835715982*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00571726673595467*std::sin(0.291199922561646*x_16 - 4.3842396736145) + 8.35787126881904e-5*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.0229914373696133*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.000385110449209297*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.00815413095050393*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 0.000170906975404347*std::sin(0.482319831848145*x_16 + 7.94760036468506) + 9.5453927432344e-5*std::sin(0.291759938001633*x_17 - 1.14455986022949) - 0.0305714887936936*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.000264656996897571*std::sin(0.36695984005928*x_17 - 7.37695980072021) + 0.000940103641503437*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.000205015057973424*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.091238256976904*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.0107843361444958*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.00495048937859529*std::sin(0.337039858102798*x_18 - 4.15015983581543) + 0.00777791965315798*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.000275211308476541*std::sin(0.396079838275909*x_18 - 1.19023990631104) - 8.18864168123256e-5*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.00118877123946534*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.00047895435707154*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.000550312873569215*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.00286676083670966*std::sin(0.436879843473434*x_2 + 2.02287983894348) + 0.00158470301416774*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.00125683727258873*std::sin(0.258719980716705*x_20 - 4.39888000488281) - 0.00241856427121541*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00898046358263023*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.000432213818741727*std::sin(0.289999932050705*x_20 + 1.97943985462189) + 0.000146737157418192*std::sin(0.341759830713272*x_20 + 8.23559951782227) - 0.0472315619063136*std::sin(0.346559852361679*x_20 - 4.35752010345459) + 0.00656516499157346*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00634373595402953*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.0175880605017383*std::sin(0.356479853391647*x_21 + 8.22696018218994) + 0.00181561667511267*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.0491822971554661*std::sin(0.370719850063324*x_22 + 1.98679983615875) - 0.00511994110887376*std::sin(0.151280030608177*x_23 + 8.14335918426514) + 0.002186747837955*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.000246511800526069*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.0161875260752282*std::sin(0.112400062382221*x_24 + 2.09047985076904) - 7.27082584432005e-5*std::sin(0.277679949998856*x_24 - 7.55751991271973) - 0.00403704814440035*std::sin(0.336079835891724*x_24 + 2.01231980323792) + 0.000282766882658817*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.0294011823531092*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.000333678012127058*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.000329870540062406*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.0026254391023393*std::sin(0.432159870862961*x_26 - 4.42119979858398) - 0.00685127775472764*std::sin(0.131920039653778*x_27 - 7.64504051208496) - 0.00031464957253583*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.000336456646802993*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.000476696880438276*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.000244571119527399*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.0223360798778035*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.0107431882199058*std::sin(0.325759828090668*x_28 - 1.14023983478546) + 0.000140835248946425*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.000372437275585057*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.000687963903526101*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00335278787191261*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 0.000377970975174993*std::sin(0.138640031218529*x_3 - 7.64983987808228) + 0.000145736540227878*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 0.0366058360109753*std::sin(0.289759933948517*x_3 - 1.13751995563507) - 0.00265111182882051*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.00527852236419759*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.000244690973515063*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 0.000557055365711234*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00414304676673091*std::sin(0.399679869413376*x_3 + 8.18696022033691) - 0.00704261717986023*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.00368750926135467*std::sin(0.103840067982674*x_30 - 7.68088006973267) + 0.00138439522532679*std::sin(0.322319835424423*x_31 - 1.04135990142822) - 0.000215877015747853*std::sin(0.376239836215973*x_31 + 5.19583988189697) - 0.0235087648042335*std::sin(0.396399825811386*x_31 + 5.1989598274231) - 0.0033959668121695*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.000148475184139188*std::sin(0.457759857177734*x_31 + 8.22959995269775) - 0.000541914333816453*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.00701300322409514*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.0012399206118031*std::sin(0.375919848680496*x_32 - 7.99271965026855) - 0.000328743845184434*std::sin(0.245119974017143*x_33 + 1.98655986785889) + 0.00305561455626414*std::sin(0.262479960918427*x_33 - 1.20239984989166) + 0.00162594579364359*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.0657228550228887*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.0044427687697131*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.0126007917787779*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.0721460762639934*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.0112748664952491*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00161466168988321*std::sin(0.232639983296394*x_36 - 1.21487987041473) + 0.000198746973601704*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.000652971985723981*std::sin(0.247599974274635*x_36 + 5.15607976913452) + 0.0656892744000857*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00200792194085436*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.000292112281714905*std::sin(0.249839976429939*x_38 - 4.424880027771) + 0.00157105367669962*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.000609267270912165*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 6.3353255873509e-5*std::sin(0.345279842615128*x_4 - 4.37623977661133) - 0.000876876314416572*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00496328367424036*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.000749430569350088*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.00119404919857875*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.000493195340714307*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.000415514916592094*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.0108683496762764*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.026732886030008*std::sin(0.293119937181473*x_44 + 8.14287948608398) - 0.000304988456690228*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00016112075787653*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.0152814072451899*std::sin(0.0756000876426697*x_49 + 8.10095977783203) + 0.0119026057137412*std::sin(0.348799854516983*x_49 - 1.33007991313934) + 0.000106205711261656*std::sin(0.303839921951294*x_5 - 4.58752012252808) + 0.000193861961003161*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.00250847421604705*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.0378098840810247*std::sin(0.393919855356216*x_5 + 1.97943985462189) - 0.000455124134778597*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.0155031295987485*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.065759666512709*std::sin(0.218479990959167*x_52 + 5.18767976760864) + 0.00029541958483671*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.000450455429763644*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.0742492955558309*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.00159416956191828*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.0117991775880239*std::sin(0.246639966964722*x_6 - 7.37775993347168) + 0.000156230966977413*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.00342898463865144*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.000520208960954083*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00885822680118122*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.0260336609314159*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.000143476064060276*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.0101591604252086*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.000255600800607458*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.00620177426516524*std::sin(0.338559836149216*x_7 + 2.02039980888367) - 0.00257377783112935*std::sin(0.347919851541519*x_7 - 7.36895990371704) + 0.000238004041673638*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.000780506624970381*std::sin(0.367679834365845*x_7 - 1.17919993400574) - 0.00155026504720007*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.000259069762735358*std::sin(0.442559868097305*x_7 - 1.41695988178253) + 0.000670662013608668*std::sin(1.39911985397339*x_78 - 6.79120016098022) + 0.0012877334397583*std::sin(0.332879841327667*x_8 - 4.35008001327515) - 0.000192668982606747*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 0.000625256237615716*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.000110187005229203*std::sin(0.369919836521149*x_8 + 1.81647992134094) - 0.0109503037526795*std::sin(0.16176001727581*x_9 + 8.17623996734619) - 0.00208834261982133*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.000253215661316062*std::sin(0.463119864463806*x_9 + 4.93391990661621) - 0.0285105069161857*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.0036520089664533*std::sin(0.340319842100143*x_91 + 5.19456005096436) + 0.00114375888239587*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.000716327236945762*std::sin(0.356319844722748*x_91 + 5.19551992416382) - 0.000591803596154867*std::sin(0.36303985118866*x_91 + 5.18800020217896) - 0.0181245764998394*std::sin(0.405119866132736*x_91 - 1.19711995124817) + 0.0288971743356817*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.00947496616185141*std::sin(0.289599925279617*x_92 + 1.99127984046936) + 8.52283816407981e-5*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.00179122350651063*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.000428477895863817*std::sin(0.302559942007065*x_92 - 1.19743990898132) + 0.00148317617359381*std::sin(0.314959913492203*x_92 + 8.21815967559814) + 0.00085518096328011*std::sin(0.273039966821671*x_94 - 7.60464000701904) + 0.000203541799069778*std::sin(0.288959950208664*x_94 - 1.20831990242004) - 0.000281233524511532*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.00145476926846969*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.0406667675073184*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.00981925557830184*std::sin(0.286399960517883*x_95 - 1.2111998796463) - 0.00124027637226555*std::sin(0.288799941539764*x_95 + 8.17711925506592) + 0.000217124574090763*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.000835436678629073*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.000441685487506108*std::sin(0.277199953794479*x_97 + 1.97303986549377) + 0.0541509949459033*std::sin(0.287119954824448*x_97 - 4.41831970214844) + 0.0019616183684399*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.000882696001255136*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.00333705419213852*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.0499859672756931*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.000460929596261999*std::sin(0.251759976148605*x_99 + 1.95271980762482) - 0.171180026060463);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00176858148317056*x_1 + 0.00207890504691263*x_10 - 0.000218678764457594*x_100 + 0.000644894737242634*x_101 + 0.00137560749513446*x_102 - 0.00291995766104084*x_103 + 0.00516770629125988*x_104 - 0.00346345336394072*x_105 + 0.00334877515677622*x_106 - 0.000280230615559566*x_107 - 0.00569111056872319*x_108 - 0.000518158756038174*x_109 + 0.00168119928060867*x_11 + 0.000339744469438604*x_110 + 0.000780290314738407*x_111 - 0.00732071639646426*x_112 - 0.00248417224394375*x_113 + 0.000364579099283043*x_114 - 0.00357450067449559*x_115 - 0.00680388256717635*x_116 - 0.00305871346460793*x_117 + 0.00413575040140683*x_118 - 0.00801452555089583*x_119 - 0.00385172802114364*x_12 - 0.00817735194888307*x_120 - 4.33018194207222e-5*x_13 + 0.000267120920787507*x_14 + 0.000114915503483965*x_15 - 0.000476608802494893*x_16 + 0.00160402333761276*x_17 + 0.000299216809306258*x_18 - 0.0025000225883754*x_19 + 0.00276878318861653*x_2 + 0.000228571347346495*x_20 + 0.000425380967005098*x_21 + 0.000786487463697283*x_22 - 0.00118712892173692*x_23 - 0.000722068928191976*x_24 + 0.000868582797551611*x_25 + 0.000354358228778561*x_26 + 0.00196154685116428*x_27 + 0.000102271516382138*x_28 - 0.00195146361254927*x_29 - 1.22866863034938e-8*x_3 + 0.004892738375957*x_30 + 0.00145770335334711*x_31 + 0.000452807529340383*x_32 + 0.0025871280708228*x_33 - 0.000361910511858652*x_34 + 0.00625895499365762*x_35 + 0.000249304774978106*x_36 - 0.00463291073428887*x_37 - 0.00351126784208559*x_38 + 0.000855347449581375*x_39 + 0.00137563859604386*x_4 - 0.00145483740825003*x_40 - 0.000350779175913319*x_41 - 0.00587727027046158*x_42 - 0.00708865143923479*x_43 + 0.00096574188559237*x_44 - 0.000462238726117304*x_45 - 0.000657769091097692*x_46 - 0.00475601255982828*x_47 + 0.000677542222484808*x_48 - 0.00156938642383608*x_49 + 0.00102346275486269*x_5 - 0.00226887778061069*x_50 - 0.00564292766309797*x_51 - 0.00271122749057478*x_52 - 0.00259338231748009*x_53 + 0.00604212109104927*x_54 + 0.00236711156655861*x_55 + 0.00725703908597399*x_56 + 0.000327667733611564*x_57 - 0.00429597763486689*x_58 + 0.00112607677169552*x_59 - 0.00582092036735226*x_6 - 0.000238433902792335*x_60 + 0.000135039812520871*x_61 - 0.0016851123456014*x_62 + 0.000480614395800473*x_63 + 0.000531000190105759*x_64 - 0.000195819191932542*x_65 - 0.0020178597508762*x_66 - 0.00063629316177329*x_67 + 0.00165756152497397*x_68 + 0.000460093327533808*x_69 - 0.000236799488694783*x_7 + 0.000575227084377419*x_70 + 0.000284078319351857*x_71 + 0.000155273691610512*x_72 + 0.00049366819427619*x_73 - 0.000535908070314654*x_74 - 0.00010459210716595*x_75 + 0.00107829753265464*x_76 + 0.000504808842769857*x_77 + 0.000363443090535227*x_78 - 0.000473282239857556*x_79 + 0.00148601676276845*x_8 + 0.00183751018498265*x_80 - 0.000224826993054687*x_81 - 0.00112461454186834*x_82 - 0.000516210235383296*x_83 - 1.83974974254022e-5*x_84 + 0.00111396209589468*x_85 + 0.000369283190614368*x_86 - 0.00161202177763715*x_87 - 0.000459678215382973*x_88 - 0.000664519858201848*x_89 - 0.0043155575512051*x_9 + 0.000996158791203611*x_90 - 7.31131955229908e-5*x_91 + 0.00241811546285565*x_92 - 0.00576291084816331*x_93 - 0.00105124501223611*x_94 - 3.78820586970463e-5*x_95 - 0.00130080396246186*x_96 - 0.00134528304636669*x_97 - 0.000817541763626073*x_98 + 0.00240178829030602*x_99 - 5.18267579621219e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.000181397136111634*std::exp(0.237919852137566*x_28) + 0.00114446120063431*std::exp(0.200159847736359*x_49) + 0.000756443896834919*std::sin(0.304559946060181*x_1 + 5.10119962692261) + 0.00282004401643871*std::sin(0.323359847068787*x_1 + 8.33455944061279) + 6.46863410589541e-6*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.00223522993191582*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.00209003343000815*std::sin(0.121440060436726*x_10 - 4.46895980834961) + 0.024158502427425*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.000284091034576918*std::sin(0.370639860630035*x_10 + 8.21944046020508) + 0.00328521856654638*std::sin(0.527119874954224*x_10 - 4.52896022796631) - 0.00307455451057371*std::sin(0.239199981093407*x_100 - 1.19463992118835) + 0.0255957384000817*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.00072097925177366*std::sin(0.262639969587326*x_100 - 1.2196798324585) - 0.0212094673999436*std::sin(0.240559980273247*x_101 + 1.96103990077972) - 0.0255140618445641*std::sin(0.224239990115166*x_102 - 1.20831990242004) - 0.00482501339883149*std::sin(0.227439999580383*x_102 - 7.42063999176025) + 0.00260041664134868*std::sin(0.238879978656769*x_102 - 1.21063983440399) + 2.18186569353234e-6*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 0.00226815000631176*std::sin(0.237279981374741*x_104 - 1.20263981819153) + 0.00341643421426872*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.000487066095221844*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.00864443006012028*std::sin(0.252239972352982*x_107 - 7.43511962890625) + 0.000559112216353381*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.000834750518413801*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 0.00265738855690749*std::sin(0.249039977788925*x_109 + 1.95839989185333) + 0.0321774473251018*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00701251019359178*std::sin(0.253679990768433*x_109 + 8.17984008789063) - 0.0233828988433918*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.00618139408368716*std::sin(0.28383994102478*x_11 - 7.43631982803345) - 0.00210239163856025*std::sin(0.199520006775856*x_110 - 7.39160013198853) - 0.0087797866963335*std::sin(0.213839992880821*x_110 - 7.42335987091064) + 0.0300253780887565*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.00231312282059972*std::sin(0.242079973220825*x_110 + 8.17360019683838) + 0.00339212293341893*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.00079706734677305*std::sin(0.220319986343384*x_111 - 1.18911993503571) + 0.0120551060573019*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 0.000242590630426859*std::sin(0.28519994020462*x_112 + 8.17903995513916) + 0.00497682739365735*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.00955199666621569*std::sin(0.299759924411774*x_113 - 1.20455992221832) + 0.0142161854500448*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.000567769352587361*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.000525984885487999*std::sin(0.203199997544289*x_117 - 4.20279979705811) + 0.00535620876555524*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.000287109484886595*std::sin(0.251519978046417*x_118 - 1.22175991535187) + 0.00147721376330763*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.000713890073069786*std::sin(0.279679954051971*x_12 + 5.15056037902832) - 0.00658862271377911*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.000862516255251603*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00923390923863172*std::sin(0.287439942359924*x_13 + 1.95335984230042) + 0.0211963266935418*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.000906709053198088*std::sin(0.225679993629456*x_14 - 4.19647979736328) - 0.0284210385192253*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00835457912511427*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.00219937593645879*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.000347448476436775*std::sin(0.369119822978973*x_14 + 4.83024024963379) + 0.00340894385081974*std::sin(0.25231996178627*x_15 + 1.56383979320526) + 0.00716406891282037*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.00250849449588802*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.000389779485466563*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.000610974304104903*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00555039333051262*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.000235488666580788*std::sin(0.308079928159714*x_16 - 1.1775997877121) + 0.0133334953798772*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00620965161163868*std::sin(0.330239832401276*x_16 - 4.33816003799438) - 0.00326912311338189*std::sin(0.352959841489792*x_16 + 2.01791977882385) + 0.00244829164443598*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 0.000268947885986262*std::sin(0.291759938001633*x_17 - 1.14455986022949) + 0.0177294180452337*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.00426741925774986*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.00100309931512315*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.00020006223485604*std::sin(0.166160017251968*x_18 + 7.98320007324219) + 0.0529120845431537*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.0104695670457329*std::sin(0.257679969072342*x_18 - 1.18119990825653) - 0.00198473134026836*std::sin(0.337039858102798*x_18 - 4.15015983581543) - 0.00238946111599696*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.00443760056038823*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.000230720508679693*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.00116005250175746*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.00772282263801751*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.00887343158120179*std::sin(0.387439846992493*x_2 + 5.19392013549805) - 0.00114933083227544*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.00169089283139368*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.00122647417262914*std::sin(0.258719980716705*x_20 - 4.39888000488281) + 5.1183983929284e-6*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.0087183452296317*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.00696916233156646*std::sin(0.289999932050705*x_20 + 1.97943985462189) - 0.000413441849328072*std::sin(0.341759830713272*x_20 + 8.23559951782227) + 0.0273911457704051*std::sin(0.346559852361679*x_20 - 4.35752010345459) - 0.0020168897554888*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00615857740349057*std::sin(0.316399931907654*x_21 + 1.97503972053528) - 0.0101998983217495*std::sin(0.356479853391647*x_21 + 8.22696018218994) - 3.84238268243358e-6*std::sin(0.356319844722748*x_22 - 7.38351964950562) - 0.0285224416965274*std::sin(0.370719850063324*x_22 + 1.98679983615875) + 1.08353119474382e-5*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 0.00233328024885827*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.00397483995193476*std::sin(0.343919843435287*x_23 + 2.00119972229004) - 0.00648984127949653*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 0.000204860427727309*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 8.54358967441842e-6*std::sin(0.336079835891724*x_24 + 2.01231980323792) + 0.00405071703187595*std::sin(0.377839833498001*x_24 - 4.59847974777222) - 0.0170507186117135*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.0053803375370038*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.00531894456495882*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.00254880878508773*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.00731037698406858*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.000886546417065683*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.00542514118574665*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.00768642231846563*std::sin(0.183280006051064*x_28 - 1.20519983768463) - 0.00350355172451348*std::sin(0.221039995551109*x_28 + 8.60432052612305) - 0.0129534318828136*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.0104296201311045*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.000396812823687496*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.00600530505811898*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.009855281053869*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00325492797561071*std::sin(0.398559868335724*x_29 - 4.39160013198853) + 0.00541454307626064*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.000410622542828536*std::sin(0.287599951028824*x_3 + 5.06271982192993) - 0.0212289356895085*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.00282876093911505*std::sin(0.295359939336777*x_3 - 4.13687992095947) - 0.00211624507504814*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.00394548031911611*std::sin(0.377199828624725*x_3 - 4.3931999206543) + 0.000543597833760995*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00402212109458723*std::sin(0.399679869413376*x_3 + 8.18696022033691) + 0.00216356823630798*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.00359842516530953*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.00147716256067708*std::sin(0.322319835424423*x_31 - 1.04135990142822) - 0.00309250042387563*std::sin(0.376239836215973*x_31 + 5.19583988189697) + 0.00722214703799704*std::sin(0.396399825811386*x_31 + 5.1989598274231) + 7.18687168280688e-6*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.00239406427005877*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000578227626304452*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.00680831035520709*std::sin(0.320079833269119*x_32 + 1.98847985267639) + 0.000497104247578173*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.000926257981956953*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 6.4665854946792e-6*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 0.00173489926006769*std::sin(0.266639977693558*x_33 - 1.23087990283966) - 0.0381148585759241*std::sin(0.270159959793091*x_33 + 8.16936016082764) + 0.00178117792817428*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.0122330046643221*std::sin(0.243759974837303*x_34 + 1.95839989185333) - 0.0418398971355137*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.0109457799833089*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00157565414661561*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.000559983018343922*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.0105287419539795*std::sin(0.247599974274635*x_36 + 5.15607976913452) - 0.0380953840614864*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00195941388342253*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.00471011759004387*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.00167632886156982*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.00982403229646537*std::sin(0.334719836711884*x_4 - 7.37951993942261) - 0.000178502076298576*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 0.000935635170003501*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00481841723943039*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.0120840728999459*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.00116520295414932*std::sin(0.276719957590103*x_41 - 1.2247998714447) + 0.00706516529760601*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.00669990356474003*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.0105511284225243*std::sin(0.254719972610474*x_44 + 8.17759990692139) + 0.0155032852727594*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.000859325570812032*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00259796579363311*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.0148353793467687*std::sin(0.0756000876426697*x_49 + 8.10095977783203) - 0.0036566093248958*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.000299241762930449*std::sin(0.303839921951294*x_5 - 4.58752012252808) + 0.00312589606709028*std::sin(0.366399854421616*x_5 + 8.22288036346436) - 0.00100568792539383*std::sin(0.389279842376709*x_5 - 1.38399982452393) + 0.0219272030105578*std::sin(0.393919855356216*x_5 + 1.97943985462189) - 0.00651978430794495*std::sin(0.417199850082397*x_5 - 1.20159983634949) + 0.00621545565170148*std::sin(0.193999990820885*x_50 + 2.01047992706299) - 0.0381362067770633*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.000832364628234775*std::sin(0.244319975376129*x_53 - 1.22295987606049) - 0.00645290376400341*std::sin(0.24975997209549*x_53 - 1.19007992744446) - 0.043059623604101*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.00155565707440957*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.0114547876834657*std::sin(0.246639966964722*x_6 - 7.37775993347168) - 3.30631002789513e-7*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.00332890074012319*std::sin(0.291599929332733*x_60 - 4.26775979995728) + 0.0074521431875519*std::sin(0.334559857845306*x_60 + 1.88487982749939) + 0.00355140653922547*std::sin(0.418079853057861*x_60 - 4.41295957565308) - 0.0150977814988243*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.00231345676091813*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.00986263871739227*std::sin(0.28519994020462*x_7 + 5.22079992294312) + 0.00366155508256961*std::sin(0.338319838047028*x_7 - 1.38855981826782) + 0.0024863917095881*std::sin(0.338559836149216*x_7 + 2.02039980888367) + 5.44687626100876e-6*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.000670592458436881*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.000761650881916006*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.0016541472008542*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.00417732879749041*std::sin(0.442559868097305*x_7 - 1.41695988178253) - 0.000388939095723041*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.00137402353789097*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.000542857868304436*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 0.000610151085932892*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00177669267610889*std::sin(0.369919836521149*x_8 + 1.81647992134094) + 0.00336405185347469*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.00222828096733589*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.00408293527898769*std::sin(0.463119864463806*x_9 + 4.93391990661621) + 0.0165341864509671*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00354541551873039*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.00122040134826254*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.000699021961256126*std::sin(0.356319844722748*x_91 + 5.19551992416382) - 0.00847775695629258*std::sin(0.36303985118866*x_91 + 5.18800020217896) + 0.0055680661052721*std::sin(0.405119866132736*x_91 - 1.19711995124817) - 0.00887752477736918*std::sin(0.28519994020462*x_92 + 5.19591999053955) + 0.00379866733392423*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 0.000240136720247259*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.00174795052315447*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.0069089230428964*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.00158256274974071*std::sin(0.314959913492203*x_92 + 8.21815967559814) - 1.80981622866536e-6*std::sin(0.273039966821671*x_94 - 7.60464000701904) + 0.00291579489237938*std::sin(0.288959950208664*x_94 - 1.20831990242004) - 0.00453470481602216*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.00141962446040262*std::sin(0.281839966773987*x_95 + 1.94663977622986) + 0.0235840042515137*std::sin(0.283279925584793*x_95 + 4.98383951187134) - 0.00393669853502253*std::sin(0.286399960517883*x_95 - 1.2111998796463) + 2.62479218193398e-6*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00061176314865376*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.000815253916758183*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.00712188673395129*std::sin(0.277199953794479*x_97 + 1.97303986549377) - 0.0314039539729352*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.00209306501437253*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.0142328899619186*std::sin(0.257279962301254*x_98 - 7.43447971343994) + 0.00133787905251311*std::sin(0.264959961175919*x_98 + 1.95287978649139) - 0.0289885165948786*std::sin(0.265839964151382*x_98 + 1.95631980895996) + 0.0066029492156866*std::sin(0.251759976148605*x_99 + 1.95271980762482) + 0.266585590448633);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000543411748416699*x_1 + 2.27197061467624e-5*x_10 + 7.11818921008598e-5*x_100 - 0.000213050673134858*x_101 - 4.1199872843676e-5*x_102 - 0.000732734241998055*x_103 - 0.00336697465432608*x_104 - 0.000953435015138791*x_105 - 0.00132000243206891*x_106 + 0.000231186833638342*x_107 + 0.00377188822589926*x_108 + 8.85839314677613e-5*x_109 - 0.000493983485536256*x_11 + 6.36178745416132e-5*x_110 - 0.00178109968897878*x_111 + 0.00279084470852054*x_112 + 0.00103768845284436*x_113 - 0.00173451740737606*x_114 + 0.00106047155043399*x_115 + 0.00109239479518883*x_116 + 0.00124391958581031*x_117 - 0.0023339535294399*x_118 + 0.00647003656275163*x_119 + 0.00404357857058829*x_12 + 0.00534293576313483*x_120 + 3.10659201913652e-6*x_13 - 0.000604621240039173*x_14 + 0.000554624376149451*x_15 + 0.000598496346329272*x_16 - 0.00259333955865629*x_17 - 0.000575839170182044*x_18 - 0.000459755739943101*x_19 - 0.00148117338333208*x_2 - 0.000161331044375795*x_20 - 0.00058348575234723*x_21 - 0.00117854566824101*x_22 - 0.000528934055453508*x_23 - 0.000104986120327294*x_24 + 0.00417453837964351*x_25 + 0.00238736520684225*x_26 - 0.00199498184604491*x_27 - 9.31392481157839e-5*x_28 + 0.00133138553388074*x_29 - 5.5930033684025e-6*x_3 - 0.0035875586712101*x_30 - 0.000252495950296699*x_31 - 0.000179596363301277*x_32 - 0.00169734559911557*x_33 - 0.00375125954032854*x_34 - 0.00342434105340394*x_35 - 0.00331408373574806*x_36 + 0.00308005068481331*x_37 + 0.000882029671098041*x_38 - 0.00301005379010881*x_39 - 0.000595639672071956*x_4 - 0.00156344416381938*x_40 + 0.00129165364599929*x_41 + 0.00293938259199046*x_42 + 0.00128161759944472*x_43 - 0.00159693841455739*x_44 - 0.00119059509743483*x_45 - 0.0010050468059846*x_46 + 0.00391859958504672*x_47 - 0.00353136268678873*x_48 - 0.00138359045860414*x_49 - 0.000201569836630546*x_5 + 0.00409436219728744*x_50 + 0.00529931068782614*x_51 + 0.00127711579085089*x_52 + 0.00117101312755192*x_53 - 0.00596340242068391*x_54 + 4.54156913978063e-6*x_55 - 0.00587790822078503*x_56 + 0.00421802121940182*x_57 + 0.00522148801304806*x_58 - 0.00153580051906075*x_59 + 0.00256350154365338*x_6 - 0.000155294490203974*x_60 - 0.000463897193086671*x_61 + 0.00100822641507702*x_62 + 0.000230875625627018*x_63 + 0.000148308267640204*x_64 + 0.000302331990972639*x_65 + 0.000355996317570572*x_66 + 0.000675838505310733*x_67 - 0.00088797344834623*x_68 - 0.000153952133110287*x_69 - 0.000217297925355181*x_7 - 0.000379883920377688*x_70 - 0.000737062591216838*x_71 + 0.000522276172330613*x_72 + 0.000317056927936734*x_73 - 0.000139536707967799*x_74 + 0.000505988521134164*x_75 + 0.000258563580705318*x_76 + 0.0005313135501462*x_77 - 0.00102185401233149*x_78 - 0.00056744665257789*x_79 - 0.0017860128704075*x_8 - 0.000680938319602607*x_80 - 0.000160938929147094*x_81 + 0.000504824476352275*x_82 - 0.000332858678283511*x_83 - 0.000678142085163105*x_84 - 0.000158132808855777*x_85 - 0.000234273224137197*x_86 + 0.00177280209491961*x_87 + 0.000226332152926719*x_88 + 0.000363295683984708*x_89 + 0.0029367191659047*x_9 + 0.000353675371916158*x_90 - 2.54073639730665e-6*x_91 - 0.000992931877083649*x_92 + 0.0038683978074195*x_93 + 0.000452396235565429*x_94 + 0.000248103351011298*x_95 + 0.000163298491914108*x_96 + 0.000906553185471855*x_97 + 0.00114994473308065*x_98 - 0.00136529673488775*x_99 - 1.27771817105242e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) + 0.000531366111255484*std::exp(0.237919852137566*x_28) + 0.000117440762420927*std::exp(-0.0116795823137492*x_1 - 0.0495852108626663*x_10 - 0.00148266900080917*x_100 - 0.11040546729156*x_101 - 0.0236127484154266*x_102 + 0.00723568364273375*x_103 + 0.061750457508843*x_104 + 0.0717775050433362*x_105 + 0.00657737609275882*x_106 + 0.000453875041578513*x_108 + 0.0369260956563652*x_109 - 0.0275234500418709*x_110 + 0.10694094065851*x_111 + 0.0483183094239878*x_114 + 0.0851360110631708*x_115 - 0.0143866961206289*x_116 - 0.0593937208482084*x_117 + 0.0393959857506267*x_118 + 0.0525498533353828*x_119 + 0.0934151434156243*x_120 - 0.0572380961403634*x_13 - 0.0100560424092925*x_21 + 0.0100038495413226*x_22 + 0.0345370427959219*x_24 - 0.0733097791943589*x_30 - 0.0156161076428631*x_32 - 0.113470221012725*x_33 + 0.0783825629070943*x_34 + 0.0716973600319631*x_35 + 0.0202233257577243*x_37 + 0.105701693034376*x_39 - 0.0131214140667666*x_40 + 0.118144032794687*x_42 - 0.0886012794148267*x_43 + 0.107889840205223*x_45 + 0.0523774363806008*x_46 - 0.000892285379742092*x_47 - 0.0814058256046278*x_50 - 0.0279932849621475*x_51 + 0.114228069574713*x_52 + 0.0213210439716197*x_53 - 0.0096597752005812*x_54 - 0.191410442889547*x_55 - 0.0867263482648218*x_56 + 0.0820513623603245*x_57 - 0.0686702024806028*x_58 + 0.00759749563892922*x_59 - 0.0196921434238127*x_6 + 0.0304849066974978*x_61 - 0.0107564500429601*x_62 - 0.0562389133850367*x_63 + 0.0193144133695423*x_64 + 0.0123370335900093*x_65 + 0.0434369988644061*x_66 - 0.0159247853044174*x_67 - 0.00964759209442547*x_68 - 0.0308837539301715*x_69 - 0.0230527085379697*x_70 + 0.000788086254893187*x_71 - 0.00018922626277382*x_72 - 0.0416955652568971*x_73 + 0.0369752837714033*x_74 + 0.00016601165032361*x_75 - 0.0453413153034229*x_76 + 0.00234854072059595*x_77 - 0.000850443934514196*x_78 - 0.00268724957123148*x_79 + 0.00240992218653734*x_80 + 0.0140027309198776*x_81 + 0.0128837458249495*x_82 + 0.0345055900001471*x_83 + 0.000697379191236727*x_84 + 0.00475981166996208*x_85 + 0.0615640446649983*x_86 - 0.0416504431514648*x_87 + 0.0164984665635758*x_88 - 0.0210120103525443*x_89 - 0.0740670387209319*x_90 + 0.00614463175413024*x_91 + 0.111371425170293*x_93 - 0.000131144096561264*x_94 + 0.0525599567807733*x_96 - 0.0590166221056581*x_99 - 0.0825901023990309*std::exp(0.200159847736359*x_49) - 0.623825747391784*std::sin(0.252239972352982*x_107 - 7.43511962890625) - 0.446080627335846*std::sin(0.28383994102478*x_11 - 7.43631982803345) - 0.869957359106557*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 0.689320338986342*std::sin(0.299759924411774*x_113 - 1.20455992221832) + 0.475468302724465*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.602908639507888*std::sin(0.294079929590225*x_14 + 1.97463977336884) - 0.181025636489879*std::sin(0.317439913749695*x_15 - 1.2267199754715) + 0.448119833318334*std::sin(0.330239832401276*x_16 - 4.33816003799438) - 0.307958533921305*std::sin(0.36695984005928*x_17 - 7.37695980072021) + 0.320239676526676*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.557317899575722*std::sin(0.262319952249527*x_19 - 7.57184028625488) - 0.640351654137397*std::sin(0.387439846992493*x_2 + 5.19392013549805) - 0.50292996414429*std::sin(0.289999932050705*x_20 + 1.97943985462189) + 0.286844533015277*std::sin(0.343919843435287*x_23 + 2.00119972229004) - 0.388272339749228*std::sin(0.424319863319397*x_25 + 1.77583980560303) + 0.383841912710754*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.391505597403984*std::sin(0.342079848051071*x_27 - 1.15599977970123) - 0.554691068611525*std::sin(0.183280006051064*x_28 - 1.20519983768463) + 0.433373153596271*std::sin(0.223119989037514*x_29 + 8.21144008636475) - 0.284725793577412*std::sin(0.377199828624725*x_3 - 4.3931999206543) - 0.172767773258217*std::sin(0.457759857177734*x_31 + 8.22959995269775) - 0.75980721376154*std::sin(0.247599974274635*x_36 + 5.15607976913452) - 0.3399058822244*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.708951804470757*std::sin(0.334719836711884*x_4 - 7.37951993942261) + 0.872047752820926*std::sin(0.240399971604347*x_41 + 1.98135983943939) - 0.483498891154042*std::sin(0.223600000143051*x_44 - 1.18495988845825) - 0.187482337370998*std::sin(0.299679934978485*x_48 + 7.96231985092163) - 0.225580453165758*std::sin(0.366399854421616*x_5 + 8.22288036346436) - 0.166950728145315*std::sin(0.516559839248657*x_60 + 1.67543983459473) - 0.301457151144955*std::sin(0.442559868097305*x_7 - 1.41695988178253) - 0.128215119892324*std::sin(0.369919836521149*x_8 + 1.81647992134094) + 0.294645237945431*std::sin(0.463119864463806*x_9 + 4.93391990661621) + 0.498582792726904*std::sin(0.302559942007065*x_92 - 1.19743990898132) + 0.327247210213045*std::sin(0.265439957380295*x_95 + 1.96335983276367) + 0.513951328629869*std::sin(0.277199953794479*x_97 + 1.97303986549377) - 1.0271172484812*std::sin(0.257279962301254*x_98 - 7.43447971343994)) + 0.00374424056659811*std::sin(0.304559946060181*x_1 + 5.10119962692261) + 0.000265080741517688*std::sin(0.323359847068787*x_1 + 8.33455944061279) + 0.00294457687366435*std::sin(0.352879852056503*x_1 + 8.36448001861572) + 0.00416853190134256*std::sin(0.366799831390381*x_1 - 4.22656011581421) + 0.00612232894026469*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.0142708495414512*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.00140619176216562*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.00606793877659727*std::sin(0.527119874954224*x_10 - 4.52896022796631) - 0.000289004421473059*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.0151198499454688*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.00356869792123607*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.0125288030178273*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.0150716021768683*std::sin(0.224239990115166*x_102 - 1.20831990242004) + 0.00891200548983555*std::sin(0.227439999580383*x_102 - 7.42063999176025) + 0.000244436032744677*std::sin(0.238879978656769*x_102 - 1.21063983440399) + 0.000993203689904427*std::sin(0.254799962043762*x_102 + 7.98680019378662) - 0.00422992530805862*std::sin(0.237279981374741*x_104 - 1.20263981819153) - 0.00631029967307416*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.00241087625926362*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.00163780581395892*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.00413184211956944*std::sin(0.237919986248016*x_109 + 1.9521598815918) - 0.00495582526681587*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.019007780419502*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.00172883893404851*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.0138126869510838*std::sin(0.267999976873398*x_11 - 1.19399988651276) - 0.000197622282227328*std::sin(0.199520006775856*x_110 - 7.39160013198853) + 0.0162166404048243*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.0177365155152749*std::sin(0.220159992575645*x_110 + 1.96663987636566) + 0.00431379614764239*std::sin(0.242079973220825*x_110 + 8.17360019683838) + 0.00951752425632304*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.00394531822728114*std::sin(0.220319986343384*x_111 - 1.18911993503571) - 0.00120077335982404*std::sin(0.28519994020462*x_112 + 8.17903995513916) - 0.00919241241174162*std::sin(0.301439940929413*x_112 - 1.24199986457825) - 0.00839774916596853*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.00281034066283527*std::sin(0.250879973173141*x_116 + 5.16208028793335) - 0.001540766018538*std::sin(0.203199997544289*x_117 - 4.20279979705811) + 0.0150283017003518*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.00142113246582526*std::sin(0.251519978046417*x_118 - 1.22175991535187) + 0.00013885631482172*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.00353360795541314*std::sin(0.279679954051971*x_12 + 5.15056037902832) + 0.00426927676431253*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.00227649463095327*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.0125210405729286*std::sin(0.324719846248627*x_13 - 4.29655981063843) - 0.00265602023254385*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.0167888040965329*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.00410166695750873*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.00171979797275195*std::sin(0.369119822978973*x_14 + 4.83024024963379) + 0.0095647199188972*std::sin(0.25231996178627*x_15 + 1.56383979320526) - 0.0132323407632562*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.0011417799303737*std::sin(0.36959981918335*x_15 + 8.21647930145264) + 0.00178972527906644*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00136837392376873*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.0011656201101961*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.00787632871695949*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00030729363582851*std::sin(0.352959841489792*x_16 + 2.01791977882385) - 0.00452209906426707*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 0.00133123631405321*std::sin(0.291759938001633*x_17 - 1.14455986022949) - 0.0104730770519035*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.00187070306978298*std::sin(0.379279851913452*x_17 + 1.78831994533539) + 0.000586041731547035*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.0312560929514693*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.00258112924353889*std::sin(0.257679969072342*x_18 - 1.18119990825653) - 0.000186562355879869*std::sin(0.337039858102798*x_18 - 4.15015983581543) - 0.00670428359390864*std::sin(0.350399851799011*x_18 + 2.01143980026245) + 0.00114201871646957*std::sin(0.419119864702225*x_18 - 1.2196798324585) + 0.00339813847078438*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.000108035714156498*std::sin(0.436879843473434*x_2 + 2.02287983894348) + 0.00315338507630608*std::sin(0.255439966917038*x_20 - 7.40359973907471) + 0.00359270728102436*std::sin(0.258719980716705*x_20 - 4.39888000488281) + 0.00232993817416289*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.00214938934238373*std::sin(0.283439934253693*x_20 + 1.97463977336884) - 0.00204645149582236*std::sin(0.341759830713272*x_20 + 8.23559951782227) - 0.0161804284529517*std::sin(0.346559852361679*x_20 - 4.35752010345459) - 0.00565893322470083*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00151831342836914*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.00602525817670494*std::sin(0.356479853391647*x_21 + 8.22696018218994) - 0.00174908504658669*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.0168487047253344*std::sin(0.370719850063324*x_22 + 1.98679983615875) + 0.00493232550443491*std::sin(0.151280030608177*x_23 + 8.14335918426514) + 0.00435138820094526*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.000610037264905376*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 0.00101401667353875*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 0.00388911417179124*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 0.00748184708349026*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.0100721574365949*std::sin(0.42087984085083*x_24 + 1.98071980476379) - 0.000628374111617168*std::sin(0.432159870862961*x_26 - 4.42119979858398) - 0.0136332908010101*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.0043882210866379*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.00647120942925229*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.00765181856782725*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.00257128087549405*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.00196414126416213*std::sin(0.347279846668243*x_28 - 4.38199949264526) + 0.0182031243430792*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.000802458186356982*std::sin(0.398559868335724*x_29 - 4.39160013198853) - 0.0100008919420352*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.00203249651276359*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 0.0125403032766717*std::sin(0.289759933948517*x_3 - 1.13751995563507) - 0.00527542157860514*std::sin(0.295359939336777*x_3 - 4.13687992095947) - 0.00019892448857424*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.00159235957746722*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.000991599206819638*std::sin(0.399679869413376*x_3 + 8.18696022033691) + 0.00607047962985136*std::sin(0.421359837055206*x_3 + 8.18671989440918) - 0.0105408565301587*std::sin(0.103840067982674*x_30 - 7.68088006973267) + 0.00275479456038493*std::sin(0.322319835424423*x_31 - 1.04135990142822) + 0.00571198014943811*std::sin(0.376239836215973*x_31 + 5.19583988189697) + 0.020263699449002*std::sin(0.396399825811386*x_31 + 5.1989598274231) + 0.0032715246843069*std::sin(0.405279844999313*x_31 - 7.38151979446411) - 0.00107835004894631*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.00167849624345985*std::sin(0.320079833269119*x_32 + 1.98847985267639) + 4.67272006364012e-5*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.00458478510526655*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 0.00294364432853788*std::sin(0.262479960918427*x_33 - 1.20239984989166) + 0.00323545368104892*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.0225151129986115*std::sin(0.270159959793091*x_33 + 8.16936016082764) + 0.000167428580271466*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.00301588078451615*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.0247155583689198*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.00269853306109504*std::sin(0.198479995131493*x_36 - 1.18119990825653) - 0.00461555917870423*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.00277179992153065*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.0225036090626259*std::sin(0.265039950609207*x_36 + 8.17183971405029) - 0.00573970547657096*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.00312622439276561*std::sin(0.229519993066788*x_39 - 1.18871986865997) - 0.000883548294983435*std::sin(0.345279842615128*x_4 - 4.37623977661133) - 0.00174488762810847*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00118791518215977*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.00341322567622399*std::sin(0.276719957590103*x_41 - 1.2247998714447) - 0.0130496615686309*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.00260123709077459*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.00915806152266235*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.00425348353739399*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00365746083898898*std::sin(0.0756000876426697*x_49 + 8.10095977783203) - 0.010259612823205*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.00148118472853386*std::sin(0.303839921951294*x_5 - 4.58752012252808) - 9.45334538910648e-5*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.0129527819850827*std::sin(0.393919855356216*x_5 + 1.97943985462189) + 0.0120423196252721*std::sin(0.417199850082397*x_5 - 1.20159983634949) + 0.000584245346320516*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.0225277237540734*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.00412003245750047*std::sin(0.244319975376129*x_53 - 1.22295987606049) + 0.0119187884087754*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.0254360721080154*std::sin(0.20040000975132*x_55 + 8.20783996582031) - 0.00455698181236655*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.00282402198096367*std::sin(0.246639966964722*x_6 - 7.37775993347168) - 0.000150506024702055*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.000820695164531394*std::sin(0.291599929332733*x_60 - 4.26775979995728) - 0.0137644262323887*std::sin(0.334559857845306*x_60 + 1.88487982749939) + 0.000333827937919037*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.00891852335742619*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.00243149932568563*std::sin(0.28519994020462*x_7 + 5.22079992294312) - 0.00676304836896376*std::sin(0.338319838047028*x_7 - 1.38855981826782) + 0.000233717826473284*std::sin(0.338559836149216*x_7 + 2.02039980888367) + 0.00247946407376176*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.00331929373353392*std::sin(0.358479827642441*x_7 - 1.18127989768982) - 0.00223110174688178*std::sin(0.367679834365845*x_7 - 1.17919993400574) - 0.00308485730162319*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.00022975312035694*std::sin(1.39911985397339*x_78 - 6.79120016098022) + 0.00256244821577925*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.00268703397688463*std::sin(0.33383983373642*x_8 + 8.25695991516113) + 0.00178731382843303*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00943876320033701*std::sin(0.16176001727581*x_9 + 8.17623996734619) - 0.0041555726168774*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.00976703286310463*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.000874073936001144*std::sin(0.340319842100143*x_91 + 5.19456005096436) + 0.00227595464790217*std::sin(0.35183984041214*x_91 - 7.39383983612061) + 0.00204764302897408*std::sin(0.356319844722748*x_91 + 5.19551992416382) + 0.0156587785961938*std::sin(0.36303985118866*x_91 + 5.18800020217896) + 0.0156227251364161*std::sin(0.405119866132736*x_91 - 1.19711995124817) - 0.0249083123056393*std::sin(0.28519994020462*x_92 + 5.19591999053955) + 0.000357070154857825*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 0.00118862701284485*std::sin(0.294319927692413*x_92 + 7.99768018722534) + 0.00512026646100952*std::sin(0.300319939851761*x_92 + 2.00071978569031) + 0.00295135780618161*std::sin(0.314959913492203*x_92 + 8.21815967559814) - 0.000823843631479103*std::sin(0.273039966821671*x_94 - 7.60464000701904) - 0.00538559749790802*std::sin(0.288959950208664*x_94 - 1.20831990242004) + 0.00415850186577959*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.0139314834298763*std::sin(0.283279925584793*x_95 + 4.98383951187134) - 0.000370044921537503*std::sin(0.286399960517883*x_95 - 1.2111998796463) + 0.00119482756801065*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00302810083857293*std::sin(0.273919969797134*x_97 + 1.96983981132507) - 0.00238812096331555*std::sin(0.275439947843552*x_97 + 1.9748797416687) + 0.0185508643799733*std::sin(0.287119954824448*x_97 - 4.41831970214844) + 0.00390340526467346*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.000125759019800343*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.0171240233122128*std::sin(0.265839964151382*x_98 + 1.95631980895996) - 0.012195928756085*std::sin(0.251759976148605*x_99 + 1.95271980762482) - 0.169083072479755);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000506715401505754*x_1 + 0.0028236516016561*x_10 - 0.000246536039265912*x_100 + 0.0030646418528244*x_101 + 0.00173680967054299*x_102 - 0.00309167570710635*x_103 - 0.000716307902621579*x_104 + 0.000720443263608208*x_105 + 0.000448720103209634*x_106 - 0.000743774146573377*x_107 + 0.000446826060670035*x_108 - 0.000719875906828709*x_109 + 0.000764736587086011*x_11 + 0.000463095483934825*x_110 - 0.00256271673821421*x_111 + 0.000257414209364782*x_112 - 8.78253026442699e-5*x_113 - 0.000995825001815616*x_114 - 0.00305154563458533*x_115 + 0.00189423532562364*x_116 + 0.00216932121501459*x_117 - 0.00136002248306098*x_118 + 0.000828301506100248*x_119 + 0.00112951015372358*x_12 - 0.00184611417353179*x_120 + 0.00210222281243272*x_13 - 0.00112448678674013*x_14 - 0.000522618239248916*x_15 + 3.45715128583369e-7*x_16 + 2.57465371106373e-5*x_17 - 0.000292368510323138*x_18 - 0.00341711874991884*x_19 + 5.93224116507254e-5*x_2 - 0.000198210114695276*x_20 - 0.000333767580593905*x_21 - 0.000632328244650007*x_22 - 0.000590220523534673*x_23 - 0.000946172346781203*x_24 - 0.00180718500867086*x_25 - 0.00215839563632274*x_26 - 0.000716677877387913*x_27 - 5.19974712024879e-5*x_28 + 0.000209359273418*x_29 - 1.87652771496574e-6*x_3 - 0.00176428833551508*x_30 + 0.000458954922708461*x_31 + 0.000567845978973663*x_32 + 0.00208619519467142*x_33 - 0.000488781921403828*x_34 - 0.00327989402551403*x_35 + 0.000506294450807766*x_36 - 0.000134289757129901*x_37 - 0.00127487820539149*x_38 - 0.005257846828215*x_39 + 0.00172305249939997*x_4 - 0.000571138018694037*x_40 - 0.000615232906381282*x_41 + 0.000227959358004995*x_42 + 0.00230293269415505*x_43 - 0.00114939010840464*x_44 - 0.00492531593108558*x_45 - 0.00236720332360658*x_46 + 0.00110166045620872*x_47 - 0.00390010047271998*x_48 - 6.13838880525419e-5*x_49 + 0.00200057505103093*x_5 + 0.00468324417231791*x_50 - 2.12623567617072e-5*x_51 - 0.00337444999632586*x_52 - 6.24784534890195e-5*x_53 + 0.00221130350453857*x_54 + 0.00647862735506387*x_55 + 0.000725380170183666*x_56 - 0.00227339288374983*x_57 + 0.000116376155014297*x_58 - 0.00150446243958684*x_59 + 0.00143323151273912*x_6 - 0.000666531486667583*x_60 - 0.000689081789989124*x_61 + 0.0004130765071973*x_62 + 0.00105980041874283*x_63 - 0.000344423674581846*x_64 - 0.00101517324015717*x_65 - 0.000848801083607245*x_66 - 7.66262208542346e-5*x_67 - 0.000138272786829797*x_68 + 0.00066135643074576*x_69 + 0.000233895803916228*x_7 + 0.00043809402420182*x_70 - 0.000183469998233185*x_71 + 0.000680404971427259*x_72 + 0.000698585411071219*x_73 - 0.000684984108499966*x_74 + 7.99999916148698e-5*x_75 + 0.000976370184035791*x_76 + 5.86671445418888e-5*x_77 + 0.000290890039297921*x_78 - 0.000790439072699757*x_79 + 0.000295784288510829*x_8 - 0.000129024954136979*x_80 - 9.95491144631167e-5*x_81 - 0.00117185984485224*x_82 - 0.000711145884563696*x_83 - 0.000632426250396732*x_84 - 0.000443293832505781*x_85 + 0.000299485640216371*x_86 - 0.000576145914522649*x_87 + 0.00134224144820874*x_88 + 0.000366590114569187*x_89 - 0.000589903613026156*x_9 + 0.0021333206152319*x_90 - 0.00015536757393854*x_91 + 0.000689265104979445*x_92 - 0.00191364678384474*x_93 + 0.000208806324399536*x_94 - 7.41199203036842e-5*x_95 - 0.000121324842145615*x_96 + 4.42424618131162e-5*x_97 + 6.87836810562012e-5*x_98 + 0.00305962678171404*x_99 - 7.51166795382433e-6*std::pow(-6.9029598236084*x_22 - 9.12671947479248, 2) - 0.00033958696041612*std::exp(0.237919852137566*x_28) + 0.00157691879216761*std::exp(0.200159847736359*x_49) + 0.00416621386918387*std::sin(0.304559946060181*x_1 + 5.10119962692261) - 0.00304806109033249*std::sin(0.323359847068787*x_1 + 8.33455944061279) + 0.000987945071425293*std::sin(0.352879852056503*x_1 + 8.36448001861572) - 0.000720879743275*std::sin(0.366799831390381*x_1 - 4.22656011581421) - 0.00391267533147688*std::sin(0.121440060436726*x_10 - 4.46895980834961) - 0.00141345478139113*std::sin(0.341759830713272*x_10 - 7.55480003356934) - 0.00156466859382097*std::sin(0.370639860630035*x_10 + 8.21944046020508) - 0.00184719056679774*std::sin(0.527119874954224*x_10 - 4.52896022796631) + 0.00332315024842083*std::sin(0.239199981093407*x_100 - 1.19463992118835) - 0.00149754393648846*std::sin(0.252879977226257*x_100 + 1.95943987369537) - 0.00397088769002092*std::sin(0.262639969587326*x_100 - 1.2196798324585) + 0.00124091396796092*std::sin(0.240559980273247*x_101 + 1.96103990077972) + 0.00149276524135739*std::sin(0.224239990115166*x_102 - 1.20831990242004) + 0.00271297603323964*std::sin(0.227439999580383*x_102 - 7.42063999176025) - 0.00281067555575166*std::sin(0.238879978656769*x_102 - 1.21063983440399) + 0.000333233171508751*std::sin(0.254799962043762*x_102 + 7.98680019378662) + 0.000731496733697455*std::sin(0.237279981374741*x_104 - 1.20263981819153) - 0.00192096961734772*std::sin(0.229439988732338*x_106 - 1.21535992622375) + 0.00268258033360182*std::sin(0.238159984350204*x_106 + 8.17735958099365) + 0.0119109011313159*std::sin(0.252239972352982*x_107 - 7.43511962890625) - 0.00104669358156855*std::sin(0.215519994497299*x_109 + 4.98439979553223) + 0.00459749784706501*std::sin(0.237919986248016*x_109 + 1.9521598815918) + 0.000857029316462077*std::sin(0.249039977788925*x_109 + 1.95839989185333) - 0.00188262359851393*std::sin(0.25095996260643*x_109 - 1.24199986457825) - 0.0101637937946202*std::sin(0.253679990768433*x_109 + 8.17984008789063) + 0.00136807611615271*std::sin(0.267999976873398*x_11 - 1.19399988651276) + 0.00851715766944088*std::sin(0.28383994102478*x_11 - 7.43631982803345) + 0.00227238231487907*std::sin(0.199520006775856*x_110 - 7.39160013198853) + 0.00493663932412655*std::sin(0.213839992880821*x_110 - 7.42335987091064) - 0.00175671130071588*std::sin(0.220159992575645*x_110 + 1.96663987636566) - 0.000746000830280698*std::sin(0.242079973220825*x_110 + 8.17360019683838) - 0.00729619403359069*std::sin(0.213199988007545*x_111 + 1.97535979747772) - 0.00438995284209976*std::sin(0.220319986343384*x_111 - 1.18911993503571) + 0.0166103693797544*std::sin(0.268079966306686*x_112 - 1.21143984794617) - 0.00133609968068657*std::sin(0.28519994020462*x_112 + 8.17903995513916) - 0.00279833698365123*std::sin(0.301439940929413*x_112 - 1.24199986457825) + 0.013161409960713*std::sin(0.299759924411774*x_113 - 1.20455992221832) - 0.000831754176728188*std::sin(0.162400022149086*x_115 + 8.4596004486084) - 0.003127064097079*std::sin(0.250879973173141*x_116 + 5.16208028793335) + 0.000984677114073989*std::sin(0.203199997544289*x_117 - 4.20279979705811) - 0.011520790727511*std::sin(0.239599987864494*x_118 + 1.96927976608276) - 0.00158129310437124*std::sin(0.251519978046417*x_118 - 1.22175991535187) - 0.00159665514715184*std::sin(0.292079925537109*x_119 - 1.4268798828125) - 0.00393184310950307*std::sin(0.279679954051971*x_12 + 5.15056037902832) - 0.00907826579538237*std::sin(0.284559935331345*x_12 + 5.14287996292114) + 0.0047504212804958*std::sin(0.254559963941574*x_13 + 1.98231983184814) - 0.0133834457032883*std::sin(0.287439942359924*x_13 + 1.95335984230042) - 0.00124014513742806*std::sin(0.324719846248627*x_13 - 4.29655981063843) + 0.00169741693809227*std::sin(0.225679993629456*x_14 - 4.19647979736328) + 0.00166284532361977*std::sin(0.261919975280762*x_14 + 1.97167980670929) - 0.0115115242139638*std::sin(0.294079929590225*x_14 + 1.97463977336884) + 0.000709316539565439*std::sin(0.310879945755005*x_14 + 8.31400012969971) + 0.00191361800579588*std::sin(0.369119822978973*x_14 + 4.83024024963379) - 0.00733237452574506*std::sin(0.25231996178627*x_15 + 1.56383979320526) - 0.00402816441207516*std::sin(0.26463994383812*x_15 - 1.01159977912903) + 0.00345637939357179*std::sin(0.317439913749695*x_15 - 1.2267199754715) - 0.000729691954015695*std::sin(0.36959981918335*x_15 + 8.21647930145264) - 0.00114378270391024*std::sin(0.259519964456558*x_16 + 8.21255970001221) + 0.00804463048651501*std::sin(0.291199922561646*x_16 - 4.3842396736145) - 0.001296984684323*std::sin(0.308079928159714*x_16 - 1.1775997877121) - 0.000780110143580321*std::sin(0.308479934930801*x_16 - 1.17567980289459) - 0.00855609287040902*std::sin(0.330239832401276*x_16 - 4.33816003799438) + 0.00353345086222789*std::sin(0.352959841489792*x_16 + 2.01791977882385) - 0.00137660893446312*std::sin(0.482319831848145*x_16 + 7.94760036468506) - 0.00148126571894092*std::sin(0.291759938001633*x_17 - 1.14455986022949) - 0.00103730480739028*std::sin(0.358159840106964*x_17 + 1.98871982097626) + 0.00587994911306214*std::sin(0.36695984005928*x_17 - 7.37695980072021) - 0.000323507647441677*std::sin(0.379279851913452*x_17 + 1.78831994533539) - 0.000374529210797508*std::sin(0.166160017251968*x_18 + 7.98320007324219) - 0.00309575641600993*std::sin(0.170800015330315*x_18 - 7.62080001831055) + 0.015174383727673*std::sin(0.257679969072342*x_18 - 1.18119990825653) + 0.0021452084924104*std::sin(0.337039858102798*x_18 - 4.15015983581543) + 0.00513954602478461*std::sin(0.350399851799011*x_18 + 2.01143980026245) - 0.00611443683012697*std::sin(0.396079838275909*x_18 - 1.19023990631104) + 0.00127072342997073*std::sin(0.419119864702225*x_18 - 1.2196798324585) - 0.00217169196515041*std::sin(0.254959970712662*x_19 + 1.82567989826202) - 0.0106410458823048*std::sin(0.262319952249527*x_19 - 7.57184028625488) + 0.012226435464702*std::sin(0.387439846992493*x_2 + 5.19392013549805) + 0.0012422609609485*std::sin(0.436879843473434*x_2 + 2.02287983894348) - 0.000545326622910719*std::sin(0.255439966917038*x_20 - 7.40359973907471) - 0.00229603755185909*std::sin(0.258719980716705*x_20 - 4.39888000488281) + 0.000781725536350272*std::sin(0.277519941329956*x_20 + 2.00039982795715) - 0.0126361974097753*std::sin(0.283439934253693*x_20 + 1.97463977336884) + 0.00960259993106172*std::sin(0.289999932050705*x_20 + 1.97943985462189) - 0.00227708515327945*std::sin(0.341759830713272*x_20 + 8.23559951782227) - 0.00160258882243502*std::sin(0.346559852361679*x_20 - 4.35752010345459) + 0.00433817384842701*std::sin(0.43343985080719*x_20 + 4.7992000579834) + 0.00892612047173725*std::sin(0.316399931907654*x_21 + 1.97503972053528) + 0.000596771057969795*std::sin(0.356479853391647*x_21 + 8.22696018218994) - 0.000586841514220209*std::sin(0.356319844722748*x_22 - 7.38351964950562) + 0.00166877817505526*std::sin(0.370719850063324*x_22 + 1.98679983615875) + 0.00165486142214645*std::sin(0.151280030608177*x_23 + 8.14335918426514) - 0.000752501764032801*std::sin(0.3435198366642*x_23 - 1.15847992897034) - 0.00547681285533363*std::sin(0.343919843435287*x_23 + 2.00119972229004) + 0.00701458295372565*std::sin(0.112400062382221*x_24 + 2.09047985076904) + 0.0011282956460031*std::sin(0.277679949998856*x_24 - 7.55751991271973) + 0.00130485001515684*std::sin(0.336079835891724*x_24 + 2.01231980323792) - 0.00227760988758632*std::sin(0.377839833498001*x_24 - 4.59847974777222) + 0.000997595766553894*std::sin(0.42087984085083*x_24 + 1.98071980476379) + 0.00741340585910971*std::sin(0.424319863319397*x_25 + 1.77583980560303) - 0.00732881432269844*std::sin(0.330559849739075*x_26 + 5.04143953323364) - 0.0036941931203496*std::sin(0.432159870862961*x_26 - 4.42119979858398) + 0.00235765574193165*std::sin(0.131920039653778*x_27 - 7.64504051208496) + 0.00488277054505784*std::sin(0.186720013618469*x_27 - 4.40975952148438) + 0.00747513946407694*std::sin(0.342079848051071*x_27 - 1.15599977970123) + 0.0105908909728064*std::sin(0.183280006051064*x_28 - 1.20519983768463) + 0.00196995346419606*std::sin(0.221039995551109*x_28 + 8.60432052612305) + 0.000757873559637643*std::sin(0.29911994934082*x_28 + 1.9845597743988) + 0.0151164854584648*std::sin(0.325759828090668*x_28 - 1.14023983478546) - 0.0021854986158711*std::sin(0.347279846668243*x_28 - 4.38199949264526) - 0.00827452987798839*std::sin(0.223119989037514*x_29 + 8.21144008636475) + 0.00554136104709314*std::sin(0.265919953584671*x_29 - 7.56527996063232) + 0.00471762833096193*std::sin(0.398559868335724*x_29 - 4.39160013198853) - 0.00304445280927017*std::sin(0.138640031218529*x_3 - 7.64983987808228) - 0.00226155745335485*std::sin(0.287599951028824*x_3 + 5.06271982192993) + 0.00124205300988017*std::sin(0.289759933948517*x_3 - 1.13751995563507) + 0.00091229829668029*std::sin(0.295359939336777*x_3 - 4.13687992095947) + 0.00228735588283758*std::sin(0.371919840574265*x_3 - 1.20223987102509) + 0.00543635909709595*std::sin(0.377199828624725*x_3 - 4.3931999206543) - 0.00101764967194454*std::sin(0.393519848585129*x_3 + 1.98551976680756) + 0.00582958288741371*std::sin(0.399679869413376*x_3 + 8.18696022033691) - 0.00465366791441902*std::sin(0.421359837055206*x_3 + 8.18671989440918) + 0.00673648046692599*std::sin(0.103840067982674*x_30 - 7.68088006973267) - 0.000476396880836167*std::sin(0.322319835424423*x_31 - 1.04135990142822) + 0.00173883030766088*std::sin(0.376239836215973*x_31 + 5.19583988189697) - 0.0155342796126902*std::sin(0.396399825811386*x_31 + 5.1989598274231) + 0.00109764045109987*std::sin(0.405279844999313*x_31 - 7.38151979446411) + 0.00329870941454399*std::sin(0.457759857177734*x_31 + 8.22959995269775) + 0.000186483089212928*std::sin(0.295679926872253*x_32 - 7.37351989746094) + 0.00986783058131419*std::sin(0.320079833269119*x_32 + 1.98847985267639) - 0.000537298037211317*std::sin(0.375919848680496*x_32 - 7.99271965026855) + 0.00510148719160527*std::sin(0.245119974017143*x_33 + 1.98655986785889) - 0.000987632190016145*std::sin(0.262479960918427*x_33 - 1.20239984989166) - 0.000559519052312281*std::sin(0.266639977693558*x_33 - 1.23087990283966) + 0.00223000698234626*std::sin(0.270159959793091*x_33 + 8.16936016082764) - 0.00192519659486848*std::sin(0.226719990372658*x_34 - 7.41680002212524) + 0.0177302753884645*std::sin(0.243759974837303*x_34 + 1.95839989185333) + 0.00244794986099676*std::sin(0.244799971580505*x_34 + 1.96495985984802) - 0.0158645973553518*std::sin(0.198479995131493*x_36 - 1.18119990825653) + 0.00294972464166667*std::sin(0.232639983296394*x_36 - 1.21487987041473) - 0.00308417984108745*std::sin(0.241119980812073*x_36 + 1.96823978424072) + 0.0145072380224964*std::sin(0.247599974274635*x_36 + 5.15607976913452) + 0.00222886757622496*std::sin(0.265039950609207*x_36 + 8.17183971405029) + 0.00366814724384133*std::sin(0.224559992551804*x_37 - 1.2190397977829) + 0.00648992987874365*std::sin(0.249839976429939*x_38 - 4.424880027771) - 0.000540629624772954*std::sin(0.229519993066788*x_39 - 1.18871986865997) + 0.0135362397035143*std::sin(0.334719836711884*x_4 - 7.37951993942261) - 0.00098312357210483*std::sin(0.345279842615128*x_4 - 4.37623977661133) + 0.000301749914637679*std::sin(0.410959869623184*x_4 - 1.20031988620758) - 0.00698371879484282*std::sin(0.236879989504814*x_41 + 1.98095989227295) - 0.0166502819241812*std::sin(0.240399971604347*x_41 + 1.98135983943939) + 0.00218133393916396*std::sin(0.276719957590103*x_41 - 1.2247998714447) - 0.00397255355351417*std::sin(0.23335999250412*x_42 - 1.1956799030304) + 0.00923159634515672*std::sin(0.223600000143051*x_44 - 1.18495988845825) + 0.0152925971765562*std::sin(0.254719972610474*x_44 + 8.17759990692139) - 0.000907059233571382*std::sin(0.293119937181473*x_44 + 8.14287948608398) + 0.00473284816790945*std::sin(0.262559950351715*x_48 + 8.17479991912842) + 0.00357965921353918*std::sin(0.299679934978485*x_48 + 7.96231985092163) + 0.0215021058626503*std::sin(0.0756000876426697*x_49 + 8.10095977783203) + 0.0078650838024277*std::sin(0.348799854516983*x_49 - 1.33007991313934) - 0.00164811321523814*std::sin(0.303839921951294*x_5 - 4.58752012252808) + 0.00430707851679506*std::sin(0.366399854421616*x_5 + 8.22288036346436) + 0.00108700368382238*std::sin(0.389279842376709*x_5 - 1.38399982452393) - 0.00128290691986864*std::sin(0.393919855356216*x_5 + 1.97943985462189) + 0.00366590040426213*std::sin(0.417199850082397*x_5 - 1.20159983634949) - 0.00671801164102511*std::sin(0.193999990820885*x_50 + 2.01047992706299) + 0.00223125601328536*std::sin(0.218479990959167*x_52 + 5.18767976760864) - 0.00458435724431073*std::sin(0.244319975376129*x_53 - 1.22295987606049) + 0.00362829526251322*std::sin(0.24975997209549*x_53 - 1.19007992744446) + 0.00251931306797506*std::sin(0.20040000975132*x_55 + 8.20783996582031) + 0.00291228885236352*std::sin(0.226319998502731*x_57 - 1.19551992416382) + 0.0166023430642985*std::sin(0.246639966964722*x_6 - 7.37775993347168) - 5.04967917985348e-5*std::sin(0.933999836444855*x_6 - 8.37304019927979) + 0.00482484299506465*std::sin(0.291599929332733*x_60 - 4.26775979995728) - 0.0041901408748408*std::sin(0.334559857845306*x_60 + 1.88487982749939) - 0.00383855855620145*std::sin(0.418079853057861*x_60 - 4.41295957565308) + 0.000883334201365325*std::sin(0.472959846258163*x_60 - 4.67736005783081) + 0.00318764274327262*std::sin(0.516559839248657*x_60 + 1.67543983459473) + 0.0142947137939302*std::sin(0.28519994020462*x_7 + 5.22079992294312) - 0.00205879452807403*std::sin(0.338319838047028*x_7 - 1.38855981826782) - 0.00268743104048833*std::sin(0.338559836149216*x_7 + 2.02039980888367) + 0.000831893483018722*std::sin(0.347919851541519*x_7 - 7.36895990371704) - 0.00369337582416842*std::sin(0.358479827642441*x_7 - 1.18127989768982) + 0.00142585882794169*std::sin(0.367679834365845*x_7 - 1.17919993400574) + 0.000533475859670862*std::sin(0.383679836988449*x_7 - 1.19735991954803) + 0.00575581616762072*std::sin(0.442559868097305*x_7 - 1.41695988178253) + 2.27558734723389e-5*std::sin(1.39911985397339*x_78 - 6.79120016098022) - 0.00044313371125971*std::sin(0.332879841327667*x_8 - 4.35008001327515) + 0.00298986083355115*std::sin(0.33383983373642*x_8 + 8.25695991516113) - 0.00114224158720473*std::sin(0.357119828462601*x_8 + 8.24271965026855) + 0.00244805159607845*std::sin(0.369919836521149*x_8 + 1.81647992134094) - 0.0072358153120568*std::sin(0.16176001727581*x_9 + 8.17623996734619) + 0.000718638645958396*std::sin(0.339039832353592*x_9 - 4.36039972305298) - 0.0056257541671761*std::sin(0.463119864463806*x_9 + 4.93391990661621) - 0.00096737473548864*std::sin(0.31007993221283*x_91 - 4.15040016174316) - 0.00513865523953916*std::sin(0.340319842100143*x_91 + 5.19456005096436) - 0.000393589311804677*std::sin(0.35183984041214*x_91 - 7.39383983612061) - 0.00130861351052972*std::sin(0.356319844722748*x_91 + 5.19551992416382) + 0.00476681607632892*std::sin(0.36303985118866*x_91 + 5.18800020217896) - 0.0119764794771096*std::sin(0.405119866132736*x_91 - 1.19711995124817) + 0.019094869079055*std::sin(0.28519994020462*x_92 + 5.19591999053955) - 0.00410581183419735*std::sin(0.289599925279617*x_92 + 1.99127984046936) - 0.00132258444886732*std::sin(0.294319927692413*x_92 + 7.99768018722534) - 0.00327227440211898*std::sin(0.300319939851761*x_92 + 2.00071978569031) - 0.0095195980204002*std::sin(0.302559942007065*x_92 - 1.19743990898132) - 0.000510389294837263*std::sin(0.314959913492203*x_92 + 8.21815967559814) - 0.000276410598284714*std::sin(0.273039966821671*x_94 - 7.60464000701904) - 0.00163947351167638*std::sin(0.288959950208664*x_94 - 1.20831990242004) - 0.00624823387403176*std::sin(0.265439957380295*x_95 + 1.96335983276367) - 0.00265762715869901*std::sin(0.281839966773987*x_95 + 1.94663977622986) - 0.00137984230081284*std::sin(0.283279925584793*x_95 + 4.98383951187134) + 0.00425500366626347*std::sin(0.286399960517883*x_95 - 1.2111998796463) + 0.000400880689370568*std::sin(0.288799941539764*x_95 + 8.17711925506592) - 0.00336936569287055*std::sin(0.273919969797134*x_97 + 1.96983981132507) + 0.00152620711381502*std::sin(0.275439947843552*x_97 + 1.9748797416687) - 0.00981303430839993*std::sin(0.277199953794479*x_97 + 1.97303986549377) + 0.00183736839777131*std::sin(0.287119954824448*x_97 - 4.41831970214844) - 0.000675030406793772*std::sin(0.294079929590225*x_97 - 4.4256796836853) + 0.0196110725600517*std::sin(0.257279962301254*x_98 - 7.43447971343994) - 0.00144605440899675*std::sin(0.264959961175919*x_98 + 1.95287978649139) + 0.00169604707533333*std::sin(0.265839964151382*x_98 + 1.95631980895996) - 0.00371266180839923*std::sin(0.251759976148605*x_99 + 1.95271980762482) + 0.221780108639129);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
