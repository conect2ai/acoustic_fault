
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000647520479497208*x_1 + 0.013330931407958*x_10 + 0.00137135923897481*x_100 + 0.0535376666442637*x_101 + 0.00922276756176743*x_103 + 0.0165059120569863*x_104 - 0.0207247382854067*x_105 + 0.0163157375557289*x_106 - 0.035546228916496*x_107 - 0.0135621116380399*x_108 - 0.00607194734111997*x_11 - 0.00275955904498882*x_110 - 0.00635563143640208*x_111 - 0.00355837571261191*x_112 - 0.00630006152382209*x_113 - 0.0187780884299388*x_114 + 0.00840948271449744*x_116 - 0.00656195534095989*x_117 - 0.0445679242092909*x_118 + 0.0215031315545341*x_119 - 0.0958601638798817*x_12 + 0.0234879026148701*x_120 - 0.00429176580155068*x_13 - 0.0229366599979089*x_14 - 0.0151486282919067*x_15 - 0.00401045169113753*x_16 + 0.0148816659058497*x_17 + 0.0289727954651748*x_18 + 0.00813433553310017*x_19 - 0.0246039323045397*x_2 - 0.00942596476803264*x_20 - 0.0601139024950088*x_21 + 0.0223359088099896*x_22 + 0.0116151686940134*x_23 + 0.00217080402155265*x_24 - 0.0393818867804563*x_25 - 0.00695026243446401*x_26 + 0.0182814573922853*x_27 + 0.00022825392964083*x_28 - 0.00506167113718891*x_29 - 0.0286172845957199*x_3 + 0.0244492337537292*x_30 - 0.0719412752254947*x_32 + 0.0145537474927614*x_33 + 0.00771693408194481*x_34 + 0.00163549486625526*x_35 - 0.00369894440281494*x_36 - 0.030985990284247*x_37 - 0.00214067516612366*x_38 + 0.0152330726382755*x_39 - 0.0110773789319509*x_4 - 0.00976947918503501*x_40 - 0.00815632399165652*x_41 + 0.00305337675312275*x_42 - 0.00227829481272983*x_43 - 0.046850916980532*x_44 - 0.0249333555585189*x_45 - 0.00536499269240194*x_46 - 0.0118788769010907*x_47 + 0.0293036592343775*x_48 - 0.0170439761585588*x_49 + 0.0200549090781982*x_5 - 0.0132769396294167*x_50 - 0.0227847486643732*x_51 + 0.00209813202410899*x_52 + 0.00206398578033793*x_53 + 0.00763291321939638*x_54 - 0.0228279193540661*x_55 - 0.028764457053266*x_56 - 0.0238590959700085*x_57 - 0.000621763356277078*x_58 + 0.00305545382378428*x_59 - 0.00044819569409801*x_6 - 0.00906107774386255*x_60 - 0.0162133429361802*x_61 + 0.000982639406692446*x_62 + 0.0222514017189305*x_63 - 0.00383677888583892*x_64 - 0.000902118736756117*x_65 - 3.91150831746256e-5*x_66 + 0.000159405286555917*x_67 + 0.000334488273772198*x_68 + 0.0148363937249151*x_69 - 0.0172926029281946*x_7 - 0.000840612338046135*x_70 + 0.015891641679589*x_71 - 0.0103256504480775*x_72 - 0.00856318833056331*x_73 - 0.00598962499426537*x_74 - 0.00491513535465824*x_75 - 0.027400030260657*x_76 + 0.00479221781831695*x_77 + 0.00743584349371415*x_78 + 0.0261403710727418*x_79 + 0.0271452298794134*x_8 + 0.020843396231145*x_80 - 0.00319920710806424*x_81 + 0.0104846787129145*x_82 - 0.00800357962105012*x_83 + 0.0354378270403124*x_84 - 0.0299100612467829*x_85 - 0.0158001793922738*x_86 + 0.0107910857287486*x_88 + 0.0186559971838338*x_89 + 0.0685470541170465*x_9 + 0.0181830530546379*x_90 + 0.0273697365010065*x_91 - 0.00560334136498915*x_92 - 0.00765803266926921*x_93 - 0.0323397403986446*x_94 - 0.000505781203591638*x_95 + 0.00608156971369966*x_96 - 0.0209946004710699*x_97 + 0.0145289858647263*x_98 - 0.00128818485386653*x_99 - 4.40651577106134e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) - 1.90208840539822e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) - 2.25388450106147e-5*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) - 2.25744006886546e-5*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) - 5.51368909518238e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) + 2.66753858182066e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) + 6.39827418840212e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) + 2.26990818524647e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) - 3.96535517491348e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) - 3.42122166379144e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.000720144865462548*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) - 1.10526486539856e-5*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) - 1.37624780186896e-5*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.00061217709297641*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) + 6.33602390091915e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) + 0.000102500856529121*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) + 2.9196190333713e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) - 3.9573186613883e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) + 4.10583049000708e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) - 5.43743508412633e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) + 6.31972797443158e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) + 2.91875234618753e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) - 0.000461409250392036*std::exp(0.556959867477417*x_1) - 0.000221039257263275*std::exp(1.15583980083466*x_1) - 5.6237582342424e-5*std::exp(1.25871992111206*x_1) + 0.000313824238876249*std::exp(1.35671985149384*x_100) + 0.000789735573203303*std::exp(1.49143993854523*x_100) - 0.00610075518654262*std::exp(1.58023989200592*x_100) - 0.00199781031746191*std::exp(0.715599834918976*x_104) - 0.0125940965824122*std::exp(0.580799877643585*x_109) + 0.000834874437721141*std::exp(0.60999983549118*x_109) + 0.00255584536583566*std::exp(0.793439865112305*x_109) + 0.0243842388855844*std::exp(0.801999866962433*x_109) - 0.00500123418776783*std::exp(0.865199863910675*x_109) + 0.00222987875226584*std::exp(1.1865599155426*x_110) - 0.000105330614440604*std::exp(1.69735991954803*x_110) - 0.00580085513898707*std::exp(0.49823984503746*x_112) - 0.00263510989027672*std::exp(0.789599895477295*x_112) + 0.00105317234253802*std::exp(0.855839908123016*x_112) + 0.00565688591540039*std::exp(0.682959854602814*x_114) + 0.00122533199496588*std::exp(0.611999869346619*x_23) + 0.0421524378890674*std::exp(0.579439878463745*x_26) - 0.00581631958101942*std::exp(0.771439850330353*x_26) - 0.000186655896272387*std::exp(0.956879794597626*x_26) - 0.00271074035050312*std::exp(0.595679819583893*x_31) - 0.0116044888636644*std::exp(0.637759864330292*x_31) + 0.00102258101931477*std::exp(0.657039821147919*x_31) - 0.00285229211601644*std::exp(0.663919866085052*x_31) - 0.00553873089366678*std::exp(0.667439818382263*x_31) - 0.00141847773887167*std::exp(0.782479882240295*x_49) - 0.00101463610506986*std::exp(0.841519832611084*x_50) + 0.00428666462567209*std::exp(0.942319810390472*x_66) - 0.00414260291965179*std::exp(1.11359989643097*x_66) - 0.00321184707137492*std::exp(1.22135984897614*x_66) + 0.00498982121201774*std::exp(1.04599988460541*x_68) + 0.000459338078115899*std::exp(1.10527992248535*x_68) + 0.000844552421321133*std::exp(0.880079865455627*x_72) - 0.00166897592488046*std::exp(0.601599872112274*x_74) + 0.00272275268370783*std::exp(1.07575976848602*x_74) + 0.00335125661357824*std::exp(1.08567976951599*x_74) - 0.000605870996532296*std::exp(0.743279814720154*x_77) + 0.00192494789477288*std::exp(0.79695987701416*x_80) + 0.00089625581665588*std::exp(0.936159789562225*x_81) + 0.043010068937907*std::sin(0.498079836368561*x_10 - 0.920319855213165) + 0.0216201839658169*std::sin(0.265119940042496*x_100 - 7.51448011398315) - 0.138052248177083*std::sin(0.124000057578087*x_102 + 1.72023987770081) + 0.0196503386987931*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.182234083551454*std::sin(0.360079854726791*x_102 - 4.23984003067017) + 0.00572573931334953*std::sin(0.375039845705032*x_102 + 1.98391973972321) - 0.00715718223058228*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 1.31464499140604*std::sin(0.135920032858849*x_103 - 1.44095981121063) - 0.0327028117448292*std::sin(0.323599934577942*x_105 + 1.91183984279633) + 0.0307924987175152*std::sin(0.437919855117798*x_105 - 4.17088031768799) + 0.124209643251826*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.0952075352227549*std::sin(0.596959829330444*x_110 - 7.18480014801025) + 0.0306109503046013*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.284282799526481*std::sin(0.32847985625267*x_111 - 7.46783971786499) + 0.00565219092733996*std::sin(0.399279862642288*x_111 + 2.00383973121643) + 0.0201483149560868*std::sin(0.441359847784042*x_111 + 8.42160034179688) - 0.00373606302666533*std::sin(0.445599853992462*x_112 + 5.21031999588013) + 0.107095563829416*std::sin(0.193120002746582*x_114 + 4.97639989852905) + 0.010226963330594*std::sin(0.422959864139557*x_115 + 8.4026403427124) - 0.0154570850518681*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.164067216635548*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.0956613299733042*std::sin(0.417359858751297*x_117 + 5.20456027984619) + 0.0505648720401681*std::sin(0.314319849014282*x_120 + 5.11375999450684) + 0.00258412964375593*std::sin(0.584559857845306*x_120 - 4.00031995773315) - 0.029011861714003*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.160655541507093*std::sin(0.301679849624634*x_24 + 5.10272026062012) - 0.0310725092356726*std::sin(0.385919839143753*x_24 + 5.174720287323) + 0.0189317747539037*std::sin(0.278719931840897*x_28 - 4.29207992553711) + 0.0428549374992969*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.211166803529393*std::sin(0.343599855899811*x_28 - 4.2596001625061) - 0.0274080330888519*std::sin(0.3643998503685*x_28 - 4.23311996459961) + 0.0445080384420656*std::sin(0.285519927740097*x_3 - 7.52663993835449) + 0.00389897133731304*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.114520777040941*std::sin(0.321119844913483*x_35 - 7.4300799369812) + 0.036593456891556*std::sin(0.322399854660034*x_35 + 1.97791981697083) + 0.0606791576357653*std::sin(0.300879925489426*x_36 + 5.09055995941162) - 0.0419602362687879*std::sin(0.395119845867157*x_36 + 5.20344018936157) + 0.025954113628539*std::sin(0.413039863109589*x_36 + 5.20256042480469) + 0.0221285423523011*std::sin(0.566959857940674*x_38 + 2.16863989830017) - 0.0172395501908517*std::sin(0.50903981924057*x_4 + 8.50519943237305) - 0.0272781653448709*std::sin(0.389039844274521*x_41 - 7.40383958816528) - 0.0318149511524337*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.116149019845575*std::sin(0.431999862194061*x_43 + 8.21175956726074) - 0.00525211027276969*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.112832239008571*std::sin(0.459439843893051*x_46 - 4.13912010192871) + 0.00268839514759917*std::sin(0.58383983373642*x_46 + 2.18727993965149) - 0.1758148688079*std::sin(0.157680034637451*x_49 + 1.74911987781525) - 0.0953268427013929*std::sin(0.21815998852253*x_53 + 5.01399946212769) + 0.0402350088476259*std::sin(0.266399949789047*x_53 + 5.08383941650391) - 0.040173691029099*std::sin(0.284799933433533*x_53 + 8.30632019042969) - 0.0580220219750668*std::sin(0.303599923849106*x_55 + 5.13560009002686) + 0.327946704420505*std::sin(0.133360043168068*x_56 + 1.70503997802734) + 0.0106161034956173*std::sin(0.808799862861633*x_57 + 2.41383981704712) - 0.0391169619177169*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.062039862680588*std::sin(0.497999846935272*x_58 - 0.917919814586639) - 0.0451551094438773*std::sin(0.1112000644207*x_59 + 1.70367991924286) + 0.013508865221111*std::sin(0.264479964971542*x_63 + 1.86495995521545) + 0.0632320166136897*std::sin(0.281199932098389*x_64 - 7.49600028991699) + 0.00579660714801444*std::sin(0.387279838323593*x_64 + 5.17727994918823) + 0.0532791623939637*std::sin(0.173920020461082*x_67 - 4.43959999084473) + 0.056427757377149*std::sin(0.242239981889725*x_70 + 5.05904006958008) + 0.0146521103232671*std::sin(0.56855982542038*x_70 + 5.37879991531372) - 0.058783234414936*std::sin(0.276239961385727*x_71 - 4.30703973770142) - 0.00846042095208505*std::sin(0.217999994754791*x_73 - 4.382080078125) - 0.0629377918489592*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0622910701581781*std::sin(0.511119842529297*x_73 + 8.51000022888184) - 0.0473655607697808*std::sin(0.261919975280762*x_75 - 4.32567977905273) + 0.0175579181869366*std::sin(0.473759859800339*x_75 + 5.26640033721924) - 0.0143964899510779*std::sin(0.348879843950272*x_76 + 8.32695960998535) + 0.0383891220417762*std::sin(0.282159954309464*x_78 + 5.10751962661743) - 0.0398845423701461*std::sin(0.341039836406708*x_79 - 4.25072002410889) - 0.0276199686705689*std::sin(0.404719859361649*x_80 + 5.20512008666992) + 0.0313095449473808*std::sin(0.363439828157425*x_81 + 5.15120029449463) - 0.00835540541607451*std::sin(0.262559950351715*x_84 + 1.8562399148941) - 0.0471891136966168*std::sin(0.286319941282272*x_84 - 7.49336004257202) - 0.0174709635609784*std::sin(0.166400015354156*x_85 + 4.94312000274658) - 0.249789200201564*std::sin(0.118160054087639*x_86 + 4.88919973373413) + 0.00688683691621136*std::sin(0.25095996260643*x_86 + 5.07471990585327) - 0.0111296132257866*std::sin(0.346959829330444*x_86 - 7.45160007476807) - 0.0758007605482266*std::sin(0.290559947490692*x_87 + 5.0991997718811) - 0.00468304382209118*std::sin(0.347999840974808*x_87 + 5.15296030044556) - 0.0124348001492335*std::sin(0.453119844198227*x_87 + 5.2597599029541) - 0.00843267919557652*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.0288236285867355*std::sin(0.983599841594696*x_87 - 7.00167989730835) + 0.0343629228130303*std::sin(0.332959830760956*x_92 + 8.3908805847168) - 0.0297378430144259*std::sin(0.352719843387604*x_92 + 2.00847983360291) - 0.0216812960704856*std::sin(0.371759831905365*x_92 - 1.19367980957031) + 0.00610893569389923*std::sin(0.372879832983017*x_95 - 7.40407991409302) - 0.030872491136373*std::sin(0.378959834575653*x_95 + 1.9592798948288) - 0.0108960343233956*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.0662135506999841*std::sin(0.420239865779877*x_95 + 1.98823988437653) - 0.00386141052072117*std::sin(0.404959857463837*x_97 + 5.19767999649048) + 0.0494790877198635*std::sin(0.36303985118866*x_98 - 4.22512006759644) + 0.028796416244143*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 1.84804514404827);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00506210129828172*x_1 - 0.00124721940366058*x_10 - 0.00152491896692354*x_100 - 0.00887074611099628*x_101 + 0.000306868601803067*x_103 - 0.00392236438564969*x_104 + 0.00800266484236508*x_105 + 0.00105612636901328*x_106 + 0.00526729841732348*x_107 + 0.0063144225832164*x_108 + 0.00557709967272678*x_11 + 0.00236235125773561*x_110 - 0.00225480567723664*x_111 - 0.000312030871045767*x_112 + 0.00256724915108378*x_113 + 0.00127604101544764*x_114 + 0.000821886700831057*x_116 + 0.00292430105697589*x_117 + 0.0022830817422708*x_118 - 0.00230848552269995*x_119 + 0.0270293738791334*x_12 - 0.00866552955139742*x_120 + 0.00768158592342539*x_13 + 0.00688090526278725*x_14 + 0.00302028198067758*x_15 + 0.00886207947831716*x_16 - 0.00536783963368051*x_17 - 0.000663032904025525*x_18 - 0.00277811197196551*x_19 + 0.00521304311692176*x_2 + 0.00786987497449716*x_20 + 0.000613885471495691*x_21 - 0.00409642549846694*x_22 - 4.78490886051575e-5*x_23 + 0.00102439037274485*x_24 - 0.0062462990876663*x_25 - 0.00163388884153683*x_26 - 0.0100469760475846*x_27 + 0.000923702255188601*x_28 + 0.000417252280551871*x_29 + 0.00591495687001389*x_3 - 0.0163004820135229*x_30 + 0.027976620108964*x_32 + 0.0125646755178875*x_33 + 0.000536161231048925*x_34 + 0.000583389287732093*x_35 - 0.000105917235574177*x_36 + 0.00414290490033194*x_37 + 0.00241255255076507*x_38 + 0.00547990580972535*x_39 - 0.00277581206542682*x_4 + 0.00705325947845489*x_40 + 0.000664590865100951*x_41 - 0.012949226742226*x_42 - 0.0013211100424545*x_43 + 0.00763017353644158*x_44 + 0.00158822061107155*x_45 + 0.000117928992578554*x_46 + 0.00410333612824259*x_47 - 0.00317539585965715*x_48 + 0.00112326590425311*x_49 + 0.000105539478331101*x_5 + 0.00507492574249408*x_50 + 0.0011713825121248*x_51 + 0.000651707601972033*x_52 - 0.00250926004183816*x_53 - 0.00150424068147524*x_54 + 0.00145607211746075*x_55 + 0.0055511883685275*x_56 - 0.00760681044815351*x_57 - 0.00973388731363262*x_58 - 0.00262475643448555*x_59 - 0.00353789697390781*x_6 + 0.000322989748340972*x_60 - 0.00829158844670228*x_61 + 0.00497251891375816*x_62 + 0.00233771886400216*x_63 - 0.000328433646245198*x_64 + 0.00264500785402575*x_65 + 0.000549582063842222*x_66 + 0.00297293595690083*x_67 + 0.000776067953154579*x_68 - 0.00579163203212598*x_69 + 0.00492303088393874*x_7 - 0.000298226461233344*x_70 - 0.00138223365605689*x_71 + 0.00224856309352555*x_72 - 0.00191042400452996*x_73 + 0.00112739409424375*x_74 - 0.00104787200683921*x_75 - 0.00358901328064873*x_76 + 0.000502964313236988*x_77 - 0.00472576200637829*x_78 - 0.0122926228059499*x_79 + 0.00862756879397594*x_8 + 0.00137031003196515*x_80 + 0.000719055691280795*x_81 + 0.00498219256123227*x_82 - 0.00442046240620647*x_83 - 0.00646462629536365*x_84 + 0.00410052171519959*x_85 + 0.00188922048034928*x_86 + 0.000798673907954726*x_88 - 0.00159458815680763*x_89 - 0.0118034620267584*x_9 + 0.00185459590691809*x_90 + 0.00136593991164168*x_91 + 0.000992655410840859*x_92 - 0.0231223009595236*x_93 + 0.00949192927081653*x_94 - 0.000179437454910634*x_95 - 0.00145959946327166*x_96 + 0.000749924874267775*x_97 - 0.00525971631018971*x_98 - 0.00151536674287405*x_99 - 3.86403535030854e-6*std::pow(-8.0*x_114 - 9.99962043762207, 2) - 1.66792477769811e-6*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) - 9.12106179219402e-5*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) - 9.13545053022886e-5*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) - 4.83490600766962e-6*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) + 2.33914137926353e-6*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) + 5.61059098149959e-6*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) + 8.05301867188994e-6*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) - 3.47718546090761e-6*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) - 1.2137566672634e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) - 9.1280548212698e-5*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) - 4.47280645006146e-5*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) - 5.56942524619439e-5*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) - 7.75953052366081e-5*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 7.04550838817073e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 0.000113978522771331*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) + 1.03580165679659e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) - 3.47013831210164e-6*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 4.56558617993148e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) - 1.92905451173146e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) + 2.24206810258436e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 3.24558342260579e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) - 0.00186723955124305*std::exp(0.556959867477417*x_1) + 0.000245790414543341*std::exp(1.15583980083466*x_1) + 7.12828431134621e-6*std::exp(1.25871992111206*x_1) + 0.00126998977690759*std::exp(1.35671985149384*x_100) + 0.000280176764778322*std::exp(1.49143993854523*x_100) + 0.000773289243104423*std::exp(1.58023989200592*x_100) + 0.00222151771675135*std::exp(0.715599834918976*x_104) - 0.00110436537454896*std::exp(0.580799877643585*x_109) + 0.0033785854295513*std::exp(0.60999983549118*x_109) + 0.000906744624620272*std::exp(0.793439865112305*x_109) - 0.00309077631456263*std::exp(0.801999866962433*x_109) + 0.00556125386711576*std::exp(0.865199863910675*x_109) + 0.000195536128163722*std::exp(1.1865599155426*x_110) - 3.73684455752434e-5*std::exp(1.69735991954803*x_110) - 0.00205798609172023*std::exp(0.49823984503746*x_112) + 0.000334008179355228*std::exp(0.789599895477295*x_112) - 0.00117110268041517*std::exp(0.855839908123016*x_112) + 0.00200690971544843*std::exp(0.682959854602814*x_114) + 0.00495869634702783*std::exp(0.611999869346619*x_23) - 0.00534294948634315*std::exp(0.579439878463745*x_26) + 0.00646760950355779*std::exp(0.771439850330353*x_26) - 0.000755362558718518*std::exp(0.956879794597626*x_26) - 0.000961697164631212*std::exp(0.595679819583893*x_31) + 0.00147090419720354*std::exp(0.637759864330292*x_31) + 0.00413819992120367*std::exp(0.657039821147919*x_31) + 0.00317168122203451*std::exp(0.663919866085052*x_31) - 0.000485686494293873*std::exp(0.667439818382263*x_31) + 0.0015773136219079*std::exp(0.782479882240295*x_49) - 0.00410604829421154*std::exp(0.841519832611084*x_50) + 0.00152079236045924*std::exp(0.942319810390472*x_66) - 0.000363261246650899*std::exp(1.11359989643097*x_66) + 0.000407111368158047*std::exp(1.22135984897614*x_66) + 0.00177025324860918*std::exp(1.04599988460541*x_68) + 0.00185885789268689*std::exp(1.10527992248535*x_68) + 0.00341775047389931*std::exp(0.880079865455627*x_72) - 0.00675404286836776*std::exp(0.601599872112274*x_74) - 0.00302763644392109*std::exp(1.07575976848602*x_74) + 0.00118893496480827*std::exp(1.08567976951599*x_74) - 0.00245185003706565*std::exp(0.743279814720154*x_77) + 0.000682919311000149*std::exp(0.79695987701416*x_80) + 0.00362698473745291*std::exp(0.936159789562225*x_81) - 0.00545165682573662*std::sin(0.498079836368561*x_10 - 0.920319855213165) + 0.00189585512600966*std::sin(0.265119940042496*x_100 - 7.51448011398315) - 0.0121056815602258*std::sin(0.124000057578087*x_102 + 1.72023987770081) + 0.00697140727888778*std::sin(0.354159861803055*x_102 - 7.43056011199951) + 0.0230987233921762*std::sin(0.360079854726791*x_102 - 4.23984003067017) + 0.0231710285325004*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.007958616985949*std::sin(0.376559853553772*x_102 + 5.18311977386475) + 0.166635244206794*std::sin(0.135920032858849*x_103 - 1.44095981121063) - 0.00286768111591417*std::sin(0.323599934577942*x_105 + 1.91183984279633) + 0.0109243434927467*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.138118179020045*std::sin(0.136000037193298*x_108 + 4.91215991973877) - 0.0120678441601203*std::sin(0.596959829330444*x_110 - 7.18480014801025) + 0.00268424760579101*std::sin(0.290879935026169*x_111 + 5.09975957870483) + 0.036033707983949*std::sin(0.32847985625267*x_111 - 7.46783971786499) + 0.0228733915536785*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.022404448633791*std::sin(0.441359847784042*x_111 + 8.42160034179688) - 0.0151191694648494*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.119087728375924*std::sin(0.193120002746582*x_114 + 4.97639989852905) + 0.00362824924784631*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.0171879121816139*std::sin(0.432879865169525*x_115 - 4.18359994888306) + 0.0207960178520542*std::sin(0.442319840192795*x_115 - 7.35264015197754) + 0.0121253640225713*std::sin(0.417359858751297*x_117 + 5.20456027984619) + 0.0179390453467608*std::sin(0.314319849014282*x_120 + 5.11375999450684) + 0.0104575039886196*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.032260502526325*std::sin(0.461839854717255*x_2 - 4.12639999389648) + 0.0203635776709401*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.0345518937246568*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.0210516847659363*std::sin(0.278719931840897*x_28 - 4.29207992553711) + 0.0152037696549846*std::sin(0.313039928674698*x_28 - 4.25007963180542) - 0.0267660334953656*std::sin(0.343599855899811*x_28 - 4.2596001625061) - 0.00240338658114553*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.0494918837252347*std::sin(0.285519927740097*x_3 - 7.52663993835449) + 0.0157784298516083*std::sin(0.309999942779541*x_35 - 1.13671982288361) - 0.0145158561997481*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.0406910566489847*std::sin(0.322399854660034*x_35 + 1.97791981697083) + 0.0215273195899028*std::sin(0.300879925489426*x_36 + 5.09055995941162) - 0.00367945662000532*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0288603591364106*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.0246064145589021*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.0191699711644579*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.0303326732595368*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.0353774715371886*std::sin(0.39047983288765*x_43 + 8.19287967681885) - 0.0147222409189322*std::sin(0.431999862194061*x_43 + 8.21175956726074) - 0.021254337706652*std::sin(0.40871986746788*x_45 + 5.21023988723755) - 0.0143018288773791*std::sin(0.459439843893051*x_46 - 4.13912010192871) + 0.0108794475721974*std::sin(0.58383983373642*x_46 + 2.18727993965149) - 0.0154170529161627*std::sin(0.157680034637451*x_49 + 1.74911987781525) - 0.00835912791803682*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.044740376104476*std::sin(0.266399949789047*x_53 + 5.08383941650391) - 0.0142525361192503*std::sin(0.284799933433533*x_53 + 8.30632019042969) - 0.00508790063751519*std::sin(0.303599923849106*x_55 + 5.13560009002686) + 0.0287573612517176*std::sin(0.133360043168068*x_56 + 1.70503997802734) + 0.00376630562542507*std::sin(0.808799862861633*x_57 + 2.41383981704712) - 0.0138776372876411*std::sin(0.411359876394272*x_58 + 5.20424032211304) - 0.00786374096118455*std::sin(0.497999846935272*x_58 - 0.917919814586639) - 0.182734538205894*std::sin(0.1112000644207*x_59 + 1.70367991924286) + 0.0546679274675103*std::sin(0.264479964971542*x_63 + 1.86495995521545) + 0.00554476053554995*std::sin(0.281199932098389*x_64 - 7.49600028991699) + 0.023457817806198*std::sin(0.387279838323593*x_64 + 5.17727994918823) + 0.0189020019562887*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.0627463286350125*std::sin(0.242239981889725*x_70 + 5.05904006958008) + 0.00128483080935595*std::sin(0.56855982542038*x_70 + 5.37879991531372) - 0.0051546506942395*std::sin(0.276239961385727*x_71 - 4.30703973770142) - 0.0342377891394162*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.0699853326532525*std::sin(0.241199985146523*x_73 - 7.54744052886963) - 0.00789558227168924*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.0526693808187009*std::sin(0.261919975280762*x_75 - 4.32567977905273) + 0.00622907322498436*std::sin(0.473759859800339*x_75 + 5.26640033721924) - 0.00126241568126575*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.0426877937314295*std::sin(0.282159954309464*x_78 + 5.10751962661743) - 0.0141499540163866*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.0307127504555778*std::sin(0.404719859361649*x_80 + 5.20512008666992) + 0.00274550676235556*std::sin(0.363439828157425*x_81 + 5.15120029449463) - 0.0338128103116894*std::sin(0.262559950351715*x_84 + 1.8562399148941) - 0.00413797233340069*std::sin(0.286319941282272*x_84 - 7.49336004257202) - 0.0707018208492078*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.277759669599617*std::sin(0.118160054087639*x_86 + 4.88919973373413) + 0.0278697799447771*std::sin(0.25095996260643*x_86 + 5.07471990585327) - 0.00394848495197795*std::sin(0.346959829330444*x_86 - 7.45160007476807) - 0.00664690275845931*std::sin(0.290559947490692*x_87 + 5.0991997718811) - 0.0189514289914722*std::sin(0.347999840974808*x_87 + 5.15296030044556) - 0.00441152987745729*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.00937693937653366*std::sin(0.792079865932465*x_87 - 0.782159864902496) + 0.0036534824381293*std::sin(0.983599841594696*x_87 - 7.00167989730835) + 0.00301325481146507*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.0330677765236725*std::sin(0.352719843387604*x_92 + 2.00847983360291) - 0.00769193587746087*std::sin(0.371759831905365*x_92 - 1.19367980957031) + 0.0247217547848406*std::sin(0.372879832983017*x_95 - 7.40407991409302) - 0.00270718189383219*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.0121161318870882*std::sin(0.405119866132736*x_95 - 0.992079794406891) - 0.00839276858986109*std::sin(0.420239865779877*x_95 + 1.98823988437653) - 0.0156264280392092*std::sin(0.404959857463837*x_97 + 5.19767999649048) + 0.00433877816360386*std::sin(0.36303985118866*x_98 - 4.22512006759644) + 0.0102161875623361*std::sin(0.432399868965149*x_98 + 2.00271987915039) + 0.275909976373894);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.011609781787273*x_1 + 0.00186844887618125*x_10 - 0.000661928900396007*x_100 + 0.080059399116191*x_101 - 0.0110881634461241*x_103 + 0.0277626980108025*x_104 - 0.0345779168717325*x_105 + 0.0285373796588357*x_106 - 0.0446522253569755*x_107 - 0.0318512219262219*x_108 - 0.0229846821496639*x_11 + 0.00253153891926826*x_110 - 0.000865512407475622*x_111 - 0.00255380142105482*x_112 + 0.00530956324743653*x_113 - 0.0242325232665409*x_114 + 0.0169457544563479*x_116 - 0.00220327927882537*x_117 - 0.0591330057074244*x_118 + 0.0201179215136977*x_119 - 0.144601140495148*x_12 + 0.016846873896268*x_120 + 0.00365445458813002*x_13 - 0.0406817549707718*x_14 - 0.0154266244449243*x_15 - 0.0317210693536277*x_16 + 0.0182103205366115*x_17 + 0.0441388176603931*x_18 - 0.0119474786756782*x_19 - 0.0398783930139518*x_2 - 0.0133778009504606*x_20 - 0.0808122026440813*x_21 + 0.0186503123933928*x_22 + 0.0212644371060285*x_23 - 0.000350419679829541*x_24 - 0.0337170683433711*x_25 - 0.00275768765328985*x_26 + 0.0295092100312995*x_27 - 0.00211026633563304*x_28 + 0.00688750295944265*x_29 - 0.0482331236281592*x_3 + 0.0368837998760954*x_30 - 0.0945078651701451*x_32 - 0.0029756697288236*x_33 + 0.00485458345577144*x_34 + 0.00021584210761962*x_35 - 0.00385858175229104*x_36 - 0.043951695911949*x_37 - 0.00868869203428117*x_38 + 0.0185311453478881*x_39 - 0.00645547594319182*x_4 - 0.0213497243607955*x_40 - 0.0118676423160512*x_41 + 0.00366045625548545*x_42 + 0.000843938449669012*x_43 - 0.0644653365182867*x_44 - 0.0314568278278771*x_45 + 0.00155500304543629*x_46 - 0.00329130329458064*x_47 + 0.0317662274409876*x_48 - 0.0220197448198032*x_49 + 0.0344236582314435*x_5 - 0.00853890552466408*x_50 - 0.0419356350479431*x_51 - 0.002539237365235*x_52 + 0.00872925793577004*x_53 + 0.0127438021440653*x_54 - 0.0472073019509976*x_55 - 0.0337526111892282*x_56 - 0.029969526845897*x_57 + 0.00812278020714538*x_58 - 0.000701520591490253*x_59 + 0.00637162658622238*x_6 - 0.0232455914620562*x_60 - 0.010566122785187*x_61 - 0.00846715211381035*x_62 + 0.0428031807503357*x_63 - 0.00222470703544761*x_64 - 0.0165344907407818*x_65 - 0.000840744342016752*x_66 + 0.00446959396208464*x_67 - 0.00428719758120132*x_68 + 0.0325966319047078*x_69 - 0.0165927555647188*x_7 - 0.000114474921294035*x_70 + 0.0263807268947063*x_71 - 0.0167765157644653*x_72 - 0.00362112029880776*x_73 - 0.00987312243974367*x_74 - 0.00116953721399567*x_75 - 0.04625249624615*x_76 + 0.00369375852574214*x_77 + 0.0194251488855434*x_78 + 0.0321040788514568*x_79 + 0.0535830598738949*x_8 + 0.0192440692999003*x_80 - 0.00545977613959085*x_81 + 0.0224283298243535*x_82 - 0.0010514255162043*x_83 + 0.0472147233512028*x_84 - 0.0383512331663952*x_85 - 0.0223855520072506*x_86 + 0.00988710350488679*x_88 + 0.0253679710164849*x_89 + 0.0685669312875039*x_9 + 0.01217649967014*x_90 + 0.0243375719434387*x_91 - 0.00879764881552634*x_92 - 0.0117455018147155*x_93 - 0.037608648491492*x_94 - 6.88774847246856e-5*x_95 - 0.00158418361987813*x_96 - 0.0323240604404249*x_97 + 0.0148697622131816*x_98 + 0.00278486899359401*x_99 - 3.16250085626196e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) - 1.36510488632813e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) + 0.000208377423971599*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) + 0.000208706145367662*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) - 3.95710520297915e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) + 1.91445883491931e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) + 4.59196078051183e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) + 3.09116996134922e-6*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) - 2.84588545408206e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) - 4.65903321859734e-6*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.00103774428219527*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) + 0.000102184581929377*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) + 0.000127237651958196*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.000882160393546858*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 3.05827766672833e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 4.94752048359636e-5*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) + 3.97594876885333e-6*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) - 2.84011774956784e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 1.98180592234497e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) - 7.40472064380554e-6*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) + 8.60623059797465e-6*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 1.4088259852936e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) + 0.00426584729377563*std::exp(0.556959867477417*x_1) + 0.000106691425810504*std::exp(1.15583980083466*x_1) - 8.10395690078987e-5*std::exp(1.25871992111206*x_1) - 0.00290138587163998*std::exp(1.35671985149384*x_100) + 0.00010754650329744*std::exp(1.49143993854523*x_100) - 0.00879131979624866*std::exp(1.58023989200592*x_100) + 0.000964304865606147*std::exp(0.715599834918976*x_104) - 0.009038624458646*std::exp(0.580799877643585*x_109) - 0.00771862908636792*std::exp(0.60999983549118*x_109) + 0.0003480560346923*std::exp(0.793439865112305*x_109) + 0.0351382141188296*std::exp(0.801999866962433*x_109) + 0.00241400017766816*std::exp(0.865199863910675*x_109) + 0.0016003558888211*std::exp(1.1865599155426*x_110) - 1.43439648125634e-5*std::exp(1.69735991954803*x_110) - 0.000789962751459398*std::exp(0.49823984503746*x_112) - 0.0037972501822039*std::exp(0.789599895477295*x_112) - 0.000508346165476542*std::exp(0.855839908123016*x_112) + 0.000770356965542484*std::exp(0.682959854602814*x_114) - 0.0113285097129299*std::exp(0.611999869346619*x_23) + 0.0607425720821803*std::exp(0.579439878463745*x_26) + 0.00280742632214596*std::exp(0.771439850330353*x_26) + 0.00172568180916247*std::exp(0.956879794597626*x_26) - 0.000369149695082608*std::exp(0.595679819583893*x_31) - 0.0167223187217082*std::exp(0.637759864330292*x_31) - 0.00945402475178795*std::exp(0.657039821147919*x_31) + 0.00137674690212784*std::exp(0.663919866085052*x_31) - 0.00397507738627856*std::exp(0.667439818382263*x_31) + 0.000684672099944762*std::exp(0.782479882240295*x_49) + 0.00938057197444957*std::exp(0.841519832611084*x_50) + 0.000583759687346873*std::exp(0.942319810390472*x_66) - 0.00297309392754009*std::exp(1.11359989643097*x_66) - 0.00462834089841647*std::exp(1.22135984897614*x_66) + 0.000679515829906468*std::exp(1.04599988460541*x_68) - 0.00424669877293087*std::exp(1.10527992248535*x_68) - 0.00780810453601301*std::exp(0.880079865455627*x_72) + 0.0154301120458223*std::exp(0.601599872112274*x_74) - 0.00131422069342262*std::exp(1.07575976848602*x_74) + 0.000456375453597527*std::exp(1.08567976951599*x_74) + 0.00560143332353758*std::exp(0.743279814720154*x_77) + 0.000262140167085139*std::exp(0.79695987701416*x_80) - 0.00828611573513905*std::exp(0.936159789562225*x_81) + 0.061978436919729*std::sin(0.498079836368561*x_10 - 0.920319855213165) + 0.0155165336644123*std::sin(0.265119940042496*x_100 - 7.51448011398315) - 0.0990783593550505*std::sin(0.124000057578087*x_102 + 1.72023987770081) + 0.00267599091059499*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.262603244564064*std::sin(0.360079854726791*x_102 - 4.23984003067017) - 0.0529359338460685*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.00345463510156888*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 1.89443178501591*std::sin(0.135920032858849*x_103 - 1.44095981121063) - 0.0234703960041169*std::sin(0.323599934577942*x_105 + 1.91183984279633) + 0.00419333467710863*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.0599536213703749*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.137196111557164*std::sin(0.596959829330444*x_110 - 7.18480014801025) + 0.0219690934014239*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.409657645126142*std::sin(0.32847985625267*x_111 - 7.46783971786499) - 0.0522559600849142*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.00972520663052892*std::sin(0.441359847784042*x_111 + 8.42160034179688) + 0.0345408644021208*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.0516929822530604*std::sin(0.193120002746582*x_114 + 4.97639989852905) + 0.00139271191887083*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.00746083959689465*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.236424397541007*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.137850039579507*std::sin(0.417359858751297*x_117 + 5.20456027984619) + 0.00688594431113798*std::sin(0.314319849014282*x_120 + 5.11375999450684) - 0.0238909437515948*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.0140034712838244*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.23150810010273*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.0149981064671934*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.00913800592087347*std::sin(0.278719931840897*x_28 - 4.29207992553711) + 0.00583600237024305*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.30429591803217*std::sin(0.343599855899811*x_28 - 4.2596001625061) - 0.0196704000655541*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.0214831796858451*std::sin(0.285519927740097*x_3 - 7.52663993835449) - 0.0360469936691861*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.165026909537796*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.0176629624051129*std::sin(0.322399854660034*x_35 + 1.97791981697083) + 0.00826331173140755*std::sin(0.300879925489426*x_36 + 5.09055995941162) - 0.030114332961308*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0125275547111455*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.0106810245560275*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.008321201459716*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.0131666491743251*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.015356468993658*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.167373242534906*std::sin(0.431999862194061*x_43 + 8.21175956726074) + 0.048557111446443*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.162593689817155*std::sin(0.459439843893051*x_46 - 4.13912010192871) - 0.0248549051741843*std::sin(0.58383983373642*x_46 + 2.18727993965149) - 0.126180116453923*std::sin(0.157680034637451*x_49 + 1.74911987781525) - 0.0684148740934366*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.0194206699506706*std::sin(0.266399949789047*x_53 + 5.08383941650391) - 0.00547086916346757*std::sin(0.284799933433533*x_53 + 8.30632019042969) - 0.0416416742187225*std::sin(0.303599923849106*x_55 + 5.13560009002686) + 0.235363218338904*std::sin(0.133360043168068*x_56 + 1.70503997802734) + 0.0014457051807434*std::sin(0.808799862861633*x_57 + 2.41383981704712) - 0.00532696337434277*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.0894007801105512*std::sin(0.497999846935272*x_58 - 0.917919814586639) + 0.41747061043454*std::sin(0.1112000644207*x_59 + 1.70367991924286) - 0.124892936360711*std::sin(0.264479964971542*x_63 + 1.86495995521545) + 0.0453808217361264*std::sin(0.281199932098389*x_64 - 7.49600028991699) - 0.053591125220026*std::sin(0.387279838323593*x_64 + 5.17727994918823) + 0.00725557744707568*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.0272366002509973*std::sin(0.242239981889725*x_70 + 5.05904006958008) + 0.0105156349939073*std::sin(0.56855982542038*x_70 + 5.37879991531372) - 0.0421879867971758*std::sin(0.276239961385727*x_71 - 4.30703973770142) + 0.0782187695456694*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.0303788694952595*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0897627755034454*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.0228624511112198*std::sin(0.261919975280762*x_75 - 4.32567977905273) + 0.00239104425615314*std::sin(0.473759859800339*x_75 + 5.26640033721924) - 0.0103321794730544*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.0185296956611292*std::sin(0.282159954309464*x_78 + 5.10751962661743) - 0.00543149278451406*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.0133316311083807*std::sin(0.404719859361649*x_80 + 5.20512008666992) + 0.0224704659757555*std::sin(0.363439828157425*x_81 + 5.15120029449463) + 0.0772478738826233*std::sin(0.262559950351715*x_84 + 1.8562399148941) - 0.0338670324186425*std::sin(0.286319941282272*x_84 - 7.49336004257202) + 0.161523555418383*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.120568473906097*std::sin(0.118160054087639*x_86 + 4.88919973373413) - 0.0636705800690672*std::sin(0.25095996260643*x_86 + 5.07471990585327) - 0.00151563513927992*std::sin(0.346959829330444*x_86 - 7.45160007476807) - 0.0544012509187812*std::sin(0.290559947490692*x_87 + 5.0991997718811) + 0.043295945623385*std::sin(0.347999840974808*x_87 + 5.15296030044556) - 0.00169337601170497*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.00407029311407349*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.041535470420653*std::sin(0.983599841594696*x_87 - 7.00167989730835) + 0.024661836803933*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.0143538885853158*std::sin(0.352719843387604*x_92 + 2.00847983360291) - 0.0029525674902541*std::sin(0.371759831905365*x_92 - 1.19367980957031) - 0.0564786830249453*std::sin(0.372879832983017*x_95 - 7.40407991409302) - 0.022156797961534*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.00525930756389854*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.0954151545586884*std::sin(0.420239865779877*x_95 + 1.98823988437653) + 0.0356997342510572*std::sin(0.404959857463837*x_97 + 5.19767999649048) + 0.0355105179263752*std::sin(0.36303985118866*x_98 - 4.22512006759644) + 0.00392150737492223*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 2.91795219824468);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0269855610969587*x_1 - 0.00598100673472836*x_10 + 0.00050875690975062*x_100 + 0.0198833192993274*x_101 + 0.0120806269350905*x_103 + 0.00167183731156121*x_104 - 0.0139187039826616*x_105 + 0.0231973353735708*x_106 - 0.0259826847852089*x_107 - 0.0180770094108362*x_108 - 0.00512959633525667*x_11 - 0.0024284753360509*x_110 + 0.0014957424933355*x_111 + 0.00565653234353895*x_112 - 0.0239466583512589*x_113 - 0.0234652186617647*x_114 + 0.00713668191791147*x_116 + 0.00262933158519269*x_117 - 0.0282626128788738*x_118 + 0.00307513879697968*x_119 - 0.127894294229131*x_12 + 0.00710807038026886*x_120 - 0.00434789310242669*x_13 - 0.0140180936905999*x_14 - 0.00818125284272053*x_15 - 0.0230390541490222*x_16 - 0.00447863740462377*x_17 + 0.0173275475319723*x_18 - 0.00336508571757321*x_19 - 0.00239101072119348*x_2 - 0.00771894053035779*x_20 - 0.0560918123602606*x_21 - 0.0145456483382144*x_22 + 0.0153667181637133*x_23 + 0.000237502263236735*x_24 - 0.0368286241241541*x_25 + 0.00585386382980889*x_26 + 0.0177923486247973*x_27 + 0.00242685086350984*x_28 + 0.0213995790200574*x_29 - 0.050352990796523*x_3 + 0.0212689551597399*x_30 - 0.0914058906860905*x_32 + 0.0118561066539952*x_33 - 0.00729118827653477*x_34 - 0.000368875792251055*x_35 - 0.00543689262483467*x_36 - 0.0557461603035196*x_37 - 0.00510323914927725*x_38 - 0.00194017047474751*x_39 - 0.0393174566192801*x_4 - 0.00144080041794801*x_40 - 0.0383738882351452*x_41 + 0.0177186225930031*x_42 - 0.00184414923171677*x_43 - 0.0519969093505653*x_44 - 0.0105638082662494*x_45 - 0.00259601243253113*x_46 - 0.0202528455048029*x_47 + 0.0324833763178407*x_48 - 0.0252767353674435*x_49 + 0.0140611853949473*x_5 - 0.00921490746731008*x_50 - 0.0321020150726404*x_51 + 0.0063639027473587*x_52 - 0.00282270981386939*x_53 - 0.0222542043451643*x_54 - 0.0239570479800497*x_55 - 0.0310064107329496*x_56 - 0.0271535180085549*x_57 - 0.0076970546217068*x_58 - 0.000129519234599657*x_59 + 0.00249478732579231*x_6 - 0.0175064902925411*x_60 + 0.00121460545380892*x_61 + 0.0136999370733798*x_62 + 0.0298673729532996*x_63 - 0.00115694066414145*x_64 - 0.013008004615097*x_65 + 0.000992136187452822*x_66 + 0.016052912987173*x_67 - 0.0149941411669983*x_68 + 0.0232788253863439*x_69 + 0.000217802238296613*x_7 + 0.000197830791010985*x_70 + 0.0293450946520298*x_71 - 0.0172657373212222*x_72 + 0.00773278857214865*x_73 - 0.0113263045867637*x_74 + 0.020676654695572*x_75 - 0.0412103123004135*x_76 - 0.000771185915205679*x_77 - 0.0182626079106355*x_78 + 0.0301611134955123*x_79 + 0.0229121878456993*x_8 + 0.0228977515596536*x_80 - 0.00444843491497896*x_81 + 0.018600536628454*x_82 - 0.000643293569351297*x_83 + 0.0380411245469203*x_84 - 0.0311105972919053*x_85 - 0.0161937832153883*x_86 + 0.0130310658252222*x_88 + 0.00982618581358614*x_89 + 0.0663423658434872*x_9 + 0.0286372324444808*x_90 + 0.0164585649715699*x_91 - 0.00560672560985686*x_92 - 0.0524171686870016*x_93 - 0.00930309610115011*x_94 + 0.000119031200300477*x_95 + 0.00311158561034262*x_96 - 0.00670501060838835*x_97 + 0.0134192808385133*x_98 + 0.000502744362280134*x_99 + 7.00476874686937e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) + 3.02363366163714e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) - 0.000239638439358287*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) - 0.000240016475907711*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) + 8.76477449769471e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) - 4.24042301441828e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) - 0.000101709453448808*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) - 5.34203117757444e-6*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) + 6.30348271572861e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) + 8.05154715602846e-6*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.000803343410024955*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) - 0.000117514427778762*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) - 0.00014632598753611*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.000682902089560769*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) + 2.35058462314184e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) + 3.80265196255444e-5*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) - 6.87106906097864e-6*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) + 6.29070756145713e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) + 1.52321111251451e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) + 1.27965298042599e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) - 1.48729292632323e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) + 1.08282015519422e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) - 0.00490581450013747*std::exp(0.556959867477417*x_1) - 8.20027650398187e-5*std::exp(1.15583980083466*x_1) - 6.27347264935428e-5*std::exp(1.25871992111206*x_1) + 0.00333665504162653*std::exp(1.35671985149384*x_100) - 0.00018585738760326*std::exp(1.49143993854523*x_100) - 0.00680557719749438*std::exp(1.58023989200592*x_100) - 0.000741162326028921*std::exp(0.715599834918976*x_104) + 0.0200200654482821*std::exp(0.580799877643585*x_109) + 0.00887658649861604*std::exp(0.60999983549118*x_109) - 0.000601495942351111*std::exp(0.793439865112305*x_109) + 0.0272013570556065*std::exp(0.801999866962433*x_109) - 0.00185539454432818*std::exp(0.865199863910675*x_109) - 0.00354470193792537*std::exp(1.1865599155426*x_110) + 2.47886425517991e-5*std::exp(1.69735991954803*x_110) + 0.0013651807245101*std::exp(0.49823984503746*x_112) - 0.0029395448979362*std::exp(0.789599895477295*x_112) + 0.000390713600927075*std::exp(0.855839908123016*x_112) - 0.0013312988218847*std::exp(0.682959854602814*x_114) + 0.0130280254747353*std::exp(0.611999869346619*x_23) + 0.0470223212282691*std::exp(0.579439878463745*x_26) - 0.00215778090237944*std::exp(0.771439850330353*x_26) - 0.00198457053405672*std::exp(0.956879794597626*x_26) + 0.000637949127670306*std::exp(0.595679819583893*x_31) - 0.0129451588179345*std::exp(0.637759864330292*x_31) + 0.0108723281725657*std::exp(0.657039821147919*x_31) - 0.00105816425150233*std::exp(0.663919866085052*x_31) + 0.00880458191391705*std::exp(0.667439818382263*x_31) - 0.000526237276468774*std::exp(0.782479882240295*x_49) - 0.0107878559270008*std::exp(0.841519832611084*x_50) - 0.00100882917762858*std::exp(0.942319810390472*x_66) + 0.00658524262022045*std::exp(1.11359989643097*x_66) - 0.00358291269235076*std::exp(1.22135984897614*x_66) - 0.00117431095488237*std::exp(1.04599988460541*x_68) + 0.00488379329667022*std::exp(1.10527992248535*x_68) + 0.00897948515579855*std::exp(0.880079865455627*x_72) - 0.0177449548003258*std::exp(0.601599872112274*x_74) + 0.00101010676269914*std::exp(1.07575976848602*x_74) - 0.000788689050515212*std::exp(1.08567976951599*x_74) - 0.0064417666474512*std::exp(0.743279814720154*x_77) - 0.000453019718415017*std::exp(0.79695987701416*x_80) + 0.00952920813236227*std::exp(0.936159789562225*x_81) + 0.0479790346401955*std::sin(0.498079836368561*x_10 - 0.920319855213165) - 0.0343682847886062*std::sin(0.265119940042496*x_100 - 7.51448011398315) + 0.219453219665425*std::sin(0.124000057578087*x_102 + 1.72023987770081) - 0.00462453603459084*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.203287639923625*std::sin(0.360079854726791*x_102 - 4.23984003067017) + 0.0608774421483123*std::sin(0.375039845705032*x_102 + 1.98391973972321) - 0.00265522396368963*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 1.46652630743956*std::sin(0.135920032858849*x_103 - 1.44095981121063) + 0.0519856606776102*std::sin(0.323599934577942*x_105 + 1.91183984279633) - 0.00724674633333356*std::sin(0.437919855117798*x_105 - 4.17088031768799) + 0.0460802045635152*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.106206889299687*std::sin(0.596959829330444*x_110 - 7.18480014801025) - 0.0486603564235054*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.317126073566265*std::sin(0.32847985625267*x_111 - 7.46783971786499) + 0.0600954579591334*std::sin(0.399279862642288*x_111 + 2.00383973121643) + 0.00747476967552569*std::sin(0.441359847784042*x_111 + 8.42160034179688) - 0.0397227237080088*std::sin(0.445599853992462*x_112 + 5.21031999588013) + 0.0397310978431776*std::sin(0.193120002746582*x_114 + 4.97639989852905) - 0.00240682673065965*std::sin(0.422959864139557*x_115 + 8.4026403427124) - 0.0057343827942704*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.183021949619328*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.106713111088998*std::sin(0.417359858751297*x_117 + 5.20456027984619) - 0.0119000021535809*std::sin(0.314319849014282*x_120 + 5.11375999450684) + 0.0274750899896387*std::sin(0.584559857845306*x_120 - 4.00031995773315) - 0.0107630332681921*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.179216122676675*std::sin(0.301679849624634*x_24 + 5.10272026062012) - 0.0115275074011652*std::sin(0.385919839143753*x_24 + 5.174720287323) + 0.00702344866768187*std::sin(0.278719931840897*x_28 - 4.29207992553711) - 0.0100855362222235*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.235562965407541*std::sin(0.343599855899811*x_28 - 4.2596001625061) + 0.0435688747229219*std::sin(0.3643998503685*x_28 - 4.23311996459961) + 0.0165119185792447*std::sin(0.285519927740097*x_3 - 7.52663993835449) + 0.0414548041807981*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.12775139553024*std::sin(0.321119844913483*x_35 - 7.4300799369812) + 0.013575709060128*std::sin(0.322399854660034*x_35 + 1.97791981697083) - 0.0142803111608682*std::sin(0.300879925489426*x_36 + 5.09055995941162) + 0.0667016225284194*std::sin(0.395119845867157*x_36 + 5.20344018936157) + 0.00962864745407128*std::sin(0.413039863109589*x_36 + 5.20256042480469) + 0.00820940896045489*std::sin(0.566959857940674*x_38 + 2.16863989830017) - 0.0063956547863747*std::sin(0.50903981924057*x_4 + 8.50519943237305) - 0.0101198538720589*std::sin(0.389039844274521*x_41 - 7.40383958816528) - 0.0118029439494493*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.129567749696957*std::sin(0.431999862194061*x_43 + 8.21175956726074) - 0.0558417038899471*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.125867780210689*std::sin(0.459439843893051*x_46 - 4.13912010192871) + 0.0285836659884591*std::sin(0.58383983373642*x_46 + 2.18727993965149) + 0.279482149218291*std::sin(0.157680034637451*x_49 + 1.74911987781525) + 0.151535254424295*std::sin(0.21815998852253*x_53 + 5.01399946212769) + 0.014926678716519*std::sin(0.266399949789047*x_53 + 5.08383941650391) + 0.00945452822235568*std::sin(0.284799933433533*x_53 + 8.30632019042969) + 0.0922340613938673*std::sin(0.303599923849106*x_55 + 5.13560009002686) - 0.521316828331756*std::sin(0.133360043168068*x_56 + 1.70503997802734) - 0.00249840747861732*std::sin(0.808799862861633*x_57 + 2.41383981704712) + 0.00920583623137806*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.0692073459571107*std::sin(0.497999846935272*x_58 - 0.917919814586639) - 0.480100020701473*std::sin(0.1112000644207*x_59 + 1.70367991924286) + 0.143629515068935*std::sin(0.264479964971542*x_63 + 1.86495995521545) - 0.100516071379093*std::sin(0.281199932098389*x_64 - 7.49600028991699) + 0.0616309260687085*std::sin(0.387279838323593*x_64 + 5.17727994918823) - 0.0125387867436013*std::sin(0.173920020461082*x_67 - 4.43959999084473) + 0.0209339833440123*std::sin(0.242239981889725*x_70 + 5.05904006958008) - 0.0232915640838348*std::sin(0.56855982542038*x_70 + 5.37879991531372) + 0.0934441142759065*std::sin(0.276239961385727*x_71 - 4.30703973770142) - 0.0899532372806588*std::sin(0.217999994754791*x_73 - 4.382080078125) - 0.0233491236851559*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0694875755072324*std::sin(0.511119842529297*x_73 + 8.51000022888184) - 0.017572023173048*std::sin(0.261919975280762*x_75 - 4.32567977905273) - 0.00413210309463385*std::sin(0.473759859800339*x_75 + 5.26640033721924) + 0.0228852200044755*std::sin(0.348879843950272*x_76 + 8.32695960998535) + 0.0142418780892263*std::sin(0.282159954309464*x_78 + 5.10751962661743) + 0.00938647960430497*std::sin(0.341039836406708*x_79 - 4.25072002410889) - 0.0102466585770424*std::sin(0.404719859361649*x_80 + 5.20512008666992) - 0.049770869621395*std::sin(0.363439828157425*x_81 + 5.15120029449463) - 0.0888366867588335*std::sin(0.262559950351715*x_84 + 1.8562399148941) + 0.0750136493293231*std::sin(0.286319941282272*x_84 - 7.49336004257202) - 0.185755500775068*std::sin(0.166400015354156*x_85 + 4.94312000274658) - 0.0926686297593542*std::sin(0.118160054087639*x_86 + 4.88919973373413) + 0.0732225120647796*std::sin(0.25095996260643*x_86 + 5.07471990585327) + 0.00261925752032306*std::sin(0.346959829330444*x_86 - 7.45160007476807) + 0.120495835272878*std::sin(0.290559947490692*x_87 + 5.0991997718811) - 0.0497912520559009*std::sin(0.347999840974808*x_87 + 5.15296030044556) + 0.00292642189300267*std::sin(0.453119844198227*x_87 + 5.2597599029541) - 0.00312841718386428*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.0321536307327391*std::sin(0.983599841594696*x_87 - 7.00167989730835) - 0.0546246377586035*std::sin(0.332959830760956*x_92 + 8.3908805847168) - 0.0110323631362841*std::sin(0.352719843387604*x_92 + 2.00847983360291) + 0.00510250415992839*std::sin(0.371759831905365*x_92 - 1.19367980957031) + 0.0649516785415004*std::sin(0.372879832983017*x_95 - 7.40407991409302) + 0.0490761118955398*std::sin(0.378959834575653*x_95 + 1.9592798948288) - 0.00404229073853145*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.073863221360358*std::sin(0.420239865779877*x_95 + 1.98823988437653) - 0.0410554485143982*std::sin(0.404959857463837*x_97 + 5.19767999649048) - 0.0786538810458472*std::sin(0.36303985118866*x_98 - 4.22512006759644) - 0.00677698571151324*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 1.63014122823696);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00650304152857248*x_1 - 0.00453162843601725*x_10 + 0.0023408262788369*x_100 + 0.0455445569034316*x_101 + 0.0122260688724945*x_103 + 0.0124543386457815*x_104 - 0.0268996154605779*x_105 + 0.0252641552705267*x_106 - 0.0479135843073042*x_107 - 0.0293449644729217*x_108 - 0.0183616113805556*x_11 - 0.00572964975451977*x_110 + 0.00737567178681074*x_111 + 0.0028266053012869*x_112 - 0.0315883748402568*x_113 - 0.0316830101509146*x_114 + 0.00323992466487127*x_116 + 0.00403862201522618*x_117 - 0.0432483604786676*x_118 + 0.00588979916113706*x_119 - 0.181855476804925*x_12 + 0.0257412574160954*x_120 - 0.00982676273988555*x_13 - 0.0328844793700506*x_14 - 0.0167187188506017*x_15 - 0.0372436044939003*x_16 + 0.00437191963143754*x_17 + 0.0232258818950077*x_18 + 0.0027999744691851*x_19 - 0.013483651900341*x_2 - 0.0161977757603068*x_20 - 0.0766847493538982*x_21 - 0.0085575422216867*x_22 + 0.0202588152051041*x_23 - 0.0018090180843313*x_24 - 0.0485701281983293*x_25 + 0.00692533095125751*x_26 + 0.0343410214791087*x_27 + 0.00208908013537107*x_28 + 0.0234500870615124*x_29 - 0.0652377968106578*x_3 + 0.0434938496312535*x_30 - 0.148408151051377*x_32 + 0.0054944705187459*x_33 + 0.000399612130693971*x_34 - 0.00190231396924314*x_35 - 0.0068891641315657*x_36 - 0.0678782479290474*x_37 - 0.0131785283659883*x_38 - 0.000794374661488347*x_39 - 0.0342498077905142*x_4 - 0.0099816742534033*x_40 - 0.050083063981218*x_41 + 0.0322155163004116*x_42 + 0.0029161370982548*x_43 - 0.0739707937979561*x_44 - 0.0239496312850819*x_45 + 0.00195255307013518*x_46 - 0.021869419168971*x_47 + 0.047273364794292*x_48 - 0.0345754047891368*x_49 + 0.0137561768966175*x_5 - 0.0166818223111051*x_50 - 0.0447074777067906*x_51 + 0.00221214890662636*x_52 - 0.000815530135507952*x_53 - 0.0259229252619221*x_54 - 0.0328488485799264*x_55 - 0.045968229313624*x_56 - 0.0332184641716612*x_57 - 0.00318584385097846*x_58 + 0.00360411707355853*x_59 + 0.00890605400314715*x_6 - 0.0277455542962811*x_60 + 0.000104477038133093*x_61 + 0.00396474106565337*x_62 + 0.0356185314184237*x_63 - 0.000117907391360686*x_64 - 0.00818598923929184*x_65 + 0.000663649834355269*x_66 + 0.0119660296422428*x_67 - 0.0126639053515162*x_68 + 0.0332174141013859*x_69 - 0.0166296110005082*x_7 + 0.000975525526836048*x_70 + 0.0416091392807352*x_71 - 0.0226745415918916*x_72 + 0.0083917683649727*x_73 - 0.0135445913322243*x_74 + 0.0151332916168524*x_75 - 0.0497515554013216*x_76 - 0.000393604221417748*x_77 - 0.01065898192834*x_78 + 0.0476405244391724*x_79 + 0.0378222959079502*x_8 + 0.0320006218948264*x_80 - 0.00684136800210527*x_81 + 0.00958338974462608*x_82 - 0.00566846527513275*x_83 + 0.0562645547834252*x_84 - 0.0429317344813685*x_85 - 0.0237160829123431*x_86 + 0.015160766081485*x_88 + 0.019702702636569*x_89 + 0.0967702257001106*x_9 + 0.0357563741536421*x_90 + 0.00767992201799616*x_91 - 0.00834402841255883*x_92 - 0.0347400633946702*x_93 - 0.0301382520209533*x_94 + 0.000586956023325015*x_95 + 0.00769251716314628*x_96 - 0.0226201555002666*x_97 + 0.0231409757257572*x_98 - 0.000779316617415344*x_99 + 3.50032763390906e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) + 1.5109290317937e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) - 0.000206285400912808*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) - 0.00020661082208216*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) + 4.37981373660248e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) - 2.11896643461156e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) - 5.08248628044664e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) - 2.63421470047528e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) + 3.14989052987568e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) + 3.97030701898866e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.00113822972884008*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) - 0.000101158691035945*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) - 0.000125960238614804*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.000967580552133905*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) + 0.00010815204965329*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) + 0.000174962687928531*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) - 3.38820020452016e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) + 3.14350670377951e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) + 7.00840132498272e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) + 6.3101104813763e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) - 7.33400603665601e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) + 4.98213159556956e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) - 0.00422301995320405*std::exp(0.556959867477417*x_1) - 0.000377300482143008*std::exp(1.15583980083466*x_1) - 8.88866826247865e-5*std::exp(1.25871992111206*x_1) + 0.00287225715879655*std::exp(1.35671985149384*x_100) - 0.000916483349389095*std::exp(1.49143993854523*x_100) - 0.00964258894943028*std::exp(1.58023989200592*x_100) - 0.00341013992419839*std::exp(0.715599834918976*x_104) + 0.01000415443445*std::exp(0.580799877643585*x_109) + 0.00764113724620995*std::exp(0.60999983549118*x_109) - 0.00296604306666918*std::exp(0.793439865112305*x_109) + 0.0385406700037827*std::exp(0.801999866962433*x_109) - 0.00853680062862033*std::exp(0.865199863910675*x_109) - 0.00177131017392066*std::exp(1.1865599155426*x_110) + 0.000122235540086131*std::exp(1.69735991954803*x_110) + 0.00673185725385984*std::exp(0.49823984503746*x_112) - 0.00416494036091891*std::exp(0.789599895477295*x_112) + 0.00179770072311628*std::exp(0.855839908123016*x_112) - 0.00656478184188812*std::exp(0.682959854602814*x_114) + 0.0112147761659387*std::exp(0.611999869346619*x_23) + 0.0666243144254103*std::exp(0.579439878463745*x_26) - 0.00992810150281414*std::exp(0.771439850330353*x_26) - 0.0017083566783105*std::exp(0.956879794597626*x_26) + 0.0031457977581994*std::exp(0.595679819583893*x_31) - 0.018341551604527*std::exp(0.637759864330292*x_31) + 0.00935911025768316*std::exp(0.657039821147919*x_31) - 0.00486868805075607*std::exp(0.663919866085052*x_31) + 0.00439970575646393*std::exp(0.667439818382263*x_31) - 0.00242125467399643*std::exp(0.782479882240295*x_49) - 0.00928639491581642*std::exp(0.841519832611084*x_50) - 0.0049746483343892*std::exp(0.942319810390472*x_66) + 0.00329068775180555*std::exp(1.11359989643097*x_66) - 0.00507650612599835*std::exp(1.22135984897614*x_66) - 0.0057906572939263*std::exp(1.04599988460541*x_68) + 0.0042040636755802*std::exp(1.10527992248535*x_68) + 0.00772971439938757*std::exp(0.880079865455627*x_72) - 0.0152752001096617*std::exp(0.601599872112274*x_74) + 0.0046475721690267*std::exp(1.07575976848602*x_74) - 0.00388911300198437*std::exp(1.08567976951599*x_74) - 0.00554519725222153*std::exp(0.743279814720154*x_77) - 0.0022338903727549*std::exp(0.79695987701416*x_80) + 0.00820292656399311*std::exp(0.936159789562225*x_81) + 0.0679798488504714*std::sin(0.498079836368561*x_10 - 0.920319855213165) - 0.0171740511818295*std::sin(0.265119940042496*x_100 - 7.51448011398315) + 0.109662173999465*std::sin(0.124000057578087*x_102 + 1.72023987770081) - 0.02280409904071*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.288031285723275*std::sin(0.360079854726791*x_102 - 4.23984003067017) + 0.0524044789881771*std::sin(0.375039845705032*x_102 + 1.98391973972321) - 0.0122168719702477*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 2.07787083384667*std::sin(0.135920032858849*x_103 - 1.44095981121063) + 0.0259775663141177*std::sin(0.323599934577942*x_105 + 1.91183984279633) - 0.0357345082559967*std::sin(0.437919855117798*x_105 - 4.17088031768799) + 0.21201825805045*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.150480899326449*std::sin(0.596959829330444*x_110 - 7.18480014801025) - 0.0243158905625806*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.449325058522901*std::sin(0.32847985625267*x_111 - 7.46783971786499) + 0.0517313318820441*std::sin(0.399279862642288*x_111 + 2.00383973121643) + 0.0343919403341379*std::sin(0.441359847784042*x_111 + 8.42160034179688) - 0.0341940884250377*std::sin(0.445599853992462*x_112 + 5.21031999588013) + 0.182805572044099*std::sin(0.193120002746582*x_114 + 4.97639989852905) - 0.011868329001927*std::sin(0.422959864139557*x_115 + 8.4026403427124) - 0.0263842980419039*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.2593175240966*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.151198147620006*std::sin(0.417359858751297*x_117 + 5.20456027984619) - 0.0586802277385502*std::sin(0.314319849014282*x_120 + 5.11375999450684) + 0.0236510885682836*std::sin(0.584559857845306*x_120 - 4.00031995773315) - 0.0495214721044861*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.253925178413683*std::sin(0.301679849624634*x_24 + 5.10272026062012) - 0.0530388712899471*std::sin(0.385919839143753*x_24 + 5.174720287323) + 0.0323153806744965*std::sin(0.278719931840897*x_28 - 4.29207992553711) - 0.0497328954018197*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.333761087592991*std::sin(0.343599855899811*x_28 - 4.2596001625061) + 0.021771644672656*std::sin(0.3643998503685*x_28 - 4.23311996459961) + 0.0759724972448184*std::sin(0.285519927740097*x_3 - 7.52663993835449) + 0.0356850967778687*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.18100657138497*std::sin(0.321119844913483*x_35 - 7.4300799369812) + 0.0624627909965268*std::sin(0.322399854660034*x_35 + 1.97791981697083) - 0.070417794911486*std::sin(0.300879925489426*x_36 + 5.09055995941162) + 0.0333312263402193*std::sin(0.395119845867157*x_36 + 5.20344018936157) + 0.0443020832900219*std::sin(0.413039863109589*x_36 + 5.20256042480469) + 0.0377720672880326*std::sin(0.566959857940674*x_38 + 2.16863989830017) - 0.0294268569279057*std::sin(0.50903981924057*x_4 + 8.50519943237305) - 0.0465621585234419*std::sin(0.389039844274521*x_41 - 7.40383958816528) - 0.0543061741963421*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.183580101316081*std::sin(0.431999862194061*x_43 + 8.21175956726074) - 0.0480696181524089*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.178337741432976*std::sin(0.459439843893051*x_46 - 4.13912010192871) + 0.0246053722173149*std::sin(0.58383983373642*x_46 + 2.18727993965149) + 0.139659013087377*std::sin(0.157680034637451*x_49 + 1.74911987781525) + 0.0757231334453207*std::sin(0.21815998852253*x_53 + 5.01399946212769) + 0.068678697282972*std::sin(0.266399949789047*x_53 + 5.08383941650391) + 0.0466213251130743*std::sin(0.284799933433533*x_53 + 8.30632019042969) + 0.0460899489406998*std::sin(0.303599923849106*x_55 + 5.13560009002686) - 0.260505345168892*std::sin(0.133360043168068*x_56 + 1.70503997802734) - 0.0123199238064713*std::sin(0.808799862861633*x_57 + 2.41383981704712) + 0.0453949973797698*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.0980575151790401*std::sin(0.497999846935272*x_58 - 0.917919814586639) - 0.413279378357903*std::sin(0.1112000644207*x_59 + 1.70367991924286) + 0.123639062991097*std::sin(0.264479964971542*x_63 + 1.86495995521545) - 0.0502285221703372*std::sin(0.281199932098389*x_64 - 7.49600028991699) + 0.0530530925120195*std::sin(0.387279838323593*x_64 + 5.17727994918823) - 0.0618301452540687*std::sin(0.173920020461082*x_67 - 4.43959999084473) + 0.096318727850631*std::sin(0.242239981889725*x_70 + 5.05904006958008) - 0.0116389431751116*std::sin(0.56855982542038*x_70 + 5.37879991531372) + 0.0466946200861085*std::sin(0.276239961385727*x_71 - 4.30703973770142) - 0.0774334854856164*std::sin(0.217999994754791*x_73 - 4.382080078125) - 0.107430958209132*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0984545628187762*std::sin(0.511119842529297*x_73 + 8.51000022888184) - 0.0808501129467985*std::sin(0.261919975280762*x_75 - 4.32567977905273) - 0.0203758577101869*std::sin(0.473759859800339*x_75 + 5.26640033721924) + 0.0114358904461415*std::sin(0.348879843950272*x_76 + 8.32695960998535) + 0.0655278814937252*std::sin(0.282159954309464*x_78 + 5.10751962661743) + 0.0462857698456908*std::sin(0.341039836406708*x_79 - 4.25072002410889) - 0.0471455958783293*std::sin(0.404719859361649*x_80 + 5.20512008666992) - 0.024870821092747*std::sin(0.363439828157425*x_81 + 5.15120029449463) - 0.0764723372130316*std::sin(0.262559950351715*x_84 + 1.8562399148941) + 0.0374847991641615*std::sin(0.286319941282272*x_84 - 7.49336004257202) - 0.159901925800199*std::sin(0.166400015354156*x_85 + 4.94312000274658) - 0.426374874929626*std::sin(0.118160054087639*x_86 + 4.88919973373413) + 0.0630313538077365*std::sin(0.25095996260643*x_86 + 5.07471990585327) + 0.0129158487380791*std::sin(0.346959829330444*x_86 - 7.45160007476807) + 0.0602125376608775*std::sin(0.290559947490692*x_87 + 5.0991997718811) - 0.0428612722558486*std::sin(0.347999840974808*x_87 + 5.15296030044556) + 0.0144305102574121*std::sin(0.453119844198227*x_87 + 5.2597599029541) - 0.014394067215213*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.0455573767500163*std::sin(0.983599841594696*x_87 - 7.00167989730835) - 0.0272962799984177*std::sin(0.332959830760956*x_92 + 8.3908805847168) - 0.0507606777463604*std::sin(0.352719843387604*x_92 + 2.00847983360291) + 0.0251610127693462*std::sin(0.371759831905365*x_92 - 1.19367980957031) + 0.0559116604321598*std::sin(0.372879832983017*x_95 - 7.40407991409302) + 0.0245236462245161*std::sin(0.378959834575653*x_95 + 1.9592798948288) - 0.0185988636342878*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.104654265375306*std::sin(0.420239865779877*x_95 + 1.98823988437653) - 0.0353413237005164*std::sin(0.404959857463837*x_97 + 5.19767999649048) - 0.0393038461779371*std::sin(0.36303985118866*x_98 - 4.22512006759644) - 0.0334180666356291*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 2.44843414111801);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0142676032337983*x_1 - 0.00549489359807654*x_10 + 0.00106428310635686*x_100 - 0.0442718176604116*x_101 - 0.00643077694757308*x_103 - 0.0131427621558886*x_104 + 0.0108965045871488*x_105 - 0.0198513577776274*x_106 + 0.0354975536183664*x_107 + 0.00933758114569776*x_108 + 0.00545350348641178*x_11 - 0.000859175503160073*x_110 + 0.00367875864318431*x_111 + 0.00455473102130075*x_112 + 0.00687586482366351*x_113 + 0.0207086697874742*x_114 - 0.00639663022856165*x_116 - 0.00388704759251102*x_117 + 0.0435386961863406*x_118 - 0.012340240756213*x_119 + 0.0741759121867534*x_12 - 0.0126353315819833*x_120 - 0.00971130322825343*x_13 + 0.0201432384059804*x_14 + 0.0119558218685448*x_15 + 0.00134640023170866*x_16 - 0.00551792764965178*x_17 - 0.0274896611156124*x_18 - 0.00175459947277956*x_19 + 0.0167275899053829*x_2 - 0.0022838007680759*x_20 + 0.0670076798421563*x_21 - 0.00891412015607579*x_22 - 0.0151254698887969*x_23 - 0.00180832832380656*x_24 + 0.054781079906031*x_25 + 0.00620689412389842*x_26 - 0.0078693567479622*x_27 - 0.00196118709014931*x_28 - 0.00341216640864978*x_29 + 0.0281134504937613*x_3 - 0.00368818679748509*x_30 + 0.0500339762303269*x_32 - 0.0319147527775237*x_33 - 0.0114368172479188*x_34 - 0.000938358876262597*x_35 + 0.00472951081233169*x_36 + 0.0313401700766236*x_37 + 0.00424501213503922*x_38 - 0.0235536737125122*x_39 + 0.0144167956206769*x_4 - 0.000176042693950376*x_40 + 0.0193967460315092*x_41 + 0.0119113441271191*x_42 + 0.000468554944724647*x_43 + 0.042712633684668*x_44 + 0.0268482690708661*x_45 - 0.000718188543522308*x_46 + 0.00230147304125823*x_47 - 0.0300567785180175*x_48 + 0.0209190681997419*x_49 - 0.0174208979488687*x_5 + 0.00485175289451551*x_50 + 0.03005997757619*x_51 + 0.00018359857606252*x_52 + 0.00203565239568345*x_53 + 0.00345821193478774*x_54 + 0.0259375970112172*x_55 + 0.0247207201325726*x_56 + 0.0424728524417923*x_57 + 0.0180755372234542*x_58 + 0.00104672621850505*x_59 + 0.00168443216000221*x_6 + 0.0179425909060012*x_60 + 0.0294057601065569*x_61 - 0.00438730834554502*x_62 - 0.0316392054365197*x_63 + 0.002488574325234*x_64 - 0.00549076128761663*x_65 - 0.000949394321207377*x_66 - 0.00597909435676542*x_67 - 0.00123943131289749*x_68 - 0.0109257445383105*x_69 + 0.0147853028506384*x_7 + 0.000486562182703471*x_70 - 0.0231750658257429*x_71 + 0.00972819690975139*x_72 + 0.00791676358856819*x_73 + 0.0054764188482075*x_74 + 0.00694017390684612*x_75 + 0.0415550764210416*x_76 - 0.00448110295423924*x_77 + 0.00010296082829016*x_78 - 0.0102130245369236*x_79 - 0.055980314862598*x_8 - 0.0277427632258925*x_80 + 0.00345724769930794*x_81 - 0.014720134489244*x_82 + 0.0185652039948541*x_83 - 0.0317406894548147*x_84 + 0.026542152352193*x_85 + 0.015884079922234*x_86 - 0.0126043176252462*x_88 - 0.0195631946917761*x_89 - 0.055349485247893*x_9 - 0.0256184984912641*x_90 - 0.0166116143114637*x_91 + 0.00506572313646847*x_92 + 0.0490966284100823*x_93 + 0.0204222480069209*x_94 + 0.00029275564401296*x_95 - 0.00426710840951883*x_96 + 0.0280607562950008*x_97 - 0.00831759372103852*x_98 + 0.00470447018878394*x_99 + 5.64035270563714e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) + 2.43467856264244e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) + 0.000193656652182284*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) + 0.000193962151136291*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) + 7.05753770593302e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) - 3.4144569630667e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) - 8.18980913831383e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) - 1.3138654182939e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) + 5.07566588925392e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) + 1.98026724675007e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) - 0.000717112618938841*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) + 9.49657773089014e-5*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) + 0.000118248979376562*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) - 0.00060959945623817*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) + 4.91725509084159e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) + 7.95487621993231e-5*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) - 1.68993023923683e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) + 5.06537912911037e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) + 3.1864488194546e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) + 3.14728937834807e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) - 3.65797704620754e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) + 2.26518240108192e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) + 0.0039644875624628*std::exp(0.556959867477417*x_1) - 0.000171543925662277*std::exp(1.15583980083466*x_1) + 5.60007880226451e-5*std::exp(1.25871992111206*x_1) - 0.0026964181814022*std::exp(1.35671985149384*x_100) - 0.000457113757275457*std::exp(1.49143993854523*x_100) + 0.0060750673081815*std::exp(1.58023989200592*x_100) - 0.0015504586326845*std::exp(0.715599834918976*x_104) + 0.016120479404651*std::exp(0.580799877643585*x_109) - 0.00717334843580051*std::exp(0.60999983549118*x_109) - 0.0014793712197278*std::exp(0.793439865112305*x_109) - 0.0242815664551609*std::exp(0.801999866962433*x_109) - 0.00388135282550384*std::exp(0.865199863910675*x_109) - 0.00285425113786807*std::exp(1.1865599155426*x_110) + 6.09673345823592e-5*std::exp(1.69735991954803*x_110) + 0.00335764372021065*std::exp(0.49823984503746*x_112) + 0.00262401447991196*std::exp(0.789599895477295*x_112) + 0.000817344938065553*std::exp(0.855839908123016*x_112) - 0.00327431163418241*std::exp(0.682959854602814*x_114) - 0.0105282099346784*std::exp(0.611999869346619*x_23) - 0.0419749505675786*std::exp(0.579439878463745*x_26) - 0.00451392348213529*std::exp(0.771439850330353*x_26) + 0.00160377144282108*std::exp(0.956879794597626*x_26) + 0.00156902734112711*std::exp(0.595679819583893*x_31) + 0.0115556269294845*std::exp(0.637759864330292*x_31) - 0.00878614750189652*std::exp(0.657039821147919*x_31) - 0.00221360401213363*std::exp(0.663919866085052*x_31) + 0.00708959127913548*std::exp(0.667439818382263*x_31) - 0.00110085078462225*std::exp(0.782479882240295*x_49) + 0.00871788377792046*std::exp(0.841519832611084*x_50) - 0.00248120186010201*std::exp(0.942319810390472*x_66) + 0.00530254350607045*std::exp(1.11359989643097*x_66) + 0.00319832324778895*std::exp(1.22135984897614*x_66) - 0.00288820207643227*std::exp(1.04599988460541*x_68) - 0.00394669178415649*std::exp(1.10527992248535*x_68) - 0.00725650291434485*std::exp(0.880079865455627*x_72) + 0.0143400555810631*std::exp(0.601599872112274*x_74) + 0.00211307117909115*std::exp(1.07575976848602*x_74) - 0.00193977016384523*std::exp(1.08567976951599*x_74) + 0.0052057214461314*std::exp(0.743279814720154*x_77) - 0.00111419593417833*std::exp(0.79695987701416*x_80) - 0.0077007451300515*std::exp(0.936159789562225*x_81) - 0.0428289704697014*std::sin(0.498079836368561*x_10 - 0.920319855213165) - 0.0276738968980467*std::sin(0.265119940042496*x_100 - 7.51448011398315) + 0.176707269865813*std::sin(0.124000057578087*x_102 + 1.72023987770081) - 0.0113739844818011*std::sin(0.354159861803055*x_102 - 7.43056011199951) + 0.181466767567059*std::sin(0.360079854726791*x_102 - 4.23984003067017) - 0.0491962878385985*std::sin(0.375039845705032*x_102 + 1.98391973972321) - 0.00555453882588831*std::sin(0.376559853553772*x_102 + 5.18311977386475) + 1.30910953889324*std::sin(0.135920032858849*x_103 - 1.44095981121063) + 0.0418596919403428*std::sin(0.323599934577942*x_105 + 1.91183984279633) - 0.0178232756156212*std::sin(0.437919855117798*x_105 - 4.17088031768799) + 0.0963964956828929*std::sin(0.136000037193298*x_108 + 4.91215991973877) - 0.0948066537729864*std::sin(0.596959829330444*x_110 - 7.18480014801025) - 0.0391821033539831*std::sin(0.290879935026169*x_111 + 5.09975957870483) + 0.283085796573387*std::sin(0.32847985625267*x_111 - 7.46783971786499) - 0.048564350656311*std::sin(0.399279862642288*x_111 + 2.00383973121643) + 0.0156366841159367*std::sin(0.441359847784042*x_111 + 8.42160034179688) + 0.0321007335444776*std::sin(0.445599853992462*x_112 + 5.21031999588013) + 0.0831146180446621*std::sin(0.193120002746582*x_114 + 4.97639989852905) - 0.00591955813083613*std::sin(0.422959864139557*x_115 + 8.4026403427124) - 0.0119959191046997*std::sin(0.432879865169525*x_115 - 4.18359994888306) + 0.163376394175851*std::sin(0.442319840192795*x_115 - 7.35264015197754) + 0.0952585377724899*std::sin(0.417359858751297*x_117 + 5.20456027984619) - 0.0292678960258559*std::sin(0.314319849014282*x_120 + 5.11375999450684) - 0.0222031739150383*std::sin(0.584559857845306*x_120 - 4.00031995773315) - 0.0225154966172521*std::sin(0.461839854717255*x_2 - 4.12639999389648) + 0.159979084268262*std::sin(0.301679849624634*x_24 + 5.10272026062012) - 0.0241147218845195*std::sin(0.385919839143753*x_24 + 5.174720287323) + 0.0146925528127814*std::sin(0.278719931840897*x_28 - 4.29207992553711) - 0.0248052413526844*std::sin(0.313039928674698*x_28 - 4.25007963180542) - 0.210277663251328*std::sin(0.343599855899811*x_28 - 4.2596001625061) + 0.0350823602185052*std::sin(0.3643998503685*x_28 - 4.23311996459961) + 0.0345417539509078*std::sin(0.285519927740097*x_3 - 7.52663993835449) - 0.0335004626804581*std::sin(0.309999942779541*x_35 - 1.13671982288361) - 0.114038575133063*std::sin(0.321119844913483*x_35 - 7.4300799369812) + 0.0283994134184679*std::sin(0.322399854660034*x_35 + 1.97791981697083) - 0.0351222341709735*std::sin(0.300879925489426*x_36 + 5.09055995941162) + 0.0537092216308641*std::sin(0.395119845867157*x_36 + 5.20344018936157) + 0.0201424425418756*std::sin(0.413039863109589*x_36 + 5.20256042480469) + 0.0171734970126883*std::sin(0.566959857940674*x_38 + 2.16863989830017) - 0.0133792528666893*std::sin(0.50903981924057*x_4 + 8.50519943237305) - 0.0211700112733834*std::sin(0.389039844274521*x_41 - 7.40383958816528) - 0.0246909154645845*std::sin(0.39047983288765*x_43 + 8.19287967681885) - 0.115659962048249*std::sin(0.431999862194061*x_43 + 8.21175956726074) + 0.0451268062688108*std::sin(0.40871986746788*x_45 + 5.21023988723755) - 0.112357146869608*std::sin(0.459439843893051*x_46 - 4.13912010192871) - 0.0230990365203702*std::sin(0.58383983373642*x_46 + 2.18727993965149) + 0.22504353155487*std::sin(0.157680034637451*x_49 + 1.74911987781525) + 0.122018629476309*std::sin(0.21815998852253*x_53 + 5.01399946212769) + 0.0312255454177412*std::sin(0.266399949789047*x_53 + 5.08383941650391) + 0.0232532856224869*std::sin(0.284799933433533*x_53 + 8.30632019042969) + 0.0742683529655862*std::sin(0.303599923849106*x_55 + 5.13560009002686) - 0.419772713337516*std::sin(0.133360043168068*x_56 + 1.70503997802734) - 0.00614479975471167*std::sin(0.808799862861633*x_57 + 2.41383981704712) + 0.0226416309991971*std::sin(0.411359876394272*x_58 + 5.20424032211304) - 0.0617786372425316*std::sin(0.497999846935272*x_58 - 0.917919814586639) + 0.387978501991013*std::sin(0.1112000644207*x_59 + 1.70367991924286) - 0.116069905634916*std::sin(0.264479964971542*x_63 + 1.86495995521545) - 0.0809371609043431*std::sin(0.281199932098389*x_64 - 7.49600028991699) - 0.0498051933793283*std::sin(0.387279838323593*x_64 + 5.17727994918823) - 0.0308389781754511*std::sin(0.173920020461082*x_67 - 4.43959999084473) + 0.0437923974982652*std::sin(0.242239981889725*x_70 + 5.05904006958008) - 0.0187547428396537*std::sin(0.56855982542038*x_70 + 5.37879991531372) + 0.0752427070511831*std::sin(0.276239961385727*x_71 - 4.30703973770142) + 0.0726930238378244*std::sin(0.217999994754791*x_73 - 4.382080078125) - 0.048844698538894*std::sin(0.241199985146523*x_73 - 7.54744052886963) - 0.0620287869843283*std::sin(0.511119842529297*x_73 + 8.51000022888184) - 0.0367594170205046*std::sin(0.261919975280762*x_75 - 4.32567977905273) - 0.0101628522567509*std::sin(0.473759859800339*x_75 + 5.26640033721924) + 0.0184275480370475*std::sin(0.348879843950272*x_76 + 8.32695960998535) + 0.0297929914319734*std::sin(0.282159954309464*x_78 + 5.10751962661743) + 0.023085920957161*std::sin(0.341039836406708*x_79 - 4.25072002410889) - 0.0214352776564713*std::sin(0.404719859361649*x_80 + 5.20512008666992) - 0.0400763064814113*std::sin(0.363439828157425*x_81 + 5.15120029449463) + 0.0717907168597449*std::sin(0.262559950351715*x_84 + 1.8562399148941) + 0.0604021995934498*std::sin(0.286319941282272*x_84 - 7.49336004257202) + 0.150112763632047*std::sin(0.166400015354156*x_85 + 4.94312000274658) - 0.193856152618081*std::sin(0.118160054087639*x_86 + 4.88919973373413) - 0.0591725876233125*std::sin(0.25095996260643*x_86 + 5.07471990585327) + 0.00644202881481731*std::sin(0.346959829330444*x_86 - 7.45160007476807) + 0.0970251888476882*std::sin(0.290559947490692*x_87 + 5.0991997718811) + 0.0402373142094016*std::sin(0.347999840974808*x_87 + 5.15296030044556) + 0.00719749547830265*std::sin(0.453119844198227*x_87 + 5.2597599029541) - 0.00654442523454928*std::sin(0.792079865932465*x_87 - 0.782159864902496) + 0.0287022636339678*std::sin(0.983599841594696*x_87 - 7.00167989730835) - 0.043984638823928*std::sin(0.332959830760956*x_92 + 8.3908805847168) - 0.0230789154586555*std::sin(0.352719843387604*x_92 + 2.00847983360291) + 0.0125495406888932*std::sin(0.371759831905365*x_92 - 1.19367980957031) - 0.0524887603743772*std::sin(0.372879832983017*x_95 - 7.40407991409302) + 0.0395168763616746*std::sin(0.378959834575653*x_95 + 1.9592798948288) - 0.00845618341795225*std::sin(0.405119866132736*x_95 - 0.992079794406891) - 0.0659347515047646*std::sin(0.420239865779877*x_95 + 1.98823988437653) + 0.0331777353183866*std::sin(0.404959857463837*x_97 + 5.19767999649048) - 0.0633333728489008*std::sin(0.36303985118866*x_98 - 4.22512006759644) - 0.0166679056535796*std::sin(0.432399868965149*x_98 + 2.00271987915039) + 1.95962832405866);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0126434811362767*x_1 + 0.00226231548108736*x_10 - 0.00138452932148736*x_100 + 0.0433410837609354*x_101 - 0.00476186818975894*x_103 + 0.0133411847087527*x_104 - 0.0167795142938962*x_105 + 0.0200212559239366*x_106 - 0.0214972173386879*x_107 - 0.0152184523380678*x_108 - 0.00715029192077166*x_11 + 0.00314496154412885*x_110 - 0.00512019463266021*x_111 - 0.000502292128600147*x_112 + 0.0058700805274183*x_113 - 0.0141399489025093*x_114 + 0.0142409266138713*x_116 - 0.00267472361514663*x_117 - 0.0361794235926107*x_118 + 0.0141721567189686*x_119 - 0.075339342024462*x_12 + 0.00308925062101166*x_120 + 0.00553824662238727*x_13 - 0.0178829060453126*x_14 - 0.00718382781432102*x_15 - 0.0116490941142744*x_16 + 0.00785170211929745*x_17 + 0.0291571575350355*x_18 - 0.00974642688577464*x_19 - 0.0217597752502191*x_2 - 0.00417190630293441*x_20 - 0.0502419714272593*x_21 + 0.0108254486141006*x_22 + 0.0128142565271852*x_23 + 0.00144328889431715*x_24 - 0.0232549741890227*x_25 - 0.00352967690069489*x_26 + 0.0111455885820772*x_27 - 0.000828864510418815*x_28 + 0.0029922115389287*x_29 - 0.0269930940332115*x_3 + 0.0127350141856067*x_30 - 0.0377039914828406*x_32 + 0.00659581985024828*x_33 - 2.01459889855688e-5*x_34 + 0.00132544155042574*x_35 - 0.00240463552421023*x_36 - 0.0267575992788815*x_37 - 0.00107414342564348*x_38 + 0.0141182627025331*x_39 - 0.0103620112018545*x_4 - 0.00896596108105373*x_40 - 0.00349635212509888*x_41 - 0.00658032787479773*x_42 - 0.00272952567434257*x_43 - 0.0359758240463809*x_44 - 0.0163242055908547*x_45 - 0.00250981100441402*x_46 - 0.00320577309507861*x_47 + 0.0169942053631567*x_48 - 0.0119960605184293*x_49 + 0.0250665704145627*x_5 - 0.00294979480495946*x_50 - 0.0235384703587388*x_51 + 0.00138258898528623*x_52 + 0.00407838336851318*x_53 + 0.010057826278614*x_54 - 0.0284349024758706*x_55 - 0.0175791517745004*x_56 - 0.0212420363052827*x_57 + 0.000551551668743957*x_58 - 0.00234346605983375*x_59 - 0.000156691918075343*x_6 - 0.010716202125521*x_60 - 0.00994690085824476*x_61 + 0.00154991924393548*x_62 + 0.0281695236603768*x_63 - 0.00267195395877636*x_64 - 0.0128215335980528*x_65 - 0.000217704957671875*x_66 + 0.00597717301821547*x_67 - 0.00418640331126397*x_68 + 0.016871152342612*x_69 - 0.00318539179783922*x_7 - 0.000677210254320272*x_70 + 0.012941739482932*x_71 - 0.0092888303158521*x_72 - 0.00409345675291849*x_73 - 0.00604355049295274*x_74 + 0.00195601714484541*x_75 - 0.0302403433877442*x_76 + 0.00292946532055576*x_77 + 0.00761057145877299*x_78 + 0.0136367309342932*x_79 + 0.0314169311130517*x_8 + 0.0113990097574216*x_80 - 0.00261598194402048*x_81 + 0.0217627896477032*x_82 - 5.62504582416327e-5*x_83 + 0.0252501711046876*x_84 - 0.022509128196091*x_85 - 0.0125304781602365*x_86 + 0.0073041160450672*x_88 + 0.0134014427501971*x_89 + 0.0374758515664577*x_9 + 0.00798371609758513*x_90 + 0.0250645534276069*x_91 - 0.00487130239877886*x_92 - 0.0235454707094812*x_93 - 0.015999465506826*x_94 - 0.000407465132275882*x_95 - 0.00251341090051995*x_96 - 0.0148085236483543*x_97 + 0.00591074678679376*x_98 + 0.00193220103688099*x_99 - 6.22013627878511e-6*std::pow(-8.0*x_114 - 9.99962043762207, 2) - 2.68494423044453e-6*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) + 8.18459019063782e-5*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) + 8.19750161771272e-5*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) - 7.78299666963982e-6*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) + 3.7654360882601e-6*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) + 9.03165663499004e-6*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) + 1.82867301589626e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) - 5.59740413133864e-6*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) - 2.75618889725964e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.000587388894975869*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) + 4.0135774353732e-5*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) + 4.99760491443052e-5*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.000499324571233306*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 6.39687298787244e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 0.000103485240999455*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) + 2.35209008792727e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) - 5.58605997374791e-6*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 4.1452615338934e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) - 4.38048150081884e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) + 5.09127025038367e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 2.94678308251138e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) + 0.00167552757155466*std::exp(0.556959867477417*x_1) + 0.000223162045496974*std::exp(1.15583980083466*x_1) - 4.58703976553574e-5*std::exp(1.25871992111206*x_1) - 0.00113959822958154*std::exp(1.35671985149384*x_100) + 0.00063622314849419*std::exp(1.49143993854523*x_100) - 0.00497610414154641*std::exp(1.58023989200592*x_100) + 0.00201699662982821*std::exp(0.715599834918976*x_104) - 0.00177775369749596*std::exp(0.580799877643585*x_109) - 0.00303170154911162*std::exp(0.60999983549118*x_109) + 0.00205902841519543*std::exp(0.793439865112305*x_109) + 0.019889097070256*std::exp(0.801999866962433*x_109) + 0.00504926439389144*std::exp(0.865199863910675*x_109) + 0.00031476455423919*std::exp(1.1865599155426*x_110) - 8.48559662576794e-5*std::exp(1.69735991954803*x_110) - 0.00467325829773021*std::exp(0.49823984503746*x_112) - 0.00214933739143645*std::exp(0.789599895477295*x_112) - 0.00106328666288308*std::exp(0.855839908123016*x_112) + 0.00455727447247962*std::exp(0.682959854602814*x_114) - 0.00444958036738321*std::exp(0.611999869346619*x_23) + 0.0343817960797305*std::exp(0.579439878463745*x_26) + 0.00587217759883438*std::exp(0.771439850330353*x_26) + 0.000677808475516921*std::exp(0.956879794597626*x_26) - 0.00218381420195107*std::exp(0.595679819583893*x_31) - 0.00946524542115494*std::exp(0.637759864330292*x_31) - 0.00371332540592674*std::exp(0.657039821147919*x_31) + 0.00287968459017654*std::exp(0.663919866085052*x_31) - 0.000781834509622706*std::exp(0.667439818382263*x_31) + 0.00143210033194007*std::exp(0.782479882240295*x_49) + 0.00368447482943815*std::exp(0.841519832611084*x_50) + 0.0034534030848091*std::exp(0.942319810390472*x_66) - 0.000584760296975426*std::exp(1.11359989643097*x_66) - 0.00261975526392823*std::exp(1.22135984897614*x_66) + 0.0040198768672103*std::exp(1.04599988460541*x_68) - 0.00166800646908184*std::exp(1.10527992248535*x_68) - 0.00306684546602499*std::exp(0.880079865455627*x_72) + 0.0060605962624767*std::exp(0.601599872112274*x_74) - 0.00274890110382019*std::exp(1.07575976848602*x_74) + 0.00269982397456705*std::exp(1.08567976951599*x_74) + 0.00220011531765485*std::exp(0.743279814720154*x_77) + 0.00155076768966109*std::exp(0.79695987701416*x_80) - 0.00325459736816556*std::exp(0.936159789562225*x_81) + 0.0350813261024174*std::sin(0.498079836368561*x_10 - 0.920319855213165) + 0.00305185542561658*std::sin(0.265119940042496*x_100 - 7.51448011398315) - 0.0194871377266691*std::sin(0.124000057578087*x_102 + 1.72023987770081) + 0.0158306156897721*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.148639922462651*std::sin(0.360079854726791*x_102 - 4.23984003067017) - 0.0207920280724766*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.00722591745170828*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 1.07229518090303*std::sin(0.135920032858849*x_103 - 1.44095981121063) - 0.00461625366436163*std::sin(0.323599934577942*x_105 + 1.91183984279633) + 0.024806911514188*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.125402511760667*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.077656387749082*std::sin(0.596959829330444*x_110 - 7.18480014801025) + 0.00432097131634408*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.231876345278463*std::sin(0.32847985625267*x_111 - 7.46783971786499) - 0.020524949879966*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.0203418127376446*std::sin(0.441359847784042*x_111 + 8.42160034179688) + 0.0135668641340091*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.108124074355524*std::sin(0.193120002746582*x_114 + 4.97639989852905) + 0.00823899926824003*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.0156055298063503*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.133822048456073*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.0780265271611013*std::sin(0.417359858751297*x_117 + 5.20456027984619) + 0.0407358401776336*std::sin(0.314319849014282*x_120 + 5.11375999450684) - 0.00938381808103324*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.0292904820796642*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.131039302678343*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.0313709193815157*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.0191135892839931*std::sin(0.278719931840897*x_28 - 4.29207992553711) + 0.034524598092665*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.172239005413234*std::sin(0.343599855899811*x_28 - 4.2596001625061) - 0.00386885489133399*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.0449354789857935*std::sin(0.285519927740097*x_3 - 7.52663993835449) - 0.014158437375971*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.0934093067991953*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.0369448884005175*std::sin(0.322399854660034*x_35 + 1.97791981697083) + 0.0488840645260684*std::sin(0.300879925489426*x_36 + 5.09055995941162) - 0.00592301041099007*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0262033683885707*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.02234105758564*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.017405113153524*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.0275401358615471*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.032120491465943*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.0947373892276549*std::sin(0.431999862194061*x_43 + 8.21175956726074) + 0.019072126454756*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.0920320443392017*std::sin(0.459439843893051*x_46 - 4.13912010192871) - 0.00976244015309392*std::sin(0.58383983373642*x_46 + 2.18727993965149) - 0.0248176223719373*std::sin(0.157680034637451*x_49 + 1.74911987781525) - 0.0134561177909085*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.0406214126223308*std::sin(0.266399949789047*x_53 + 5.08383941650391) - 0.032364544615222*std::sin(0.284799933433533*x_53 + 8.30632019042969) - 0.00819025512686759*std::sin(0.303599923849106*x_55 + 5.13560009002686) + 0.0462922022671595*std::sin(0.133360043168068*x_56 + 1.70503997802734) + 0.00855249658227446*std::sin(0.808799862861633*x_57 + 2.41383981704712) - 0.0315132273576975*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.0506030496530707*std::sin(0.497999846935272*x_58 - 0.917919814586639) + 0.163972939002635*std::sin(0.1112000644207*x_59 + 1.70367991924286) - 0.0490550983084017*std::sin(0.264479964971542*x_63 + 1.86495995521545) + 0.00892568598307371*std::sin(0.281199932098389*x_64 - 7.49600028991699) - 0.0210493723082424*std::sin(0.387279838323593*x_64 + 5.17727994918823) + 0.0429225143169467*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.0569696709761055*std::sin(0.242239981889725*x_70 + 5.05904006958008) + 0.00206825818214568*std::sin(0.56855982542038*x_70 + 5.37879991531372) - 0.00829770612350733*std::sin(0.276239961385727*x_71 - 4.30703973770142) + 0.030722549580731*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.0635422256750863*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0508079479863756*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.0478204440168995*std::sin(0.261919975280762*x_75 - 4.32567977905273) + 0.0141449294788453*std::sin(0.473759859800339*x_75 + 5.26640033721924) - 0.00203217539853027*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.0387577985274886*std::sin(0.282159954309464*x_78 + 5.10751962661743) - 0.0321316019994605*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.0278852217538218*std::sin(0.404719859361649*x_80 + 5.20512008666992) + 0.00441958332881558*std::sin(0.363439828157425*x_81 + 5.15120029449463) + 0.0303412038970938*std::sin(0.262559950351715*x_84 + 1.8562399148941) - 0.00666110671827562*std::sin(0.286319941282272*x_84 - 7.49336004257202) + 0.0634427704324831*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.252188093419257*std::sin(0.118160054087639*x_86 + 4.88919973373413) - 0.025008352398892*std::sin(0.25095996260643*x_86 + 5.07471990585327) - 0.0089661879346667*std::sin(0.346959829330444*x_86 - 7.45160007476807) - 0.0106998609591261*std::sin(0.290559947490692*x_87 + 5.0991997718811) + 0.017005660454457*std::sin(0.347999840974808*x_87 + 5.15296030044556) - 0.0100176666346075*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.00851366386950529*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.0235101021429666*std::sin(0.983599841594696*x_87 - 7.00167989730835) + 0.00485059112322071*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.0300234354654149*std::sin(0.352719843387604*x_92 + 2.00847983360291) - 0.017466786247766*std::sin(0.371759831905365*x_92 - 1.19367980957031) - 0.0221835391884445*std::sin(0.372879832983017*x_95 - 7.40407991409302) - 0.00435788981841255*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.0110006762487353*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.0540073341397933*std::sin(0.420239865779877*x_95 + 1.98823988437653) + 0.0140220417927521*std::sin(0.404959857463837*x_97 + 5.19767999649048) + 0.00698435418270127*std::sin(0.36303985118866*x_98 - 4.22512006759644) + 0.0231988367117427*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 1.69078049749232);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00878661063634735*x_1 - 0.00228132165897183*x_10 - 0.00493780331988446*x_100 + 0.0192878712832508*x_101 - 0.0160328436593433*x_103 + 0.00748566658965532*x_104 + 0.00395343774321294*x_105 + 0.0107724156557996*x_106 - 0.00166016375056027*x_107 + 0.00199345584318594*x_108 - 0.000571504962831138*x_11 + 0.0097748538637197*x_110 - 0.00542091590142609*x_111 - 0.00451389092123417*x_112 + 0.02330070710041*x_113 - 0.000708470181265738*x_114 + 0.0102662623171349*x_116 + 0.00601703750745851*x_117 - 0.017438965254871*x_118 + 0.00348491771371439*x_119 + 0.0347139663768359*x_12 - 0.0174544716494368*x_120 + 0.0252739029242544*x_13 - 0.00313755390810154*x_14 + 0.00280152997407594*x_15 + 0.00832504637582356*x_16 - 0.000570685715059875*x_17 + 0.0184593076770187*x_18 - 0.0171017690576333*x_19 - 0.0115933817766276*x_2 + 0.0149214734502172*x_20 - 0.0223002036946978*x_21 + 0.0056894544736341*x_22 + 0.00694698177996507*x_23 + 0.00162604097101715*x_24 - 0.0157782848169503*x_25 - 0.00722253197676587*x_26 - 0.0143073129835568*x_27 - 0.000552769503797336*x_28 - 0.00194868571357102*x_29 + 0.00647812040206819*x_3 - 0.0272220567331681*x_30 + 0.054511969150106*x_32 + 0.0199413806552753*x_33 + 0.00660235236031389*x_34 + 0.00139004728347478*x_35 + 7.39921779238411e-5*x_36 + 0.00855155183591947*x_37 + 0.00196453682033334*x_38 + 0.0256167820442341*x_39 + 0.00870507165138741*x_4 + 0.0036794712448171*x_40 + 0.0118323991810999*x_41 - 0.0384243308660291*x_42 - 0.00121446509695769*x_43 + 0.00314937222819149*x_44 - 0.01006706485579*x_45 + 0.00409293291161958*x_46 + 0.0199514813952866*x_47 - 0.00482868287939349*x_48 + 0.00107798751516742*x_49 + 0.016363345980447*x_5 + 0.013475784859601*x_50 - 0.0102030864262995*x_51 - 0.00385228584699647*x_52 + 0.00149385953677847*x_53 + 0.0147405637681707*x_54 - 0.0174585680639441*x_55 + 0.00836789392253164*x_56 - 0.0245815808563926*x_57 - 0.0141716666424532*x_58 - 0.00786488372545215*x_59 - 0.00478452489664566*x_6 - 0.00750770829544259*x_60 - 0.0256755049801225*x_61 - 0.000862117549272893*x_62 + 0.020864219632941*x_63 - 0.00110363509231506*x_64 - 0.000477225437475977*x_65 + 0.000256495706320003*x_66 + 0.00364329924035321*x_67 + 0.00528439440039937*x_68 - 0.00279270198497172*x_69 + 0.00334314098809592*x_7 - 0.000716984431184844*x_70 + 0.000198992110228072*x_71 + 0.00271365524672437*x_72 - 0.00905834950202868*x_73 + 0.00161641293891638*x_74 - 0.0117805095493083*x_75 - 0.0202486589507571*x_76 + 0.00335856286265882*x_77 + 0.0102358230799545*x_78 - 0.0255241114157643*x_79 + 0.0471990118067057*x_8 + 0.00305913443188164*x_80 + 0.000274797528727406*x_81 + 0.0193154368772379*x_82 - 0.00956814742176967*x_83 - 0.00477326587273307*x_84 + 0.00137272340434109*x_85 - 0.00178425466688533*x_86 + 0.00121252277792112*x_88 + 0.00710525646427514*x_89 - 0.0224342175278812*x_9 - 0.00335631234210527*x_90 + 0.00847011975595044*x_91 - 0.000577140012701828*x_92 - 0.0413920670291777*x_93 + 0.00611007676114328*x_94 - 0.000431396533393772*x_95 - 0.00791599256564249*x_96 - 0.0156313987887002*x_97 - 0.0111040143640291*x_98 - 0.00145650325211655*x_99 - 5.58977835386273e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) - 2.41284796152389e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) + 5.45830084603018e-5*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) + 5.46691147303591e-5*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) - 6.99425613238102e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) + 3.38384115647075e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) + 8.11637502701927e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) + 1.93607535290713e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) - 5.03015481475747e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) - 2.9180664588772e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 5.24796631826466e-5*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) + 2.67665363821936e-5*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) + 3.33290128121062e-5*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 4.46116457789346e-5*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 0.000228138907469748*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 0.00036907110498549*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) + 2.4902339606194e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) - 5.01996029108446e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 0.000147837144697372*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) - 4.63775764933261e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) + 5.39029272104508e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 0.000105094453847844*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) + 0.00111740885595287*std::exp(0.556959867477417*x_1) + 0.00079588801192263*std::exp(1.15583980083466*x_1) - 4.09824400767078e-6*std::exp(1.25871992111206*x_1) - 0.000759997731807593*std::exp(1.35671985149384*x_100) + 0.000673590054668612*std::exp(1.49143993854523*x_100) - 0.000444584961588109*std::exp(1.58023989200592*x_100) + 0.00719344292706077*std::exp(0.715599834918976*x_104) - 0.0159759347566952*std::exp(0.580799877643585*x_109) - 0.00202184089184524*std::exp(0.60999983549118*x_109) + 0.00217996007538915*std::exp(0.793439865112305*x_109) + 0.00177697114157542*std::exp(0.801999866962433*x_109) + 0.0180077619882745*std::exp(0.865199863910675*x_109) + 0.00282865842963995*std::exp(1.1865599155426*x_110) - 8.98397599737605e-5*std::exp(1.69735991954803*x_110) - 0.00494772992730456*std::exp(0.49823984503746*x_112) - 0.000192030362394044*std::exp(0.789599895477295*x_112) - 0.0037921193379514*std::exp(0.855839908123016*x_112) + 0.00482493409477925*std::exp(0.682959854602814*x_114) - 0.00296742386827731*std::exp(0.611999869346619*x_23) + 0.00307180658897683*std::exp(0.579439878463745*x_26) + 0.0209426103098534*std::exp(0.771439850330353*x_26) + 0.00045203027753209*std::exp(0.956879794597626*x_26) - 0.00231207482965664*std::exp(0.595679819583893*x_31) - 0.000845662721736858*std::exp(0.637759864330292*x_31) - 0.00247641564606862*std::exp(0.657039821147919*x_31) + 0.0102701444519199*std::exp(0.663919866085052*x_31) - 0.00702602229648491*std::exp(0.667439818382263*x_31) + 0.0051074611882287*std::exp(0.782479882240295*x_49) + 0.00245717520489953*std::exp(0.841519832611084*x_50) + 0.00365622970210201*std::exp(0.942319810390472*x_66) - 0.00525499812822429*std::exp(1.11359989643097*x_66) - 0.000234059368585044*std::exp(1.22135984897614*x_66) + 0.00425597384369613*std::exp(1.04599988460541*x_68) - 0.00111239303487518*std::exp(1.10527992248535*x_68) - 0.00204527835993503*std::exp(0.880079865455627*x_72) + 0.00404180990573774*std::exp(0.601599872112274*x_74) - 0.00980371653082489*std::exp(1.07575976848602*x_74) + 0.00285839108955473*std::exp(1.08567976951599*x_74) + 0.00146725627306986*std::exp(0.743279814720154*x_77) + 0.00164184798262912*std::exp(0.79695987701416*x_80) - 0.00217049004951601*std::exp(0.936159789562225*x_81) + 0.0031343053871168*std::sin(0.498079836368561*x_10 - 0.920319855213165) + 0.027425758267409*std::sin(0.265119940042496*x_100 - 7.51448011398315) - 0.175122820081608*std::sin(0.124000057578087*x_102 + 1.72023987770081) + 0.0167603855866441*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.0132800826387007*std::sin(0.360079854726791*x_102 - 4.23984003067017) - 0.0138661975462742*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.0257706056697492*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 0.0958031219307917*std::sin(0.135920032858849*x_103 - 1.44095981121063) - 0.0414843560534144*std::sin(0.323599934577942*x_105 + 1.91183984279633) + 0.0262638807194452*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.447237143543096*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.00693813095193134*std::sin(0.596959829330444*x_110 - 7.18480014801025) + 0.0388307761264668*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.020716756146261*std::sin(0.32847985625267*x_111 - 7.46783971786499) - 0.0136880831764424*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.0725473046396053*std::sin(0.441359847784042*x_111 + 8.42160034179688) + 0.00904773779209431*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.385615100400034*std::sin(0.193120002746582*x_114 + 4.97639989852905) + 0.00872289538763794*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.0556557637967337*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.0119561947620325*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.00697120068109977*std::sin(0.417359858751297*x_117 + 5.20456027984619) + 0.0431283534356887*std::sin(0.314319849014282*x_120 + 5.11375999450684) - 0.00625806558149804*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.104461954983091*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.0117075731718265*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.11188165354524*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.0681669525929723*std::sin(0.278719931840897*x_28 - 4.29207992553711) + 0.0365523102573223*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.0153885186940279*std::sin(0.343599855899811*x_28 - 4.2596001625061) - 0.0347677934317519*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.16025847475609*std::sin(0.285519927740097*x_3 - 7.52663993835449) - 0.00944225781715102*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.00834555947665244*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.131760728910284*std::sin(0.322399854660034*x_35 + 1.97791981697083) + 0.0517551424755163*std::sin(0.300879925489426*x_36 + 5.09055995941162) - 0.0532276366644534*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0934520326967456*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.0796774373818201*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.0620738211741947*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.0982194975409609*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.114554937143887*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.00846421564996538*std::sin(0.431999862194061*x_43 + 8.21175956726074) + 0.0127191956516856*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.00822250936346033*std::sin(0.459439843893051*x_46 - 4.13912010192871) - 0.00651056853254603*std::sin(0.58383983373642*x_46 + 2.18727993965149) - 0.223025673572685*std::sin(0.157680034637451*x_49 + 1.74911987781525) - 0.120924546639256*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.144872732553951*std::sin(0.266399949789047*x_53 + 5.08383941650391) - 0.0342653916763156*std::sin(0.284799933433533*x_53 + 8.30632019042969) - 0.0736024240769844*std::sin(0.303599923849106*x_55 + 5.13560009002686) + 0.416008811684981*std::sin(0.133360043168068*x_56 + 1.70503997802734) + 0.00905480514822856*std::sin(0.808799862861633*x_57 + 2.41383981704712) - 0.0333640745214879*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.00452107798516856*std::sin(0.497999846935272*x_58 - 0.917919814586639) + 0.10935350589794*std::sin(0.1112000644207*x_59 + 1.70367991924286) - 0.0327148309643072*std::sin(0.264479964971542*x_63 + 1.86495995521545) + 0.0802114359965538*std::sin(0.281199932098389*x_64 - 7.49600028991699) - 0.0140378203431503*std::sin(0.387279838323593*x_64 + 5.17727994918823) + 0.0454434561736643*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.203177373070251*std::sin(0.242239981889725*x_70 + 5.05904006958008) + 0.0185865780082482*std::sin(0.56855982542038*x_70 + 5.37879991531372) - 0.0745680415943471*std::sin(0.276239961385727*x_71 - 4.30703973770142) + 0.0204888594862732*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.226617817349095*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.00453938441828383*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.170547451440992*std::sin(0.261919975280762*x_75 - 4.32567977905273) + 0.0149756949955211*std::sin(0.473759859800339*x_75 + 5.26640033721924) - 0.0182623170053367*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.13822631508797*std::sin(0.282159954309464*x_78 + 5.10751962661743) - 0.0340187677839646*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.0994502163405374*std::sin(0.404719859361649*x_80 + 5.20512008666992) + 0.0397169613610638*std::sin(0.363439828157425*x_81 + 5.15120029449463) + 0.0202345401594475*std::sin(0.262559950351715*x_84 + 1.8562399148941) - 0.0598606018867791*std::sin(0.286319941282272*x_84 - 7.49336004257202) + 0.042309965369095*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.899406885498964*std::sin(0.118160054087639*x_86 + 4.88919973373413) - 0.0166780630278637*std::sin(0.25095996260643*x_86 + 5.07471990585327) - 0.00949279358252766*std::sin(0.346959829330444*x_86 - 7.45160007476807) - 0.0961552102687144*std::sin(0.290559947490692*x_87 + 5.0991997718811) + 0.0113410700699519*std::sin(0.347999840974808*x_87 + 5.15296030044556) - 0.0106060281396989*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.0303632411873101*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.00210048615560427*std::sin(0.983599841594696*x_87 - 7.00167989730835) + 0.0435902495520783*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.107075969439348*std::sin(0.352719843387604*x_92 + 2.00847983360291) - 0.0184926523521882*std::sin(0.371759831905365*x_92 - 1.19367980957031) - 0.0147941959096176*std::sin(0.372879832983017*x_95 - 7.40407991409302) - 0.0391625473843141*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.039232954375878*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.00482523031894472*std::sin(0.420239865779877*x_95 + 1.98823988437653) + 0.00935129564190007*std::sin(0.404959857463837*x_97 + 5.19767999649048) + 0.0627654927100721*std::sin(0.36303985118866*x_98 - 4.22512006759644) + 0.024561359840326*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 0.480158922736045);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0220489234457728*x_1 + 0.00174514821843056*x_10 + 0.00305243440715243*x_100 + 0.0499727003230158*x_101 + 0.00608555358375681*x_103 + 0.0169663083006628*x_104 - 0.0279941623877369*x_105 + 0.0152720736855082*x_106 - 0.0422264437282796*x_107 - 0.0258693889339191*x_108 - 0.0198395563272258*x_11 - 0.00587736622075149*x_110 + 0.00631497809205848*x_111 - 0.000539805755979152*x_112 - 0.0196445289633014*x_113 - 0.022579287993272*x_114 + 0.00130346602480885*x_116 - 0.000725715266111054*x_117 - 0.037239228304257*x_118 + 0.00983910935917884*x_119 - 0.144241293330495*x_12 + 0.0300281477911929*x_120 - 0.0123925253912656*x_13 - 0.0331698320144753*x_14 - 0.0163568230475698*x_15 - 0.0308041524000473*x_16 + 0.0128007585451078*x_17 + 0.0200855496374302*x_18 + 0.00655592505596787*x_19 - 0.0203290412879806*x_2 - 0.0183322799472256*x_20 - 0.0567823452686884*x_21 + 0.00624722674783158*x_22 + 0.0139906112502442*x_23 - 0.00206851464019011*x_24 - 0.030253079091042*x_25 + 0.00333857116138111*x_26 + 0.0335628345188771*x_27 + 6.62277174541466e-5*x_28 + 0.0103856357563389*x_29 - 0.0460830255453603*x_3 + 0.0456565407816798*x_30 - 0.125334761073942*x_32 - 0.00672550398054995*x_33 + 0.00477134299417794*x_34 - 0.00163858445783925*x_35 - 0.00436850151161682*x_36 - 0.0449608620771773*x_37 - 0.0117801000873042*x_38 - 0.000119251179837038*x_39 - 0.0128416036724754*x_4 - 0.0155714196548075*x_40 - 0.0294218408867432*x_41 + 0.029905298135517*x_42 + 0.00398319036750531*x_43 - 0.0579729964552128*x_44 - 0.0231131175896191*x_45 + 0.00204792530715026*x_46 - 0.0150529993823833*x_47 + 0.0356660692585215*x_48 - 0.0238334667753594*x_49 + 0.0107298171964068*x_5 - 0.0165829157645672*x_50 - 0.0316971273540255*x_51 - 0.00114516083450218*x_52 + 0.00300702039090686*x_53 - 0.0100542449339162*x_54 - 0.025328122817073*x_55 - 0.0367820031120931*x_56 - 0.0174299527149351*x_57 + 0.00748569461345727*x_58 + 0.00546478514817227*x_59 + 0.00939209504619895*x_6 - 0.019539796250221*x_60 + 0.0019668898054359*x_61 - 0.00628007466820078*x_62 + 0.0222562124206964*x_63 - 8.80347431974858e-5*x_64 - 0.00413665997434632*x_65 - 0.000276959456551992*x_66 + 0.0016180055687063*x_67 - 0.00513754434372645*x_68 + 0.0268437936378023*x_69 - 0.0217502998787214*x_7 + 0.000835235421026949*x_70 + 0.0284434758195587*x_71 - 0.0163135942142306*x_72 + 0.00367321967430348*x_73 - 0.00910662272896603*x_74 + 0.00393113811825104*x_75 - 0.0298230223341286*x_76 + 0.000616548571193334*x_77 + 0.0041436648552006*x_78 + 0.04265784509653*x_79 + 0.0244736028280404*x_8 + 0.0214215780590213*x_80 - 0.0053269581924914*x_81 - 0.000427787800111285*x_82 - 0.00310872774583893*x_83 + 0.0450965431583289*x_84 - 0.0334878861928516*x_85 - 0.0186415139410364*x_86 + 0.00924759438919576*x_88 + 0.0183714754645692*x_89 + 0.078177789564729*x_9 + 0.0210487853444061*x_90 + 0.00406904187818767*x_91 - 0.00687327154983091*x_92 + 0.00654563806292732*x_93 - 0.0359600467199471*x_94 + 0.000502546010104117*x_95 + 0.00728390160375686*x_96 - 0.022531796527702*x_97 + 0.0210567043821529*x_98 + 3.22258894321278e-5*x_99 - 6.68468641071585e-6*std::pow(-8.0*x_114 - 9.99962043762207, 2) - 2.88546896825997e-6*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) - 6.53963005786859e-6*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) - 6.54994651289227e-6*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) - 8.36426884241027e-6*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) + 4.04665723088106e-6*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) + 9.70618482750695e-6*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) - 2.25538887902071e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) - 6.01544558752856e-6*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) + 3.39933806280456e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.000875309926453104*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) - 3.20691824814557e-6*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) - 3.99317333605125e-6*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.000744079020663828*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) + 0.000141030131347378*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) + 0.000228151116308504*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) - 2.90094389792591e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) - 6.0032541928888e-6*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) + 9.13894616483005e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) + 5.40265491742962e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) - 6.27930428402831e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) + 6.49669308686762e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) - 0.000133877570098259*std::exp(0.556959867477417*x_1) - 0.000491999335423029*std::exp(1.15583980083466*x_1) - 6.83547386433565e-5*std::exp(1.25871992111206*x_1) + 9.10558826096155e-5*std::exp(1.35671985149384*x_100) - 0.000784684085791063*std::exp(1.49143993854523*x_100) - 0.00741524633409849*std::exp(1.58023989200592*x_100) - 0.00444681800265819*std::exp(0.715599834918976*x_104) - 0.00191052501916762*std::exp(0.580799877643585*x_109) + 0.00024223823203434*std::exp(0.60999983549118*x_109) - 0.00253949708277583*std::exp(0.793439865112305*x_109) + 0.0296381566670572*std::exp(0.801999866962433*x_109) - 0.0111319768585086*std::exp(0.865199863910675*x_109) + 0.00033827270721932*std::exp(1.1865599155426*x_110) + 0.00010465687465855*std::exp(1.69735991954803*x_110) + 0.00576375038176313*std::exp(0.49823984503746*x_112) - 0.00320288035765203*std::exp(0.789599895477295*x_112) + 0.00234419939258776*std::exp(0.855839908123016*x_112) - 0.00562070204707315*std::exp(0.682959854602814*x_114) + 0.00035552921817303*std::exp(0.611999869346619*x_23) + 0.0512347571690317*std::exp(0.579439878463745*x_26) - 0.0129462313794381*std::exp(0.771439850330353*x_26) - 5.41580772735441e-5*std::exp(0.956879794597626*x_26) + 0.00269340129269308*std::exp(0.595679819583893*x_31) - 0.0141048347088552*std::exp(0.637759864330292*x_31) + 0.000296701164916275*std::exp(0.657039821147919*x_31) - 0.00634876285274956*std::exp(0.663919866085052*x_31) - 0.000840225726199745*std::exp(0.667439818382263*x_31) - 0.00315731292928649*std::exp(0.782479882240295*x_49) - 0.000294395953625337*std::exp(0.841519832611084*x_50) - 0.00425924528034712*std::exp(0.942319810390472*x_66) - 0.00062843304961821*std::exp(1.11359989643097*x_66) - 0.00390388345269679*std::exp(1.22135984897614*x_66) - 0.00495790417561073*std::exp(1.04599988460541*x_68) + 0.000133276620916273*std::exp(1.10527992248535*x_68) + 0.000245046292182066*std::exp(0.880079865455627*x_72) - 0.000484252193005768*std::exp(0.601599872112274*x_74) + 0.00606042803206653*std::exp(1.07575976848602*x_74) - 0.00332982053905774*std::exp(1.08567976951599*x_74) - 0.000175793044330684*std::exp(0.743279814720154*x_77) - 0.00191263510250467*std::exp(0.79695987701416*x_80) + 0.000260047996043366*std::exp(0.936159789562225*x_81) + 0.0522771765575272*std::sin(0.498079836368561*x_10 - 0.920319855213165) + 0.0032797828820357*std::sin(0.265119940042496*x_100 - 7.51448011398315) - 0.0209425322704756*std::sin(0.124000057578087*x_102 + 1.72023987770081) - 0.0195246467052305*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.221498909345439*std::sin(0.360079854726791*x_102 - 4.23984003067017) + 0.0016613192423776*std::sin(0.375039845705032*x_102 + 1.98391973972321) - 0.0159307850765795*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 1.59790323576139*std::sin(0.135920032858849*x_103 - 1.44095981121063) - 0.00496101801560569*std::sin(0.323599934577942*x_105 + 1.91183984279633) - 0.0305955366900457*std::sin(0.437919855117798*x_105 - 4.17088031768799) + 0.27647153130017*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.115721300880323*std::sin(0.596959829330444*x_110 - 7.18480014801025) + 0.00464368254084295*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.34553541694084*std::sin(0.32847985625267*x_111 - 7.46783971786499) + 0.00163997922980688*std::sin(0.399279862642288*x_111 + 2.00383973121643) + 0.0448470452308907*std::sin(0.441359847784042*x_111 + 8.42160034179688) - 0.00108401606452175*std::sin(0.445599853992462*x_112 + 5.21031999588013) + 0.238378226941235*std::sin(0.193120002746582*x_114 + 4.97639989852905) - 0.0101615472871956*std::sin(0.422959864139557*x_115 + 8.4026403427124) - 0.0344050901511958*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.19941774247656*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.116272871916621*std::sin(0.417359858751297*x_117 + 5.20456027984619) - 0.050241437433346*std::sin(0.314319849014282*x_120 + 5.11375999450684) + 0.000749783402112078*std::sin(0.584559857845306*x_120 - 4.00031995773315) - 0.0645759348787218*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.195270975278752*std::sin(0.301679849624634*x_24 + 5.10272026062012) - 0.0691626188178331*std::sin(0.385919839143753*x_24 + 5.174720287323) + 0.0421392141496608*std::sin(0.278719931840897*x_28 - 4.29207992553711) - 0.0425808189402811*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.256665579567703*std::sin(0.343599855899811*x_28 - 4.2596001625061) - 0.00415779985485835*std::sin(0.3643998503685*x_28 - 4.23311996459961) + 0.0990680370790278*std::sin(0.285519927740097*x_3 - 7.52663993835449) + 0.00113128379649677*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.139195844803634*std::sin(0.321119844913483*x_35 - 7.4300799369812) + 0.0814513977941606*std::sin(0.322399854660034*x_35 + 1.97791981697083) - 0.0602910277206608*std::sin(0.300879925489426*x_36 + 5.09055995941162) - 0.00636536973312216*std::sin(0.395119845867157*x_36 + 5.20344018936157) + 0.0577698586886112*std::sin(0.413039863109589*x_36 + 5.20256042480469) + 0.0492547263595125*std::sin(0.566959857940674*x_38 + 2.16863989830017) - 0.0383725829606297*std::sin(0.50903981924057*x_4 + 8.50519943237305) - 0.0607169938381159*std::sin(0.389039844274521*x_41 - 7.40383958816528) - 0.0708151801508709*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.141174914790693*std::sin(0.431999862194061*x_43 + 8.21175956726074) - 0.00152389610873447*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.137143488157339*std::sin(0.459439843893051*x_46 - 4.13912010192871) + 0.000780035964859237*std::sin(0.58383983373642*x_46 + 2.18727993965149) - 0.0266711235221311*std::sin(0.157680034637451*x_49 + 1.74911987781525) - 0.0144610863341803*std::sin(0.21815998852253*x_53 + 5.01399946212769) + 0.0895569314648642*std::sin(0.266399949789047*x_53 + 5.08383941650391) + 0.039916722872386*std::sin(0.284799933433533*x_53 + 8.30632019042969) - 0.00880194334866905*std::sin(0.303599923849106*x_55 + 5.13560009002686) + 0.0497495298411422*std::sin(0.133360043168068*x_56 + 1.70503997802734) - 0.0105481983448367*std::sin(0.808799862861633*x_57 + 2.41383981704712) + 0.0388667530535893*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.0754071996406261*std::sin(0.497999846935272*x_58 - 0.917919814586639) - 0.0131017233068711*std::sin(0.1112000644207*x_59 + 1.70367991924286) + 0.00391958776086653*std::sin(0.264479964971542*x_63 + 1.86495995521545) + 0.00959229977016249*std::sin(0.281199932098389*x_64 - 7.49600028991699) + 0.00168188149485737*std::sin(0.387279838323593*x_64 + 5.17727994918823) - 0.0529383660219881*std::sin(0.173920020461082*x_67 - 4.43959999084473) + 0.125599495187871*std::sin(0.242239981889725*x_70 + 5.05904006958008) + 0.00222272579640995*std::sin(0.56855982542038*x_70 + 5.37879991531372) - 0.00891741931010503*std::sin(0.276239961385727*x_71 - 4.30703973770142) - 0.00245478520014756*std::sin(0.217999994754791*x_73 - 4.382080078125) - 0.140089829046967*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0757125332051342*std::sin(0.511119842529297*x_73 + 8.51000022888184) - 0.105428441577301*std::sin(0.261919975280762*x_75 - 4.32567977905273) - 0.0174456102123234*std::sin(0.473759859800339*x_75 + 5.26640033721924) - 0.00218394817442805*std::sin(0.348879843950272*x_76 + 8.32695960998535) + 0.0854482717951365*std::sin(0.282159954309464*x_78 + 5.10751962661743) + 0.0396294237322601*std::sin(0.341039836406708*x_79 - 4.25072002410889) - 0.0614777953860893*std::sin(0.404719859361649*x_80 + 5.20512008666992) + 0.00474965937963825*std::sin(0.363439828157425*x_81 + 5.15120029449463) - 0.00242431501609357*std::sin(0.262559950351715*x_84 + 1.8562399148941) - 0.00715859067458921*std::sin(0.286319941282272*x_84 - 7.49336004257202) - 0.00506918781284016*std::sin(0.166400015354156*x_85 + 4.94312000274658) - 0.555992279455773*std::sin(0.118160054087639*x_86 + 4.88919973373413) + 0.0019982108967733*std::sin(0.25095996260643*x_86 + 5.07471990585327) + 0.0110584234465481*std::sin(0.346959829330444*x_86 - 7.45160007476807) - 0.0114989787915048*std::sin(0.290559947490692*x_87 + 5.0991997718811) - 0.00135878187754698*std::sin(0.347999840974808*x_87 + 5.15296030044556) + 0.01235526183469*std::sin(0.453119844198227*x_87 + 5.2597599029541) - 0.0187698448294984*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.0350340735987364*std::sin(0.983599841594696*x_87 - 7.00167989730835) + 0.00521285693947296*std::sin(0.332959830760956*x_92 + 8.3908805847168) - 0.0661918574155596*std::sin(0.352719843387604*x_92 + 2.00847983360291) + 0.0215426132025772*std::sin(0.371759831905365*x_92 - 1.19367980957031) + 0.00177250340319547*std::sin(0.372879832983017*x_95 - 7.40407991409302) - 0.00468335829681036*std::sin(0.378959834575653*x_95 + 1.9592798948288) - 0.0242528938625231*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.0804801658291016*std::sin(0.420239865779877*x_95 + 1.98823988437653) - 0.00112038555192982*std::sin(0.404959857463837*x_97 + 5.19767999649048) + 0.00750597983712482*std::sin(0.36303985118866*x_98 - 4.22512006759644) - 0.0286122220162132*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 2.04808378636408);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0120732289417791*x_1 - 0.0091550736463834*x_10 - 0.00227212728150483*x_100 - 0.0724393239360412*x_101 - 0.0158056316328763*x_103 - 0.0215836715322373*x_104 + 0.031257690681565*x_105 - 0.0283574809567235*x_106 + 0.0602901347681875*x_107 + 0.0267203757463295*x_108 + 0.0155520096634215*x_11 + 0.00548239429580197*x_110 + 0.000940986035760292*x_111 + 0.0026779091681898*x_112 + 0.0243593167995382*x_113 + 0.0350452312718456*x_114 - 0.00759027794886258*x_116 + 0.00133595662121244*x_117 + 0.0644661206619147*x_118 - 0.0210916808533535*x_119 + 0.180727643547619*x_12 - 0.0355919963259001*x_120 + 0.00673967481826082*x_13 + 0.0389068239422605*x_14 + 0.0231123158639086*x_15 + 0.021964190179232*x_16 - 0.0146653466988158*x_17 - 0.0380931380957975*x_18 - 0.00994174481631283*x_19 + 0.0281265468966875*x_2 + 0.0148751433415431*x_20 + 0.0985589802118516*x_21 - 0.0140263506307385*x_22 - 0.0220870662098295*x_23 - 0.000883186545519756*x_24 + 0.0680289433634129*x_25 + 0.00291186778850287*x_26 - 0.033417251041887*x_27 - 0.00189587972875552*x_28 - 0.00889916289975013*x_29 + 0.0605514213790763*x_3 - 0.0418155584200203*x_30 + 0.14401093315531*x_32 - 0.0215545142059572*x_33 - 0.00987459332390155*x_34 - 0.000234991579116989*x_35 + 0.00746242160062736*x_36 + 0.0644602299396509*x_37 + 0.0100378363453147*x_38 - 0.0159503558273903*x_39 + 0.0282977757052191*x_4 + 0.0118674086682907*x_40 + 0.0378030155743154*x_41 - 0.0174814368035843*x_42 - 0.000360621081100246*x_43 + 0.0822964728254396*x_44 + 0.0375568893795592*x_45 + 0.00219290654786925*x_46 + 0.020598166271598*x_47 - 0.0537892832491398*x_48 + 0.0356524310683269*x_49 - 0.0237153918409799*x_5 + 0.0201750953958164*x_50 + 0.0464327563797148*x_51 - 0.00218760701816234*x_52 - 0.00014442695935966*x_53 + 0.0101815250656587*x_54 + 0.0382433539914081*x_55 + 0.0511258226972522*x_56 + 0.0447130719152266*x_57 + 0.0069861985640452*x_58 - 0.0044798634571353*x_59 - 0.00424464240910704*x_6 + 0.0254723059886503*x_60 + 0.0192940776628932*x_61 - 0.0031095051764016*x_62 - 0.0406556258409729*x_63 + 0.00323369324505218*x_64 + 0.00118607241900749*x_65 - 0.000587487734595762*x_66 - 0.00683175757865679*x_67 + 0.00514779090390617*x_68 - 0.0298023392411871*x_69 + 0.0266613241934529*x_7 + 0.000124457259597956*x_70 - 0.0391119548021969*x_71 + 0.0213520453857045*x_72 + 0.00381992008722382*x_73 + 0.012381378070587*x_74 - 0.00139942769752806*x_75 + 0.0545584660183888*x_76 - 0.00432810460451651*x_77 + 0.000375931993534557*x_78 - 0.0466142601450599*x_79 - 0.052612948532138*x_8 - 0.0392229504328343*x_80 + 0.00673513403837146*x_81 - 0.0133612136357643*x_82 + 0.0146188987899492*x_83 - 0.0626408324095266*x_84 + 0.0500319227929524*x_85 + 0.0274928733559053*x_86 - 0.0187013034648975*x_88 - 0.0286917958014746*x_89 - 0.114503458923572*x_9 - 0.0388658781402636*x_90 - 0.025316516500138*x_91 + 0.00949980173223194*x_92 + 0.033011978078643*x_93 + 0.0451345957947485*x_94 + 7.48836767034417e-5*x_95 - 0.0104749618902935*x_96 + 0.0346162130580047*x_97 - 0.0251762946154074*x_98 + 0.00307839964028108*x_99 + 3.31618972703602e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) + 1.43144524100424e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) + 0.000187207902323638*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) + 0.000187503228188757*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) + 4.14940966638374e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) - 2.00749628529646e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) - 4.81511748435848e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) - 3.36072336186957e-6*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) + 2.98418768439582e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) + 5.06530600945418e-6*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) - 0.00127772475298398*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) + 9.18034250938041e-5*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) + 0.000114311298535514*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) - 0.00108616177441373*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 0.000104977983539217*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 0.000169827850995144*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) - 4.32265584880675e-6*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) + 2.97813968525591e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 6.80271748236698e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) + 8.05042038028001e-6*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) - 9.35670331618578e-6*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 4.83591508719965e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) + 0.00383247046767191*std::exp(0.556959867477417*x_1) + 0.000366227398655151*std::exp(1.15583980083466*x_1) + 9.97801337661929e-5*std::exp(1.25871992111206*x_1) - 0.00260662768791685*std::exp(1.35671985149384*x_100) - 0.000116924675976514*std::exp(1.49143993854523*x_100) + 0.0108243303362777*std::exp(1.58023989200592*x_100) + 0.00331005851462411*std::exp(0.715599834918976*x_104) + 0.00947787682553456*std::exp(0.580799877643585*x_109) - 0.00693447654996493*std::exp(0.60999983549118*x_109) - 0.000378406901482552*std::exp(0.793439865112305*x_109) - 0.0432639974274816*std::exp(0.801999866962433*x_109) + 0.00828626104398212*std::exp(0.865199863910675*x_109) - 0.00167812879721495*std::exp(1.1865599155426*x_110) + 1.55947742279354e-5*std::exp(1.69735991954803*x_110) + 0.000858848367133325*std::exp(0.49823984503746*x_112) + 0.00467537199126856*std::exp(0.789599895477295*x_112) - 0.00174494147382991*std::exp(0.855839908123016*x_112) - 0.000837532935247456*std::exp(0.682959854602814*x_114) - 0.0101776214495272*std::exp(0.611999869346619*x_23) - 0.0747894151198142*std::exp(0.579439878463745*x_26) + 0.00963672976591052*std::exp(0.771439850330353*x_26) + 0.00155036599173718*std::exp(0.956879794597626*x_26) + 0.000401339952122741*std::exp(0.595679819583893*x_31) + 0.0205893888548485*std::exp(0.637759864330292*x_31) - 0.00849356954589858*std::exp(0.657039821147919*x_31) + 0.00472580090426702*std::exp(0.663919866085052*x_31) + 0.00416825524851597*std::exp(0.667439818382263*x_31) + 0.00235019524942785*std::exp(0.782479882240295*x_49) + 0.00842757899805863*std::exp(0.841519832611084*x_50) - 0.000634664170367394*std::exp(0.942319810390472*x_66) + 0.00311757814088792*std::exp(1.11359989643097*x_66) + 0.00569865412184663*std::exp(1.22135984897614*x_66) - 0.000738770353258121*std::exp(1.04599988460541*x_68) - 0.00381526728725234*std::exp(1.10527992248535*x_68) - 0.00701486199152698*std::exp(0.880079865455627*x_72) + 0.0138625329637955*std::exp(0.601599872112274*x_74) - 0.00451117437183553*std::exp(1.07575976848602*x_74) - 0.000496171892152959*std::exp(1.08567976951599*x_74) + 0.00503237136978964*std::exp(0.743279814720154*x_77) - 0.000284999076279485*std::exp(0.79695987701416*x_80) - 0.00744431097966588*std::exp(0.936159789562225*x_81) - 0.0763110762085536*std::sin(0.498079836368561*x_10 - 0.920319855213165) - 0.0162705946577839*std::sin(0.265119940042496*x_100 - 7.51448011398315) + 0.103893295969937*std::sin(0.124000057578087*x_102 + 1.72023987770081) - 0.00290934024393207*std::sin(0.354159861803055*x_102 - 7.43056011199951) + 0.323330777678305*std::sin(0.360079854726791*x_102 - 4.23984003067017) - 0.0475580556856103*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.0118583289794763*std::sin(0.376559853553772*x_102 + 5.18311977386475) + 2.33252297900784*std::sin(0.135920032858849*x_103 - 1.44095981121063) + 0.0246109928995614*std::sin(0.323599934577942*x_105 + 1.91183984279633) - 0.00455899804595205*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.205795907474569*std::sin(0.136000037193298*x_108 + 4.91215991973877) - 0.168922990718781*std::sin(0.596959829330444*x_110 - 7.18480014801025) - 0.0230367311065993*std::sin(0.290879935026169*x_111 + 5.09975957870483) + 0.50439180673636*std::sin(0.32847985625267*x_111 - 7.46783971786499) - 0.0469471619571315*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.0333825993853369*std::sin(0.441359847784042*x_111 + 8.42160034179688) + 0.0310317818788641*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.177440560714687*std::sin(0.193120002746582*x_114 + 4.97639989852905) - 0.00151415792099004*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.0256099668422003*std::sin(0.432879865169525*x_115 - 4.18359994888306) + 0.2910980191656*std::sin(0.442319840192795*x_115 - 7.35264015197754) + 0.169728140923079*std::sin(0.417359858751297*x_117 + 5.20456027984619) - 0.00748640618417289*std::sin(0.314319849014282*x_120 + 5.11375999450684) - 0.0214638101336624*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.0480681068929179*std::sin(0.461839854717255*x_2 - 4.12639999389648) + 0.2850448179698*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.0514822768044073*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.0313669829780023*std::sin(0.278719931840897*x_28 - 4.29207992553711) - 0.00634490815802354*std::sin(0.313039928674698*x_28 - 4.25007963180542) - 0.374664966478252*std::sin(0.343599855899811*x_28 - 4.2596001625061) + 0.0206263275770876*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.07374284251447*std::sin(0.285519927740097*x_3 - 7.52663993835449) - 0.032384900155026*std::sin(0.309999942779541*x_35 - 1.13671982288361) - 0.203189717199726*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.0606296215935601*std::sin(0.322399854660034*x_35 + 1.97791981697083) - 0.00898388154950594*std::sin(0.300879925489426*x_36 + 5.09055995941162) + 0.0315778069767453*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0430018976550338*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.0366635257557935*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.0285632321540989*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.045195643787557*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.052712386673552*std::sin(0.39047983288765*x_43 + 8.19287967681885) - 0.20607864446301*std::sin(0.431999862194061*x_43 + 8.21175956726074) + 0.0436240875020254*std::sin(0.40871986746788*x_45 + 5.21023988723755) - 0.200193810481807*std::sin(0.459439843893051*x_46 - 4.13912010192871) - 0.022329840591302*std::sin(0.58383983373642*x_46 + 2.18727993965149) + 0.132312124157113*std::sin(0.157680034637451*x_49 + 1.74911987781525) + 0.0717396493967382*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.0666631023265802*std::sin(0.266399949789047*x_53 + 5.08383941650391) + 0.00594793493637996*std::sin(0.284799933433533*x_53 + 8.30632019042969) + 0.0436653454139871*std::sin(0.303599923849106*x_55 + 5.13560009002686) - 0.246801225439086*std::sin(0.133360043168068*x_56 + 1.70503997802734) - 0.00157177225324082*std::sin(0.808799862861633*x_57 + 2.41383981704712) + 0.00579148040509662*std::sin(0.411359876394272*x_58 + 5.20424032211304) - 0.110074891900811*std::sin(0.497999846935272*x_58 - 0.917919814586639) + 0.375058851249983*std::sin(0.1112000644207*x_59 + 1.70367991924286) - 0.112204787762013*std::sin(0.264479964971542*x_63 + 1.86495995521545) - 0.0475862052488658*std::sin(0.281199932098389*x_64 - 7.49600028991699) - 0.048146684724214*std::sin(0.387279838323593*x_64 + 5.17727994918823) - 0.00788827173372188*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.0934919482269304*std::sin(0.242239981889725*x_70 + 5.05904006958008) - 0.0110266660231909*std::sin(0.56855982542038*x_70 + 5.37879991531372) + 0.0442382072858914*std::sin(0.276239961385727*x_71 - 4.30703973770142) + 0.0702723523973336*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.104278054818515*std::sin(0.241199985146523*x_73 - 7.54744052886963) - 0.110520599462783*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.0784773090596217*std::sin(0.261919975280762*x_75 - 4.32567977905273) - 0.0025995459296617*std::sin(0.473759859800339*x_75 + 5.26640033721924) + 0.0108342950670169*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.063604757254813*std::sin(0.282159954309464*x_78 + 5.10751962661743) + 0.00590512489412749*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.0457619583163511*std::sin(0.404719859361649*x_80 + 5.20512008666992) - 0.0235624690133967*std::sin(0.363439828157425*x_81 + 5.15120029449463) + 0.0694000921640045*std::sin(0.262559950351715*x_84 + 1.8562399148941) + 0.035512877338679*std::sin(0.286319941282272*x_84 - 7.49336004257202) + 0.145114021516326*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.413861547195709*std::sin(0.118160054087639*x_86 + 4.88919973373413) - 0.0572021455456896*std::sin(0.25095996260643*x_86 + 5.07471990585327) + 0.00164780018062327*std::sin(0.346959829330444*x_86 - 7.45160007476807) + 0.0570450025578832*std::sin(0.290559947490692*x_87 + 5.0991997718811) + 0.0388974151075833*std::sin(0.347999840974808*x_87 + 5.15296030044556) + 0.00184104025146596*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.0139716275005892*std::sin(0.792079865932465*x_87 - 0.782159864902496) + 0.0511406322288135*std::sin(0.983599841594696*x_87 - 7.00167989730835) - 0.0258603344555956*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.0492709441011948*std::sin(0.352719843387604*x_92 + 2.00847983360291) + 0.00321003460374676*std::sin(0.371759831905365*x_92 - 1.19367980957031) - 0.0507408891691776*std::sin(0.372879832983017*x_95 - 7.40407991409302) + 0.0232335575936886*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.0180530207860836*std::sin(0.405119866132736*x_95 - 0.992079794406891) - 0.117480102642944*std::sin(0.420239865779877*x_95 + 1.98823988437653) + 0.0320729195863494*std::sin(0.404959857463837*x_97 + 5.19767999649048) - 0.0372362317360333*std::sin(0.36303985118866*x_98 - 4.22512006759644) - 0.00426346710579854*std::sin(0.432399868965149*x_98 + 2.00271987915039) + 3.10592773813006);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0041626086106278*x_1 - 0.00826659218686765*x_10 - 0.0016483768260553*x_100 - 0.0259325800865498*x_101 + 0.00794036772861386*x_103 - 0.0115531711703366*x_104 + 0.0149290746180819*x_105 + 0.00315957870560616*x_106 + 0.00354315592909374*x_107 + 0.00811329853224935*x_108 + 0.00750581423086356*x_11 + 0.00110305880480381*x_110 + 0.00211416727648552*x_111 + 0.00189257427649635*x_112 - 0.0124762094709693*x_113 - 0.00358684127484252*x_114 - 0.00438899204139623*x_116 + 0.0103843924225971*x_117 + 0.00763385527052136*x_118 - 0.0121046296707361*x_119 + 0.0163531227278369*x_12 - 0.0112650558476696*x_120 + 0.00928451520828516*x_13 + 0.0108521235163706*x_14 + 0.0040470078346236*x_15 + 0.00631642901537484*x_16 - 0.0157478770239803*x_17 - 0.00819885427941741*x_18 - 0.00142417827104447*x_19 + 0.0190308385888597*x_2 + 0.0120631055753957*x_20 - 0.0037766568307239*x_21 - 0.0222465944363841*x_22 + 0.00216621311115511*x_23 + 0.000331726513894901*x_24 - 0.0202320145291897*x_25 + 0.00293247102247043*x_26 - 0.0124887834898334*x_27 + 0.00341708099308201*x_28 + 0.0123870628600317*x_29 - 0.00331278856595681*x_3 - 0.0229021006498181*x_30 + 0.0144052273598957*x_32 + 0.0241735122297672*x_33 - 0.000560623557846516*x_34 - 0.000541681625781661*x_35 - 0.00198980705383724*x_36 - 0.00838817873468151*x_37 - 0.000347199306437008*x_38 + 0.00171154426796263*x_39 - 0.0175894754125728*x_4 + 0.0160120084034902*x_40 - 0.0210131204158377*x_41 - 0.00856047664299435*x_42 + 2.36600408733669e-5*x_43 + 0.00344346351192906*x_44 + 0.00361663433874071*x_45 + 0.00289822275577381*x_46 + 0.000528030582085985*x_47 + 0.00425592792002925*x_48 - 0.00663216031346722*x_49 - 0.00767791787500188*x_5 + 0.00591095024707781*x_50 - 0.00512364332197051*x_51 + 0.00191016920297024*x_52 - 0.00811478623728004*x_53 - 0.0224889522758257*x_54 + 0.0037484675885834*x_55 + 0.00158605693252548*x_56 - 0.0188539627991977*x_57 - 0.022499685938321*x_58 - 0.00324095329418941*x_59 - 0.00310015214198259*x_6 - 0.00645957647023832*x_60 - 0.009782835201185*x_61 + 0.0124197841600753*x_62 + 0.00610375777285959*x_63 + 0.00104079143845112*x_64 + 0.00705958812129697*x_65 + 0.00163357021780204*x_66 + 0.00995978249766633*x_67 - 0.00331192862688796*x_68 - 0.00585623016065934*x_69 + 0.00721405099646579*x_7 + 0.000279625260698439*x_70 + 0.00925446296622761*x_71 - 0.000715461172666246*x_72 + 0.0036895577930112*x_73 - 0.000757643390594744*x_74 + 0.00612552154606914*x_75 - 0.0141093477882488*x_76 - 0.00134888509839896*x_77 - 0.0209577946461143*x_78 - 0.0126450618619908*x_79 + 0.017185086794033*x_8 + 0.0101769348122805*x_80 - 0.000138885189245315*x_81 + 0.00412839395980118*x_82 - 0.0104561334146533*x_83 - 0.00308171758706588*x_84 + 0.00243691913029665*x_85 + 0.000589739318498305*x_86 + 0.00427270249070842*x_88 - 0.00316986667123939*x_89 - 0.00494720322299262*x_9 + 0.0154025855799956*x_90 - 0.00861759280793326*x_91 + 0.00112748262361633*x_92 - 0.0554790464869463*x_93 + 0.0184552087752537*x_94 + 0.000168245449786534*x_95 + 0.000874070620189927*x_96 + 0.00146649034834705*x_97 - 0.00471533939455055*x_98 - 0.00417631745176876*x_99 + 2.34366999744518e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) + 1.01165359658895e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) - 0.000337418326216698*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) - 0.00033795061335768*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) + 2.93253635729237e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) - 1.41876949182795e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) - 3.40301590414465e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) - 7.5507298588595e-6*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) + 2.10903226846283e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) + 1.13805134227321e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) - 1.4535662875025e-5*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) - 0.000165463944906348*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) - 0.000206031511174303*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) - 1.23564025379845e-5*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 7.61591468579404e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 0.000123206255335204*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) - 9.71195872813571e-6*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) + 2.10475793095637e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 4.93521729324437e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) + 1.80873410264675e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) - 2.10222417922286e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 3.50834674949707e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) - 0.00690753838073161*std::exp(0.556959867477417*x_1) + 0.000265689674132097*std::exp(1.15583980083466*x_1) + 1.13511958085112e-6*std::exp(1.25871992111206*x_1) + 0.00469811338415895*std::exp(1.35671985149384*x_100) - 0.000262701373207402*std::exp(1.49143993854523*x_100) + 0.000123139836062964*std::exp(1.58023989200592*x_100) + 0.00240137240233291*std::exp(0.715599834918976*x_104) + 0.00669835485418384*std::exp(0.580799877643585*x_109) + 0.0124985080311039*std::exp(0.60999983549118*x_109) - 0.000850188480920763*std::exp(0.793439865112305*x_109) - 0.000492180244425228*std::exp(0.801999866962433*x_109) + 0.00601149451033333*std::exp(0.865199863910675*x_109) - 0.00118599369686749*std::exp(1.1865599155426*x_110) + 3.50376733595649e-5*std::exp(1.69735991954803*x_110) + 0.00192962386714828*std::exp(0.49823984503746*x_112) + 5.31880054148611e-5*std::exp(0.789599895477295*x_112) - 0.00126591547564141*std::exp(0.855839908123016*x_112) - 0.00188173326424379*std::exp(0.682959854602814*x_114) + 0.0183438623676786*std::exp(0.611999869346619*x_23) - 0.000850819961234284*std::exp(0.579439878463745*x_26) + 0.00699122894847843*std::exp(0.771439850330353*x_26) - 0.00279433662501541*std::exp(0.956879794597626*x_26) + 0.000901713480624183*std::exp(0.595679819583893*x_31) + 0.000234229175335251*std::exp(0.637759864330292*x_31) + 0.0153085739662196*std::exp(0.657039821147919*x_31) + 0.00342846140643392*std::exp(0.663919866085052*x_31) + 0.00294585520484431*std::exp(0.667439818382263*x_31) + 0.00170501336672317*std::exp(0.782479882240295*x_49) - 0.0151896344347046*std::exp(0.841519832611084*x_50) - 0.00142593637902867*std::exp(0.942319810390472*x_66) + 0.0022033040793539*std::exp(1.11359989643097*x_66) + 6.48290760299395e-5*std::exp(1.22135984897614*x_66) - 0.00165983770889226*std::exp(1.04599988460541*x_68) + 0.00687653184590735*std::exp(1.10527992248535*x_68) + 0.0126433925194583*std::exp(0.880079865455627*x_72) - 0.0249854445870637*std::exp(0.601599872112274*x_74) - 0.00327275472345163*std::exp(1.07575976848602*x_74) - 0.00111477783732905*std::exp(1.08567976951599*x_74) - 0.0090702064572028*std::exp(0.743279814720154*x_77) - 0.000640323764647427*std::exp(0.79695987701416*x_80) + 0.0134174194540841*std::exp(0.936159789562225*x_81) - 0.000868130694664395*std::sin(0.498079836368561*x_10 - 0.920319855213165) - 0.0114990117209376*std::sin(0.265119940042496*x_100 - 7.51448011398315) + 0.0734251115716662*std::sin(0.124000057578087*x_102 + 1.72023987770081) - 0.00653658152845369*std::sin(0.354159861803055*x_102 - 7.43056011199951) + 0.00367827826022435*std::sin(0.360079854726791*x_102 - 4.23984003067017) + 0.0857173193459419*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.00860294880688319*std::sin(0.376559853553772*x_102 + 5.18311977386475) + 0.0265352671550944*std::sin(0.135920032858849*x_103 - 1.44095981121063) + 0.0173934697390165*std::sin(0.323599934577942*x_105 + 1.91183984279633) - 0.0102429622927673*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.149300264795654*std::sin(0.136000037193298*x_108 + 4.91215991973877) - 0.00192170312048417*std::sin(0.596959829330444*x_110 - 7.18480014801025) - 0.016280882572423*std::sin(0.290879935026169*x_111 + 5.09975957870483) + 0.00573806623259212*std::sin(0.32847985625267*x_111 - 7.46783971786499) + 0.0846162614482723*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.0242183189595931*std::sin(0.441359847784042*x_111 + 8.42160034179688) - 0.0559308222095596*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.128729103631304*std::sin(0.193120002746582*x_114 + 4.97639989852905) - 0.00340194541293274*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.0185794502809581*std::sin(0.432879865169525*x_115 - 4.18359994888306) + 0.00331159168693961*std::sin(0.442319840192795*x_115 - 7.35264015197754) + 0.0019308626768801*std::sin(0.417359858751297*x_117 + 5.20456027984619) - 0.0168201379952137*std::sin(0.314319849014282*x_120 + 5.11375999450684) + 0.038685775544951*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.0348723216870834*std::sin(0.461839854717255*x_2 - 4.12639999389648) + 0.00324272920956226*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.0373492245472907*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.0227560349567943*std::sin(0.278719931840897*x_28 - 4.29207992553711) - 0.0142554689338839*std::sin(0.313039928674698*x_28 - 4.25007963180542) - 0.00426226668231314*std::sin(0.343599855899811*x_28 - 4.2596001625061) + 0.0145773641073014*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.0534987602489378*std::sin(0.285519927740097*x_3 - 7.52663993835449) + 0.058369645027661*std::sin(0.309999942779541*x_35 - 1.13671982288361) - 0.00231152853694767*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.0439854157911153*std::sin(0.322399854660034*x_35 + 1.97791981697083) - 0.020184601753884*std::sin(0.300879925489426*x_36 + 5.09055995941162) + 0.0223171666545933*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0311969017527985*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.026598556651855*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.0207219773044013*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.0327884148324287*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.0382416413666764*std::sin(0.39047983288765*x_43 + 8.19287967681885) - 0.0023443935751114*std::sin(0.431999862194061*x_43 + 8.21175956726074) - 0.078626844299647*std::sin(0.40871986746788*x_45 + 5.21023988723755) - 0.00227744647822963*std::sin(0.459439843893051*x_46 - 4.13912010192871) + 0.0402466848006098*std::sin(0.58383983373642*x_46 + 2.18727993965149) + 0.0935097148263673*std::sin(0.157680034637451*x_49 + 1.74911987781525) + 0.0507009784595914*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.0483625692638619*std::sin(0.266399949789047*x_53 + 5.08383941650391) + 0.0133635664369868*std::sin(0.284799933433533*x_53 + 8.30632019042969) + 0.0308598627938909*std::sin(0.303599923849106*x_55 + 5.13560009002686) - 0.174423261334712*std::sin(0.133360043168068*x_56 + 1.70503997802734) - 0.003531390836427*std::sin(0.808799862861633*x_57 + 2.41383981704712) + 0.01301205107148*std::sin(0.411359876394272*x_58 + 5.20424032211304) - 0.00125223489326505*std::sin(0.497999846935272*x_58 - 0.917919814586639) - 0.675995661779005*std::sin(0.1112000644207*x_59 + 1.70367991924286) + 0.202234794633335*std::sin(0.264479964971542*x_63 + 1.86495995521545) - 0.0336308748033293*std::sin(0.281199932098389*x_64 - 7.49600028991699) + 0.0867782479846531*std::sin(0.387279838323593*x_64 + 5.17727994918823) - 0.0177230323657097*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.0678262886654689*std::sin(0.242239981889725*x_70 + 5.05904006958008) - 0.0077929396257731*std::sin(0.56855982542038*x_70 + 5.37879991531372) + 0.0312647247868332*std::sin(0.276239961385727*x_71 - 4.30703973770142) - 0.126656937185415*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.0756513644407815*std::sin(0.241199985146523*x_73 - 7.54744052886963) - 0.00125730535530826*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.0569335083813546*std::sin(0.261919975280762*x_75 - 4.32567977905273) - 0.00584054888101649*std::sin(0.473759859800339*x_75 + 5.26640033721924) + 0.00765698418429483*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.0461438092571415*std::sin(0.282159954309464*x_78 + 5.10751962661743) + 0.0132673826606123*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.0331992631828365*std::sin(0.404719859361649*x_80 + 5.20512008666992) - 0.0166524403722181*std::sin(0.363439828157425*x_81 + 5.15120029449463) - 0.125084799554993*std::sin(0.262559950351715*x_84 + 1.8562399148941) + 0.0250982217522287*std::sin(0.286319941282272*x_84 - 7.49336004257202) - 0.261549483984738*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.300247168873821*std::sin(0.118160054087639*x_86 + 4.88919973373413) + 0.103099559187751*std::sin(0.25095996260643*x_86 + 5.07471990585327) + 0.00370220713981785*std::sin(0.346959829330444*x_86 - 7.45160007476807) + 0.0403157454801567*std::sin(0.290559947490692*x_87 + 5.0991997718811) - 0.0701076211893416*std::sin(0.347999840974808*x_87 + 5.15296030044556) + 0.00413637068609331*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.01013609896845*std::sin(0.792079865932465*x_87 - 0.782159864902496) + 0.000581786482227594*std::sin(0.983599841594696*x_87 - 7.00167989730835) - 0.0182764241422484*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.0357449528093713*std::sin(0.352719843387604*x_92 + 2.00847983360291) + 0.00721216878648388*std::sin(0.371759831905365*x_92 - 1.19367980957031) + 0.091453970060585*std::sin(0.372879832983017*x_95 - 7.40407991409302) + 0.0164199868971041*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.0130970572583267*std::sin(0.405119866132736*x_95 - 0.992079794406891) - 0.00133647811279632*std::sin(0.420239865779877*x_95 + 1.98823988437653) - 0.0578073399113256*std::sin(0.404959857463837*x_97 + 5.19767999649048) - 0.0263161779997606*std::sin(0.36303985118866*x_98 - 4.22512006759644) - 0.0095789759857264*std::sin(0.432399868965149*x_98 + 2.00271987915039) + 0.404521406863594);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0240059401300947*x_1 - 0.00151928348905168*x_10 - 0.00138031835656979*x_100 + 0.0524035402918323*x_101 - 0.0155003338860317*x_103 + 0.0175071605246132*x_104 - 0.0265218877461839*x_105 + 0.0225598540670736*x_106 - 0.0178573629595268*x_107 - 0.025226039039866*x_108 - 0.0140197128620998*x_11 + 0.00460732519994341*x_110 - 0.00390135992353996*x_111 + 0.00219844376801563*x_112 + 0.0144235510187979*x_113 - 0.0123073529918826*x_114 + 0.0203410388273075*x_116 - 0.00670716734783237*x_117 - 0.0363921755640383*x_118 + 0.0159844888778009*x_119 - 0.0986702176038688*x_12 - 0.000182810164982276*x_120 + 0.00169532809191233*x_13 - 0.0233252152859098*x_14 - 0.00584194876328795*x_15 - 0.0272167993214189*x_16 + 0.0120837238804326*x_17 + 0.0338838529292655*x_18 - 0.0195116025997799*x_19 - 0.0301234219809155*x_2 - 0.0119834385794334*x_20 - 0.0459746189934931*x_21 + 0.0127702004707806*x_22 + 0.0137326967600532*x_23 + 0.000300515408011452*x_24 - 0.00188961844697144*x_25 - 0.000430148137778948*x_26 + 0.0196663944059489*x_27 - 0.00328058707822654*x_28 + 0.0052710986703083*x_29 - 0.0334265035808064*x_3 + 0.0273934007567722*x_30 - 0.0476722060508051*x_32 - 0.0165637214971386*x_33 - 0.00746235272750757*x_34 + 0.00101850981519513*x_35 - 0.00111949170177454*x_36 - 0.0291319288564129*x_37 - 0.00165508414226053*x_38 + 0.00725171819554138*x_39 - 0.00630956437576279*x_4 - 0.0195683860055219*x_40 + 0.00425432184121823*x_41 + 0.00195479758989064*x_42 - 0.00286635459155219*x_43 - 0.0395368087568149*x_44 - 0.0124901380320885*x_45 - 0.0029933662876396*x_46 - 0.00376571743279695*x_47 + 0.01167020249167*x_48 - 0.00865138795073957*x_49 + 0.0326897779265805*x_5 - 0.00301636265509165*x_50 - 0.0246894385383828*x_51 + 0.00110116672685892*x_52 + 0.0100048194873854*x_53 + 0.0193833929361101*x_54 - 0.0359374796962649*x_55 - 0.0171364126041219*x_56 - 0.00760843928504532*x_57 + 0.0169611757366866*x_58 - 0.00282500403248744*x_59 + 0.00360394516234267*x_6 - 0.00988236392277197*x_60 + 0.00570491860341659*x_61 - 0.00396236976362257*x_62 + 0.0299517183307539*x_63 - 0.00233182292318313*x_64 - 0.0278545367950134*x_65 - 0.00127185788042609*x_66 + 0.00583440779158571*x_67 - 0.00872331535028438*x_68 + 0.0266431229395815*x_69 + 0.00159356480428014*x_7 - 0.000516004006793534*x_70 + 0.010144426463803*x_71 - 0.0114951286476401*x_72 - 5.66603996277884e-5*x_73 - 0.00776672930151415*x_74 + 0.00843829768345587*x_75 - 0.0267609278222313*x_76 + 0.0016183621483286*x_77 + 0.0163748629733706*x_78 + 0.0221610892652063*x_79 + 0.0197539952884762*x_8 + 0.00138665570624205*x_80 - 0.00295071088521091*x_81 + 0.0265649912638722*x_82 + 0.013802370029803*x_83 + 0.0270786517419273*x_84 - 0.0240161692098004*x_85 - 0.0129610735306412*x_86 + 0.00389879327121769*x_88 + 0.0120858406765967*x_89 + 0.0327770449692769*x_9 - 0.00386764560270697*x_90 + 0.0290083170728557*x_91 - 0.00590721907504026*x_92 - 0.00091917250395521*x_93 - 0.0185978202508361*x_94 - 0.000310470255790866*x_95 - 0.00740778910727241*x_96 - 0.0100383889774502*x_97 + 0.00687925881136937*x_98 + 0.00722274408664781*x_99 + 2.72244358604888e-5*std::pow(-8.0*x_114 - 9.99962043762207, 2) + 1.17515258049946e-5*std::pow(-7.86952018737793*x_115 - 9.08383941650391, 2) + 0.000323940287978055*std::pow(-4.51136016845703*x_115 - 5.94143962860107, 2) + 0.000324451313125*std::pow(-4.6637601852417*x_15 - 6.48375988006592, 2) + 3.40647992484808e-5*std::pow(-5.6386399269104*x_23 - 7.65976047515869, 2) - 1.64806474773297e-5*std::pow(-7.05600023269653*x_24 - 9.61480045318604, 2) - 3.95299629707259e-5*std::pow(-5.69040012359619*x_40 - 5.8950400352478, 2) + 1.39336727005824e-5*std::pow(-7.64344024658203*x_48 - 7.65119981765747, 2) + 2.44988474414305e-5*std::pow(-6.87992000579834*x_50 - 6.67888021469116, 2) - 2.10009299976315e-5*std::pow(-6.55320024490356*x_59 - 7.7480001449585, 2) + 0.00062663892814864*std::pow(-4.68255996704102*x_59 - 5.90823984146118, 2) + 0.000158854554712372*std::pow(-6.28327989578247*x_7 - 9.11575984954834, 2) + 0.000197801665993371*std::pow(-5.79672002792358*x_70 - 7.99311971664429, 2) + 0.000532690040265014*std::pow(-5.08551979064941*x_70 - 6.91183996200562, 2) - 6.37741727298361e-5*std::pow(-5.12688016891479*x_77 - 7.48663997650146, 2) - 0.000103170496694244*std::pow(-5.22112035751343*x_81 - 7.03175973892212, 2) + 1.79218773190023e-5*std::pow(-9.80000019073486*x_84 - 9.90707969665527, 2) + 2.44491960709656e-5*std::pow(-9.25152015686035*x_88 - 8.66520023345947, 2) - 4.13265396349205e-5*std::pow(-8.10367965698242*x_88 - 8.89791965484619, 2) - 3.33773151201944e-5*std::pow(-6.60647964477539*x_89 - 6.22368001937866, 2) + 3.87932083441881e-5*std::pow(-5.47584009170532*x_90 - 8.41143989562988, 2) - 2.93782061419268e-5*std::pow(-6.67664003372192*x_99 - 5.89383983612061, 2) + 0.00663161956068921*std::exp(0.556959867477417*x_1) + 0.0002224833111936*std::exp(1.15583980083466*x_1) - 4.89355128541984e-5*std::exp(1.25871992111206*x_1) - 0.00451044914982063*std::exp(1.35671985149384*x_100) + 0.00048477366038604*std::exp(1.49143993854523*x_100) - 0.00530861341146525*std::exp(1.58023989200592*x_100) + 0.00201086205260023*std::exp(0.715599834918976*x_104) + 0.00778091336652812*std::exp(0.580799877643585*x_109) - 0.0119992601951668*std::exp(0.60999983549118*x_109) + 0.00156888780930968*std::exp(0.793439865112305*x_109) + 0.0212181104827688*std::exp(0.801999866962433*x_109) + 0.00503390735168783*std::exp(0.865199863910675*x_109) - 0.00137766875739801*std::exp(1.1865599155426*x_110) - 6.46564612835762e-5*std::exp(1.69735991954803*x_110) - 0.0035608143719417*std::exp(0.49823984503746*x_112) - 0.00229295870371342*std::exp(0.789599895477295*x_112) - 0.00106005273871461*std::exp(0.855839908123016*x_112) + 0.00347243987056529*std::exp(0.682959854602814*x_114) - 0.0176111242226935*std::exp(0.611999869346619*x_23) + 0.0366792290891242*std::exp(0.579439878463745*x_26) + 0.00585431771426952*std::exp(0.771439850330353*x_26) + 0.00268271798145836*std::exp(0.956879794597626*x_26) - 0.00166396901274099*std::exp(0.595679819583893*x_31) - 0.0100977245162594*std::exp(0.637759864330292*x_31) - 0.0146970791858107*std::exp(0.657039821147919*x_31) + 0.0028709261979961*std::exp(0.663919866085052*x_31) + 0.00342195130568704*std::exp(0.667439818382263*x_31) + 0.00142774468257776*std::exp(0.782479882240295*x_49) + 0.0145828906456595*std::exp(0.841519832611084*x_50) + 0.00263133911140084*std::exp(0.942319810390472*x_66) + 0.00255939234853504*std::exp(1.11359989643097*x_66) - 0.00279481046482362*std::exp(1.22135984897614*x_66) + 0.00306296686599812*std::exp(1.04599988460541*x_68) - 0.00660185156932728*std::exp(1.10527992248535*x_68) - 0.0121383573313755*std::exp(0.880079865455627*x_72) + 0.0239874111330726*std::exp(0.601599872112274*x_74) - 0.0027405404819609*std::exp(1.07575976848602*x_74) + 0.00205714544283169*std::exp(1.08567976951599*x_74) + 0.00870790073767276*std::exp(0.743279814720154*x_77) + 0.00118161580744853*std::exp(0.79695987701416*x_80) - 0.0128814660739173*std::exp(0.936159789562225*x_81) + 0.0374255025501543*std::sin(0.498079836368561*x_10 - 0.920319855213165) - 0.0133574311825867*std::sin(0.265119940042496*x_100 - 7.51448011398315) + 0.0852917536475317*std::sin(0.124000057578087*x_102 + 1.72023987770081) + 0.0120622230301725*std::sin(0.354159861803055*x_102 - 7.43056011199951) - 0.158572221042617*std::sin(0.360079854726791*x_102 - 4.23984003067017) - 0.0822933757776942*std::sin(0.375039845705032*x_102 + 1.98391973972321) + 0.00720394024659303*std::sin(0.376559853553772*x_102 + 5.18311977386475) - 1.14394723592388*std::sin(0.135920032858849*x_103 - 1.44095981121063) + 0.0202045254586778*std::sin(0.323599934577942*x_105 + 1.91183984279633) + 0.0189017600602367*std::sin(0.437919855117798*x_105 - 4.17088031768799) - 0.125021107358893*std::sin(0.136000037193298*x_108 + 4.91215991973877) + 0.0828454810760068*std::sin(0.596959829330444*x_110 - 7.18480014801025) - 0.0189121268706025*std::sin(0.290879935026169*x_111 + 5.09975957870483) - 0.247370601846821*std::sin(0.32847985625267*x_111 - 7.46783971786499) - 0.0812362991913367*std::sin(0.399279862642288*x_111 + 2.00383973121643) - 0.0202799443044749*std::sin(0.441359847784042*x_111 + 8.42160034179688) + 0.0536966881928582*std::sin(0.445599853992462*x_112 + 5.21031999588013) - 0.107795221310096*std::sin(0.193120002746582*x_114 + 4.97639989852905) + 0.00627774994140927*std::sin(0.422959864139557*x_115 + 8.4026403427124) + 0.0155580665005794*std::sin(0.432879865169525*x_115 - 4.18359994888306) - 0.142764198854345*std::sin(0.442319840192795*x_115 - 7.35264015197754) - 0.0832403536491815*std::sin(0.417359858751297*x_117 + 5.20456027984619) + 0.0310388931910931*std::sin(0.314319849014282*x_120 + 5.11375999450684) - 0.0371404879254767*std::sin(0.584559857845306*x_120 - 4.00031995773315) + 0.0292013967923092*std::sin(0.461839854717255*x_2 - 4.12639999389648) - 0.139795506653348*std::sin(0.301679849624634*x_24 + 5.10272026062012) + 0.0312755065658408*std::sin(0.385919839143753*x_24 + 5.174720287323) - 0.0190554564205899*std::sin(0.278719931840897*x_28 - 4.29207992553711) + 0.0263062037751224*std::sin(0.313039928674698*x_28 - 4.25007963180542) + 0.183748223129024*std::sin(0.343599855899811*x_28 - 4.2596001625061) + 0.0169332932787821*std::sin(0.3643998503685*x_28 - 4.23311996459961) - 0.0447988103557928*std::sin(0.285519927740097*x_3 - 7.52663993835449) - 0.0560380932222811*std::sin(0.309999942779541*x_35 - 1.13671982288361) + 0.0996510291434091*std::sin(0.321119844913483*x_35 - 7.4300799369812) - 0.0368325226842241*std::sin(0.322399854660034*x_35 + 1.97791981697083) + 0.0372474766926308*std::sin(0.300879925489426*x_36 + 5.09055995941162) + 0.0259239685125518*std::sin(0.395119845867157*x_36 + 5.20344018936157) - 0.0261236723768691*std::sin(0.413039863109589*x_36 + 5.20256042480469) - 0.022273108566248*std::sin(0.566959857940674*x_38 + 2.16863989830017) + 0.0173521765203026*std::sin(0.50903981924057*x_4 + 8.50519943237305) + 0.0274563741497955*std::sin(0.389039844274521*x_41 - 7.40383958816528) + 0.0320227988706335*std::sin(0.39047983288765*x_43 + 8.19287967681885) + 0.101067855638737*std::sin(0.431999862194061*x_43 + 8.21175956726074) + 0.0754861268823783*std::sin(0.40871986746788*x_45 + 5.21023988723755) + 0.0981817363476282*std::sin(0.459439843893051*x_46 - 4.13912010192871) - 0.0386390472937696*std::sin(0.58383983373642*x_46 + 2.18727993965149) + 0.108622341728918*std::sin(0.157680034637451*x_49 + 1.74911987781525) + 0.0588950465569739*std::sin(0.21815998852253*x_53 + 5.01399946212769) - 0.0404978649727433*std::sin(0.266399949789047*x_53 + 5.08383941650391) - 0.0246603393746082*std::sin(0.284799933433533*x_53 + 8.30632019042969) + 0.0358472974527813*std::sin(0.303599923849106*x_55 + 5.13560009002686) - 0.20261277807714*std::sin(0.133360043168068*x_56 + 1.70503997802734) + 0.00651662091113956*std::sin(0.808799862861633*x_57 + 2.41383981704712) - 0.0240116735974249*std::sin(0.411359876394272*x_58 + 5.20424032211304) + 0.0539844063564656*std::sin(0.497999846935272*x_58 - 0.917919814586639) + 0.648993289143315*std::sin(0.1112000644207*x_59 + 1.70367991924286) - 0.194156607755301*std::sin(0.264479964971542*x_63 + 1.86495995521545) - 0.039066148178431*std::sin(0.281199932098389*x_64 - 7.49600028991699) - 0.0833119260520725*std::sin(0.387279838323593*x_64 + 5.17727994918823) + 0.0327050413485363*std::sin(0.173920020461082*x_67 - 4.43959999084473) - 0.0567964010553297*std::sin(0.242239981889725*x_70 + 5.05904006958008) - 0.009052400092069*std::sin(0.56855982542038*x_70 + 5.37879991531372) + 0.0363175914519886*std::sin(0.276239961385727*x_71 - 4.30703973770142) + 0.121597677181031*std::sin(0.217999994754791*x_73 - 4.382080078125) + 0.0633489657137771*std::sin(0.241199985146523*x_73 - 7.54744052886963) + 0.0542029962430975*std::sin(0.511119842529297*x_73 + 8.51000022888184) + 0.0476750009345663*std::sin(0.261919975280762*x_75 - 4.32567977905273) + 0.0107778053275672*std::sin(0.473759859800339*x_75 + 5.26640033721924) + 0.00889447213290903*std::sin(0.348879843950272*x_76 + 8.32695960998535) - 0.0386399189511238*std::sin(0.282159954309464*x_78 + 5.10751962661743) - 0.0244828474918154*std::sin(0.341039836406708*x_79 - 4.25072002410889) + 0.027800410483521*std::sin(0.404719859361649*x_80 + 5.20512008666992) - 0.0193437342001333*std::sin(0.363439828157425*x_81 + 5.15120029449463) + 0.120088337950852*std::sin(0.262559950351715*x_84 + 1.8562399148941) + 0.0291544854459338*std::sin(0.286319941282272*x_84 - 7.49336004257202) + 0.251101995888968*std::sin(0.166400015354156*x_85 + 4.94312000274658) + 0.251421078089545*std::sin(0.118160054087639*x_86 + 4.88919973373413) - 0.0989812890964359*std::sin(0.25095996260643*x_86 + 5.07471990585327) - 0.00683183526893822*std::sin(0.346959829330444*x_86 - 7.45160007476807) + 0.0468313981144432*std::sin(0.290559947490692*x_87 + 5.0991997718811) + 0.0673072006852005*std::sin(0.347999840974808*x_87 + 5.15296030044556) - 0.00763301513703115*std::sin(0.453119844198227*x_87 + 5.2597599029541) + 0.00848777005901094*std::sin(0.792079865932465*x_87 - 0.782159864902496) - 0.0250810754740926*std::sin(0.983599841594696*x_87 - 7.00167989730835) - 0.0212301790508955*std::sin(0.332959830760956*x_92 + 8.3908805847168) + 0.0299321209432248*std::sin(0.352719843387604*x_92 + 2.00847983360291) - 0.0133089120138913*std::sin(0.371759831905365*x_92 - 1.19367980957031) - 0.0878008783053949*std::sin(0.372879832983017*x_95 - 7.40407991409302) + 0.019073712621554*std::sin(0.378959834575653*x_95 + 1.9592798948288) + 0.0109672183356134*std::sin(0.405119866132736*x_95 - 0.992079794406891) + 0.0576161692313162*std::sin(0.420239865779877*x_95 + 1.98823988437653) + 0.055498249155838*std::sin(0.404959857463837*x_97 + 5.19767999649048) - 0.0305692824001961*std::sin(0.36303985118866*x_98 - 4.22512006759644) + 0.0176764787890333*std::sin(0.432399868965149*x_98 + 2.00271987915039) - 1.98552683444479);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
