
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000123758129763955*x_1 - 6.27969898525593e-5*x_10 + 1.70519753976557e-5*x_100 + 9.81512427902505e-5*x_101 - 2.79360076496854e-5*x_102 + 2.66757063745228e-5*x_103 + 1.95317259905332e-6*x_104 - 1.03651658773316e-5*x_105 - 1.12140596874346e-5*x_106 + 1.07254966053606e-5*x_107 + 5.01576075091053e-5*x_108 + 7.89076409459043e-6*x_109 - 1.99959565439787e-5*x_11 - 2.40773338295851e-5*x_110 + 5.49882113100568e-5*x_111 + 1.14131261685127e-5*x_112 - 8.44441892813647e-6*x_113 - 1.12120804448398e-6*x_114 + 2.76216668801589e-6*x_115 - 6.5891365258393e-5*x_116 + 1.57298629668285e-5*x_117 - 2.96072811911939e-5*x_118 + 1.22399318561505e-5*x_119 + 2.48138466318978e-5*x_12 - 6.96407211419698e-6*x_120 - 6.30227567005303e-5*x_13 + 6.90378079954549e-7*x_14 - 9.52054237501043e-7*x_15 - 7.76487584197788e-5*x_16 + 1.33024654446542e-5*x_17 + 1.25238137109852e-5*x_18 - 1.59044658098695e-6*x_19 - 3.30445599870303e-6*x_2 - 3.09168563115247e-5*x_20 - 4.85614521747697e-7*x_21 - 2.97898049591797e-5*x_22 - 1.65395207006152e-5*x_23 - 1.20188964550076e-5*x_24 - 3.65854334454143e-5*x_25 + 2.18885484991554e-5*x_26 - 1.97827755230604e-5*x_27 - 6.95419153582492e-5*x_28 + 1.25289165549449e-5*x_29 - 5.75795031485231e-6*x_3 - 3.28565156473508e-5*x_30 - 8.79389384022898e-5*x_31 - 4.3242370856359e-5*x_32 + 8.56246456938096e-5*x_33 + 4.3204023078155e-5*x_34 - 4.28682725020947e-5*x_35 - 2.58491727363421e-5*x_36 - 1.56715233014313e-5*x_37 + 3.29727730812521e-6*x_38 - 1.34244476520909e-5*x_39 + 1.4914886471079e-5*x_4 + 2.28454325094587e-5*x_40 + 1.76330006028682e-5*x_41 - 4.73135719773451e-5*x_42 - 1.84474813077457e-5*x_43 - 1.82540970497148e-5*x_44 - 1.40672584495566e-5*x_45 + 3.254760773412e-5*x_46 + 1.36013423699236e-6*x_47 - 0.000119435017569721*x_48 + 2.39183243024816e-5*x_49 - 3.16946540818123e-5*x_5 + 8.13454468997749e-6*x_50 + 8.39644070230068e-7*x_51 - 7.31540263368261e-5*x_52 - 3.04397462934331e-6*x_53 - 1.80883198927956e-5*x_54 - 1.55534299599168e-5*x_55 + 3.90647450199242e-5*x_56 - 2.65292277038262e-5*x_57 - 9.14252159617675e-6*x_58 + 2.65926996092037e-5*x_59 + 6.68542163322213e-5*x_6 - 1.71033924291348e-6*x_60 - 4.70398363118548e-5*x_61 + 1.27494132926766e-5*x_62 - 4.7402007707406e-6*x_63 + 5.38593930719833e-6*x_64 - 1.71145131970198e-5*x_65 - 4.93788737982441e-5*x_66 + 2.39069769663731e-5*x_67 - 1.23594262221304e-5*x_68 - 2.36602769569163e-5*x_69 - 3.25302066025439e-5*x_7 - 3.18411558687654e-5*x_70 - 1.1496051210551e-5*x_71 - 4.76375026054017e-5*x_72 + 4.1913890539161e-6*x_73 + 3.54170204122264e-6*x_74 + 5.42133359828401e-6*x_75 - 4.62963976574033e-5*x_76 + 2.48499483128621e-5*x_77 + 5.12316521756676e-6*x_78 - 2.54331107645047e-5*x_79 - 1.44917567982948e-5*x_8 - 1.37760786876456e-5*x_80 + 4.13707606389961e-5*x_81 - 2.30414515596269e-5*x_82 - 3.7173564107139e-5*x_83 - 1.46702863629469e-5*x_84 - 1.51986691671404e-5*x_85 - 2.17930232513966e-5*x_86 + 3.58662636383288e-5*x_87 + 7.84098547070453e-7*x_88 - 2.52985956972539e-5*x_89 + 3.12605526667734e-5*x_9 - 2.50814635914844e-5*x_90 + 7.70320873702548e-5*x_91 - 5.09066092494697e-5*x_92 + 2.81852584322739e-5*x_93 + 5.04538258699892e-6*x_94 + 5.9385136003588e-6*x_95 + 1.07242416015697e-5*x_96 - 2.81155894721582e-5*x_97 + 6.07022396098729e-5*x_98 - 2.7429001110555e-5*x_99 + 5.70635096139338e-6*std::sin(1.61255979537964*x_23 + 4.38775968551636) - 8.50755377834688e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) + 1.71449727404434e-5*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0296682978041178);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.28963138057988e-5*x_1 + 2.91165812089048e-5*x_10 + 6.57084119125651e-5*x_100 - 5.02658706254131e-5*x_101 - 1.13430487281287e-5*x_102 + 1.37752009390917e-5*x_103 - 7.06540975159919e-5*x_104 - 1.47574225921184e-5*x_105 - 4.64510379304573e-5*x_106 - 1.96083639533496e-6*x_107 + 3.58344739606737e-5*x_108 - 4.36649262606734e-5*x_109 + 1.47447789230361e-6*x_11 + 2.20056065390382e-5*x_110 - 1.25603165834421e-6*x_111 - 2.31438024924667e-6*x_112 + 1.84809599086921e-5*x_113 + 1.97590635552196e-5*x_114 + 1.12895265681358e-6*x_115 - 1.91045799681098e-5*x_116 + 2.11341407920107e-5*x_117 + 2.8110238241798e-5*x_118 - 2.34399801855632e-5*x_119 + 6.36874430776948e-6*x_12 - 2.77048990394999e-5*x_120 - 1.84167235413421e-5*x_13 + 2.39981788130702e-5*x_14 - 1.00455471945662e-6*x_15 - 2.84565294080558e-5*x_16 + 1.09393130916622e-5*x_17 - 6.73529339170036e-6*x_18 - 1.55755379365527e-5*x_19 - 1.94433652178206e-5*x_2 - 5.7333187348953e-7*x_20 + 9.8408941690934e-6*x_21 - 5.77877923473448e-6*x_22 + 6.82129558848633e-6*x_23 + 2.36915277412116e-6*x_24 + 3.63149406140848e-6*x_25 - 2.85414056653376e-6*x_26 + 5.90932594187027e-6*x_27 + 1.67283232171433e-5*x_28 + 8.17003093428822e-6*x_29 + 2.21395351386034e-5*x_3 - 3.12673455295883e-6*x_30 + 5.82469043498795e-5*x_31 + 1.70075405779043e-5*x_32 - 5.27474242286893e-5*x_33 + 1.06182221144985e-5*x_34 - 5.82065494158726e-6*x_35 - 6.03711805384406e-6*x_36 + 2.4743560261321e-5*x_37 - 3.8230653618179e-5*x_38 + 3.78100171120031e-5*x_39 - 9.10417002171464e-7*x_4 + 1.60662180437158e-5*x_40 - 2.69353349420549e-6*x_41 - 4.30190914227238e-6*x_42 + 4.40232875347681e-5*x_43 - 1.92570198117672e-5*x_44 + 8.28035497314713e-6*x_45 - 3.48564155879219e-5*x_46 + 2.7674459628659e-5*x_47 + 1.33805629864838e-5*x_48 - 1.53109433977274e-5*x_49 - 2.13184497293285e-5*x_5 - 6.01247198479445e-6*x_50 + 1.93226642839002e-5*x_51 + 3.39744980561344e-5*x_52 - 1.64944194325837e-7*x_53 + 5.38309434807967e-5*x_54 - 4.47683433143341e-6*x_55 - 6.85472306788484e-6*x_56 + 9.46745620462559e-6*x_57 - 4.12098724995736e-6*x_58 - 1.0822550026629e-5*x_59 - 2.75419267696946e-5*x_6 - 1.45577325837792e-5*x_60 + 4.50700202967503e-6*x_61 + 2.85628241531667e-7*x_62 - 2.4401412823952e-5*x_63 - 2.49458744426854e-5*x_64 - 3.0235298554325e-6*x_65 + 7.4742940938235e-6*x_66 - 7.44570554854363e-6*x_67 - 6.77754738806409e-6*x_68 - 2.06152019346814e-6*x_69 + 8.69525205650385e-6*x_7 - 6.70235899135719e-6*x_70 - 3.62484475389318e-5*x_71 - 1.84994722724678e-5*x_72 + 1.01526420960326e-5*x_73 - 1.18452541585513e-5*x_74 + 1.95911252414399e-5*x_75 - 1.30854035067279e-5*x_76 - 8.57219192413982e-7*x_77 + 4.76987323542472e-7*x_78 + 4.71983065453695e-6*x_79 + 1.66298213968743e-5*x_8 - 6.3788874735738e-6*x_80 - 1.7099632170302e-6*x_81 + 2.91214712873475e-6*x_82 - 5.37791348461172e-5*x_83 + 1.1701548621323e-5*x_84 - 3.82032638409182e-5*x_85 + 3.23519983852614e-6*x_86 + 5.62924537128916e-7*x_87 + 2.25956482118921e-5*x_88 - 2.52662758192183e-5*x_89 - 1.16165444047402e-5*x_9 - 2.45216115482673e-5*x_90 + 1.2752034709121e-5*x_91 + 2.49967194852958e-5*x_92 - 3.4995314802182e-5*x_93 + 1.67100009434558e-5*x_94 + 4.23901999141027e-6*x_95 + 6.93303095513147e-6*x_96 + 3.57734158627228e-5*x_97 - 5.03339274901564e-5*x_98 + 2.31021966029014e-5*x_99 + 1.14502075377203e-5*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 3.037955076975e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 6.12228360095642e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0741039394056818);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.09503800732533e-5*x_1 + 7.73871823102706e-6*x_10 - 4.34218884097064e-6*x_100 - 5.05491652299839e-5*x_101 - 2.53254578350512e-5*x_102 + 4.42239701052226e-6*x_103 - 3.64975390094514e-5*x_104 - 8.28051628534019e-6*x_105 + 1.51795420898927e-5*x_106 - 2.79560015239971e-5*x_107 + 1.13484086864256e-5*x_108 - 2.02853167097523e-5*x_109 - 3.03663718373466e-5*x_11 - 2.99840431016867e-5*x_110 - 4.56567140338945e-5*x_111 - 6.46192384659997e-6*x_112 - 6.11677434262111e-5*x_113 + 1.86889757501648e-5*x_114 - 1.78788726790674e-5*x_115 - 8.98172192135671e-5*x_116 + 3.6539461186936e-6*x_117 - 2.47145398291296e-6*x_118 - 3.66700710121149e-5*x_119 + 3.82658628342665e-5*x_12 + 8.96942586825085e-6*x_120 + 3.77435729422759e-6*x_13 - 2.44470909554568e-5*x_14 + 2.0114410503146e-5*x_15 - 1.79139939096062e-5*x_16 - 1.05163914065319e-6*x_17 - 1.6427976834631e-6*x_18 - 6.56635787349594e-6*x_19 - 7.57707802302517e-6*x_2 + 6.72665918785597e-6*x_20 - 1.35995275011674e-5*x_21 - 5.19037681924018e-6*x_22 - 6.11849874424961e-6*x_23 - 1.83347331253529e-5*x_24 - 6.05083599228331e-6*x_25 - 6.87117283182948e-6*x_26 + 1.22925981738683e-5*x_27 - 1.6155456865561e-5*x_28 - 2.07554139879122e-6*x_29 - 1.30056415615857e-5*x_3 - 1.46423487883415e-5*x_30 - 3.84963171967653e-5*x_31 - 7.36033666006711e-6*x_32 - 1.52260365837327e-6*x_33 + 1.69580026858058e-6*x_34 - 6.2250191745832e-6*x_35 - 7.28351749445006e-6*x_36 - 2.19141604612963e-6*x_37 + 1.61925817643592e-5*x_38 - 3.04026805497135e-5*x_39 - 6.07514714993056e-6*x_4 - 1.32454370102488e-6*x_40 - 2.69249920262643e-6*x_41 + 3.88853172106828e-5*x_42 + 5.02575372833105e-6*x_43 - 3.89562709778958e-5*x_44 - 2.42117824948423e-5*x_45 + 2.71619119388076e-5*x_46 - 2.16685416936298e-5*x_47 - 1.78740516376477e-5*x_48 - 4.50434264929919e-6*x_49 - 1.36496267139701e-5*x_5 - 6.58931315300498e-6*x_50 - 1.51568189063242e-5*x_51 - 6.60080100770638e-5*x_52 - 2.65696020225612e-5*x_53 + 5.09786443335235e-6*x_54 - 3.81123178806724e-5*x_55 - 3.28274031314168e-5*x_56 - 2.87250945090752e-6*x_57 + 1.68249946118619e-5*x_58 + 1.64427933195744e-5*x_59 - 1.22975833600956e-5*x_6 - 2.03017404849875e-5*x_60 - 1.0137078862065e-5*x_61 - 1.32945556340582e-5*x_62 - 3.66145174623467e-5*x_63 - 9.55836233882759e-6*x_64 + 1.00176894195816e-5*x_65 - 2.7073864751091e-6*x_66 - 4.21653123489403e-6*x_67 + 5.53472201530019e-6*x_68 + 7.79661982759734e-6*x_69 - 2.20174489555014e-5*x_7 - 1.52523544046397e-5*x_70 + 2.62542106084628e-5*x_71 - 3.87056589685826e-5*x_72 - 9.6773885012522e-6*x_73 + 3.05750523385675e-6*x_74 + 3.17642878707532e-5*x_75 - 1.9756360523321e-6*x_76 - 4.67108872211784e-6*x_77 + 2.97333166857834e-6*x_78 - 2.48610860884525e-5*x_79 - 1.75185756629056e-5*x_8 - 8.48105354086538e-6*x_80 - 2.91096483303796e-5*x_81 - 1.11344886248614e-5*x_82 - 5.2261414156261e-6*x_83 - 2.40106383142642e-5*x_84 - 3.52373610514405e-5*x_85 - 1.58376538518963e-5*x_86 - 4.6918361061795e-6*x_87 - 9.42051982616588e-6*x_88 - 5.62006960457028e-6*x_89 - 8.27435762351166e-6*x_9 - 1.56365435479236e-5*x_90 - 4.42363806290221e-5*x_91 - 2.14741760931008e-5*x_92 - 8.72229451675198e-6*x_93 + 7.30238023940471e-6*x_94 - 1.25656117153735e-5*x_95 - 1.45722883744621e-5*x_96 - 1.74079769840896e-5*x_97 + 2.56438235395186e-7*x_98 + 2.38557335555058e-6*x_99 + 8.27535897527249e-6*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 4.51215361812668e-7*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 9.09318386918347e-7*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0212787157693064);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000154890971093012*x_1 + 4.06032175030143e-5*x_10 + 2.95907799377381e-5*x_100 - 8.04439829941095e-6*x_101 - 7.34322560956913e-6*x_102 + 7.17163235316917e-5*x_103 - 3.38142735250634e-5*x_104 - 2.16470111292245e-5*x_105 + 1.81817670730545e-5*x_106 - 4.06315634188152e-5*x_107 + 7.76647085208576e-5*x_108 + 1.26823020798006e-7*x_109 - 4.28179025835287e-5*x_11 - 3.9756066398197e-5*x_110 + 9.38541693470571e-6*x_111 - 1.47293930735045e-5*x_112 - 5.99246100210438e-5*x_113 + 5.35088200413302e-5*x_114 + 2.07403252238745e-6*x_115 - 0.000102921582602849*x_116 + 6.04992654538727e-6*x_117 + 1.5603086944566e-5*x_118 + 2.43518896504916e-5*x_119 - 2.53211160952395e-5*x_12 - 1.36610925705181e-6*x_120 + 1.88952895848549e-5*x_13 - 1.28967830714335e-5*x_14 + 3.13697313003269e-5*x_15 + 1.28973261288586e-5*x_16 + 1.38386764876195e-5*x_17 + 2.00979454719153e-5*x_18 + 2.34865818995506e-5*x_19 + 1.36990526096661e-5*x_2 - 8.14399139889934e-6*x_20 - 9.22902239280166e-6*x_21 - 3.52072212900953e-5*x_22 + 4.57609416608743e-6*x_23 - 1.30841081045987e-5*x_24 - 1.15777470494278e-5*x_25 - 1.66727899156939e-5*x_26 + 2.41522594153562e-5*x_27 - 9.8313732877287e-6*x_28 - 1.9153014505753e-5*x_29 - 6.47655593455891e-6*x_3 - 5.82200759666596e-6*x_30 + 0.000160234959498939*x_31 - 1.82550813703769e-5*x_32 - 3.33899521090306e-7*x_33 + 2.02482027907418e-5*x_34 - 1.06262664399131e-5*x_35 + 1.06031437159426e-5*x_36 + 1.03742480152296e-6*x_37 - 2.91459645307042e-5*x_38 - 5.5080133943725e-5*x_39 - 3.49205503606097e-5*x_4 + 2.31770546706587e-5*x_40 - 1.43982593408101e-5*x_41 + 1.52653051359463e-5*x_42 + 3.55275123667444e-5*x_43 - 4.64472000352916e-5*x_44 - 9.24169080305522e-6*x_45 - 5.45325303376304e-6*x_46 - 3.49520815249268e-5*x_47 - 4.22931034463135e-5*x_48 + 7.46482146768221e-7*x_49 - 2.72097318635348e-6*x_5 + 5.82206845898764e-6*x_50 + 2.01920780098512e-5*x_51 - 6.73079542939627e-6*x_52 - 3.04874457664392e-5*x_53 + 4.13058430168201e-5*x_54 - 2.7719291738474e-5*x_55 + 1.03190717108692e-5*x_56 + 1.65429191917405e-5*x_57 + 6.7984942609404e-6*x_58 + 2.68483436856637e-5*x_59 - 2.91823480584122e-5*x_6 - 3.78144815799315e-5*x_60 + 1.71533692906119e-6*x_61 - 2.44095180625664e-5*x_62 - 5.46046185830109e-5*x_63 - 1.95951863194521e-5*x_64 + 3.69793957828477e-5*x_65 + 2.56948506141139e-6*x_66 + 2.29793341608651e-5*x_67 - 5.33903762038625e-6*x_68 + 2.77156933000529e-5*x_69 + 3.50506168850835e-6*x_7 - 4.64739646062616e-5*x_70 - 2.46900770365074e-5*x_71 - 3.51656387719727e-5*x_72 + 5.68464542691099e-5*x_73 + 5.95573866802625e-7*x_74 + 6.24764084450236e-5*x_75 + 6.46045423552084e-6*x_76 + 5.59832066265385e-6*x_77 + 1.71093885016297e-5*x_78 + 4.22864148972481e-6*x_79 + 1.47990995873963e-5*x_8 - 7.2846411429238e-6*x_80 - 2.9314168855097e-5*x_81 + 5.11669301677202e-5*x_82 - 4.48048840392674e-5*x_83 - 1.4118494461507e-5*x_84 - 9.29718435580374e-6*x_85 - 4.0207145951683e-5*x_86 + 8.94442282253626e-6*x_87 + 7.47295461636784e-5*x_88 - 2.39972830845591e-6*x_89 - 1.63746098328471e-5*x_9 - 5.29737788481056e-6*x_90 - 5.83205222991259e-5*x_91 - 5.53571515861339e-5*x_92 - 3.40609178915917e-5*x_93 + 3.55008700450922e-5*x_94 - 2.15395881465657e-5*x_95 + 4.31679170898462e-5*x_96 + 5.7121634778412e-5*x_97 - 3.98890789865212e-5*x_98 + 3.64166847646585e-5*x_99 + 2.04894722049799e-5*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 2.80471474605735e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 5.65224259742695e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0588720743831462);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.7218214462708e-5*x_1 - 2.91028554392675e-5*x_10 - 1.24751918527705e-5*x_100 - 2.67532077802275e-5*x_101 - 4.77205287414803e-6*x_102 + 3.66152261382199e-5*x_103 + 1.43035779116848e-5*x_104 + 4.12608297629905e-5*x_105 + 2.59119323760729e-6*x_106 + 1.62522594281126e-5*x_107 - 3.1049876641443e-6*x_108 + 1.79963034164104e-5*x_109 - 6.8254216084247e-6*x_11 - 4.76629007118252e-5*x_110 + 9.59782767738885e-6*x_111 + 5.16465297203686e-6*x_112 + 3.14637752377178e-5*x_113 - 2.45078065451216e-5*x_114 + 3.48103127697056e-6*x_115 + 6.00834462739154e-5*x_116 - 2.8345169827425e-5*x_117 - 6.80448185105546e-5*x_118 + 1.23408936739876e-5*x_119 + 2.97519875926865e-6*x_12 + 4.42850950129054e-5*x_120 - 1.41333873355119e-5*x_13 - 2.19658913158689e-5*x_14 - 1.37055117863428e-5*x_15 + 2.11071171614464e-5*x_16 - 2.22014410914293e-5*x_17 - 2.54119816923576e-5*x_18 + 1.40671696576444e-5*x_19 - 3.19148745943118e-5*x_2 - 4.76660306798097e-5*x_20 - 1.64736892735558e-5*x_21 - 4.38855151202369e-5*x_22 - 3.29553072621988e-5*x_23 + 5.34432345920352e-6*x_24 - 2.57162054357443e-5*x_25 - 3.16924776719044e-5*x_26 - 6.87899401565298e-5*x_27 - 3.07031989340839e-5*x_28 - 1.14817485071501e-5*x_29 - 1.68479640254094e-6*x_3 + 1.85862418329416e-6*x_30 + 3.15866026149234e-5*x_31 + 1.17276550208525e-5*x_32 + 6.26559233015665e-5*x_33 - 2.96497152828737e-5*x_34 + 2.11953766600729e-5*x_35 + 4.01362475579713e-5*x_36 - 2.45635755099859e-5*x_37 + 5.2412162525371e-5*x_38 + 2.64819305680811e-5*x_39 + 1.09628178361103e-5*x_4 - 8.99581955762145e-5*x_40 + 2.77350099854815e-5*x_41 - 3.36818372748741e-5*x_42 - 2.95847829514802e-5*x_43 - 5.16626584354467e-5*x_44 - 9.61122148576501e-6*x_45 - 3.17954284787067e-5*x_46 - 4.01587509633724e-5*x_47 + 6.58081966494365e-5*x_48 + 6.77418707798375e-5*x_49 - 2.41991575141783e-6*x_5 + 5.26360850036004e-6*x_50 - 4.61553125441021e-6*x_51 + 4.30758033458647e-5*x_52 + 8.63856935471606e-6*x_53 - 5.219439330281e-5*x_54 + 2.66014279546283e-5*x_55 - 1.71497705989592e-6*x_56 - 1.72586647760484e-5*x_57 - 3.22039273186444e-5*x_58 - 3.64797729465737e-6*x_59 - 1.70358912962316e-5*x_6 + 2.74945179437694e-5*x_60 - 5.86830488060773e-6*x_61 - 4.02871704480271e-5*x_62 + 4.96008473734736e-5*x_63 + 2.67572289259229e-5*x_64 - 2.01850863421895e-5*x_65 - 4.35943439642252e-5*x_66 - 3.27134145348702e-5*x_67 + 1.99658817935017e-5*x_68 - 4.57612484457056e-5*x_69 + 2.17429576298265e-5*x_7 - 3.88023955210922e-6*x_70 - 1.10272593970041e-5*x_71 - 7.88719348932758e-5*x_72 - 3.33134950850103e-5*x_73 + 6.00845848285539e-6*x_74 - 5.43822103189427e-6*x_75 - 1.13699091307266e-5*x_76 + 2.38272998373758e-5*x_77 - 1.01790293274774e-5*x_78 - 2.8948992688975e-5*x_79 - 5.1364251238857e-5*x_8 - 3.8880433044517e-6*x_80 + 2.55716715487192e-6*x_81 + 8.00668188687585e-6*x_82 - 8.94865149432388e-5*x_83 - 1.60234309196522e-5*x_84 + 1.86201229583108e-5*x_85 - 0.000132469911303381*x_86 + 1.13488007446065e-5*x_87 - 5.6109937390353e-6*x_88 + 2.91562387872617e-5*x_89 + 7.60729184900414e-6*x_9 + 4.91958928833871e-5*x_90 - 1.77537937751564e-5*x_91 - 6.68707809512603e-5*x_92 + 2.09451800363446e-5*x_93 + 1.4459564966768e-5*x_94 - 1.49837712089268e-5*x_95 + 1.76007374393946e-5*x_96 - 8.89357229328555e-5*x_97 + 5.19703886980134e-5*x_98 - 8.68148855811651e-6*x_99 - 9.9683181732751e-6*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 1.89463826372289e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 3.81819759602411e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0341771713215642);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000117879023570729*x_1 + 8.23415716114527e-5*x_10 + 3.15748244682499e-5*x_100 + 3.50862941258954e-5*x_101 + 1.92616463210478e-5*x_102 - 8.91485789705781e-5*x_103 + 1.30580100389851e-5*x_104 - 1.64728937649026e-5*x_105 + 2.64364778073997e-5*x_106 - 6.43239006251809e-6*x_107 - 1.75943952032113e-5*x_108 - 2.2375996584866e-5*x_109 + 8.02178332753196e-6*x_11 + 7.96065288269708e-6*x_110 - 0.000108711842577109*x_111 - 3.68341495031939e-6*x_112 - 7.39169157538517e-5*x_113 + 6.35940463633576e-6*x_114 - 1.71345930711771e-5*x_115 + 0.000184657685936583*x_116 - 9.75128498106874e-6*x_117 + 6.42792969508674e-5*x_118 - 2.79385173819653e-5*x_119 + 7.00138780605495e-5*x_12 + 1.8101151214685e-5*x_120 + 4.99065572182382e-5*x_13 + 1.81697588066955e-6*x_14 + 3.01246516135e-5*x_15 + 3.08147671204906e-5*x_16 + 7.45309856793376e-6*x_17 + 2.2453273293807e-5*x_18 - 1.42374472114372e-5*x_19 + 4.10430630349172e-5*x_2 + 6.65354592520911e-5*x_20 + 3.4236234892343e-6*x_21 + 7.39323232479816e-5*x_22 + 4.15822689488245e-5*x_23 - 1.12317247236693e-5*x_24 + 3.73973646481365e-5*x_25 + 1.24943035336354e-5*x_26 + 5.69876841443817e-5*x_27 + 3.6227930711184e-5*x_28 - 7.48276498289663e-6*x_29 - 2.63253067638911e-6*x_3 + 2.55482118895546e-5*x_30 - 0.000191721107490117*x_31 - 5.25338314354712e-6*x_32 - 0.000135600609430974*x_33 + 6.32431621208368e-5*x_34 + 4.17716955805352e-5*x_35 - 5.6411391141161e-5*x_36 + 2.72225929960973e-5*x_37 - 5.64598303727587e-5*x_38 - 5.67612837124201e-5*x_39 - 7.38990098499134e-6*x_4 + 8.61978893124326e-5*x_40 - 2.91783581142176e-5*x_41 + 8.06697673777226e-5*x_42 - 2.41504833630695e-5*x_43 + 5.29575327938757e-5*x_44 + 1.72392656243942e-5*x_45 + 4.38223653189504e-5*x_46 + 3.34847374582139e-5*x_47 + 3.64886913229882e-5*x_48 - 8.03564395399815e-5*x_49 + 3.0301475783889e-5*x_5 - 3.0310732818504e-5*x_50 + 2.89327973771851e-6*x_51 - 9.81102939215681e-5*x_52 + 7.21308150086747e-7*x_53 + 1.24264472844361e-5*x_54 - 1.73178805997966e-5*x_55 - 4.88645584805341e-5*x_56 + 5.1282132312367e-6*x_57 + 4.52249372294127e-5*x_58 - 1.07749372766196e-5*x_59 - 1.92561719916553e-6*x_6 - 3.05132218040402e-6*x_60 - 6.13401533042362e-6*x_61 + 5.19132063962122e-5*x_62 - 2.20517626750762e-5*x_63 + 1.63528347161288e-5*x_64 + 3.05507236342972e-5*x_65 + 8.77104358900925e-5*x_66 + 1.33511965003859e-5*x_67 - 9.0735554917312e-6*x_68 + 6.91943948215518e-5*x_69 - 1.6180832430866e-5*x_7 + 2.35542876306148e-5*x_70 + 9.41114180227479e-5*x_71 + 0.000120860168441376*x_72 + 2.14536680730773e-6*x_73 - 3.39437231323327e-6*x_74 - 7.40162273693064e-6*x_75 + 5.2179299935849e-5*x_76 - 2.34073402069555e-5*x_77 + 1.67936840780117e-6*x_78 + 4.80442450605127e-5*x_79 + 0.000102627935216591*x_8 - 2.18004542333073e-5*x_80 - 2.44506710470331e-5*x_81 - 3.69309262910185e-5*x_82 + 0.00012340956712144*x_83 + 1.31458487352566e-5*x_84 + 2.98960599479321e-5*x_85 + 0.000166667078281645*x_86 - 1.72246421555452e-5*x_87 - 1.40599333423502e-5*x_88 - 1.55657230691193e-5*x_89 - 1.10564159162071e-5*x_9 - 1.59073720218222e-5*x_90 + 6.14274241552983e-5*x_91 + 0.000118021675042857*x_92 - 4.8803805787032e-6*x_93 - 2.8553229905365e-5*x_94 + 2.95271520125544e-5*x_95 - 6.10147701927152e-5*x_96 + 5.8966190187775e-5*x_97 - 5.78159649503655e-5*x_98 + 1.62205461608553e-7*x_99 + 7.02124870053651e-6*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 2.09788482523891e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 4.22779321511382e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0565192385664959);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.81137477563494e-5*x_1 + 3.07402168219375e-5*x_10 + 6.9684053771693e-5*x_100 - 3.18652712284356e-5*x_101 - 6.13397952965754e-5*x_102 - 2.05077394132707e-5*x_103 - 8.21271354687213e-5*x_104 - 5.00338963434354e-7*x_105 - 1.45342655510458e-5*x_106 - 2.36194256159626e-5*x_107 + 3.5280154544328e-5*x_108 - 3.78883839050453e-5*x_109 - 2.16037750992531e-5*x_11 - 3.59472702525125e-5*x_110 - 8.46619417764939e-5*x_111 - 1.06480306591593e-5*x_112 - 5.95286434837944e-5*x_113 + 1.52216686072545e-5*x_114 - 2.00845165087468e-5*x_115 + 4.44263086236607e-5*x_116 - 1.32549181918857e-5*x_117 + 2.91841868304189e-5*x_118 - 5.16864316822123e-5*x_119 + 8.16433247295276e-5*x_12 + 3.59160191024744e-5*x_120 - 5.14786599653314e-6*x_13 - 1.00341523994625e-5*x_14 + 3.03943867947872e-5*x_15 - 5.34622694956762e-5*x_16 + 3.49444096049482e-6*x_17 - 8.30686026205917e-6*x_18 - 1.66166316745523e-5*x_19 - 3.2135683602483e-5*x_2 + 2.47847510470093e-5*x_20 - 2.08021652138119e-5*x_21 + 2.28223463862344e-6*x_22 + 1.04572231308968e-6*x_23 - 3.04742881743408e-5*x_24 - 4.02097225300844e-6*x_25 - 3.24120971916886e-6*x_26 + 4.52142014565498e-6*x_27 + 7.27312292429085e-6*x_28 - 7.49985259474863e-6*x_29 + 5.80403426880285e-6*x_3 + 4.58475160697585e-6*x_30 - 4.03826803963911e-6*x_31 + 3.10404702345626e-5*x_32 - 5.68502622578037e-7*x_33 + 2.48246125926029e-5*x_34 + 2.38214988762448e-5*x_35 - 3.4305191274615e-5*x_36 + 7.16111550208881e-6*x_37 - 4.84727117914667e-6*x_38 + 2.70381956412266e-5*x_39 - 6.24262477275764e-6*x_4 + 1.05394968321385e-5*x_40 - 2.77351700607555e-6*x_41 + 2.78883440938612e-5*x_42 - 8.87667799653204e-7*x_43 - 6.90446890405015e-5*x_44 - 1.4010198799491e-5*x_45 - 1.61094403752506e-5*x_46 + 2.799755808075e-6*x_47 + 6.229554450014e-5*x_48 - 2.34733958339722e-5*x_49 - 2.66043640296546e-5*x_5 - 2.68238849795571e-5*x_50 - 8.00103661364402e-6*x_51 - 5.04943522251404e-5*x_52 - 1.33636690115661e-5*x_53 + 2.62847201652619e-5*x_54 - 2.454402173459e-5*x_55 - 4.70985185244364e-5*x_56 - 5.11130472557846e-6*x_57 + 1.50718809726649e-5*x_58 + 1.14280459598671e-5*x_59 - 3.29611637173598e-5*x_6 - 7.90824846023677e-6*x_60 - 1.21554707553946e-5*x_61 - 2.67288457994477e-6*x_62 - 3.04081633662502e-5*x_63 - 2.49131091315521e-6*x_64 + 8.68532367164615e-6*x_65 + 3.63212842164899e-5*x_66 - 1.31439639274647e-5*x_67 + 5.10903960589874e-6*x_68 - 5.14000493145984e-7*x_69 - 4.25096576286635e-6*x_7 - 1.82992577693326e-5*x_70 + 4.27844894865481e-5*x_71 - 3.92399575873308e-5*x_72 - 2.15893624219871e-5*x_73 - 6.5419375695354e-6*x_74 + 3.52501655745213e-5*x_75 + 1.98268023692067e-5*x_76 + 5.32131995003467e-6*x_77 - 1.14903521744051e-5*x_78 + 4.72178534897929e-6*x_79 + 1.91825723618356e-5*x_8 - 2.81612793490644e-5*x_80 - 3.21421224991889e-5*x_81 - 4.78338602912504e-5*x_82 - 6.67290675703814e-5*x_83 - 1.65116752508434e-5*x_84 - 1.57631770868194e-5*x_85 - 6.83136843181617e-6*x_86 + 3.58053486339144e-6*x_87 + 9.7787857904477e-6*x_88 - 1.83623449252537e-5*x_89 - 1.19700874126449e-5*x_9 - 3.45952370029165e-5*x_90 + 7.19177061495112e-6*x_91 + 1.25751458228908e-5*x_92 - 2.92172833308927e-5*x_93 + 1.50203847640049e-5*x_94 + 2.01102957772987e-5*x_95 - 3.75453556482226e-5*x_96 - 1.16911182081981e-6*x_97 - 2.23143853623408e-5*x_98 + 9.72313176413052e-6*x_99 + 3.47252968496004e-6*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 4.40114206395914e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 8.86946620372236e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0323663038453111);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.58179198968136e-5*x_1 + 4.26786779238998e-5*x_10 + 1.31242810834723e-5*x_100 - 5.85002907383474e-5*x_101 - 3.2725682138113e-5*x_102 - 5.76025155069095e-5*x_103 - 6.64618800921142e-5*x_104 - 3.10258833766101e-5*x_105 - 4.07926203344224e-5*x_106 + 8.30709758696255e-6*x_107 - 4.84416742959082e-5*x_108 - 6.54800201790386e-5*x_109 + 2.02551591254851e-6*x_11 + 6.14459771724357e-6*x_110 - 7.18762290431836e-5*x_111 + 5.69222573140325e-6*x_112 - 1.99352603702819e-5*x_113 + 2.79939038913272e-6*x_114 - 3.17047256797935e-5*x_115 + 0.000148302561744814*x_116 - 2.90988196581199e-5*x_117 + 5.92976858471744e-5*x_118 - 5.78233334239409e-5*x_119 + 2.69323883793591e-5*x_12 - 2.95022220060872e-5*x_120 + 1.43550057631292e-5*x_13 + 1.58856229466612e-5*x_14 - 9.1615014461813e-6*x_15 - 1.83394356443971e-5*x_16 + 1.1979192994082e-5*x_17 + 2.05513164115446e-5*x_18 - 1.9269366654425e-5*x_19 - 5.49873143521506e-6*x_2 + 9.9926639923771e-5*x_20 + 1.93648471200834e-5*x_21 + 3.15083735062104e-5*x_22 + 3.44355376937321e-5*x_23 + 6.69745036356264e-6*x_24 + 3.59206700076432e-5*x_25 + 5.5251672322159e-6*x_26 + 8.03854473810586e-5*x_27 + 4.5793671911131e-5*x_28 + 2.97200415560661e-6*x_29 - 1.60474094377932e-5*x_3 + 8.56119545765544e-6*x_30 - 0.000262923441233907*x_31 + 3.1429675175934e-5*x_32 - 0.000146299845725527*x_33 + 1.43258877888422e-5*x_34 + 3.53276922745795e-5*x_35 - 7.37385527427445e-5*x_36 + 3.79884545601724e-5*x_37 - 5.4009261508722e-5*x_38 - 1.40384584766197e-5*x_39 - 1.85639544735752e-5*x_4 + 3.03493980185884e-5*x_40 - 5.87303739071495e-5*x_41 + 5.12359993623554e-5*x_42 + 5.47238650421484e-6*x_43 - 1.77363405972336e-5*x_44 + 1.08711453297878e-5*x_45 - 2.81698448751623e-5*x_46 + 2.7326168102946e-5*x_47 + 8.47118211185876e-5*x_48 - 6.53173413492012e-5*x_49 - 1.48129023647076e-5*x_5 - 3.57333295717985e-5*x_50 - 1.59588148062821e-5*x_51 - 3.82167815684951e-5*x_52 - 6.92135427020683e-6*x_53 + 4.60681626494785e-5*x_54 - 3.6663865946934e-5*x_55 - 4.73681716473074e-5*x_56 + 1.7448055804036e-5*x_57 + 5.41810934740495e-6*x_58 - 2.81851359485559e-5*x_59 - 1.94908475957015e-5*x_6 + 1.79929399980742e-5*x_60 - 4.34237590642707e-6*x_61 - 2.13532364041578e-5*x_62 - 2.28564883072035e-5*x_63 - 7.43207192775377e-7*x_64 - 5.52325230687163e-6*x_65 + 5.2938632191587e-5*x_66 - 1.40419427629139e-5*x_67 + 1.13911016837397e-5*x_68 - 2.37189670770727e-5*x_69 - 1.21377867822596e-5*x_7 - 2.66613161351467e-5*x_70 + 2.72837224979362e-5*x_71 - 3.89276909103362e-6*x_72 - 1.94777666406136e-5*x_73 - 1.46383704642662e-5*x_74 - 2.40783347874858e-5*x_75 - 3.99931510075448e-6*x_76 - 2.02641179794322e-5*x_77 - 2.87906678405527e-6*x_78 + 2.85800642592125e-5*x_79 + 5.34942267296107e-5*x_8 - 1.36566856816793e-5*x_80 - 1.09513035166464e-5*x_81 - 2.04016595331023e-5*x_82 - 4.40464274816452e-5*x_83 - 4.71651304349688e-6*x_84 - 2.74645322000353e-5*x_85 + 6.21621948377386e-5*x_86 - 2.88084383510578e-5*x_87 - 3.88450818018942e-5*x_88 - 3.3560022674516e-5*x_89 - 2.01264064521551e-5*x_9 - 5.95071728396966e-5*x_90 - 2.24891424666041e-5*x_91 + 0.000138069375023972*x_92 - 4.06803745166767e-5*x_93 - 2.46333141949286e-5*x_94 + 1.09375894723909e-5*x_95 - 6.23296877052792e-5*x_96 + 1.3482991813556e-5*x_97 - 6.95860142593396e-5*x_98 + 2.1822914230031e-6*x_99 + 4.71019204880899e-7*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 2.46291918443002e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 4.96343407037185e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0414192604709972);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000250802409349383*x_1 - 7.19678976207788e-7*x_10 - 0.000121925592515126*x_100 + 9.16812185291774e-5*x_101 + 2.28556301509134e-5*x_102 + 4.03383506716832e-6*x_103 - 5.61028032105551e-5*x_104 - 1.35993422611798e-5*x_105 + 1.89326462111607e-5*x_106 - 4.28512405808664e-5*x_107 - 0.000101916716550246*x_108 - 3.45971608317976e-5*x_109 - 6.6898676210302e-5*x_11 + 1.74556726191901e-5*x_110 - 5.92929762655434e-5*x_111 + 7.46453110932571e-7*x_112 - 0.000105999516937869*x_113 - 9.12122824592692e-6*x_114 - 3.85958946704253e-5*x_115 - 4.63239979099447e-5*x_116 - 9.6114385440567e-5*x_117 - 4.23062020037651e-5*x_118 - 1.38948401256026e-5*x_119 - 9.54590653612949e-7*x_12 - 2.61964130657022e-6*x_120 - 1.14334939174979e-5*x_13 - 2.00850403234255e-5*x_14 + 1.60655858534771e-5*x_15 - 3.35286011348297e-5*x_16 - 8.43837059609683e-6*x_17 + 1.58544244113405e-5*x_18 + 6.87268316171225e-6*x_19 - 3.55485628418099e-5*x_2 + 4.81261201793939e-5*x_20 + 1.56414844886062e-6*x_21 - 1.04522420964734e-5*x_22 - 7.18872207339772e-6*x_23 + 1.58693631809252e-5*x_24 + 5.81517283520096e-6*x_25 - 1.76414953164846e-5*x_26 + 2.32038345460774e-5*x_27 + 1.25693078320323e-5*x_28 - 1.22051586459603e-6*x_29 - 2.16527049641171e-5*x_3 - 2.98794541000652e-5*x_30 - 0.000502109727729922*x_31 + 1.50409868825086e-6*x_32 - 0.00017563374486527*x_33 + 1.03625865504465e-5*x_34 + 2.37854869226665e-6*x_35 - 5.53176191419869e-5*x_36 - 1.74622848004867e-7*x_37 - 1.97721089276204e-5*x_38 - 7.7707463017146e-5*x_39 + 5.46085483227217e-6*x_4 + 3.36999620817631e-5*x_40 - 6.17509969727936e-5*x_41 + 4.14670488950715e-5*x_42 + 5.25708180507564e-6*x_43 - 1.82238274673423e-5*x_44 - 3.10492171514622e-5*x_45 + 5.80580965091052e-5*x_46 - 4.56889853355329e-5*x_47 + 3.56138458415096e-7*x_48 - 4.45389806133884e-5*x_49 - 6.38801008919805e-6*x_5 + 2.44472526550848e-5*x_50 - 3.53886961669222e-6*x_51 - 0.00012926503846037*x_52 - 5.05012550619387e-5*x_53 - 9.60454061738831e-5*x_54 - 4.07447177625466e-5*x_55 - 8.80616254026666e-5*x_56 - 4.7955436856923e-5*x_57 + 2.57036054809318e-5*x_58 - 3.40735370357379e-5*x_59 - 4.72778233081043e-5*x_6 - 6.12894674780073e-5*x_60 - 5.17071773325361e-5*x_61 - 3.21755274920452e-6*x_62 - 1.58538057771426e-5*x_63 - 4.35974907082037e-5*x_64 - 1.85454326809002e-6*x_65 + 3.8307012822785e-5*x_66 - 3.75736059231756e-5*x_67 - 2.67634389812401e-5*x_68 - 9.33981695825895e-6*x_69 - 7.13818449777665e-5*x_7 - 4.77120158388747e-5*x_70 + 4.36852033733406e-5*x_71 - 3.88448207871287e-5*x_72 - 1.62198978689872e-5*x_73 - 7.25903401805358e-6*x_74 - 3.01631374356343e-5*x_75 + 2.60267228280764e-5*x_76 - 2.37532136618602e-6*x_77 - 7.02511030181346e-6*x_78 + 6.19753590827718e-6*x_79 - 3.4386054030391e-5*x_8 + 1.82115370409858e-5*x_80 - 7.28756558809769e-5*x_81 - 0.000128553356226025*x_82 + 2.41142224777046e-5*x_83 - 4.30432765798968e-5*x_84 - 4.83625256907014e-5*x_85 + 0.000120652503306962*x_86 - 1.97685926333752e-5*x_87 - 0.000115046511137125*x_88 - 4.38361716334582e-5*x_89 - 4.2347692947192e-5*x_9 - 4.27104092471604e-5*x_90 + 5.20490608893757e-5*x_91 + 6.08265382413354e-5*x_92 + 3.22567053154123e-5*x_93 - 1.53884659246e-5*x_94 - 2.32460090310815e-5*x_95 - 4.43478484587572e-5*x_96 - 3.04398067417504e-5*x_97 - 3.95603463926445e-5*x_98 - 5.28050602421315e-5*x_99 - 3.85137729755018e-5*std::sin(1.61255979537964*x_23 + 4.38775968551636) + 1.87643560727047e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) - 3.78151442518425e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0393214638817319);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000378316656543513*x_1 + 2.4279199510347e-5*x_10 + 1.81407555084941e-5*x_100 - 0.00016307583526846*x_101 - 6.30026315004047e-5*x_102 - 0.000100310635427497*x_103 + 2.75617272584487e-5*x_104 + 8.33832548251501e-6*x_105 + 3.1494810821664e-5*x_106 - 6.7753579953635e-6*x_107 + 9.78231709545296e-5*x_108 + 9.20042382855456e-7*x_109 - 3.81419346512623e-6*x_11 - 4.4293198203931e-5*x_110 - 0.000110194811105534*x_111 - 1.22917031869102e-5*x_112 - 3.97025322478276e-5*x_113 + 2.24723683833603e-5*x_114 - 3.47341575058755e-5*x_115 + 4.20656101394275e-5*x_116 + 5.28246830945203e-5*x_117 + 5.59590838787694e-5*x_118 - 5.53491674104579e-5*x_119 + 8.01859643437316e-5*x_12 + 2.3691218214003e-5*x_120 + 8.26866398451105e-5*x_13 - 4.40481395549913e-5*x_14 + 2.08831724803084e-5*x_15 + 4.08782128904114e-5*x_16 - 1.06029451777133e-5*x_17 - 1.96782214277468e-5*x_18 - 1.28657262307583e-5*x_19 + 5.32985205287542e-5*x_2 + 6.87703371106464e-5*x_20 - 2.99166852169295e-5*x_21 + 8.31970337675934e-5*x_22 + 3.88874804714257e-5*x_23 - 1.95189334428187e-5*x_24 + 2.29104172513173e-5*x_25 + 2.92385869943452e-5*x_26 + 6.05989995267367e-5*x_27 + 3.31189058815287e-5*x_28 - 1.93450018820317e-5*x_29 - 2.74252575948967e-5*x_3 + 4.55267694985294e-5*x_30 + 0.000464122336432606*x_31 + 4.44551208118615e-6*x_32 + 7.28349498252115e-5*x_33 + 6.1285023912971e-5*x_34 + 2.90885395246828e-5*x_35 + 2.72925578620832e-6*x_36 + 2.25010933772424e-5*x_37 - 4.70072127263638e-6*x_38 - 8.70931314045515e-5*x_39 - 1.86764609654535e-5*x_4 - 2.23974870464707e-5*x_40 - 7.53515404882989e-6*x_41 + 6.26658792450069e-5*x_42 - 3.9491607760899e-5*x_43 - 8.59604948439623e-6*x_44 + 1.0094412622852e-5*x_45 + 2.29898675831597e-5*x_46 + 5.63989009094835e-5*x_47 + 3.31652917538125e-5*x_48 - 8.37427479469489e-5*x_49 + 1.97204383178898e-5*x_5 - 4.74679497740952e-5*x_50 - 2.57915710137515e-5*x_51 + 5.44928074178477e-5*x_52 + 1.84860739094659e-5*x_53 + 3.53788892511303e-5*x_54 - 2.46216925499141e-5*x_55 - 5.94512279094692e-5*x_56 + 4.43542423849434e-5*x_57 + 6.34782795366159e-5*x_58 + 1.75629695375815e-5*x_59 + 3.61696221134724e-5*x_6 + 4.34142952953097e-5*x_60 + 4.78480058818779e-5*x_61 - 2.77444204181041e-5*x_62 + 3.97472414787351e-5*x_63 + 4.93652231976591e-5*x_64 + 8.68041933506444e-6*x_65 + 4.13218646625518e-5*x_66 - 2.53128115982679e-5*x_67 + 2.46377248713555e-5*x_68 + 7.94336605885141e-6*x_69 + 1.5476199061372e-5*x_7 + 1.3017616837436e-5*x_70 + 9.87988884045005e-5*x_71 + 1.64119621850481e-5*x_72 - 2.98834636889929e-5*x_73 + 3.02430981396247e-5*x_74 + 5.49536199915414e-5*x_75 + 3.85397632433829e-5*x_76 - 3.98617831415166e-5*x_77 + 1.92272272733574e-5*x_78 - 1.41524304106177e-5*x_79 + 7.05274113247758e-5*x_8 - 4.01280358360664e-5*x_80 - 2.17464775525668e-5*x_81 + 1.71496900509588e-5*x_82 + 8.95517842574066e-5*x_83 + 2.35886120831422e-5*x_84 - 3.13867133414108e-6*x_85 - 6.84516577822912e-5*x_86 - 3.09258024638553e-5*x_87 + 2.19420689322459e-5*x_88 + 3.84500396809912e-5*x_89 + 1.24064764206949e-5*x_9 - 8.55874313316848e-6*x_90 - 4.93036267052174e-5*x_91 + 2.30051585009172e-5*x_92 - 4.57731776120165e-5*x_93 - 2.22595337092958e-5*x_94 + 1.90779848823023e-5*x_95 - 4.13385145890929e-5*x_96 - 7.36507970135266e-7*x_97 - 2.9410975661593e-5*x_98 + 2.88381759008555e-5*x_99 + 2.62363931473728e-5*std::sin(1.61255979537964*x_23 + 4.38775968551636) - 1.20279443754848e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) + 2.4239491611104e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0498417412707596);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.6041982978209e-5*x_1 + 1.3083685971785e-5*x_10 + 2.78544521326962e-5*x_100 - 8.24617427863245e-5*x_101 - 2.22121580604889e-5*x_102 - 4.25946612401069e-5*x_103 + 2.97921420721609e-6*x_104 + 1.62439851768344e-5*x_105 + 3.51406316545157e-5*x_106 + 2.67648763789689e-6*x_107 + 0.000125006122328039*x_108 - 1.17792725446272e-5*x_109 + 1.03662501561038e-5*x_11 - 2.03758323470017e-5*x_110 - 7.22903085254187e-5*x_111 - 1.33341417013342e-6*x_112 + 3.7333397382036e-5*x_113 + 3.05952525739517e-5*x_114 - 4.22908840949806e-6*x_115 - 0.000121215934935269*x_116 + 4.55214745318315e-5*x_117 - 3.4918626793558e-6*x_118 - 2.37451248493635e-5*x_119 + 5.01557955877206e-5*x_12 + 4.94148394598831e-5*x_120 + 6.2638937936808e-6*x_13 - 2.28679668164571e-5*x_14 + 1.06414384221331e-5*x_15 - 4.26368427252994e-6*x_16 + 2.72035832550072e-5*x_17 - 2.43321908971306e-5*x_18 + 1.849445638937e-5*x_19 + 4.08402709199048e-5*x_2 - 1.22499370141036e-5*x_20 - 7.92180339004839e-6*x_21 + 2.81572164422679e-5*x_22 + 6.82766142666717e-6*x_23 - 7.81958163744005e-6*x_24 - 1.28838900968477e-5*x_25 - 1.04159532828161e-6*x_26 - 1.06635096107072e-5*x_27 - 1.6495444736318e-6*x_28 - 1.57403899547575e-5*x_29 - 1.12687927575645e-5*x_3 - 8.91425915515743e-6*x_30 + 0.000271209773281649*x_31 - 2.53417217407801e-5*x_32 + 5.28850941524795e-5*x_33 + 2.81209395291629e-5*x_34 - 8.83950611557141e-6*x_35 + 2.34707191687608e-5*x_36 + 8.01684896680546e-6*x_37 + 1.22083660514447e-5*x_38 - 0.000108494358278114*x_39 + 8.77290509585998e-6*x_4 - 4.78210832713108e-5*x_40 + 7.55006226864443e-6*x_41 - 1.4293038644947e-6*x_42 - 6.09680632124495e-5*x_43 - 1.45359564568501e-5*x_44 + 1.13468146281013e-5*x_45 + 3.28761765160999e-5*x_46 + 2.68106745735723e-5*x_47 - 5.62546575955028e-5*x_48 - 4.54457938338838e-6*x_49 + 2.80895030872435e-6*x_5 - 2.93502281709599e-5*x_50 - 8.78129177834512e-7*x_51 - 5.3672488565381e-5*x_52 + 8.78444953771594e-6*x_53 + 2.06742235099597e-6*x_54 - 3.83620464243556e-6*x_55 - 5.6941553549737e-6*x_56 + 1.84531280747935e-5*x_57 + 2.01936933221788e-5*x_58 + 1.82794045350039e-5*x_59 + 6.81344471688095e-5*x_6 + 3.7489798437111e-5*x_60 + 1.4023747925992e-5*x_61 - 9.80981442927534e-7*x_62 + 3.55134206253686e-5*x_63 - 2.96568618395839e-8*x_64 - 8.21110150478664e-7*x_65 - 9.50474952966698e-6*x_66 - 2.20457392775307e-5*x_67 + 2.96066579237477e-5*x_68 + 1.58167271169263e-5*x_69 + 1.7914949932113e-5*x_7 + 4.39730220935699e-5*x_70 + 5.71152581317948e-5*x_71 + 3.90599273320744e-5*x_72 - 2.85586006226282e-5*x_73 + 2.18305306710661e-5*x_74 + 1.91621257805834e-6*x_75 - 1.15781030794308e-5*x_76 - 1.44921278351218e-6*x_77 + 3.38616645367981e-5*x_78 - 3.45342033450543e-5*x_79 + 3.62793807227041e-5*x_8 - 3.22113547945902e-5*x_80 + 1.9438434946329e-5*x_81 + 2.20872539971566e-5*x_82 + 3.88446345214083e-5*x_83 + 6.78759111061723e-6*x_84 - 2.55757128204241e-5*x_85 - 7.96512517920538e-5*x_86 + 1.2649003111833e-5*x_87 + 1.40020368567988e-5*x_88 + 3.03267591701963e-5*x_89 + 3.50582289307467e-5*x_9 + 2.64589476428715e-5*x_90 + 3.27692789513802e-5*x_91 - 2.63956296984274e-5*x_92 - 1.77656741829376e-5*x_93 - 1.67255352703017e-5*x_94 - 5.8585235507868e-6*x_95 - 4.09643194045631e-6*x_96 - 1.94472201475983e-5*x_97 + 2.06342047367808e-5*x_98 + 2.01599075082799e-5*x_99 + 1.16331314658034e-6*std::sin(1.61255979537964*x_23 + 4.38775968551636) - 5.18647486225908e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) + 1.04521196632042e-5*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0503945810860755);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000113482640968154*x_1 - 4.09009018142769e-5*x_10 - 2.0241641449314e-5*x_100 + 9.74957665697408e-5*x_101 - 3.34108058709151e-5*x_102 + 1.94501244158008e-5*x_103 + 6.61119639213285e-6*x_104 - 7.00261568137054e-6*x_105 + 7.68273025912088e-6*x_106 - 1.78145440304384e-7*x_107 - 2.49223770279043e-5*x_108 + 1.32930031825224e-5*x_109 - 2.5600199072908e-5*x_11 - 6.02419700575133e-5*x_110 + 3.85337224674688e-5*x_111 + 6.41501018283162e-6*x_112 - 6.68901527758099e-5*x_113 - 4.12818216363102e-6*x_114 - 1.57064101575515e-5*x_115 + 2.11604545404041e-5*x_116 + 1.50910187027963e-5*x_117 - 2.3997755377451e-6*x_118 - 6.75875842479004e-6*x_119 + 1.88930767222486e-6*x_12 - 2.76885385863417e-5*x_120 - 4.4365005571692e-5*x_13 - 9.68684520242108e-6*x_14 - 9.29840142099707e-6*x_15 - 4.41412942415012e-5*x_16 + 2.09127285869161e-5*x_17 + 2.85685710049873e-5*x_18 - 1.79293087303754e-5*x_19 - 1.27672800716454e-5*x_2 + 1.23071000798125e-5*x_20 - 1.66252967139934e-5*x_21 - 1.7191216954102e-6*x_22 - 8.75405710795475e-6*x_23 - 2.97783341456889e-5*x_24 - 1.71627700431134e-5*x_25 + 3.80241020503222e-6*x_26 + 1.27560848737421e-6*x_27 - 6.60212336296901e-5*x_28 + 1.08689639561714e-5*x_29 - 2.7083743963343e-5*x_3 - 1.87872843903822e-5*x_30 - 0.00031538958363279*x_31 - 4.96988915157331e-5*x_32 + 1.59997653455237e-5*x_33 + 3.82704509033521e-5*x_34 - 2.37750996872043e-5*x_35 - 1.34903278036649e-5*x_36 - 9.50256955541308e-6*x_37 + 3.01787032805883e-5*x_38 - 5.25215019795373e-5*x_39 - 8.65949949964782e-6*x_4 + 3.75512118978082e-5*x_40 + 1.94290010399957e-5*x_41 - 3.16256879080625e-5*x_42 + 6.09377439070982e-7*x_43 - 1.99124347305313e-5*x_44 - 2.01666465507071e-6*x_45 + 1.48700620826505e-5*x_46 - 1.38888351249424e-5*x_47 - 7.11707870398818e-5*x_48 + 1.95489769268929e-5*x_49 - 2.58485100739793e-5*x_5 - 1.18161816239805e-6*x_50 - 3.10988719167063e-5*x_51 - 4.21131317588504e-5*x_52 - 6.33749404149532e-6*x_53 + 3.04102804918852e-6*x_54 - 5.85713268586283e-5*x_55 + 2.06573717154607e-5*x_56 - 2.53697139415541e-6*x_57 - 8.80136275930467e-6*x_58 + 1.67822179119587e-5*x_59 + 5.6248528984551e-6*x_6 - 2.07861126739938e-5*x_60 - 4.55892065161123e-5*x_61 + 7.58771152449919e-7*x_62 - 2.12358127494661e-5*x_63 + 2.7410933970174e-5*x_64 - 1.42242309670718e-5*x_65 - 3.1523424748727e-5*x_66 + 2.66524792705169e-5*x_67 - 2.68105523099148e-5*x_68 - 2.91914636773356e-5*x_69 - 3.18445151450117e-5*x_7 - 3.9946746105704e-5*x_70 - 9.48123353761514e-8*x_71 - 8.92125202256028e-5*x_72 + 1.18015034108268e-5*x_73 + 1.01747740888596e-6*x_74 + 2.13993157396619e-5*x_75 - 2.63311307197935e-5*x_76 + 1.4535899598773e-6*x_77 - 3.37030912303314e-5*x_78 - 4.97756619928279e-6*x_79 - 2.62715874616757e-5*x_8 - 1.7783189619116e-5*x_80 + 1.61498715139383e-5*x_81 + 9.63480013301581e-6*x_82 - 5.02366959400905e-5*x_83 - 1.29590078427741e-5*x_84 + 2.55769289573406e-5*x_85 - 9.47954810417943e-6*x_86 - 1.27004731665662e-5*x_87 - 1.0648215236305e-5*x_88 - 3.44152936199678e-5*x_89 + 2.04514477602516e-6*x_9 - 5.02835769729568e-5*x_90 - 4.36773967283061e-5*x_91 - 3.2045056121711e-5*x_92 + 3.72211870845013e-5*x_93 + 2.21817226046641e-5*x_94 + 1.98736324605486e-5*x_95 - 9.95484514324501e-6*x_96 + 4.08749411931646e-5*x_97 + 5.69154139369776e-5*x_98 - 1.47746406595953e-5*x_99 + 2.83373605602251e-5*std::sin(1.61255979537964*x_23 + 4.38775968551636) - 1.55362246201822e-6*std::sin(2.87527990341187*x_28 - 5.39383983612061) + 3.13096049160899e-6*std::sin(2.57279992103577*x_29 + 4.79967975616455) + 0.0226315362777181);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
