
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0011230692086634*x_1 - 34730.5619951988*x_10 - 152637.926168054*x_100 - 3223219.39738899*x_101 + 74042.3347584325*x_102 + 3450.10066477479*x_103 - 716.777474204661*x_104 + 33566.6075823806*x_105 + 96179.7960849531*x_106 - 188172.169995037*x_107 + 98402.6681297244*x_108 + 80669.931722798*x_109 - 94320.2572004536*x_11 + 52761.4650934611*x_110 + 43296.0907454981*x_111 - 103428.73737386*x_112 - 33665.9417403213*x_113 + 155166.434373611*x_114 + 137003.422553119*x_115 - 313007.229814158*x_116 - 59.9943842424365*x_117 + 158075.0757881*x_118 + 47433.0258438469*x_119 + 110704.038145746*x_12 + 131562.286348045*x_120 + 119065.813356422*x_13 + 13.4059650452111*x_14 - 26395.1121920325*x_15 + 108239.25306113*x_16 + 5473.78063885129*x_17 + 108335.888590725*x_18 - 28916.7962901342*x_19 + 105267.141061071*x_2 + 129364.132630119*x_20 + 7021.69292124684*x_21 + 27918.5592349051*x_22 - 205700.787636179*x_23 - 66147.5605480872*x_24 + 73434.2295502514*x_25 - 58.2153936224257*x_26 + 107324.762602929*x_27 + 3458.02009662382*x_28 - 20.2254116773878*x_29 + 2495.91740158185*x_3 - 247102.012113319*x_30 - 2250437.99488776*x_31 + 443467.174064695*x_32 - 440221.24776236*x_33 + 158252.472180076*x_34 + 127634.181233119*x_35 - 12.4954711135296*x_36 + 62032.603564961*x_37 + 160061.825501189*x_38 + 139197.410081285*x_39 + 308982.292073041*x_4 - 409931.733644856*x_40 - 66134.5178490825*x_41 - 188530.453381578*x_42 + 150302.779333638*x_43 + 31502.9879930618*x_44 + 120729.411829379*x_45 - 48912.29454771*x_46 - 66974.2243652901*x_47 + 70734.0295481833*x_48 + 54744.1421066813*x_49 - 47078.3684004865*x_5 + 0.0390948571001507*x_50 + 162130.789088407*x_51 - 55992.570450997*x_52 + 7680.79682233925*x_53 - 138739.16537459*x_54 - 0.353134858710316*x_55 + 155929.229076021*x_56 - 231917.861918602*x_57 + 112697.53698477*x_58 - 37218.5670952317*x_59 - 41783.2853239*x_6 + 90670.0894050985*x_60 + 47321.5869606296*x_61 - 196700.859531868*x_62 - 53719.5634874385*x_63 - 4413.38667070921*x_64 - 102938.223196076*x_65 + 128033.248227932*x_66 - 66017.2976609716*x_67 + 66443.8405579002*x_68 - 62.4530817846641*x_69 - 5849.18274960874*x_7 + 63343.2194359404*x_70 + 14.0510940618257*x_71 + 55.8663706988627*x_72 + 11.3541162911714*x_73 - 18843.0771918658*x_74 + 121614.785501044*x_75 - 16027.5917776526*x_76 + 60716.4307784949*x_77 + 32.708081489886*x_78 - 50219.3530053272*x_79 + 496235.525038794*x_8 + 92428.7724247994*x_80 + 169478.541801556*x_81 + 196376.095622026*x_82 - 263962.926480708*x_83 + 235444.387053932*x_84 + 57.26423980626*x_85 - 0.869023293829446*x_86 + 4588.28139508766*x_87 + 69814.4281607077*x_88 - 9028.75462487392*x_89 - 1346787.49272118*x_9 - 233351.17236849*x_90 + 137739.629001797*x_91 + 0.131899762808721*x_92 + 1010999.17723584*x_93 + 15175.3300914164*x_94 - 73249.8000362783*x_95 - 71160.2590947814*x_96 - 157088.73409913*x_97 + 30528.7620210244*x_98 + 119762.973468094*x_99 - 0.375181371355082*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 590.208569078564*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.000297675348206983*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 0.515837838602787*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) - 1.67327737771369e-5*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 0.302479629636928*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) - 9.07782976558573e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 787.695269817334*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 0.488568149853028*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 4.29779507652624*std::exp(0.885039865970612*x_1) - 0.0252650766597665*std::exp(0.977039813995361*x_1) + 2169.4666582706*std::exp(1.06455981731415*x_1) - 0.00110827575408756*std::exp(1.15383994579315*x_1) + 8.08103254729428e-5*std::exp(1.92399978637695*x_108) - 0.0125948351439419*std::exp(2.72216010093689*x_17) - 0.389818271705133*std::exp(3.41983985900879*x_17) + 7.16753814425874e-5*std::exp(3.7183997631073*x_17) + 0.0105881919389887*std::exp(0.835599899291992*x_22) + 932.420377907676*std::exp(2.48863983154297*x_29) - 5.10671659211668e-5*std::exp(2.54087996482849*x_38) - 0.147089322972123*std::exp(1.73679983615875*x_50) + 52582.0467001361*std::exp(1.88399982452393*x_50) + 0.0169936254627059*std::exp(1.91255986690521*x_50) - 18.450973801889*std::exp(1.95759975910187*x_50) - 44191.5771733469*std::exp(1.43127989768982*x_71) - 0.0528296866088368*std::exp(1.75855994224548*x_71) + 68257.4187588145*std::exp(1.17287981510162*x_72) + 65876.9225017008*std::exp(0.891999900341034*x_73) + 0.0141785196323836*std::exp(0.894479870796204*x_78) + 30754.269137774*std::exp(1.44431984424591*x_78) + 0.0152154832417847*std::exp(0.655359864234924*x_87) + 0.105649819851272*std::sin(0.359279841184616*x_102 - 7.42183971405029) + 0.113803011847758*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 1.70880119433903*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 540428.556864092*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 3.33735630864055*std::sin(0.308079928159714*x_118 - 7.4967999458313) - 0.0861637647219536*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 831451.582059704*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 19.3209845758889*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 0.15952230378808*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 0.208988167881263*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 548132.965109483*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 0.180511218305546*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 0.216880709320857*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 2080662.13903395*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 512.615128459313*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 0.133783878134479*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 243105.012825873*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 31.0893474287627*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 0.188070154971142*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 1.63198895793016*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 14.490807138277*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 179433.054764705*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 414.009422677297*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 0.122594086491302*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 1.73334661526873*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 3.0738792120458*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 0.121249891251288*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 21132247.4803639 + 2953.58810286166*std::exp(-2.31239986419678*x_86) - 0.000690206610094306*std::exp(-2.74000000953674*x_120));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000655495220450484*x_1 - 15176.1701703626*x_10 - 66506.1934581573*x_100 - 1407292.10746257*x_101 + 32371.0370207872*x_102 + 1536.94768135674*x_103 - 529.189047175828*x_104 + 14698.253317384*x_105 + 41930.7311581472*x_106 - 81753.8976135279*x_107 + 42881.1076696841*x_108 + 35007.2792401546*x_109 - 41224.8908080907*x_11 + 22853.5294120038*x_110 + 18931.9812200446*x_111 - 44960.5101582501*x_112 - 14554.3215905546*x_113 + 67629.6324213609*x_114 + 59824.8009091046*x_115 - 136504.751931427*x_116 - 109.373486110838*x_117 + 68943.3103975582*x_118 + 20506.4392244991*x_119 + 48319.6372974759*x_12 + 57307.9242692977*x_120 + 51964.4941187478*x_13 + 24.352112526656*x_14 - 11558.5826975251*x_15 + 47225.5365215168*x_16 + 2384.54737669867*x_17 + 47118.6808802992*x_18 - 12536.1317758258*x_19 + 45780.6834152255*x_2 + 56494.9074301824*x_20 + 2968.17749562193*x_21 + 12205.8933821802*x_22 - 89591.3706118415*x_23 - 28811.0159574451*x_24 + 31951.1266538732*x_25 - 107.142457669825*x_26 + 46849.1126264363*x_27 + 1522.15702576045*x_28 - 37.4019129903084*x_29 + 1169.32485886017*x_3 - 107585.951206234*x_30 - 980405.629616991*x_31 + 193239.442748578*x_32 - 191745.657237943*x_33 + 69058.5109842476*x_34 + 55644.8130033118*x_35 - 23.2567436021444*x_36 + 27016.4920766562*x_37 + 69730.5965026103*x_38 + 60489.5833069808*x_39 + 134344.148793931*x_4 - 178464.442725915*x_40 - 28739.1161948059*x_41 - 81931.9877045009*x_42 + 65566.4851294041*x_43 + 13759.6003490206*x_44 + 52611.1282318259*x_45 - 21350.8769324272*x_46 - 29202.198215203*x_47 + 30727.7305098782*x_48 + 23729.777269888*x_49 - 20551.3595122492*x_5 - 0.0228182660299647*x_50 + 70704.5947189364*x_51 - 24341.570115778*x_52 + 3280.28072597642*x_53 - 60424.1764252161*x_54 - 1.9753009731975*x_55 + 67827.2754562176*x_56 - 101092.656442225*x_57 + 49071.3381523189*x_58 - 16235.4135093084*x_59 - 18160.9860557202*x_6 + 39580.6222745864*x_60 + 20635.3997982442*x_61 - 85665.8530404725*x_62 - 23425.64947329*x_63 - 1776.39941955073*x_64 - 44946.9524573455*x_65 + 55957.4131553276*x_66 - 28762.1703606633*x_67 + 28930.0337856165*x_68 - 114.267001536029*x_69 - 2549.8659603227*x_7 + 27495.3786415757*x_70 + 26.0491791827225*x_71 + 109.811672772414*x_72 + 20.4547331491381*x_73 - 8258.10315051636*x_74 + 53025.5078670445*x_75 - 6982.74748439486*x_76 + 26396.0699171625*x_77 + 60.6350883655276*x_78 - 21917.4530273073*x_79 + 217317.48075224*x_8 + 40291.8975171475*x_80 + 73909.3446429518*x_81 + 85588.5932566104*x_82 - 114917.575589991*x_83 + 102707.790860355*x_84 + 105.813038528509*x_85 - 0.930984454061109*x_86 + 2000.70468006856*x_87 + 30432.0810114281*x_88 - 3940.9733164428*x_89 - 586479.293513101*x_9 - 101807.81910545*x_90 + 60270.9773966936*x_91 + 0.796374835252148*x_92 + 439887.741341267*x_93 + 6674.52223469109*x_94 - 31840.9717448832*x_95 - 30868.4228807577*x_96 - 68474.1958208138*x_97 + 13355.856615239*x_98 + 52184.9283972878*x_99 - 0.695366130730016*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 257.149877993996*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.00907385940112919*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 0.95606069303978*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 9.76631996602067e-6*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 0.560619758186803*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 5.29840367583973e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 343.193496573942*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 0.905518690158231*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 7.96559040828851*std::exp(0.885039865970612*x_1) - 0.0938163979464585*std::exp(0.977039813995361*x_1) + 945.221936301751*std::exp(1.06455981731415*x_1) - 0.0337829062125711*std::exp(1.15383994579315*x_1) + 0.00246329276481138*std::exp(1.92399978637695*x_108) - 0.04676819634653*std::exp(2.72216010093689*x_17) - 0.722494356008192*std::exp(3.41983985900879*x_17) - 4.18343496528563e-5*std::exp(3.7183997631073*x_17) - 0.00617994791031581*std::exp(0.835599899291992*x_22) + 406.249246418782*std::exp(2.48863983154297*x_29) + 2.98060733257173e-5*std::exp(2.54087996482849*x_38) - 0.546184388967353*std::exp(1.73679983615875*x_50) + 22909.6417809121*std::exp(1.88399982452393*x_50) + 0.518006509752443*std::exp(1.91255986690521*x_50) - 34.1972796103398*std::exp(1.95759975910187*x_50) - 19253.9710093157*std::exp(1.43127989768982*x_71) - 0.196171615428897*std::exp(1.75855994224548*x_71) + 29739.2952688184*std::exp(1.17287981510162*x_72) + 28702.1291649145*std::exp(0.891999900341034*x_73) + 0.432195324320043*std::exp(0.894479870796204*x_78) + 13399.426865184*std::exp(1.44431984424591*x_78) - 0.00888073189514677*std::exp(0.655359864234924*x_87) - 0.0616640109262575*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.0664227366965708*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 6.34526366250004*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 235461.063669467*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 12.3925508620815*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.0502906993759352*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 362257.825599457*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 71.7442975574069*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 4.86262286963304*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 6.3704611862437*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 238817.822185208*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 5.50241538339329*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 6.61104480115111*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 906530.408453095*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 950.087679308214*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 4.07805385176194*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 105919.208332573*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 57.6214089478328*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 5.73282992372656*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 6.06003803523853*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 53.8084782942645*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 78177.7672473814*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 767.330556133649*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 3.7369621331843*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 6.43640777453714*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 11.4141856476481*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 3.69598783454311*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 9228803.23159478 + 1286.85834141844*std::exp(-2.31239986419678*x_86) - 0.0210391548223569*std::exp(-2.74000000953674*x_120));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000882415694072192*x_1 - 109614.165338261*x_10 - 480353.387280367*x_100 - 10165493.8443424*x_101 + 233846.073695837*x_102 + 11096.0475951323*x_103 - 3842.48406059336*x_104 + 106180.250582863*x_105 + 302866.166484349*x_106 - 590540.01095113*x_107 + 309742.483831278*x_108 + 252850.949922105*x_109 - 297790.260655609*x_11 + 165037.934519139*x_110 + 136752.466661389*x_111 - 324734.024222603*x_112 - 105134.647023209*x_113 + 488504.027981109*x_114 + 432137.336739132*x_115 - 985983.364129798*x_116 - 823.490104906155*x_117 + 497986.354190945*x_118 + 148081.45794964*x_119 + 349043.085003232*x_12 + 413945.489624096*x_120 + 375362.360005791*x_13 + 184.416578735556*x_14 - 83500.5076303951*x_15 + 341118.553964475*x_16 + 17227.258518583*x_17 + 340322.355076608*x_18 - 90552.2211236461*x_19 + 330654.174690003*x_2 + 408104.919457788*x_20 + 21417.0301628542*x_21 + 88157.3584982957*x_22 - 647124.941659226*x_23 - 208103.748259962*x_24 + 230786.484718505*x_25 - 792.675049114972*x_26 + 338417.497890643*x_27 + 10993.2725064029*x_28 - 273.130762021916*x_29 + 8466.78909969743*x_3 - 777096.406408765*x_30 - 7081483.88677931*x_31 + 1395837.71528342*x_32 - 1384958.51481299*x_33 + 498838.274268794*x_34 + 401924.338707357*x_35 - 171.361427227128*x_36 + 195136.916214604*x_37 + 503667.9153533*x_38 + 436932.479852346*x_39 + 970307.542155931*x_4 - 1289045.91992643*x_40 - 207565.42004815*x_41 - 591758.760318931*x_42 + 473582.959896738*x_43 + 99388.1683446783*x_44 + 380017.334936365*x_45 - 154209.022612982*x_46 - 210941.192869037*x_47 + 222044.672734282*x_48 + 171369.214495237*x_49 - 148446.574549479*x_5 - 0.0307175329860033*x_50 + 510706.12485676*x_51 - 175809.329973972*x_52 + 23682.5672143084*x_53 - 436444.921648108*x_54 + 1.43196270714991*x_55 + 489916.765213646*x_56 - 730176.057855237*x_57 + 354459.349185004*x_58 - 117263.769775161*x_59 - 131175.809205313*x_6 + 285900.735773469*x_60 + 149052.457615216*x_61 - 618770.830645964*x_62 - 169210.166922611*x_63 - 12824.3382770985*x_64 - 324663.683252233*x_65 + 404219.393440135*x_66 - 207759.544362404*x_67 + 208977.812188658*x_68 - 855.355144713406*x_69 - 18406.3341269362*x_7 + 198584.423569177*x_70 + 190.876558054799*x_71 + 733.186453247098*x_72 + 158.196812854258*x_73 - 59664.6499004596*x_74 + 383010.657206582*x_75 - 50439.3770620809*x_76 + 190654.804606567*x_77 + 444.098929540703*x_78 - 158329.189442612*x_79 + 1569797.19730308*x_8 + 291025.487285707*x_80 + 533864.650753715*x_81 + 618204.001213193*x_82 - 830085.527254547*x_83 + 741870.016756954*x_84 + 779.008455850283*x_85 - 13.981803094843*x_86 + 14434.7768357216*x_87 + 219819.388771349*x_88 - 28469.5501496824*x_89 - 4236228.25273951*x_9 - 735403.08261527*x_90 + 435349.106464673*x_91 - 0.574193039873799*x_92 + 3177423.93595421*x_93 + 48213.0648780821*x_94 - 229977.424997421*x_95 - 222955.983066568*x_96 - 494600.466996477*x_97 + 96482.8625706668*x_98 + 376932.536120817*x_99 - 5.09558332376761*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 1857.40985140125*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) - 0.0266197906927946*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 7.00593070135408*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 1.31472415701591e-5*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 4.10817347084805*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 7.13261426052449e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 2478.90835665948*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 6.63556324218166*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 58.3711628373765*std::exp(0.885039865970612*x_1) - 0.0442917806558339*std::exp(0.977039813995361*x_1) + 6827.39789706777*std::exp(1.06455981731415*x_1) + 0.0991082022122849*std::exp(1.15383994579315*x_1) - 0.00722651023292187*std::exp(1.92399978637695*x_108) - 0.0220797935072253*std::exp(2.72216010093689*x_17) - 5.2943766302316*std::exp(3.41983985900879*x_17) - 5.63166374571186e-5*std::exp(3.7183997631073*x_17) - 0.00831933300881064*std::exp(0.835599899291992*x_22) + 2934.36403045931*std::exp(2.48863983154297*x_29) + 4.01243915450735e-5*std::exp(2.54087996482849*x_38) - 0.257859816442631*std::exp(1.73679983615875*x_50) + 165477.793214949*std::exp(1.88399982452393*x_50) - 1.51966481488562*std::exp(1.91255986690521*x_50) - 250.594729883849*std::exp(1.95759975910187*x_50) - 139072.651755768*std::exp(1.43127989768982*x_71) - 0.0926148344177109*std::exp(1.75855994224548*x_71) + 214808.81280964*std::exp(1.17287981510162*x_72) + 207317.296368105*std::exp(0.891999900341034*x_73) - 1.26792234298586*std::exp(0.894479870796204*x_78) + 96784.9086947824*std::exp(1.44431984424591*x_78) - 0.0119550790831692*std::exp(0.655359864234924*x_87) - 0.0830109653024985*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.0894170750230612*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 2.99567061296979*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 1700750.17220617*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 5.85066317364726*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.0677004210109936*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 2616611.21235819*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 33.8712928685779*std::sin(0.13448004424572*x_15 - 7.67288017272949) + 14.2653745540205*std::sin(0.39055985212326*x_21 + 1.97775983810425) - 18.6888881453548*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 1724996.25151428*std::sin(0.438799858093262*x_36 - 7.36127996444702) - 16.1423204102672*std::sin(0.473199844360352*x_41 - 1.14783978462219) - 19.3946832419985*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 6547926.54148136*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 6962.16096938388*std::sin(0.312079936265945*x_55 + 5.13167953491211) + 11.9637009092667*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 765061.148557636*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 422.24473921145*std::sin(0.93207985162735*x_7 - 1.01495981216431) - 16.8182827064743*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 2.86101237414784*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 25.4035900993972*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 564682.963019842*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 5622.93245652778*std::sin(0.367919832468033*x_92 + 1.98215985298157) + 10.9630473004558*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 3.03870077727776*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 5.38876591018894*std::sin(0.383759826421738*x_97 - 7.41007995605469) - 10.8428418613594*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 66670693.9732182 + 9295.05928353697*std::exp(-2.31239986419678*x_86) + 0.0617221264917049*std::exp(-2.74000000953674*x_120));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000855877645901143*x_1 - 14229.1895773034*x_10 - 60841.6112495527*x_100 - 1311163.18961166*x_101 + 30519.0909929006*x_102 + 1662.79364442866*x_103 - 2207.1573500219*x_104 + 14038.0027528916*x_105 + 38562.3950344524*x_106 - 72991.5891790993*x_107 + 39301.2848277566*x_108 + 30920.0319910556*x_109 - 38755.9418911293*x_11 + 19819.5635574479*x_110 + 17863.9983502044*x_111 - 40307.6183721114*x_112 - 12421.8553634361*x_113 + 62071.9531554397*x_114 + 55800.0791147382*x_115 - 125911.26612501*x_116 - 786.346895462232*x_117 + 63636.8214077626*x_118 + 17464.883899392*x_119 + 44910.1257921392*x_12 + 52334.924416642*x_120 + 48253.9409752049*x_13 + 175.741999559515*x_14 - 11044.4498498298*x_15 + 43732.9288964888*x_16 + 2181.52955354029*x_17 + 42437.997082362*x_18 - 10976.9765052505*x_19 + 41202.3062781915*x_2 + 52761.4990176428*x_20 + 1975.82546744911*x_21 + 11489.790584925*x_22 - 81719.3705454066*x_23 - 26286.9916168523*x_24 + 28891.9863527207*x_25 - 756.951948734269*x_26 + 43579.7367340392*x_27 + 1512.65246310536*x_28 - 258.544584001253*x_29 + 1733.93393124865*x_3 - 97831.91590418*x_30 - 896127.823421706*x_31 + 177026.564332675*x_32 - 174949.513492128*x_33 + 64053.6401836717*x_34 + 51180.6099697133*x_35 - 168.729765164672*x_36 + 24625.4749554802*x_37 + 63737.9526165465*x_38 + 54110.0955131106*x_39 + 120655.096477939*x_4 - 162153.678345406*x_40 - 25680.5940424191*x_41 - 73265.0604340181*x_42 + 60609.4874737505*x_43 + 12858.6976022873*x_44 + 48215.746381592*x_45 - 19839.7375932893*x_46 - 26898.2381120268*x_47 + 27485.5944892789*x_48 + 20716.9553756579*x_49 - 19116.891678408*x_5 + 0.0297937242011477*x_50 + 65195.4826971898*x_51 - 21833.0502756314*x_52 + 2469.48564174888*x_53 - 55090.0083138762*x_54 - 0.763168171643467*x_55 + 61183.6602080361*x_56 - 92840.6399746595*x_57 + 44668.5181272318*x_58 - 14999.541535227*x_59 - 16267.4238362663*x_6 + 36821.0636745793*x_60 + 19022.8042602688*x_61 - 78096.6903335603*x_62 - 21597.2261165975*x_63 - 463.835158822978*x_64 - 41896.2011916142*x_65 + 52598.1177136508*x_66 - 26314.0562016356*x_67 + 26328.5877492985*x_68 - 817.185077357968*x_69 - 2331.72466844648*x_7 + 24329.2458622322*x_70 + 183.117402263172*x_71 + 720.624582557876*x_72 + 152.367864396566*x_73 - 7949.1740888255*x_74 + 48819.3823277981*x_75 - 6388.56168162739*x_76 + 23688.912748901*x_77 + 426.047733980444*x_78 - 20361.0912818381*x_79 + 207688.165707118*x_8 + 37024.1857394013*x_80 + 68167.7213315259*x_81 + 78518.163227775*x_82 - 104458.606701874*x_83 + 94958.2401456355*x_84 + 746.056034519332*x_85 - 10.9653320619627*x_86 + 1830.14423499873*x_87 + 27957.663381411*x_88 - 3667.30656362071*x_89 - 534183.151605227*x_9 - 94260.411315492*x_90 + 57175.8734629943*x_91 + 0.300379941017592*x_92 + 397733.780945213*x_93 + 6601.02984173184*x_94 - 28540.9178576405*x_95 - 27164.8570811489*x_96 - 62899.1577972326*x_97 + 12661.7430937038*x_98 + 47776.8141803826*x_99 - 4.88855839984047*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 235.253666592427*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.00763518157987196*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 6.72129159757935*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) - 1.27518472764616e-5*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 3.94126533761926*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) - 6.91810576741532e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 313.970704748226*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 6.36597154126317*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 55.9996413101784*std::exp(0.885039865970612*x_1) - 0.0137756112578447*std::exp(0.977039813995361*x_1) + 864.736658610324*std::exp(1.06455981731415*x_1) - 0.0284265616014136*std::exp(1.15383994579315*x_1) + 0.00207273296976359*std::exp(1.92399978637695*x_108) - 0.00686724822315214*std::exp(2.72216010093689*x_17) - 5.07927507080799*std::exp(3.41983985900879*x_17) + 5.46229531225035e-5*std::exp(3.7183997631073*x_17) + 0.00806913476140645*std::exp(0.835599899291992*x_22) + 371.657282188796*std::exp(2.48863983154297*x_29) - 3.89176779260724e-5*std::exp(2.54087996482849*x_38) - 0.0801994532108523*std::exp(1.73679983615875*x_50) + 20958.8947555498*std::exp(1.88399982452393*x_50) + 0.435875583549755*std::exp(1.91255986690521*x_50) - 240.413490250545*std::exp(1.95759975910187*x_50) - 17614.5029184559*std::exp(1.43127989768982*x_71) - 0.0288050274059143*std::exp(1.75855994224548*x_71) + 27207.0059237115*std::exp(1.17287981510162*x_72) + 26258.1541073615*std::exp(0.891999900341034*x_73) + 0.36366992624379*std::exp(0.894479870796204*x_78) + 12258.470915336*std::exp(1.44431984424591*x_78) + 0.0115955382604831*std::exp(0.655359864234924*x_87) + 0.0805144673245934*std::sin(0.359279841184616*x_102 - 7.42183971405029) + 0.0867279176789465*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 0.931712232151716*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 215411.646313471*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 1.81967083479939*std::sin(0.308079928159714*x_118 - 7.4967999458313) - 0.0656643771758042*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 331411.713623532*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 10.5346354662009*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 4.09164468202649*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 5.36041233991836*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 218482.578156231*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 4.62999686493493*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 5.56285096098973*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 829339.699204915*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 6679.30015571957*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 3.43147058756761*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 96900.2292250231*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 405.089650292356*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 4.82387873772087*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 0.889830882537634*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 7.90101406132642*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 71520.9609836379*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 5394.48223010711*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 3.1444596155432*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 0.945095456016068*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 1.67601173940409*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 3.10998187058338*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 8617554.44379151 + 1177.28285762907*std::exp(-2.31239986419678*x_86) - 0.0177033564500397*std::exp(-2.74000000953674*x_120));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000854738451490458*x_1 + 21943.8112212098*x_10 + 96125.0444426091*x_100 + 2034838.60160426*x_101 - 46816.1760630406*x_102 - 2229.0024626775*x_103 + 813.936338156238*x_104 - 21262.5221263573*x_105 - 60611.6865493992*x_106 + 118126.638945044*x_107 - 61983.3280318765*x_108 - 50567.9394613431*x_109 + 59617.9406460755*x_11 - 32998.6437058576*x_110 - 27378.4006931152*x_111 + 64961.5587086008*x_112 + 21017.3926297355*x_113 - 97760.6777350747*x_114 - 86501.0385760127*x_115 + 197328.344049441*x_116 + 181.093350834392*x_117 - 99666.2804258562*x_118 - 29601.646304425*x_119 - 69865.1387383227*x_12 - 82831.2172772484*x_120 - 75131.0887276346*x_13 - 40.5612398077819*x_14 + 16721.2937490403*x_15 - 68274.4463708148*x_16 - 3447.42883983067*x_17 - 68086.0319912564*x_18 + 18107.889353954*x_19 - 66151.4313657213*x_2 - 81690.5879797905*x_20 - 4268.31378961361*x_21 - 17650.2432593559*x_22 + 129489.68732541*x_23 + 41641.723367697*x_24 - 46172.2583576998*x_25 + 175.831212796168*x_26 - 67737.5315974233*x_27 - 2203.3623245516*x_28 + 61.7730097483155*x_29 - 1710.40345276609*x_3 + 155490.293979221*x_30 + 1417060.36866746*x_31 - 279324.520799737*x_32 + 277133.479047909*x_33 - 99846.2788072863*x_34 - 80437.8897412469*x_35 + 36.3013388416236*x_36 - 39047.5503659343*x_37 - 100786.579152606*x_38 - 87401.562359335*x_39 - 194114.21663645*x_4 + 257922.480007808*x_40 + 41521.602073023*x_41 + 118376.349180801*x_42 - 94785.6434359098*x_43 - 19894.7393085204*x_44 - 76046.9126629596*x_45 + 30867.1594118168*x_46 + 42216.3313252126*x_47 - 44413.8283782952*x_48 - 34269.6647903212*x_49 + 29713.2730034977*x_5 - 0.029754068014021*x_50 - 102212.576267258*x_51 + 35170.5043685649*x_52 - 4725.91595034445*x_53 + 87332.7492362707*x_54 + 0.652649747455602*x_55 - 98014.3254735521*x_56 + 146124.986936475*x_57 - 70924.3160764153*x_58 + 23470.4951074732*x_59 + 26241.1879168998*x_6 - 57225.6897082086*x_60 - 29829.0575544421*x_61 + 123813.867939664*x_62 + 33864.410872566*x_63 + 2537.28308721538*x_64 + 64987.801706392*x_65 - 80922.7177040202*x_66 + 41573.6784886849*x_67 - 41814.773879944*x_68 + 188.468573778841*x_69 + 3684.34372590716*x_7 - 39718.1989746167*x_70 - 42.2316682161219*x_71 - 163.896960317535*x_72 - 33.8705257248527*x_73 + 11949.3402297363*x_74 - 76652.115149836*x_75 + 10092.9541334162*x_76 - 38140.384663223*x_77 - 98.2944123438662*x_78 + 31690.4318151611*x_79 - 314342.452919667*x_8 - 58241.4265936941*x_80 - 106845.737197553*x_81 - 123715.913980951*x_82 + 166088.792979177*x_83 - 148482.464016864*x_84 - 172.42234494319*x_85 + 3.19901779144406*x_86 - 2888.28937001306*x_87 - 43991.8961888275*x_88 + 5697.71979712668*x_89 + 847644.353412403*x_9 + 147190.280953914*x_90 - 87173.0150460264*x_91 - 0.250483145976189*x_92 - 635740.926743797*x_93 - 9661.29261506491*x_94 + 46005.8446891217*x_95 + 44588.118524812*x_96 + 98981.1022974309*x_97 - 19317.7798922267*x_98 - 75429.8184353277*x_99 + 1.12747250867194*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) + 371.686519266661*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.00741953668401573*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) - 1.5501648705446*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 1.27348742509213e-5*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) + 0.908993603859238*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 6.9088975967609e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) - 496.054663418901*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) + 1.46821564083113*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) + 12.9154754650729*std::exp(0.885039865970612*x_1) + 0.0908027046404277*std::exp(0.977039813995361*x_1) - 1366.23145295326*std::exp(1.06455981731415*x_1) - 0.0276236936077764*std::exp(1.15383994579315*x_1) + 0.00201419156105881*std::exp(1.92399978637695*x_108) + 0.0452658470413999*std::exp(2.72216010093689*x_17) + 1.17145844192137*std::exp(3.41983985900879*x_17) - 5.45502486148087e-5*std::exp(3.7183997631073*x_17) - 0.0080583945425641*std::exp(0.835599899291992*x_22) - 587.195955658306*std::exp(2.48863983154297*x_29) + 3.88658775298563e-5*std::exp(2.54087996482849*x_38) + 0.52863913810589*std::exp(1.73679983615875*x_50) - 33113.7820387847*std::exp(1.88399982452393*x_50) + 0.423564894689565*std::exp(1.91255986690521*x_50) + 55.4477575598165*std::exp(1.95759975910187*x_50) + 27829.8458562009*std::exp(1.43127989768982*x_71) + 0.18986993366332*std::exp(1.75855994224548*x_71) - 42985.4185821106*std::exp(1.17287981510162*x_72) - 41486.290283592*std::exp(0.891999900341034*x_73) + 0.353398583964567*std::exp(0.894479870796204*x_78) - 19367.6402669913*std::exp(1.44431984424591*x_78) - 0.0115801043109712*std::exp(0.655359864234924*x_87) - 0.0804073005682297*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.0866124806657901*std::sin(0.338559836149216*x_105 - 4.2564001083374) + 6.14143278598749*std::sin(0.431759864091873*x_112 - 7.37911987304688) - 340337.331134853*std::sin(0.416559875011444*x_117 + 5.22304010391235) - 11.9944610995753*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.065576976258374*std::sin(0.3781598508358*x_120 + 5.17304039001465) + 523610.399213626*std::sin(0.300079941749573*x_14 - 7.47968006134033) + 69.4396331913966*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 3.97608196984917*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 5.209015081229*std::sin(0.320719838142395*x_28 - 4.28087997436523) - 345189.217118497*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 4.49922915740776*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 5.40573611000717*std::sin(0.341919839382172*x_53 - 4.25631999969482) - 1310306.40479317*std::sin(0.168080016970634*x_55 + 4.96367979049683) - 1540.48017570738*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 3.3345535581887*std::sin(0.373119831085205*x_67 + 5.16088008880615) + 153096.482781662*std::sin(0.658799827098846*x_69 - 0.763359844684601) + 93.4278384128675*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 4.68763511114345*std::sin(0.262319952249527*x_71 + 5.09015989303589) + 5.86536955018847*std::sin(0.322639852762222*x_75 - 4.29216051101685) - 52.0799718242583*std::sin(0.134800031781197*x_85 + 4.90391969680786) + 112998.778840163*std::sin(0.34215983748436*x_92 + 5.20047998428345) + 1244.15623492675*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 3.05564880479503*std::sin(0.380799859762192*x_94 - 7.41264009475708) - 6.22964904738928*std::sin(0.350239843130112*x_95 - 7.41919994354248) + 11.0475242149661*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 3.02214483493714*std::sin(0.445279866456985*x_98 - 7.37824010848999) - 13344007.9444615 - 1860.03548375106*std::exp(-2.31239986419678*x_86) - 0.0172033502068301*std::exp(-2.74000000953674*x_120));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00036571204663219*x_1 - 19025.3859478404*x_10 - 83314.4534127623*x_100 - 1763966.74046672*x_101 + 40592.1447023918*x_102 + 1933.4802704215*x_103 - 730.404447562808*x_104 + 18437.7611102119*x_105 + 52537.5816376297*x_106 - 102351.558307976*x_107 + 53724.7329805809*x_108 + 43814.1922069805*x_109 - 51686.9828249655*x_11 + 28585.2801269135*x_110 + 23739.8380333711*x_111 - 56292.1703778044*x_112 - 18197.890286707*x_113 + 84732.6117083522*x_114 + 74990.9246566709*x_115 - 171052.484900304*x_116 - 166.879097458377*x_117 + 86392.9177652524*x_118 + 25635.4782908003*x_119 + 60562.8545335699*x_12 + 71791.7068918413*x_120 + 65129.6808862664*x_13 + 37.2432797294773*x_14 - 14499.3810747589*x_15 + 59184.183536828*x_16 + 2987.48443258444*x_17 + 59001.052846228*x_18 - 15686.0756090292*x_19 + 57323.8281695619*x_2 + 70822.1139452215*x_20 + 3687.14280683824*x_21 + 15302.7186656819*x_22 - 112228.846837476*x_23 - 36091.1266557522*x_24 + 40015.9910582384*x_25 - 160.783566114514*x_26 + 58722.2378026798*x_27 + 1911.15419912447*x_28 - 54.6805649877413*x_29 + 1492.74976451093*x_3 - 134757.434974315*x_30 - 1228191.88701386*x_31 + 242101.335277147*x_32 - 240193.081485796*x_33 + 86549.46941911*x_34 + 69719.6721454264*x_35 - 36.4635557010239*x_36 + 33841.0172296428*x_37 + 87355.5023180273*x_38 + 75734.3943425659*x_39 + 168208.645115636*x_4 - 223531.992537116*x_40 - 35977.6956237777*x_41 - 102572.042493671*x_42 + 82163.1777679368*x_43 + 17248.9056391303*x_44 + 65913.9626414041*x_45 - 26758.7153007611*x_46 - 36591.5760889634*x_47 + 38480.0551486379*x_48 + 29685.6345464849*x_49 - 25759.0251525889*x_5 - 0.0127307026963235*x_50 + 88595.4468938213*x_51 - 30476.5491655706*x_52 + 4087.79712543577*x_53 - 75690.045430952*x_54 - 0.60206023384276*x_55 + 84939.0970619258*x_56 - 126658.583130294*x_57 + 61468.3358653937*x_58 - 20343.7965000007*x_59 - 22737.6960035845*x_6 + 49611.0696650837*x_60 + 25858.456719336*x_61 - 107310.660332581*x_62 - 29354.3049137542*x_63 - 2179.38645343414*x_64 - 56339.6245905617*x_65 + 70160.310883533*x_66 - 36034.0755641384*x_67 + 36238.6920362762*x_68 - 173.532959063942*x_69 - 3192.74212063521*x_7 + 34412.0418573979*x_70 + 39.0222769626655*x_71 + 156.457642953931*x_72 + 32.4539146391696*x_73 - 10362.1203060432*x_74 + 66441.4422227155*x_75 - 8748.38928657676*x_76 + 33050.0184951806*x_77 + 90.7880731595104*x_78 - 27471.5089632623*x_79 + 272614.280115442*x_8 + 50482.6161363109*x_80 + 92614.213065799*x_81 + 107230.136907431*x_82 - 143943.802275934*x_83 + 128707.888623388*x_84 + 158.784243976612*x_85 - 1.9530156269749*x_86 + 2505.50172859746*x_87 + 38128.9287389159*x_88 - 4940.50943617056*x_89 - 734645.379984667*x_9 - 127588.580438657*x_90 + 75583.0935621177*x_91 + 0.245577654713822*x_92 + 550884.56557957*x_93 + 8380.51357825351*x_94 - 39865.9100243348*x_95 - 38629.0683639756*x_96 - 85793.248511487*x_97 + 16750.5432980783*x_98 + 65376.5728913519*x_99 - 1.04171489638776*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 322.151329126867*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.00667107366411079*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 1.43225650743843*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 5.44879772026964e-6*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 0.839853894953712*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 2.95607045135006e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 429.944754131183*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 1.3565404853772*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 11.9331008804329*std::exp(0.885039865970612*x_1) - 0.00636435013098609*std::exp(0.977039813995361*x_1) + 1184.15184745524*std::exp(1.06455981731415*x_1) - 0.0248370892658709*std::exp(1.15383994579315*x_1) + 0.00181100530258193*std::exp(1.92399978637695*x_108) - 0.00317267751756885*std::exp(2.72216010093689*x_17) - 1.08235517945011*std::exp(3.41983985900879*x_17) - 2.33401024961836e-5*std::exp(3.7183997631073*x_17) - 0.0034478991270275*std::exp(0.835599899291992*x_22) + 508.939516952268*std::exp(2.48863983154297*x_29) + 1.66293204556487e-5*std::exp(2.54087996482849*x_38) - 0.0370522506038951*std::exp(1.73679983615875*x_50) + 28700.6612918306*std::exp(1.88399982452393*x_50) + 0.380836800779328*std::exp(1.91255986690521*x_50) - 51.2303001422135*std::exp(1.95759975910187*x_50) - 24120.922786384*std::exp(1.43127989768982*x_71) - 0.0133079597349622*std::exp(1.75855994224548*x_71) + 37256.690817368*std::exp(1.17287981510162*x_72) + 35957.3534756416*std::exp(0.891999900341034*x_73) + 0.317748679846688*std::exp(0.894479870796204*x_78) + 16786.4873506106*std::exp(1.44431984424591*x_78) - 0.00495471291878204*std::exp(0.655359864234924*x_87) - 0.0344034112466803*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.0370583861214423*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 0.430452250411708*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 294980.091806676*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 0.840690267679562*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.02805804530916*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 453828.097893163*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 4.86701514395783*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 3.57498545327636*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 4.68354356939911*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 299185.360056617*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 4.04535895151572*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 4.86041990685103*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 1135680.00986532*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 1423.30844812761*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 2.99817271225617*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 132693.097156362*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 86.3215468788971*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 4.21475901645988*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 0.411103012986729*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 3.65027866531079*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 97939.2711494999*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 1149.52344592733*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 2.7474031245583*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 0.43663531706188*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 0.774319580710898*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 2.71727894558583*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 11569024.683759 + 1612.14591397016*std::exp(-2.31239986419678*x_86) - 0.0154679222418973*std::exp(-2.74000000953674*x_120));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000572105142921172*x_1 - 30222.2898983781*x_10 - 133714.626241038*x_100 - 2809696.08890422*x_101 + 64334.8073243954*x_102 + 2868.80199364487*x_103 + 385.356828442605*x_104 + 29058.5385947962*x_105 + 84137.9909841595*x_106 - 165902.097534198*x_107 + 86163.3131685795*x_108 + 71321.6985673051*x_109 - 82015.1308548059*x_11 + 46858.9015364103*x_110 + 37610.7767367253*x_111 - 91091.001601556*x_112 - 30014.1468882049*x_113 + 135811.070144351*x_114 + 119393.166931211*x_115 - 273604.189995012*x_116 + 349.009420593868*x_117 + 138147.829190469*x_118 + 42310.6849499436*x_119 + 96565.8489920968*x_12 + 115308.882053697*x_120 + 103887.192915093*x_13 - 78.086334951678*x_14 - 22846.8037359529*x_15 + 94511.0089959106*x_16 + 4795.01896983349*x_17 + 95296.6291495555*x_18 - 25620.5838436373*x_19 + 92614.6050749454*x_2 + 112698.289111093*x_20 + 6583.62576914121*x_21 + 24266.6745106586*x_22 - 180343.605446058*x_23 - 57989.0668351884*x_24 + 64532.0247274975*x_25 + 336.652293074074*x_26 + 93599.2889538199*x_27 + 2958.20904566129*x_28 + 116.063989495766*x_29 + 1797.55584898691*x_3 - 216816.407624657*x_30 - 1971915.76753866*x_31 + 388352.71778318*x_32 - 385921.456030047*x_33 + 138117.830308432*x_34 + 111648.118789286*x_35 + 73.0673887683578*x_36 + 54394.27169265*x_37 + 140253.041790588*x_38 + 122664.903150159*x_39 + 271994.850444804*x_4 - 359767.678152039*x_40 - 58293.2165239464*x_41 - 166147.642783391*x_42 + 131301.171903866*x_43 + 27439.7465568251*x_44 + 105713.908015349*x_45 - 42667.889167075*x_46 - 58563.8446741686*x_47 + 62336.4007140851*x_48 + 48537.1678496049*x_49 - 41057.5143428519*x_5 - 0.0199153966970419*x_50 + 141728.327226608*x_51 - 49306.6540432099*x_52 + 7040.24214552299*x_53 - 121650.048060496*x_54 + 0.285417044905782*x_55 + 137109.729274666*x_56 - 202958.182306382*x_57 + 98859.3401437958*x_58 - 32517.0515348523*x_59 - 36806.6275630015*x_6 + 79073.444026436*x_60 + 41372.5856968773*x_61 - 172479.398448139*x_62 - 46963.0657382921*x_63 - 4547.11660634813*x_64 - 89721.8753771604*x_65 + 111337.825043767*x_66 - 57834.173590086*x_67 + 58288.1034691895*x_68 + 362.76875999542*x_69 - 5123.23601380845*x_7 + 55974.369498877*x_70 - 81.1934266409473*x_71 - 316.279595408943*x_72 - 66.9000797727084*x_73 - 16275.7934326477*x_74 + 106356.99987211*x_75 - 14041.11581147*x_76 + 53459.0753071618*x_77 - 188.925021869601*x_78 - 43812.6326727812*x_79 + 429530.477968398*x_8 + 80874.614247867*x_80 + 148144.469671016*x_81 + 171901.845563428*x_82 - 231638.535377376*x_83 + 205669.868021178*x_84 - 331.127632084085*x_85 + 5.48093558017258*x_86 + 4020.19926282079*x_87 + 61089.679618545*x_88 - 7874.40550853044*x_89 - 1181222.03298775*x_9 - 203763.87555756*x_90 + 119463.476170949*x_91 - 0.107256237635186*x_92 + 888384.728427105*x_93 + 13002.4671564387*x_94 - 64514.8210491902*x_95 - 62970.1245012815*x_96 - 137464.4739191*x_97 + 26484.9104705167*x_98 + 104894.009916899*x_99 + 2.1675772272411*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 517.04097297646*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.00503072909297035*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) - 2.98020754033242*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 8.52387890202202e-6*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) + 1.7475493373705*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 4.62435712366774e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 690.045434872527*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) + 2.82265932274784*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) + 24.8301313617474*std::exp(0.885039865970612*x_1) + 0.0499748184732247*std::exp(0.977039813995361*x_1) + 1900.5199358312*std::exp(1.06455981731415*x_1) - 0.0187299187275836*std::exp(1.15383994579315*x_1) + 0.00136569876483846*std::exp(1.92399978637695*x_108) + 0.0249128315933835*std::exp(2.72216010093689*x_17) + 2.25214062590233*std::exp(3.41983985900879*x_17) - 3.65123128902655e-5*std::exp(3.7183997631073*x_17) - 0.00539375402317477*std::exp(0.835599899291992*x_22) + 816.829108681223*std::exp(2.48863983154297*x_29) + 2.60142367296125e-5*std::exp(2.54087996482849*x_38) + 0.2909455733648*std::exp(1.73679983615875*x_50) + 46063.5002798699*std::exp(1.88399982452393*x_50) + 0.287193167070161*std::exp(1.91255986690521*x_50) + 106.598871071201*std::exp(1.95759975910187*x_50) - 38713.1892963589*std::exp(1.43127989768982*x_71) + 0.10449815901324*std::exp(1.75855994224548*x_71) + 59795.6113429816*std::exp(1.17287981510162*x_72) + 57710.2229473736*std::exp(0.891999900341034*x_73) + 0.239617729985107*std::exp(0.894479870796204*x_78) + 26941.6915837051*std::exp(1.44431984424591*x_78) - 0.00775095261049482*std::exp(0.655359864234924*x_87) - 0.0538193058979355*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.057972641272489*std::sin(0.338559836149216*x_105 - 4.2564001083374) + 3.38004236614542*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 473432.141626666*std::sin(0.416559875011444*x_117 + 5.22304010391235) - 6.60135640792963*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.0438928719179708*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 728377.318618263*std::sin(0.300079941749573*x_14 - 7.47968006134033) + 38.217287440162*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 2.69593535198062*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 3.5319110654598*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 480181.441694646*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 3.05064911490688*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 3.66529543227686*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 1822724.428554*std::sin(0.168080016970634*x_55 + 4.96367979049683) - 2961.58861719196*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 2.26095460022287*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 212967.515133134*std::sin(0.658799827098846*x_69 - 0.763359844684601) + 179.615958151063*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 3.17839554343912*std::sin(0.262319952249527*x_71 + 5.09015989303589) + 3.22810625200853*std::sin(0.322639852762222*x_75 - 4.29216051101685) - 28.6631014826532*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 157188.90927748*std::sin(0.34215983748436*x_92 + 5.20047998428345) + 2391.90286345327*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 2.07184653096997*std::sin(0.380799859762192*x_94 - 7.41264009475708) - 3.42859369143247*std::sin(0.350239843130112*x_95 - 7.41919994354248) + 6.0801935295623*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 2.04912956048081*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 18410849.293457 + 2587.4345891986*std::exp(-2.31239986419678*x_86) - 0.0116645281326672*std::exp(-2.74000000953674*x_120));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000487115446605846*x_1 + 27662.429958067*x_10 + 125153.636540743*x_100 + 2586872.51000332*x_101 - 58580.617155338*x_102 - 2218.62025898531*x_103 - 3478.72306082242*x_104 - 26128.2616449268*x_105 - 78384.7112878769*x_106 + 158535.479782887*x_107 - 80517.4195303734*x_108 - 68757.8732821568*x_109 + 74878.655866279*x_11 - 45826.0895162158*x_110 - 34219.2308691008*x_111 + 86749.4556749804*x_112 + 29705.6523370618*x_113 - 126749.287825655*x_114 - 109814.488806647*x_115 + 254224.280508683*x_116 - 1567.31143932083*x_117 - 128281.189332664*x_118 - 41942.7189652789*x_119 - 89106.420283454*x_12 - 108094.575331003*x_120 - 95943.3738846204*x_13 + 350.559086616094*x_14 + 20533.2102659492*x_15 - 87502.8678008508*x_16 - 4487.7516400943*x_17 - 90402.4259518864*x_18 + 24869.2201946894*x_19 - 87912.8138321236*x_2 - 103535.49408083*x_20 - 7498.71818975989*x_21 - 22127.290360703*x_22 + 169235.379130134*x_23 + 54403.8043703862*x_24 - 61013.8514335863*x_25 - 1507.72672174238*x_26 - 86304.7741945933*x_27 - 2551.06989410982*x_28 - 516.019424803682*x_29 - 481.66820381064*x_3 + 204004.350036911*x_30 + 1847077.48783079*x_31 - 363049.11955226*x_32 + 362055.846684217*x_33 - 127687.710047406*x_34 - 104001.119227089*x_35 - 333.143588968966*x_36 - 51073.8694603794*x_37 - 131372.516167017*x_38 - 117034.046093165*x_39 - 258643.90081306*x_4 + 338745.592649074*x_40 + 55665.1803414967*x_41 + 158563.509440774*x_42 - 121759.871667433*x_43 - 25193.7028222423*x_44 - 98792.1263794908*x_45 + 39380.124863491*x_46 + 54482.8774074547*x_47 - 59478.2953044536*x_48 - 47221.8859006877*x_49 + 37858.0755888237*x_5 + 0.0169568434691537*x_50 - 131725.094703257*x_51 + 46937.3267145438*x_52 - 7550.55246023178*x_53 + 114201.321308376*x_54 + 0.814440435190694*x_55 - 129900.873736412*x_56 + 189317.648400739*x_57 - 92935.2645874402*x_58 + 30168.5145656713*x_59 + 35077.1147418617*x_6 - 72906.7336490076*x_60 - 38463.5111390275*x_61 + 161932.739714036*x_62 + 43655.4266379852*x_63 + 6355.78019054206*x_64 + 82572.2727459151*x_65 - 101666.9978741*x_66 + 54129.9687147139*x_67 - 54805.1875108674*x_68 - 1628.20322807797*x_69 + 4795.99489112406*x_7 - 53881.764757085*x_70 + 364.135304984251*x_71 + 1418.19656667884*x_72 + 303.243227506722*x_73 + 14520.4052220116*x_74 - 98987.3389407862*x_75 + 13141.746156677*x_76 - 50866.7800170368*x_77 + 847.191296403043*x_78 + 40446.9192432021*x_79 - 385988.305393781*x_8 - 75400.5663684673*x_80 - 137659.521318295*x_81 - 160499.020919924*x_82 + 218025.974147073*x_83 - 190696.332081809*x_84 + 1484.54019307627*x_85 - 23.6880678115223*x_86 - 3763.74006531952*x_87 - 56965.2034336816*x_88 + 7259.09974453676*x_89 + 1109851.61505933*x_9 + 188686.091879869*x_90 - 108125.059454061*x_91 - 0.332578408710052*x_92 - 839961.827675114*x_93 - 11274.0038407884*x_94 + 61448.6557713826*x_95 + 60882.7087734141*x_96 + 128199.321130585*x_97 - 23987.9841822561*x_98 - 98111.9401604038*x_99 - 9.72098858500542*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) + 483.93109778312*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) - 0.0101402278485732*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 13.365412367518*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) - 7.25760488180876e-6*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 7.83727885069851*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) - 3.93738076546309e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) - 645.856831994814*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 12.6588518789318*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 111.356320087821*std::exp(0.885039865970612*x_1) + 0.00230184395188348*std::exp(0.977039813995361*x_1) - 1778.81589076186*std::exp(1.06455981731415*x_1) + 0.0377531049621312*std::exp(1.15383994579315*x_1) - 0.00275278123549291*std::exp(1.92399978637695*x_108) + 0.00114748692400445*std::exp(2.72216010093689*x_17) - 10.1002322044549*std::exp(3.41983985900879*x_17) + 3.1088186883516e-5*std::exp(3.7183997631073*x_17) + 0.0045924790790473*std::exp(0.835599899291992*x_22) - 764.521629668426*std::exp(2.48863983154297*x_29) - 2.21496637452906e-5*std::exp(2.54087996482849*x_38) + 0.0134009753079113*std::exp(1.73679983615875*x_50) - 43113.7210071461*std::exp(1.88399982452393*x_50) - 0.578883119489407*std::exp(1.91255986690521*x_50) - 478.06666163242*std::exp(1.95759975910187*x_50) + 36234.1036282354*std::exp(1.43127989768982*x_71) + 0.004813193177209*std::exp(1.75855994224548*x_71) - 55966.4656231012*std::exp(1.17287981510162*x_72) - 54014.619737888*std::exp(0.891999900341034*x_73) - 0.482987323249449*std::exp(0.894479870796204*x_78) - 25216.4201014496*std::exp(1.44431984424591*x_78) + 0.0065995014888411*std::exp(0.655359864234924*x_87) + 0.0458241208855934*std::sin(0.359279841184616*x_102 - 7.42183971405029) + 0.0493604530457086*std::sin(0.338559836149216*x_105 - 4.2564001083374) + 0.155685009277028*std::sin(0.431759864091873*x_112 - 7.37911987304688) - 443114.855490644*std::sin(0.416559875011444*x_117 + 5.22304010391235) - 0.304058979823235*std::sin(0.308079928159714*x_118 - 7.4967999458313) - 0.0373723190075945*std::sin(0.3781598508358*x_120 + 5.17304039001465) + 681734.047826244*std::sin(0.300079941749573*x_14 - 7.47968006134033) + 1.76029117541791*std::sin(0.13448004424572*x_15 - 7.67288017272949) + 5.43408285934273*std::sin(0.39055985212326*x_21 + 1.97775983810425) - 7.1191237458412*std::sin(0.320719838142395*x_28 - 4.28087997436523) - 449431.949032308*std::sin(0.438799858093262*x_36 - 7.36127996444702) - 6.14906438798897*std::sin(0.473199844360352*x_41 - 1.14783978462219) - 7.38798097229227*std::sin(0.341919839382172*x_53 - 4.25631999969482) - 1706002.19280186*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 13281.9116105259*std::sin(0.312079936265945*x_55 + 5.13167953491211) + 4.55731055635177*std::sin(0.373119831085205*x_67 + 5.16088008880615) + 199329.663947567*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 805.528244589312*std::sin(0.93207985162735*x_7 - 1.01495981216431) - 6.4065574607065*std::sin(0.262319952249527*x_71 + 5.09015989303589) + 0.148686820267375*std::sin(0.322639852762222*x_75 - 4.29216051101685) - 1.32022464124441*std::sin(0.134800031781197*x_85 + 4.90391969680786) + 147122.965880396*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 10727.0274571328*std::sin(0.367919832468033*x_92 + 1.98215985298157) + 4.17613341983935*std::sin(0.380799859762192*x_94 - 7.41264009475708) - 0.157921287024145*std::sin(0.350239843130112*x_95 - 7.41919994354248) + 0.280054177881658*std::sin(0.383759826421738*x_97 - 7.41007995605469) - 4.13034378328123*std::sin(0.445279866456985*x_98 - 7.37824010848999) - 16914259.3222288 - 2421.74242784798*std::exp(-2.31239986419678*x_86) + 0.0235116959839116*std::exp(-2.74000000953674*x_120));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00102914444094914*x_1 - 100259.045173342*x_10 - 441388.747709708*x_100 - 9308961.59365692*x_101 + 213664.916649416*x_102 + 9845.90075941276*x_103 - 1211.69276598276*x_104 + 96772.5047554594*x_105 + 278027.514611594*x_106 - 545053.764839592*x_107 + 284523.186886005*x_108 + 233832.510137061*x_109 - 272232.168934897*x_11 + 153113.431062669*x_110 + 124931.187060633*x_111 - 299501.578349587*x_112 - 97800.2138171747*x_113 + 448603.928490918*x_114 + 395649.157918703*x_115 - 904629.189821818*x_116 + 165.018127846403*x_117 + 456833.620583388*x_118 + 137807.030947606*x_119 + 319779.762838178*x_12 + 380494.968534145*x_120 + 343955.408034104*x_13 - 36.8095324113743*x_14 - 76094.4952398792*x_15 + 312738.275828046*x_16 + 15829.183922285*x_17 + 313612.762171762*x_18 - 83866.8462944196*x_19 + 304743.6994323*x_2 + 373557.991775479*x_20 + 20671.3085370633*x_21 + 80570.4909424386*x_22 - 594959.496858434*x_23 - 191318.383387347*x_24 + 212525.409339137*x_25 + 159.660739167054*x_26 + 310001.371620289*x_27 + 9939.10294803074*x_28 + 54.6944134574276*x_29 + 6888.29665080217*x_3 - 714855.587674912*x_30 - 6508115.30794985*x_31 + 1282289.01881531*x_32 - 1273243.99964489*x_33 + 457191.564746069*x_34 + 368948.44788865*x_35 + 35.7326299994524*x_36 + 179427.22435738*x_37 + 462888.828789104*x_38 + 403143.496467646*x_39 + 894617.664789767*x_4 - 1185980.61740218*x_40 - 191547.748326899*x_41 - 546023.81552396*x_42 + 434324.523063172*x_43 + 90964.4625291396*x_44 + 349079.136088018*x_45 - 141287.356954886*x_46 - 193583.142894695*x_47 + 204873.437212732*x_48 + 158797.650600663*x_49 - 135982.205106743*x_5 - 0.0358252675293318*x_50 + 468585.825627504*x_51 - 162133.51339808*x_52 + 22475.411184932*x_53 - 401294.218902057*x_54 + 1.11876412459904*x_55 + 451344.683141309*x_56 - 670469.634107895*x_57 + 326008.923103007*x_58 - 107552.180516008*x_59 - 121000.333603271*x_6 + 261892.689717451*x_60 + 136771.931774586*x_61 - 568950.631292317*x_62 - 155261.903935955*x_63 - 13342.4055708441*x_64 - 297285.501496956*x_65 + 369543.429989251*x_66 - 190907.704495475*x_67 + 192210.691108144*x_68 + 171.771278450488*x_69 - 16912.663082264*x_7 + 183583.893709017*x_70 - 38.7411872699094*x_71 - 156.910928737638*x_72 - 31.7583236409738*x_73 - 54294.3430324349*x_74 + 351526.648461296*x_75 - 46348.4842483164*x_76 + 175806.589816857*x_77 - 90.156231949303*x_78 - 145069.984413699*x_79 + 1430577.80936045*x_8 + 267199.412751136*x_80 + 489816.681062331*x_81 + 567761.408949507*x_82 - 763660.253483976*x_83 + 680349.435569939*x_84 - 157.608566070601*x_85 + 1.87023350780013*x_86 + 13266.6236291915*x_87 + 201828.096979594*x_88 - 26079.2644227868*x_89 - 3895778.98415795*x_9 - 674238.645109882*x_90 + 397288.50619429*x_91 - 0.440775767701883*x_92 + 2925903.77481502*x_93 + 43635.2792024763*x_94 - 212114.090188099*x_95 - 206315.685871222*x_96 - 454135.784753549*x_97 + 88062.1405578517*x_98 + 346306.878705465*x_99 + 1.03430201187472*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 1706.74142094902*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) - 0.00764524006682726*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) - 1.42206451333379*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 1.53333748103508e-5*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) + 0.833877461331894*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 8.31863073715101e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 2277.82552561331*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) + 1.34688728948815*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) + 11.8481844613476*std::exp(0.885039865970612*x_1) + 0.0400844622240371*std::exp(0.977039813995361*x_1) + 6273.5764965578*std::exp(1.06455981731415*x_1) + 0.0284640103766733*std::exp(1.15383994579315*x_1) - 0.0020754635606893*std::exp(1.92399978637695*x_108) + 0.0199824128912807*std::exp(2.72216010093689*x_17) + 1.07465309707116*std::exp(3.41983985900879*x_17) - 6.56810103914588e-5*std::exp(3.7183997631073*x_17) - 0.00970267797358751*std::exp(0.835599899291992*x_22) + 2696.33577702281*std::exp(2.48863983154297*x_29) + 4.67963056215781e-5*std::exp(2.54087996482849*x_38) + 0.233365466870891*std::exp(1.73679983615875*x_50) + 152054.649497053*std::exp(1.88399982452393*x_50) - 0.436449800262928*std::exp(1.91255986690521*x_50) + 50.8657432948077*std::exp(1.95759975910187*x_50) - 127791.426912978*std::exp(1.43127989768982*x_71) + 0.0838172630820432*std::exp(1.75855994224548*x_71) + 197384.060459522*std::exp(1.17287981510162*x_72) + 190500.23704982*std::exp(0.891999900341034*x_73) - 0.364149020181622*std::exp(0.894479870796204*x_78) + 88933.9595499267*std::exp(1.44431984424591*x_78) - 0.0139429786462348*std::exp(0.655359864234924*x_87) - 0.0968140911962288*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.10428541367079*std::sin(0.338559836149216*x_105 - 4.2564001083374) + 2.71110900810959*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 1562789.58217035*std::sin(0.416559875011444*x_117 + 5.22304010391235) - 5.29490310610799*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.0789576980570799*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 2404358.27089118*std::sin(0.300079941749573*x_14 - 7.47968006134033) + 30.6538264970608*std::sin(0.13448004424572*x_15 - 7.67288017272949) + 4.09703496046707*std::sin(0.39055985212326*x_21 + 1.97775983810425) - 5.36747407604501*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 1585068.88031209*std::sin(0.438799858093262*x_36 - 7.36127996444702) - 4.63609636140163*std::sin(0.473199844360352*x_41 - 1.14783978462219) - 5.57017938707103*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 6016775.15667676*std::sin(0.168080016970634*x_55 + 4.96367979049683) - 1413.18012876788*std::sin(0.312079936265945*x_55 + 5.13167953491211) + 3.4359911614114*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 703001.306263703*std::sin(0.658799827098846*x_69 - 0.763359844684601) + 85.7072793281312*std::sin(0.93207985162735*x_7 - 1.01495981216431) - 4.83023365159551*std::sin(0.262319952249527*x_71 + 5.09015989303589) + 2.58924208365342*std::sin(0.322639852762222*x_75 - 4.29216051101685) - 22.9904788792926*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 518877.296770614*std::sin(0.34215983748436*x_92 + 5.20047998428345) + 1141.3433915005*std::sin(0.367919832468033*x_92 + 1.98215985298157) + 3.14860208493879*std::sin(0.380799859762192*x_94 - 7.41264009475708) - 2.75005169612432*std::sin(0.350239843130112*x_95 - 7.41919994354248) + 4.87688190365623*std::sin(0.383759826421738*x_97 - 7.41007995605469) - 3.11407891945501*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 61024492.8300638 + 8541.06737800551*std::exp(-2.31239986419678*x_86) + 0.0177266786170445*std::exp(-2.74000000953674*x_120));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000362662070780253*x_1 + 17331.3372905504*x_10 + 74168.8138177702*x_100 + 1597707.33874923*x_101 - 37175.7249455374*x_102 - 2017.32495597968*x_103 + 2625.45525744165*x_104 - 17093.5349790991*x_105 - 47003.9619717347*x_106 + 89074.6816576042*x_107 - 47912.9803950807*x_108 - 37737.9351866899*x_109 + 47212.7074866656*x_11 - 24198.5714181494*x_110 - 21755.9800794126*x_111 + 49170.1693819424*x_112 + 15188.0071247232*x_113 - 75672.161804854*x_114 - 67987.7149955463*x_115 + 153456.329839247*x_116 + 939.269526644418*x_117 - 77560.2097876992*x_118 - 21337.9260426518*x_119 - 54732.0136146587*x_12 - 63809.1521408267*x_120 - 58803.870784345*x_13 - 210.318325669409*x_14 + 13449.0734416753*x_15 - 53295.9756504*x_16 - 2661.01077656407*x_17 - 51762.3237260096*x_18 + 13404.8880383118*x_19 - 50255.5912338163*x_2 - 64287.6431637634*x_20 - 2434.8297947781*x_21 - 13992.8338133197*x_22 + 99638.8688425499*x_23 + 32050.7259913785*x_24 - 35236.1247339196*x_25 + 901.782686345651*x_26 - 53105.4390274284*x_27 - 1839.17464121139*x_28 + 308.794500939661*x_29 - 2091.42086427484*x_3 + 119297.416756914*x_30 + 1092542.22320365*x_31 - 215828.533119037*x_32 + 213301.116135124*x_33 - 78064.4578898124*x_34 - 62387.4201455379*x_35 + 197.786412833365*x_36 - 30025.9141993788*x_37 - 77706.9827902163*x_38 - 66023.3647268065*x_39 - 147174.645967238*x_4 + 197733.284679611*x_40 + 31330.0271681048*x_41 + 89383.5753100871*x_42 - 73864.1004485465*x_43 - 15664.5620176359*x_44 - 58779.3468443629*x_45 + 24171.8201449594*x_46 + 32789.8072934778*x_47 - 33565.1583988033*x_48 - 25291.7114569447*x_49 + 23293.2657906489*x_5 + 0.0126245308155787*x_50 - 79465.5477432877*x_51 + 26633.1732339496*x_52 - 3030.13178814945*x_53 + 67171.3224141062*x_54 - 3.1083486765938*x_55 - 74627.082280149*x_56 + 113164.0935023*x_57 - 54471.1962662169*x_58 + 18280.1583493314*x_59 + 19847.3790605878*x_6 - 44864.5870459548*x_60 - 23183.7575720829*x_61 + 95222.0669617297*x_62 + 26324.2976929083*x_63 + 614.162344499272*x_64 + 51047.0208326875*x_65 - 64075.0477523112*x_66 + 32082.199227724*x_67 - 32109.3617756408*x_68 + 975.030554186686*x_69 + 2840.36454938037*x_7 - 29691.5252569394*x_70 - 217.332194112901*x_71 - 832.603069774928*x_72 - 181.904069715289*x_73 + 9679.61089766039*x_74 - 59506.4529117002*x_75 + 7788.79196908778*x_76 - 28898.5284802276*x_77 - 505.609365150209*x_78 + 24815.318049846*x_79 - 252831.793788069*x_8 - 45129.4334044009*x_80 - 83087.8553892958*x_81 - 95715.9656211503*x_82 + 127386.666810054*x_83 - 115729.837758208*x_84 - 886.853316771439*x_85 + 15.7116671868035*x_86 - 2224.94758724943*x_87 - 34083.3737405091*x_88 + 4468.27632299398*x_89 + 651360.568568527*x_9 + 114883.781217644*x_90 - 69626.7145076205*x_91 + 1.24691453461507*x_92 - 485172.412150833*x_93 - 8028.33594874531*x_94 + 34816.9792560041*x_95 + 33161.1152157464*x_96 + 76675.391201198*x_97 - 15420.9127093951*x_98 - 58246.277663357*x_99 + 5.80187697369579*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) + 286.81083219449*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) + 0.0269803523749946*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) - 7.97701566882442*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) - 5.40335568022214e-6*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) + 4.67760323990499*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) - 2.93141732992223e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) - 382.779152469236*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) + 7.55531195079162*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) + 66.4619306712895*std::exp(0.885039865970612*x_1) - 0.0768876645477054*std::exp(0.977039813995361*x_1) - 1054.24856614368*std::exp(1.06455981731415*x_1) - 0.100450610216986*std::exp(1.15383994579315*x_1) + 0.00732439239571149*std::exp(1.92399978637695*x_108) - 0.0383290924710776*std::exp(2.72216010093689*x_17) + 6.02822481927384*std::exp(3.41983985900879*x_17) + 2.31454500376423e-5*std::exp(3.7183997631073*x_17) + 0.0034191442386551*std::exp(0.835599899291992*x_22) - 453.108068153452*std::exp(2.48863983154297*x_29) - 1.64906347703099e-5*std::exp(2.54087996482849*x_38) - 0.447627952035442*std::exp(1.73679983615875*x_50) - 25552.154547841*std::exp(1.88399982452393*x_50) + 1.54024848169047*std::exp(1.91255986690521*x_50) + 285.32941189697*std::exp(1.95759975910187*x_50) + 21474.8204094399*std::exp(1.43127989768982*x_71) - 0.160773358293788*std::exp(1.75855994224548*x_71) - 33169.5744577667*std::exp(1.17287981510162*x_72) - 32012.7764234641*std::exp(0.891999900341034*x_73) + 1.28509618999923*std::exp(0.894479870796204*x_78) - 14944.9838363227*std::exp(1.44431984424591*x_78) + 0.00491339146138207*std::exp(0.655359864234924*x_87) + 0.0341164926874123*std::sin(0.359279841184616*x_102 - 7.42183971405029) + 0.0367493255263019*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 5.20029029709155*std::sin(0.431759864091873*x_112 - 7.37911987304688) - 262620.32145322*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 10.1563726004263*std::sin(0.308079928159714*x_118 - 7.4967999458313) - 0.0278240460153615*std::sin(0.3781598508358*x_120 + 5.17304039001465) + 404042.456639131*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 58.7983721881202*std::sin(0.13448004424572*x_15 - 7.67288017272949) - 14.4585972395694*std::sin(0.39055985212326*x_21 + 1.97775983810425) + 18.9420267603763*std::sin(0.320719838142395*x_28 - 4.28087997436523) - 266364.265299844*std::sin(0.438799858093262*x_36 - 7.36127996444702) + 16.3609660889244*std::sin(0.473199844360352*x_41 - 1.14783978462219) + 19.6573817619145*std::sin(0.341919839382172*x_53 - 4.25631999969482) - 1011094.16378612*std::sin(0.168080016970634*x_55 + 4.96367979049683) - 7927.17905858232*std::sin(0.312079936265945*x_55 + 5.13167953491211) - 12.1257477177847*std::sin(0.373119831085205*x_67 + 5.16088008880615) + 118136.460045126*std::sin(0.658799827098846*x_69 - 0.763359844684601) + 480.771655380122*std::sin(0.93207985162735*x_7 - 1.01495981216431) + 17.0460842085351*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 4.96653230990249*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 44.0989882309596*std::sin(0.134800031781197*x_85 + 4.90391969680786) + 87195.1822736316*std::sin(0.34215983748436*x_92 + 5.20047998428345) + 6402.32143629315*std::sin(0.367919832468033*x_92 + 1.98215985298157) - 11.1115403830014*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 5.27498787731422*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 9.35454884616711*std::sin(0.383759826421738*x_97 - 7.41007995605469) + 10.9897067765076*std::sin(0.445279866456985*x_98 - 7.37824010848999) - 10500090.5836979 - 1435.2910244323*std::exp(-2.31239986419678*x_86) - 0.0625581448516402*std::exp(-2.74000000953674*x_120));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000527552094849787*x_1 + 58658.1154013593*x_10 + 259102.234411296*x_100 + 5450890.38831795*x_101 - 124910.462616586*x_102 - 5630.07435518711*x_103 - 271.848314816397*x_104 - 56469.5247818589*x_105 - 163091.452238286*x_106 + 320969.403455075*x_107 - 166978.880996394*x_108 - 137895.930627002*x_109 + 159208.002655554*x_11 - 90501.1254576528*x_110 - 73029.1978655176*x_111 + 176281.73591629*x_112 + 57910.3805318039*x_113 - 263217.189192319*x_114 - 231644.1756655*x_115 + 530452.183035105*x_116 - 489.291053665306*x_117 - 267846.574348813*x_118 - 81630.5216107895*x_119 - 187309.349027301*x_12 - 223409.276869696*x_120 - 201499.577447102*x_13 + 109.605267931625*x_14 + 44399.4772815319*x_15 - 183281.086828636*x_16 - 9291.01250752518*x_17 - 184474.002931745*x_18 + 49508.9108820578*x_19 - 179274.073554454*x_2 - 218671.954837472*x_20 - 12554.3008120983*x_21 - 47111.7991295115*x_22 + 349386.751049994*x_23 + 112346.613510785*x_24 - 124951.074145368*x_25 - 471.818979667036*x_26 - 181565.881403149*x_27 - 5765.44723234534*x_28 - 163.405123359214*x_29 - 3665.20760642631*x_3 + 419963.96954179*x_30 + 3820790.0487305*x_31 - 752577.93342917*x_32 + 747678.034574023*x_33 - 267872.391846907*x_34 - 216417.633358144*x_35 - 100.66767790451*x_36 - 105375.683862799*x_37 - 271755.172401808*x_38 - 237348.305706415*x_39 - 526431.069120717*x_4 + 696819.266215849*x_40 + 112787.858154901*x_41 + 321481.842606169*x_42 - 254597.826196763*x_43 - 53245.2996316357*x_44 - 204866.339878955*x_45 + 82763.9378387271*x_46 + 113529.277309744*x_47 - 120608.151520739*x_48 - 93779.0922532912*x_49 + 79644.8165901836*x_5 - 0.0183644726450861*x_50 - 274769.653271033*x_51 + 95422.5051420225*x_52 - 13495.8343075803*x_53 + 235670.647391894*x_54 + 0.461886097008091*x_55 - 265439.506697839*x_56 + 393375.447039032*x_57 - 191497.713775645*x_58 + 63049.5854095116*x_59 + 71224.6727438114*x_6 - 153390.339924242*x_60 - 80208.3800646906*x_61 + 334139.675280614*x_62 + 91046.5788617034*x_63 + 8489.95803845314*x_64 + 174069.433984973*x_65 - 216126.74967528*x_66 + 112065.7080871*x_67 - 112906.012525399*x_68 - 508.403784716453*x_69 + 9927.94719704109*x_7 - 108235.372887886*x_70 + 113.494353988466*x_71 + 435.639795963813*x_72 + 93.3888917135774*x_73 + 31645.4758243085*x_74 - 206174.494525086*x_75 + 27207.6200669453*x_76 - 103461.602429691*x_77 + 264.07650950266*x_78 + 84980.4939038077*x_79 - 834758.134851319*x_8 - 156757.463621325*x_80 - 287212.934750853*x_81 - 333157.06379395*x_82 + 448660.179691352*x_83 - 398804.135879318*x_84 + 463.322971910155*x_85 - 8.54590748232137*x_86 - 7791.6111127529*x_87 - 118405.772365022*x_88 + 15275.3137237925*x_89 + 2288213.0391617*x_9 + 395142.585187669*x_90 - 232048.276528976*x_91 - 0.187338954999351*x_92 - 1720119.88168891*x_93 - 25331.6818187422*x_94 + 124849.342001716*x_95 + 121721.23540492*x_96 + 266436.740781893*x_97 - 51441.7854154499*x_98 - 203264.351722314*x_99 - 3.02981103402781*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) + 1001.87696383453*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) - 0.0191062751843791*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) + 4.16569503310606*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) + 7.86007646784467e-6*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) - 2.44270155560376*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) + 4.26423240222574e-5*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) - 1337.10994163211*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) - 3.94547619982521*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) - 34.7072321256743*std::exp(0.885039865970612*x_1) - 0.0736122839180835*std::exp(0.977039813995361*x_1) - 3682.66199882818*std::exp(1.06455981731415*x_1) + 0.0711346158333828*std::exp(1.15383994579315*x_1) - 0.00518680611453153*std::exp(1.92399978637695*x_108) - 0.0366962900213054*std::exp(2.72216010093689*x_17) - 3.14801264415674*std::exp(3.41983985900879*x_17) - 3.36688935441443e-5*std::exp(3.7183997631073*x_17) - 0.00497371203394754*std::exp(0.835599899291992*x_22) - 1582.78030204478*std::exp(2.48863983154297*x_29) + 2.39883616716872e-5*std::exp(2.54087996482849*x_38) - 0.428559198523433*std::exp(1.73679983615875*x_50) - 89257.8387711027*std::exp(1.88399982452393*x_50) - 1.09073487753164*std::exp(1.91255986690521*x_50) - 149.002504606268*std::exp(1.95759975910187*x_50) + 75015.0463498244*std::exp(1.43127989768982*x_71) - 0.153924484074334*std::exp(1.75855994224548*x_71) - 115866.727540108*std::exp(1.17287981510162*x_72) - 111825.843541728*std::exp(0.891999900341034*x_73) - 0.910047470961815*std::exp(0.894479870796204*x_78) - 52205.2633644523*std::exp(1.44431984424591*x_78) - 0.00714734229772756*std::exp(0.655359864234924*x_87) - 0.0496280935788222*std::sin(0.359279841184616*x_102 - 7.42183971405029) - 0.0534579853470934*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 4.97876022191367*std::sin(0.431759864091873*x_112 - 7.37911987304688) - 917375.56871764*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 9.72371560299575*std::sin(0.308079928159714*x_118 - 7.4967999458313) + 0.0404746868924571*std::sin(0.3781598508358*x_120 + 5.17304039001465) + 1411386.12729716*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 56.2935874420732*std::sin(0.13448004424572*x_15 - 7.67288017272949) + 10.2389299368582*std::sin(0.39055985212326*x_21 + 1.97775983810425) - 13.4138935920289*std::sin(0.320719838142395*x_28 - 4.28087997436523) - 930453.774534076*std::sin(0.438799858093262*x_36 - 7.36127996444702) - 11.5861022136612*std::sin(0.473199844360352*x_41 - 1.14783978462219) - 13.9204759125244*std::sin(0.341919839382172*x_53 - 4.25631999969482) - 3531916.64071436*std::sin(0.168080016970634*x_55 + 4.96367979049683) + 4139.66974641097*std::sin(0.312079936265945*x_55 + 5.13167953491211) + 8.58691055966599*std::sin(0.373119831085205*x_67 + 5.16088008880615) + 412669.90163018*std::sin(0.658799827098846*x_69 - 0.763359844684601) - 251.06483176437*std::sin(0.93207985162735*x_7 - 1.01495981216431) - 12.0712721308346*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 4.75496022197475*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 42.2203907642881*std::sin(0.134800031781197*x_85 + 4.90391969680786) + 304586.977447439*std::sin(0.34215983748436*x_92 + 5.20047998428345) - 3343.37046769838*std::sin(0.367919832468033*x_92 + 1.98215985298157) + 7.86869442360307*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 5.05027571813392*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 8.95604918734892*std::sin(0.383759826421738*x_97 - 7.41007995605469) - 7.7824173290706*std::sin(0.445279866456985*x_98 - 7.37824010848999) - 35722943.0199721 - 5013.70538474667*std::exp(-2.31239986419678*x_86) + 0.0443008717583483*std::exp(-2.74000000953674*x_120));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00136623829364796*x_1 - 104742.668389342*x_10 - 461385.8778636*x_100 - 9726595.49832684*x_101 + 223188.204620455*x_102 + 10249.0996657965*x_103 - 973.42825622082*x_104 + 101054.964328469*x_105 + 290587.9810953*x_106 - 570046.586214512*x_107 + 297398.907504603*x_108 + 244612.766597479*x_109 - 284386.226936385*x_11 + 160236.482379164*x_110 + 130497.85036263*x_111 - 313209.881996383*x_112 - 102381.103208949*x_113 + 468890.451390544*x_114 + 413389.123984745*x_115 - 945433.7651585*x_116 + 291.587459169857*x_117 + 477431.98559283*x_118 + 144272.161278238*x_119 + 334143.950047834*x_12 + 397746.242737002*x_120 + 359413.731349174*x_13 - 65.2050587442599*x_14 - 79460.8997532928*x_15 + 326815.144354244*x_16 + 16545.932340533*x_17 + 327934.017483834*x_18 - 87748.9129659569*x_19 + 318665.515184368*x_2 + 390294.071503167*x_20 + 21734.9151359284*x_21 + 84166.2074011706*x_22 - 621951.793584782*x_23 - 199996.956249072*x_24 + 222209.669497794*x_25 + 279.949638136544*x_26 + 323920.252565048*x_27 + 10369.1593389118*x_28 + 95.2969588440026*x_29 + 7086.13690788447*x_3 - 747338.756258316*x_30 - 6803067.78479466*x_31 + 1340329.79970373*x_32 - 1331003.29881513*x_33 + 477751.902264904*x_34 + 385615.512284593*x_35 + 62.6756129798716*x_36 + 187570.998988809*x_37 + 483866.664226762*x_38 + 421612.334536153*x_39 + 935529.985657909*x_4 - 1239894.40314318*x_40 - 200329.95167984*x_41 - 571048.019043473*x_42 + 453893.902701309*x_43 + 95039.0684924796*x_44 + 364877.528403614*x_45 - 147636.556362026*x_46 - 202320.447021453*x_47 + 214251.366554794*x_48 + 166161.975778564*x_49 - 142088.406832369*x_5 + 0.0475597500518147*x_50 + 489725.794322332*x_51 - 169552.812880685*x_52 + 23584.4479462791*x_53 - 419504.789193186*x_54 - 0.393656916466469*x_55 + 471937.451497874*x_56 - 700783.221936179*x_57 + 340813.611285268*x_58 - 112399.959514494*x_59 - 126540.52197918*x_6 + 273652.16153598*x_60 + 142942.890517741*x_61 - 594769.923513832*x_62 - 162266.552740523*x_63 - 14143.8682699366*x_64 - 310620.117759182*x_65 + 386042.548314854*x_66 - 199554.702514509*x_67 + 200939.764873569*x_68 + 302.813119122444*x_69 - 17680.005101889*x_7 + 192041.143393572*x_70 - 67.692230317212*x_71 - 263.815798068829*x_72 - 56.8031826583211*x_73 - 56685.7758293164*x_74 + 367397.917481923*x_75 - 48447.7179311624*x_76 + 183848.71181181*x_77 - 157.470371633732*x_78 - 151587.496677427*x_79 + 1493870.84901179*x_8 + 279276.240528311*x_80 + 511910.519868059*x_81 + 593444.610823108*x_82 - 798364.859596299*x_83 + 710999.965984403*x_84 - 275.888687397842*x_85 + 4.24753596360017*x_86 + 13869.0252227494*x_87 + 210950.468196494*x_88 - 27249.7679717778*x_89 - 4072648.82612482*x_9 - 704588.107090888*x_90 + 414940.154010704*x_91 + 0.145956896840602*x_92 + 3059235.06490224*x_93 + 45528.108403156*x_94 - 221823.36947053*x_95 - 215844.267387954*x_96 - 474663.985983922*x_97 + 91975.2106781775*x_98 + 361988.664787434*x_99 + 1.8070226881586*std::pow(-8.6846399307251*x_100 - 9.69048023223877, 2) - 1784.05558240352*std::pow(-9.8120002746582*x_26 - 9.95392036437988, 2) - 8.20662172413434e-5*std::pow(-4.1101598739624*x_27 - 5.7422399520874, 2) - 2.48448017128158*std::pow(-4.92655992507935*x_67 - 6.78000020980835, 2) - 2.03557858384171e-5*std::pow(-9.17960071563721*x_75 - 9.99520015716553, 2) + 1.45686218770823*std::pow(-6.76800012588501*x_76 - 8.60000038146973, 2) - 0.000110433787635591*std::pow(-6.57543992996216*x_76 - 7.36975955963135, 2) + 2381.00938714667*std::pow(-8.95576000213623*x_85 - 8.34360027313232, 2) + 2.35313850553773*std::pow(-7.30359983444214*x_87 - 9.52600002288818, 2) + 20.6998902538503*std::exp(0.885039865970612*x_1) - 0.0305981280347374*std::exp(0.977039813995361*x_1) + 6557.76500935684*std::exp(1.06455981731415*x_1) + 0.000305540916794432*std::exp(1.15383994579315*x_1) - 2.22786259109198e-5*std::exp(1.92399978637695*x_108) - 0.0152534022952102*std::exp(2.72216010093689*x_17) + 1.8775198211088*std::exp(3.41983985900879*x_17) + 8.71946716046391e-5*std::exp(3.7183997631073*x_17) + 0.0128807674326299*std::exp(0.835599899291992*x_22) + 2818.4778525836*std::exp(2.48863983154297*x_29) - 6.21243259911003e-5*std::exp(2.54087996482849*x_38) - 0.178137513590488*std::exp(1.73679983615875*x_50) + 158942.615990879*std::exp(1.88399982452393*x_50) - 0.00468497834080213*std::exp(1.91255986690521*x_50) + 88.867227491096*std::exp(1.95759975910187*x_50) - 133580.286837264*std::exp(1.43127989768982*x_71) - 0.0639811838555166*std::exp(1.75855994224548*x_71) + 206325.416737398*std::exp(1.17287981510162*x_72) + 199129.7610677*std::exp(0.891999900341034*x_73) - 0.00390888086407065*std::exp(0.894479870796204*x_78) + 92962.604090356*std::exp(1.44431984424591*x_78) + 0.0185099686652664*std::exp(0.655359864234924*x_87) + 0.128525320153335*std::sin(0.359279841184616*x_102 - 7.42183971405029) + 0.1384438568162*std::sin(0.338559836149216*x_105 - 4.2564001083374) - 2.06950164586523*std::sin(0.431759864091873*x_112 - 7.37911987304688) + 1633582.82864125*std::sin(0.416559875011444*x_117 + 5.22304010391235) + 4.04181855469842*std::sin(0.308079928159714*x_118 - 7.4967999458313) - 0.104820107238189*std::sin(0.3781598508358*x_120 + 5.17304039001465) - 2513273.97497409*std::sin(0.300079941749573*x_14 - 7.47968006134033) - 23.3993337036524*std::sin(0.13448004424572*x_15 - 7.67288017272949) + 0.0439787577855095*std::sin(0.39055985212326*x_21 + 1.97775983810425) - 0.0576160185568626*std::sin(0.320719838142395*x_28 - 4.28087997436523) + 1656871.36299913*std::sin(0.438799858093262*x_36 - 7.36127996444702) - 0.0497651987146141*std::sin(0.473199844360352*x_41 - 1.14783978462219) - 0.0597919159708386*std::sin(0.341919839382172*x_53 - 4.25631999969482) + 6289330.75308343*std::sin(0.168080016970634*x_55 + 4.96367979049683) - 2468.95831760962*std::sin(0.312079936265945*x_55 + 5.13167953491211) + 0.0368829225278655*std::sin(0.373119831085205*x_67 + 5.16088008880615) - 734846.760899107*std::sin(0.658799827098846*x_69 - 0.763359844684601) + 149.738660959928*std::sin(0.93207985162735*x_7 - 1.01495981216431) - 0.0518491245158229*std::sin(0.262319952249527*x_71 + 5.09015989303589) - 1.97647558162946*std::sin(0.322639852762222*x_75 - 4.29216051101685) + 17.5495834869073*std::sin(0.134800031781197*x_85 + 4.90391969680786) - 542382.06592029*std::sin(0.34215983748436*x_92 + 5.20047998428345) + 1994.03402462985*std::sin(0.367919832468033*x_92 + 1.98215985298157) + 0.0337980050921234*std::sin(0.380799859762192*x_94 - 7.41264009475708) + 2.09922821041864*std::sin(0.350239843130112*x_95 - 7.41919994354248) - 3.72272568019844*std::sin(0.383759826421738*x_97 - 7.41007995605469) - 0.0334274234526084*std::sin(0.445279866456985*x_98 - 7.37824010848999) + 63755630.3955551 + 8927.97160037429*std::exp(-2.31239986419678*x_86) + 0.000190283293348245*std::exp(-2.74000000953674*x_120));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
