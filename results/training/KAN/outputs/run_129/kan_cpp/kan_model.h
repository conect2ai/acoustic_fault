
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.40516529814133*x_1 - 7.19683331142205*x_10 - 1.32844494060971*x_100 + 16.9210699575661*x_101 + 25.630007513283*x_102 - 0.750758318441722*x_103 + 201.643648538224*x_104 + 23.6334095470553*x_105 + 30.2524899505332*x_106 + 7.31971885491932*x_107 + 12.443469250861*x_108 - 18.2183317402986*x_109 + 26.7561893707627*x_110 + 38.9193593660669*x_111 + 19.9562167267618*x_112 - 15.9781057496375*x_113 - 36.3068908950236*x_114 - 7.03056472955501*x_115 + 17.5368820661633*x_116 + 46.1074145634586*x_117 + 20.4181851850487*x_118 + 17.5747798908889*x_119 + 6.97310660073695*x_12 + 6.56563921004584*x_120 - 26.9790623217393*x_13 - 4.24004153731124*x_14 + 0.389767799879502*x_15 + 14.5902685273797*x_16 - 5.86875380436134*x_17 - 67.087474292267*x_18 - 0.0286059684505572*x_19 - 4.39150572578248*x_2 + 0.0155720104222269*x_20 - 11.5096909524155*x_21 + 19.7282674065329*x_22 - 0.0405991748132092*x_23 + 7.32987887844003*x_24 - 0.090041571037497*x_25 - 0.9690346872713*x_26 - 63.7152974353021*x_27 - 3.79075257953234*x_28 - 2.92814189744679*x_29 - 0.479865038614305*x_3 + 0.0238048066911948*x_30 + 5.71349374757779*x_31 + 7.7118718788439*x_32 - 59.143170326931*x_33 + 135.209547943447*x_34 - 159.099306719454*x_35 - 103.278035909308*x_36 + 341.486732527306*x_37 + 118.822642059317*x_38 + 105.348202273924*x_39 - 4.1684031032031*x_4 + 2052.37276000112*x_40 - 15.8088826233528*x_41 + 40.593665053041*x_42 - 9.01608717275757*x_43 + 70.0076664812877*x_44 - 88.5485698618807*x_45 + 236.586539689025*x_46 - 0.636473048302896*x_47 + 178.992906094625*x_48 - 51.096709889011*x_5 + 0.118737702599489*x_50 + 6.33531354314132*x_52 - 4.60243797175212*x_53 - 44.7084640939906*x_54 + 53.7145909773189*x_58 + 43.1163479985011*x_59 + 4.40330306271393*x_6 - 2.76901567120134*x_60 - 25.7495874572408*x_61 - 13.4183410819974*x_62 - 9.05517502796893*x_63 - 33.4152134641497*x_64 + 8.92087491236098*x_65 + 0.809280497418641*x_66 - 10.3755590572094*x_67 - 12.6092597889994*x_68 - 19.3114009008704*x_69 - 32.1985435500039*x_7 + 9.74672822846766*x_70 + 14.6437168231612*x_71 + 19.2905290632491*x_72 - 19.980284126951*x_73 + 29.2146078949479*x_74 + 0.352252290090632*x_75 + 9.11154788756284*x_76 + 10.5654543656313*x_77 + 1.56222221618457*x_78 + 50.0708656110234*x_79 - 0.560765709050746*x_8 + 8.28660074773036*x_80 - 5.26499838036066*x_81 + 20.5349200731286*x_82 - 1.08495608411174*x_83 - 15.4761043494373*x_84 + 21.8506545375374*x_85 - 353.052587549456*x_86 - 82.667417953989*x_87 - 33.968840948184*x_88 - 9.13320994998151*x_89 - 0.513448827325835*x_9 + 22.5538473359701*x_90 + 9.15559224802621*x_91 + 37.2318658892892*x_92 + 11.2333806065752*x_93 - 8.32211042517972*x_94 + 15.0745973409639*x_95 + 48.3888821843895*x_96 + 9.44288785464014*x_97 + 39.1626257558054*x_98 + 41.2662595899377*x_99 + 0.0241638321472799*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 0.000107716907512214*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) - 0.038476718700746*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.00769330817082557*std::exp(1.13951992988586*x_1) - 1.48869458872748*std::exp(1.17007982730865*x_1) + 0.899099481118221*std::exp(1.22071981430054*x_1) + 0.000625603879370221*std::exp(1.40399980545044*x_1) + 0.704485837469856*std::exp(1.6639997959137*x_1) - 0.00631242725226618*std::exp(1.76023995876312*x_1) + 0.000116883939994784*std::exp(0.627359867095947*x_10) + 0.00275774466292952*std::exp(0.778879821300507*x_10) - 4.74568107742891*std::exp(0.80351984500885*x_10) - 0.010774902403329*std::exp(0.810399830341339*x_10) - 0.708347419043183*std::exp(0.840799868106842*x_10) - 0.00130600568523659*std::exp(0.934159815311432*x_10) - 0.359886004968174*std::exp(0.94543981552124*x_10) - 0.0134626712582758*std::exp(0.969839811325073*x_10) + 0.602428533043542*std::exp(0.82207989692688*x_11) - 1.92311694147667e-5*std::exp(0.895919859409332*x_11) - 0.00899788934292907*std::exp(0.902079820632935*x_11) + 2.82904467295971*std::exp(0.914159834384918*x_11) - 5.6996013880243*std::exp(0.925199866294861*x_11) - 0.00626323839490739*std::exp(0.933279812335968*x_11) + 0.00482566238985779*std::exp(0.937199831008911*x_11) - 0.00139050222374458*std::exp(0.951599836349487*x_11) + 0.210344341690588*std::exp(0.983759820461273*x_11) + 0.00869483953126232*std::exp(1.06111979484558*x_11) - 0.000124241903826389*std::exp(0.537679851055145*x_12) + 0.00722870336269462*std::exp(0.696079850196838*x_12) + 0.00350255948524873*std::exp(0.854959905147552*x_12) + 0.00106720742737803*std::exp(0.925439834594727*x_12) - 0.158313092389757*std::exp(1.2235199213028*x_12) + 7.00801966535357e-5*std::exp(1.10399985313416*x_13) - 3.27842765984275e-5*std::exp(1.32895994186401*x_13) + 1.53815024738395e-5*std::exp(1.4015998840332*x_13) - 54.1141971780732*std::exp(0.345279842615128*x_14) + 0.00660507664486629*std::exp(0.428239852190018*x_14) - 0.00543401841838834*std::exp(0.715599834918976*x_14) + 0.00149053572235465*std::exp(0.868079900741577*x_14) + 0.0149538436883298*std::exp(0.67935985326767*x_15) - 2.08541178767637*std::exp(0.82151985168457*x_15) - 0.176117674540307*std::exp(0.898239850997925*x_15) + 4.47481098407057*std::exp(0.92087984085083*x_15) + 0.00422748323928208*std::exp(0.927359819412231*x_15) + 4.54870813135283e-6*std::exp(0.993359804153442*x_15) + 0.00148826266032088*std::exp(1.03111982345581*x_15) - 0.000145608049342607*std::exp(1.05295991897583*x_15) - 2.93921317060075*std::exp(0.357999831438065*x_16) + 0.0510216893705702*std::exp(0.539119839668274*x_16) - 11.4506557257705*std::exp(0.590719819068909*x_16) + 0.00309200584212307*std::exp(0.703679859638214*x_16) + 0.00284887075761712*std::exp(0.912239849567413*x_16) + 0.000407692516772498*std::exp(0.620319843292236*x_17) + 0.0621103465655742*std::exp(0.655279815196991*x_17) - 3.21457858958873*std::exp(0.659599840641022*x_17) - 13.2315217711584*std::exp(0.695119857788086*x_17) + 0.0347646422504417*std::exp(0.7079998254776*x_17) + 0.00670970285329977*std::exp(0.857999861240387*x_17) - 7.38195926442239*std::exp(0.434639871120453*x_18) - 0.00273832701824023*std::exp(0.695919871330261*x_19) - 0.0001637706152635*std::exp(0.704799830913544*x_19) + 47.9282737544523*std::exp(0.716879844665527*x_19) - 5.51203079710757*std::exp(0.719519853591919*x_19) - 0.0293370030339838*std::exp(0.728719890117645*x_19) - 19.8178992142269*std::exp(0.748239874839783*x_19) + 0.626439190594862*std::exp(0.766079843044281*x_19) + 1.49567179831335*std::exp(0.823999881744385*x_19) - 0.00105999576378799*std::exp(1.00991988182068*x_19) + 2.86705119806586*std::exp(0.735999822616577*x_2) - 0.0326880809435525*std::exp(0.754559874534607*x_2) + 0.279892657074074*std::exp(0.755999863147736*x_2) - 10.1462967629049*std::exp(0.924879848957062*x_2) + 0.00122400347718337*std::exp(1.01583981513977*x_2) + 0.00549425330577888*std::exp(1.11415982246399*x_2) - 0.0129320562922641*std::exp(0.26639986038208*x_20) + 0.203812673601546*std::exp(0.403999865055084*x_20) + 1.45619668269498*std::exp(0.516959846019745*x_20) + 6.3433205318401*std::exp(0.532159864902496*x_20) - 2.09981257069251*std::exp(0.886239886283875*x_20) - 0.150809224601353*std::exp(0.916319847106934*x_20) + 0.00056545863328831*std::exp(1.04447984695435*x_20) + 0.052779037728828*std::exp(0.525999844074249*x_22) - 3.58095841525477*std::exp(0.651039838790894*x_22) - 1.97553073017392e-5*std::exp(1.28135991096497*x_22) - 0.00904343560749188*std::exp(1.33199989795685*x_22) - 0.0518314017081044*std::exp(0.638159871101379*x_23) + 13.9035245240699*std::exp(0.658639848232269*x_23) + 0.000154934466825354*std::exp(0.673119843006134*x_23) - 0.00643286586192831*std::exp(0.69023984670639*x_23) - 0.0110542862870261*std::exp(0.733039855957031*x_23) - 0.26513285423112*std::exp(0.734799861907959*x_23) - 1.44328010869751*std::exp(0.736159861087799*x_23) - 1.25139178241842*std::exp(0.747999846935272*x_23) - 1.98764037764547*std::exp(0.818959891796112*x_23) + 22.2970606519037*std::exp(0.305759847164154*x_24) + 0.115729513654091*std::exp(0.42087984085083*x_24) - 1.72583315883702*std::exp(0.60511988401413*x_24) - 0.0526576319750758*std::exp(0.611999869346619*x_24) + 0.00222450460287437*std::exp(0.650239825248718*x_24) - 6.0453731293269e-5*std::exp(0.758959889411926*x_24) + 1.51527163610446*std::exp(0.766159892082214*x_24) - 0.00850772695097479*std::exp(0.412159860134125*x_25) - 0.0374082786320444*std::exp(0.525519847869873*x_25) + 39.7899267822212*std::exp(0.589919865131378*x_25) + 0.0131483715890729*std::exp(0.660079836845398*x_25) + 0.723387586669199*std::exp(0.767039835453033*x_25) + 0.659926320027944*std::exp(0.949439823627472*x_25) + 0.123770397478005*std::exp(0.987279832363129*x_25) + 0.00191250786787224*std::exp(0.993919789791107*x_25) + 0.0134480911176779*std::exp(0.42087984085083*x_26) - 2.74147029966948*std::exp(0.573839843273163*x_26) + 0.0469665101589078*std::exp(0.728879868984222*x_26) + 0.00911361798496805*std::exp(0.8193598985672*x_26) - 0.00195680133314613*std::exp(0.839599847793579*x_26) - 1.53057015827928*std::exp(0.860319912433624*x_26) - 8.93816443596516e-6*std::exp(0.960159838199615*x_26) + 0.0321331459823636*std::exp(1.13951992988586*x_26) + 1.09361812834042e-6*std::exp(1.18455982208252*x_27) + 0.142137330235178*std::exp(1.20399987697601*x_27) - 0.0396056363613516*std::exp(1.23751986026764*x_27) - 0.003164020074634*std::exp(1.25919985771179*x_27) + 0.015279639501309*std::exp(1.28719985485077*x_27) + 35.8126953914485*std::exp(0.516239881515503*x_28) - 0.448981836294007*std::exp(0.543999850749969*x_28) + 0.00787526566445204*std::exp(0.647999823093414*x_28) + 0.00305909607662566*std::exp(0.654319822788239*x_28) - 0.617513086667957*std::exp(0.736559867858887*x_28) + 0.433918297924305*std::exp(0.906079828739166*x_28) + 1.06755545565915*std::exp(0.932239830493927*x_29) + 0.000711529240258908*std::exp(1.12255990505219*x_29) - 0.0659090749122555*std::exp(1.15015983581543*x_29) - 0.0149612149744182*std::exp(1.15143990516663*x_29) + 0.270391390709882*std::exp(1.16695988178253*x_29) - 8.15726756322142*std::exp(0.439999848604202*x_3) + 14.0010812993135*std::exp(0.526399850845337*x_3) - 0.0306415302234088*std::exp(0.633039832115173*x_3) - 0.000162666419431041*std::exp(0.658079862594604*x_3) - 0.00113058318829819*std::exp(0.925759851932526*x_3) - 0.0650623658204934*std::exp(0.94135981798172*x_3) - 0.0107125668784933*std::exp(0.634159862995148*x_30) + 13.6114455397747*std::exp(0.828479886054993*x_30) - 0.163653021123185*std::exp(0.857279896736145*x_30) + 2.13454118624921*std::exp(0.885519862174988*x_30) - 1.16087751705648*std::exp(0.91239982843399*x_30) + 0.651899927246862*std::exp(0.947999835014343*x_30) + 0.000383626942693911*std::exp(1.02791976928711*x_30) + 8.97995630332852e-6*std::exp(1.02927982807159*x_30) - 0.00176846552252109*std::exp(1.09479975700378*x_30) - 6.31908068911135*std::exp(0.826799869537354*x_32) + 3.18878139110074e-5*std::exp(0.831519842147827*x_32) + 0.000395297344622066*std::exp(0.832079887390137*x_32) + 2.94702433266297*std::exp(0.333039849996567*x_33) - 0.096671240571777*std::exp(0.360239863395691*x_33) + 0.000662232873480388*std::exp(0.404719859361649*x_33) - 1.05734883996579*std::exp(0.417439848184586*x_33) + 7.44946498598999*std::exp(0.369439840316772*x_34) - 0.533434824889887*std::exp(0.426799863576889*x_36) - 1.36886337248897*std::exp(0.261359840631485*x_37) + 0.0717851421366426*std::exp(0.355199843645096*x_4) - 10.131348763671*std::exp(0.535359859466553*x_4) + 0.000174837158667042*std::exp(0.541439831256866*x_4) - 0.011640875777694*std::exp(0.586239874362946*x_4) - 1.79777175739216*std::exp(0.747519850730896*x_4) - 0.021241830842052*std::exp(1.09559988975525*x_4) + 0.418751143685282*std::exp(1.10943984985352*x_4) - 0.000179888786463438*std::exp(1.15591979026794*x_4) - 8.44162515140877*std::exp(0.715999841690063*x_41) + 0.752339776319677*std::exp(0.747999846935272*x_41) - 0.0229789307315447*std::exp(0.770959854125977*x_41) - 0.00801154286727771*std::exp(0.788479864597321*x_41) + 6.40932804796505e-5*std::exp(0.796479880809784*x_41) - 0.00433131917863658*std::exp(0.802159905433655*x_41) - 0.0869887030583887*std::exp(0.802399873733521*x_41) - 0.0232483678194442*std::exp(0.806319832801819*x_41) + 0.280023640895658*std::exp(0.812319874763489*x_41) + 0.0237200094890207*std::exp(0.585839867591858*x_42) + 0.593154576551113*std::exp(0.693759858608246*x_42) - 0.532480193360269*std::exp(0.720399856567383*x_42) + 0.0103489519892482*std::exp(0.851439893245697*x_42) + 0.00253093082079055*std::exp(0.704879820346832*x_43) + 0.00302416131072134*std::exp(0.761919856071472*x_43) - 7.17857502982147e-6*std::exp(0.818479895591736*x_43) - 0.0149375096824864*std::exp(0.875679850578308*x_44) + 0.000294346535539138*std::exp(0.960559844970703*x_44) + 9.1412420686971e-7*std::exp(0.99999988079071*x_44) - 3.82701007507597*std::exp(0.555919826030731*x_45) + 1.4657433994892*std::exp(0.518719851970673*x_46) - 0.479451337318779*std::exp(0.702239871025085*x_46) + 7.94630142200765e-6*std::exp(0.715279817581177*x_46) + 0.0102863099832823*std::exp(0.752959847450256*x_46) + 0.0140362348855596*std::exp(0.756079852581024*x_46) + 0.00157541811357927*std::exp(0.795919895172119*x_46) + 0.0602780235072369*std::exp(0.406479865312576*x_47) - 0.0334798675298417*std::exp(0.552319884300232*x_47) - 7.70299327107636e-5*std::exp(0.586239874362946*x_48) + 1.7059637688443*std::exp(0.600879848003387*x_48) - 0.00100808992076986*std::exp(0.65559983253479*x_49) - 0.0191684016396084*std::exp(0.684479832649231*x_49) - 35.8748353466195*std::exp(0.703759849071503*x_49) + 0.121674837265972*std::exp(0.7079998254776*x_49) + 0.360716428276435*std::exp(0.708239853382111*x_49) + 0.000203226550183921*std::exp(0.709119856357574*x_49) - 0.0650267588139255*std::exp(0.714559853076935*x_49) + 15.7230435497445*std::exp(0.71919983625412*x_49) - 2.10219086511517*std::exp(0.719519853591919*x_49) + 4.29128162078927*std::exp(0.722239851951599*x_49) + 0.00100337043069772*std::exp(2.06119966506958*x_5) + 0.000369778047525617*std::exp(0.325439840555191*x_50) - 0.875029604191351*std::exp(0.535359859466553*x_50) + 0.285977345074447*std::exp(0.535439848899841*x_50) - 2.08075339072365*std::exp(0.538639843463898*x_50) + 0.0513112389969729*std::exp(0.539039850234985*x_50) - 34.6489855525761*std::exp(0.550159871578217*x_50) - 0.0216685917666155*std::exp(0.591119825839996*x_50) + 6.26329997770742*std::exp(0.592239856719971*x_50) + 0.00097736211287129*std::exp(0.642959833145142*x_50) + 0.0222362501775378*std::exp(0.460479855537415*x_51) + 0.000934397133005819*std::exp(0.483199834823608*x_51) - 2.71173811920337*std::exp(0.488399863243103*x_51) - 0.615082377035914*std::exp(0.493759840726852*x_51) + 241.168109472142*std::exp(0.494479864835739*x_51) - 0.418240580879658*std::exp(0.495999842882156*x_51) + 161.4909850502*std::exp(0.49703985452652*x_51) + 0.0379277317139111*std::exp(0.498159825801849*x_51) + 10.1711636450843*std::exp(0.499919831752777*x_51) - 12.8255101125778*std::exp(0.50631982088089*x_51) - 0.464109255089547*std::exp(0.521999835968018*x_52) + 0.0173597851779354*std::exp(0.526719868183136*x_52) - 0.000129985762113506*std::exp(0.590079843997955*x_52) + 0.00315080782977106*std::exp(0.628719866275787*x_52) + 0.00404233466478058*std::exp(0.705759823322296*x_52) + 0.211246385348815*std::exp(0.709279835224152*x_52) - 1.40741706448344*std::exp(0.720719873905182*x_52) - 0.0300653856647573*std::exp(0.887439906597137*x_52) - 6.13745450359963*std::exp(0.48039984703064*x_54) + 0.0155612360784425*std::exp(0.49823984503746*x_54) + 0.000273590850092213*std::exp(0.512639820575714*x_54) - 2.16951694513016*std::exp(0.519359886646271*x_54) + 0.0663116086407366*std::exp(0.533919811248779*x_54) + 12.796121365235*std::exp(0.535759806632996*x_54) - 0.127411890297066*std::exp(0.538879811763763*x_54) - 0.000264258667577716*std::exp(0.629039824008942*x_55) - 10.6439714841304*std::exp(0.631839871406555*x_55) - 0.0379986565652598*std::exp(0.651679813861847*x_55) - 24.8024492422*std::exp(0.653599858283997*x_55) - 1.56302877850118*std::exp(0.653759837150574*x_55) + 0.641534638960027*std::exp(0.655519843101501*x_55) - 291.126928927195*std::exp(0.655839860439301*x_55) + 0.421894900666324*std::exp(0.656479835510254*x_55) + 0.0992997052673054*std::exp(0.657599866390228*x_55) - 17.3858224921634*std::exp(0.658879816532135*x_55) - 11.5122280863626*std::exp(0.342799842357635*x_56) - 58.7007921605234*std::exp(0.434559851884842*x_56) - 1.80929353873073*std::exp(0.468159854412079*x_56) + 0.07044871186082*std::exp(0.510159850120544*x_56) + 19.8017378328022*std::exp(0.52839982509613*x_56) - 4.90037082134085*std::exp(0.568239867687225*x_56) - 0.0386597441867017*std::exp(0.658959865570068*x_56) + 0.00742438205095112*std::exp(0.678959846496582*x_56) + 2.45100622099118e-5*std::exp(0.747119843959808*x_56) + 0.000442328758839204*std::exp(0.824879884719849*x_56) - 0.756509735693061*std::exp(0.610959827899933*x_57) - 0.0106529450700308*std::exp(0.616639852523804*x_57) - 0.086321766675536*std::exp(0.626079857349396*x_57) + 7.79210216656494*std::exp(0.627359867095947*x_57) + 0.047241355758877*std::exp(0.628399848937988*x_57) + 171.347047789778*std::exp(0.632639825344086*x_57) + 0.000772923206133041*std::exp(0.636399865150452*x_57) - 16.5760087318559*std::exp(0.641759812831879*x_57) - 0.136348748443497*std::exp(0.643279850482941*x_57) - 2.18109656210379*std::exp(0.663679838180542*x_57) + 0.0617084003985894*std::exp(0.437759846448898*x_58) + 0.00779925008178568*std::exp(0.485119849443436*x_58) - 0.0124999754634932*std::exp(0.554479837417603*x_58) - 0.158915694759325*std::exp(0.566799819469452*x_58) + 0.000140129427755783*std::exp(0.60647988319397*x_58) - 0.0285850905971314*std::exp(0.655439853668213*x_58) + 0.0400651306359478*std::exp(0.522799849510193*x_59) + 1.07306771837105*std::exp(0.691839873790741*x_59) + 1.51781726083052*std::exp(0.765759825706482*x_59) - 0.0342749499485852*std::exp(0.827119886875153*x_59) + 0.127342132487859*std::exp(0.860399901866913*x_59) + 0.0125132006175864*std::exp(0.780719876289368*x_60) - 0.66173219043283*std::exp(0.787359893321991*x_60) + 14.8346930081232*std::exp(0.816559851169586*x_60) - 4.11672323031183e-5*std::exp(0.838639855384827*x_60) - 0.140404303986485*std::exp(0.847519874572754*x_60) - 0.00674475218250031*std::exp(0.854399859905243*x_60) - 0.000797800833585312*std::exp(0.860399901866913*x_60) - 0.00708756540928059*std::exp(0.872479856014252*x_60) - 0.0900286870213413*std::exp(1.03615987300873*x_60) + 1.37992937002586*std::exp(0.983999848365784*x_61) + 0.0011239293103893*std::exp(1.18831992149353*x_61) + 0.84836859671523*std::exp(1.23887979984283*x_61) + 0.0614901056522749*std::exp(1.32615983486176*x_61) - 0.00742160670373945*std::exp(0.599199831485748*x_66) + 11.0334448873529*std::exp(0.949999809265137*x_66) + 0.00609884081456456*std::exp(1.11047983169556*x_66) + 0.00107425073275575*std::exp(1.5058399438858*x_66) - 3.33610069478943e-6*std::exp(1.78991985321045*x_7) + 0.0469637193958212*std::exp(0.455999851226807*x_8) + 0.0322977044635721*std::exp(0.519439876079559*x_8) + 0.00798147668821743*std::exp(0.636319875717163*x_8) + 0.0318799623740372*std::exp(0.878639876842499*x_8) + 0.174184007133493*std::exp(0.925199866294861*x_8) + 0.00349070706354592*std::exp(1.39863991737366*x_8) - 0.217412323300581*std::log(9.29800033569336 - 1.38431990146637*x_5) - 23.7519736848494*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.184775552314224*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 23.1589840191287*std::sin(0.208320006728172*x_101 - 7.40863990783691) + 2.36276548915768*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.37384356487192*std::sin(0.281839966773987*x_113 - 7.41663980484009) + 29.4022896965072*std::sin(0.30583992600441*x_113 - 1.2235199213028) - 1.55541167448453*std::sin(0.319439828395844*x_113 + 5.03800010681152) - 1.36774189019585*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 12.7235874210371*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.00100293801730547*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.376702973669278*std::sin(0.267359972000122*x_117 + 1.94591987133026) + 4.19454615869282*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 29.5139870512305*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.0654057620890767*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 202.105511174454*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 2.05145258893603*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 16.8056650750071*std::sin(0.401599854230881*x_21 - 7.40983963012695) - 1.91701016512864*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 1.6834687595864*std::sin(0.0904000774025917*x_3 + 1.69007980823517) - 0.148736476275046*std::sin(0.602719843387604*x_3 + 2.19079995155334) - 0.45185509167732*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.000313875893279248*std::sin(0.467679858207703*x_31 - 1.14271986484528) - 158.400337416776*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.0420416248187344*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.0340337769985687*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.450551671797631*std::sin(0.198640003800392*x_47 + 8.2055196762085) - 1.84464986562196*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.000286343865497059*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.000394513502468121*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 18.0568813266072*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 11.787512545417*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.150419036110682*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 5.1016728707868*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.02061310382557*std::sin(0.397599816322327*x_73 + 2.00783967971802) + 3.81727710786189*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 16.1240204953143*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.229850763222078*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.19390938480697*std::sin(0.36575984954834*x_9 + 2.02055978775024) - 24.1060404091743*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 143.000544689108*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.179535217690969*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 16.9448003788337*std::sin(0.383119851350784*x_91 + 8.20567989349365) - 2.11312294045673*std::sin(0.393919825553894*x_91 - 4.39919996261597) + 32.2396869657171*std::sin(0.299039930105209*x_92 - 1.17503976821899) - 2.94740463670258*std::sin(0.306799918413162*x_92 + 8.20695972442627) - 3.30881216989856*std::sin(0.235759988427162*x_93 + 1.9755197763443) + 14.5530818718221*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.000311462655691066*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.322091261947364*std::sin(0.301119923591614*x_97 - 7.45264005661011) + 4.06035624737387*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 21.2476270123017*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.286683138032888*std::sin(0.259039968252182*x_98 + 1.97271978855133) - 24.4893048181177*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.132067458935545*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 16299.1331376885);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.288339592646114*x_1 - 9.45303102081758*x_10 + 12.5213263022359*x_100 + 23.7822383589665*x_101 + 29.1596554872568*x_102 - 4.10681393593282*x_103 + 146.494460567545*x_104 + 43.3704687404042*x_105 + 32.7339302299538*x_106 + 14.4550576551177*x_107 + 23.8886912219316*x_108 - 22.5268141879683*x_109 + 33.2394302882217*x_110 + 45.8236644502818*x_111 + 22.1244958223961*x_112 - 19.4321684933297*x_113 - 59.0908218499937*x_114 - 8.24959519688201*x_115 + 5.71258020386344*x_116 + 53.7122722241505*x_117 + 42.5104872788141*x_118 + 30.9800599971481*x_119 + 6.79591700819588*x_12 + 4.85173487788888*x_120 - 15.0237313248523*x_13 + 2.81864965855108*x_14 - 0.0547963693881717*x_15 + 20.5347502402658*x_16 - 2.20574424332825*x_17 - 93.5991703813808*x_18 + 0.106287991648193*x_19 - 2.76774255420282*x_2 - 0.170602639642339*x_20 - 10.4664350184877*x_21 + 26.4973795703049*x_22 - 0.0524186589584089*x_23 + 10.2728727246846*x_24 + 0.0970133169512833*x_25 - 0.596688969898749*x_26 - 83.4159496000577*x_27 - 2.5417959218044*x_28 - 0.760439992129988*x_29 + 1.04020153499854*x_3 - 0.0884488528732637*x_30 + 6.18397505176057*x_31 - 1.29299318687844*x_32 - 86.2730155839322*x_33 + 148.608672568452*x_34 - 27.1620456726685*x_35 - 161.026273934519*x_36 + 458.166791091916*x_37 + 26.9851339047257*x_38 + 137.869325381493*x_39 - 0.811341079324838*x_4 + 3589.98843570949*x_40 - 9.94651997392879*x_41 + 44.0216422671001*x_42 - 31.9466996778695*x_43 + 83.2838678643164*x_44 - 42.6245536597513*x_45 + 329.165752770977*x_46 - 75.13934405065*x_47 + 259.371892306857*x_48 - 68.7630620240967*x_5 + 0.153305360680448*x_50 + 8.26438504287506*x_52 - 4.37617805154461*x_53 - 61.8449600218236*x_54 + 39.6706147387319*x_58 + 56.6972055485357*x_59 - 2.85960061662279*x_6 - 0.537469061948364*x_60 - 33.8557431802536*x_61 - 24.0519717616224*x_62 - 11.8143052172593*x_63 - 38.6496164250829*x_64 + 9.23622127646516*x_65 + 3.36172408167188*x_66 - 15.061184449368*x_67 - 19.6017139985477*x_68 - 30.7587142883824*x_69 - 55.266795371421*x_7 + 16.2604728313424*x_70 + 19.1131921336052*x_71 + 16.7904510635693*x_72 - 26.7101591147765*x_73 + 31.8936943352186*x_74 + 7.92024138267429*x_75 + 5.66423754496482*x_76 + 14.2590315777056*x_77 + 10.5731784502325*x_78 + 52.6527952549762*x_79 + 0.99182336519445*x_8 + 10.7737458309309*x_80 - 6.38425069428434*x_81 + 22.3212818947974*x_82 - 16.5377161965572*x_83 - 22.6612895996133*x_84 + 21.4640117274616*x_85 - 422.537346319965*x_86 - 89.952027803793*x_87 - 45.7562771123978*x_88 - 9.06344812804343*x_89 + 1.07525386345577*x_9 + 20.7018719931268*x_90 + 5.65461421332649*x_91 + 38.5602482721794*x_92 + 28.3318450095856*x_93 - 7.53706757082397*x_94 + 14.9978598036961*x_95 + 56.7100825293023*x_96 + 18.3689068430507*x_97 + 53.3341408127897*x_98 + 73.2782457100393*x_99 + 0.00469022704795371*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) - 6.4336811572611e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) - 0.00746837445595566*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.00993303186884573*std::exp(1.13951992988586*x_1) - 0.936646239626342*std::exp(1.17007982730865*x_1) - 0.524906389847386*std::exp(1.22071981430054*x_1) + 0.00014492815308903*std::exp(1.40399980545044*x_1) + 0.925341214275438*std::exp(1.6639997959137*x_1) + 0.00663228107992798*std::exp(1.76023995876312*x_1) - 0.00244237037966079*std::exp(0.627359867095947*x_10) + 0.000638862471715884*std::exp(0.778879821300507*x_10) - 2.98585376026606*std::exp(0.80351984500885*x_10) + 0.00391685061682758*std::exp(0.810399830341339*x_10) + 0.413542766174482*std::exp(0.840799868106842*x_10) + 0.000780046917651235*std::exp(0.934159815311432*x_10) - 0.069854279089244*std::exp(0.94543981552124*x_10) + 0.0141448315051073*std::exp(0.969839811325073*x_10) + 0.116932057089213*std::exp(0.82207989692688*x_11) + 0.000401848522106294*std::exp(0.895919859409332*x_11) - 0.0116174108213412*std::exp(0.902079820632935*x_11) + 3.71594643026165*std::exp(0.914159834384918*x_11) - 3.58603453514622*std::exp(0.925199866294861*x_11) + 0.00374088708777505*std::exp(0.933279812335968*x_11) - 0.0179301730223439*std::exp(0.937199831008911*x_11) - 0.000322125430801931*std::exp(0.951599836349487*x_11) - 0.122801860461883*std::exp(0.983759820461273*x_11) - 0.00913541137373083*std::exp(1.06111979484558*x_11) + 0.00259612009855055*std::exp(0.537679851055145*x_12) - 0.0268588831022913*std::exp(0.696079850196838*x_12) + 0.00452224637528983*std::exp(0.854959905147552*x_12) - 0.000637418254477148*std::exp(0.925439834594727*x_12) - 0.207944037134608*std::exp(1.2235199213028*x_12) + 1.62348633121286e-5*std::exp(1.10399985313416*x_13) - 4.23286389961795e-5*std::exp(1.32895994186401*x_13) - 5.71513252313701e-5*std::exp(1.4015998840332*x_13) - 71.0789263076439*std::exp(0.345279842615128*x_14) + 0.00153014006261535*std::exp(0.428239852190018*x_14) + 0.020190573350735*std::exp(0.715599834918976*x_14) + 0.00192446974735096*std::exp(0.868079900741577*x_14) - 0.0555623214015891*std::exp(0.67935985326767*x_15) - 1.31208450933457*std::exp(0.82151985168457*x_15) + 0.102819871073993*std::exp(0.898239850997925*x_15) + 5.87765829973851*std::exp(0.92087984085083*x_15) + 0.00545821443888604*std::exp(0.927359819412231*x_15) - 9.50483873681369e-5*std::exp(0.993359804153442*x_15) - 0.000888904783464571*std::exp(1.03111982345581*x_15) - 3.37317372254211e-5*std::exp(1.05295991897583*x_15) + 1.71595224641117*std::exp(0.357999831438065*x_16) + 0.0658754407423973*std::exp(0.539119839668274*x_16) - 7.20444187008602*std::exp(0.590719819068909*x_16) + 0.000716297821699088*std::exp(0.703679859638214*x_16) - 0.00170156445594906*std::exp(0.912239849567413*x_16) - 0.00851901576058219*std::exp(0.620319843292236*x_17) - 0.230776455215573*std::exp(0.655279815196991*x_17) + 1.87671428777063*std::exp(0.659599840641022*x_17) - 17.3795863184539*std::exp(0.695119857788086*x_17) + 0.0448855410072052*std::exp(0.7079998254776*x_17) - 0.00400754995804174*std::exp(0.857999861240387*x_17) - 1.43284661132625*std::exp(0.434639871120453*x_18) - 0.000634364156607943*std::exp(0.695919871330261*x_19) + 0.00342209973240331*std::exp(0.704799830913544*x_19) + 62.9537240852882*std::exp(0.716879844665527*x_19) - 1.06989138875714*std::exp(0.719519853591919*x_19) - 0.0378777737226292*std::exp(0.728719890117645*x_19) - 12.4688844285828*std::exp(0.748239874839783*x_19) - 0.658181175872742*std::exp(0.766079843044281*x_19) - 0.873193345716075*std::exp(0.823999881744385*x_19) + 0.000633110895008392*std::exp(1.00991988182068*x_19) - 1.67382311467099*std::exp(0.735999822616577*x_2) - 0.0422044382642835*std::exp(0.754559874534607*x_2) - 0.29407495718176*std::exp(0.755999863147736*x_2) - 13.3271473571491*std::exp(0.924879848957062*x_2) + 0.000283554129333906*std::exp(1.01583981513977*x_2) - 0.00328159012201507*std::exp(1.11415982246399*x_2) - 0.0029958558376715*std::exp(0.26639986038208*x_20) - 0.21413996311669*std::exp(0.403999865055084*x_20) + 0.282649416975249*std::exp(0.516959846019745*x_20) + 3.99104515317093*std::exp(0.532159864902496*x_20) - 2.75810102995658*std::exp(0.886239886283875*x_20) + 0.0880444570413127*std::exp(0.916319847106934*x_20) - 0.000337735332197976*std::exp(1.04447984695435*x_20) + 0.0681443992787828*std::exp(0.525999844074249*x_22) - 2.25304186587641*std::exp(0.651039838790894*x_22) - 4.57653843807603e-6*std::exp(1.28135991096497*x_22) + 0.00527967954184783*std::exp(1.33199989795685*x_22) + 0.192584131573347*std::exp(0.638159871101379*x_23) + 18.2622610441926*std::exp(0.658639848232269*x_23) - 0.00323746232869689*std::exp(0.673119843006134*x_23) - 0.00149024550387582*std::exp(0.69023984670639*x_23) + 0.00660246891916625*std::exp(0.733039855957031*x_23) + 0.278567267789594*std::exp(0.734799861907959*x_23) + 0.842606371491544*std::exp(0.736159861087799*x_23) - 0.787341753088138*std::exp(0.747999846935272*x_23) - 0.385803237003826*std::exp(0.818959891796112*x_23) + 14.0287055333343*std::exp(0.305759847164154*x_24) - 0.430003186292261*std::exp(0.42087984085083*x_24) + 1.00756464874985*std::exp(0.60511988401413*x_24) - 0.0679876491273128*std::exp(0.611999869346619*x_24) + 0.000515331432978283*std::exp(0.650239825248718*x_24) + 0.00126322232684183*std::exp(0.758959889411926*x_24) + 0.29411593199857*std::exp(0.766159892082214*x_24) - 0.00197091033903399*std::exp(0.412159860134125*x_25) + 0.0223430975618445*std::exp(0.525519847869873*x_25) + 52.2640161182328*std::exp(0.589919865131378*x_25) - 0.0488539310270928*std::exp(0.660079836845398*x_25) + 0.14041034569642*std::exp(0.767039835453033*x_25) + 0.415207733517043*std::exp(0.949439823627472*x_25) - 0.0722588254965447*std::exp(0.987279832363129*x_25) + 0.00246928904694515*std::exp(0.993919789791107*x_25) + 0.00311540109089486*std::exp(0.42087984085083*x_26) - 0.532122474295495*std::exp(0.573839843273163*x_26) - 0.0493463265822734*std::exp(0.728879868984222*x_26) - 0.0054433527343622*std::exp(0.8193598985672*x_26) - 0.00252647750116768*std::exp(0.839599847793579*x_26) - 2.01040187533436*std::exp(0.860319912433624*x_26) + 0.000186769098200428*std::exp(0.960159838199615*x_26) - 0.0187597635259048*std::exp(1.13951992988586*x_26) - 2.2851903550119e-5*std::exp(1.18455982208252*x_27) + 0.0894289512996126*std::exp(1.20399987697601*x_27) + 0.0231223040793991*std::exp(1.23751986026764*x_27) + 0.00332434254509212*std::exp(1.25919985771179*x_27) + 0.0029657952445299*std::exp(1.28719985485077*x_27) + 47.0399279551411*std::exp(0.516239881515503*x_28) + 0.471731969190621*std::exp(0.543999850749969*x_28) + 0.0101679619591053*std::exp(0.647999823093414*x_28) + 0.000708673905528787*std::exp(0.654319822788239*x_28) + 0.360512459203358*std::exp(0.736559867858887*x_28) + 0.0842240305727216*std::exp(0.906079828739166*x_28) + 1.4022326768042*std::exp(0.932239830493927*x_29) + 0.000918674055708455*std::exp(1.12255990505219*x_29) + 0.0384786058683355*std::exp(1.15015983581543*x_29) + 0.0157193071764821*std::exp(1.15143990516663*x_29) + 0.170122925987279*std::exp(1.16695988178253*x_29) - 10.7145601382568*std::exp(0.439999848604202*x_3) + 8.80910043537836*std::exp(0.526399850845337*x_3) + 0.0183014756161319*std::exp(0.633039832115173*x_3) + 0.0033990268004448*std::exp(0.658079862594604*x_3) - 0.00026191227196115*std::exp(0.925759851932526*x_3) + 0.0683591082482095*std::exp(0.94135981798172*x_3) + 0.0063983678387951*std::exp(0.634159862995148*x_30) + 17.8786156852416*std::exp(0.828479886054993*x_30) + 0.171945401078277*std::exp(0.857279896736145*x_30) + 1.34299539379455*std::exp(0.885519862174988*x_30) - 0.225327634154775*std::exp(0.91239982843399*x_30) - 0.380587959996754*std::exp(0.947999835014343*x_30) + 8.88714825998028e-5*std::exp(1.02791976928711*x_30) - 0.000187642368035133*std::exp(1.02927982807159*x_30) - 0.00228331219861584*std::exp(1.09479975700378*x_30) - 8.30010411418238*std::exp(0.826799869537354*x_32) - 0.000666317820667706*std::exp(0.831519842147827*x_32) + 9.15750620580326e-5*std::exp(0.832079887390137*x_32) - 1.72051250805596*std::exp(0.333039849996567*x_33) + 0.359190496496311*std::exp(0.360239863395691*x_33) - 0.0138378117190294*std::exp(0.404719859361649*x_33) + 1.11092523144268*std::exp(0.417439848184586*x_33) - 4.34909801886134*std::exp(0.369439840316772*x_34) + 0.560464232712033*std::exp(0.426799863576889*x_36) + 1.4382243602262*std::exp(0.261359840631485*x_37) + 0.0926836789480089*std::exp(0.355199843645096*x_4) - 6.3743697288152*std::exp(0.535359859466553*x_4) - 0.00365334277413554*std::exp(0.541439831256866*x_4) + 0.0432526977569636*std::exp(0.586239874362946*x_4) + 1.04956337175133*std::exp(0.747519850730896*x_4) + 0.0223181649731005*std::exp(1.09559988975525*x_4) + 0.550029072505731*std::exp(1.10943984985352*x_4) - 4.16732543439755e-5*std::exp(1.15591979026794*x_4) - 11.0880634536488*std::exp(0.715999841690063*x_41) + 0.146029998331337*std::exp(0.747999846935272*x_41) - 0.0296686998883002*std::exp(0.770959854125977*x_41) + 0.00478510881682616*std::exp(0.788479864597321*x_41) - 0.00133927321226316*std::exp(0.796479880809784*x_41) - 0.00100339865160493*std::exp(0.802159905433655*x_41) + 0.0913964638965944*std::exp(0.802399873733521*x_41) + 0.0863813553069576*std::exp(0.806319832801819*x_41) - 0.163481574065255*std::exp(0.812319874763489*x_41) - 0.0881337814107453*std::exp(0.585839867591858*x_42) + 0.115131971684*std::exp(0.693759858608246*x_42) + 0.310869110517511*std::exp(0.720399856567383*x_42) - 0.0108733385324533*std::exp(0.851439893245697*x_42) - 0.00151166630273017*std::exp(0.704879820346832*x_43) - 0.011236537322353*std::exp(0.761919856071472*x_43) + 0.000150001266399737*std::exp(0.818479895591736*x_43) + 0.00872071939246658*std::exp(0.875679850578308*x_44) - 0.000175806361613984*std::exp(0.960559844970703*x_44) - 1.91012545118612e-5*std::exp(0.99999988079071*x_44) - 2.40785089364506*std::exp(0.555919826030731*x_45) + 0.284502445462391*std::exp(0.518719851970673*x_46) + 0.279910149949703*std::exp(0.702239871025085*x_46) - 0.000166043437805347*std::exp(0.715279817581177*x_46) + 0.0132809244876258*std::exp(0.752959847450256*x_46) - 0.052152865191997*std::exp(0.756079852581024*x_46) + 0.000364963270007043*std::exp(0.795919895172119*x_46) + 0.0778265364123799*std::exp(0.406479865312576*x_47) + 0.124397392332477*std::exp(0.552319884300232*x_47) + 0.00160959346517946*std::exp(0.586239874362946*x_48) + 0.331129489838113*std::exp(0.600879848003387*x_48) - 0.000233535333111933*std::exp(0.65559983253479*x_49) - 0.0247488258800158*std::exp(0.684479832649231*x_49) - 47.1215487039408*std::exp(0.703759849071503*x_49) - 0.452093559058264*std::exp(0.7079998254776*x_49) - 0.378994109059733*std::exp(0.708239853382111*x_49) - 0.00424655865084633*std::exp(0.709119856357574*x_49) + 0.0388389754738808*std::exp(0.714559853076935*x_49) + 9.89251235805044*std::exp(0.71919983625412*x_49) + 1.22728734800889*std::exp(0.719519853591919*x_49) + 0.832942598075372*std::exp(0.722239851951599*x_49) + 0.000631293448623746*std::exp(2.06119966506958*x_5) - 0.00772676682840832*std::exp(0.325439840555191*x_50) + 0.510854071425357*std::exp(0.535359859466553*x_50) - 0.300467959348661*std::exp(0.535439848899841*x_50) - 0.403876577763435*std::exp(0.538639843463898*x_50) - 0.190651421272278*std::exp(0.539039850234985*x_50) - 45.5113966233633*std::exp(0.550159871578217*x_50) + 0.0129421475024661*std::exp(0.591119825839996*x_50) + 3.94069839186157*std::exp(0.592239856719971*x_50) + 0.00022641689188408*std::exp(0.642959833145142*x_50) + 0.028709805554742*std::exp(0.460479855537415*x_51) - 0.0195248712577212*std::exp(0.483199834823608*x_51) + 2.84914323808728*std::exp(0.488399863243103*x_51) + 2.28539266783923*std::exp(0.493759840726852*x_51) + 151.736430403743*std::exp(0.494479864835739*x_51) + 0.249805402564336*std::exp(0.495999842882156*x_51) + 212.118194934306*std::exp(0.49703985452652*x_51) + 0.00878638430709038*std::exp(0.498159825801849*x_51) - 5.93806236307477*std::exp(0.499919831752777*x_51) - 2.48944596482755*std::exp(0.50631982088089*x_51) + 0.487625901818484*std::exp(0.521999835968018*x_52) - 0.0645018086066887*std::exp(0.526719868183136*x_52) + 0.00271614197106829*std::exp(0.590079843997955*x_52) + 0.000729919961440877*std::exp(0.628719866275787*x_52) + 0.00521916426045059*std::exp(0.705759823322296*x_52) + 0.0410031614317846*std::exp(0.709279835224152*x_52) - 0.885508626830696*std::exp(0.720719873905182*x_52) + 0.0175525771953838*std::exp(0.887439906597137*x_52) + 3.58312862368726*std::exp(0.48039984703064*x_54) + 0.00360493481418525*std::exp(0.49823984503746*x_54) - 0.00571686913053456*std::exp(0.512639820575714*x_54) + 2.27944744750987*std::exp(0.519359886646271*x_54) + 0.0856166563560628*std::exp(0.533919811248779*x_54) + 8.05097234134145*std::exp(0.535759806632996*x_54) + 0.0761001681859746*std::exp(0.538879811763763*x_54) + 0.00552186675337296*std::exp(0.629039824008942*x_55) - 6.69689803455432*std::exp(0.631839871406555*x_55) - 0.00880281484413311*std::exp(0.651679813861847*x_55) - 4.81418334568098*std::exp(0.653599858283997*x_55) + 1.6422282239078*std::exp(0.653759837150574*x_55) + 0.828302190977301*std::exp(0.655519843101501*x_55) - 382.394835486379*std::exp(0.655839860439301*x_55) - 1.56758760871681*std::exp(0.656479835510254*x_55) - 0.0593094118142415*std::exp(0.657599866390228*x_55) + 10.1500773947049*std::exp(0.658879816532135*x_55) + 6.72099385086588*std::exp(0.342799842357635*x_56) - 77.1034127411724*std::exp(0.434559851884842*x_56) + 1.9009713419908*std::exp(0.468159854412079*x_56) - 0.261758384822064*std::exp(0.510159850120544*x_56) + 12.4587161259281*std::exp(0.52839982509613*x_56) - 0.951167498233234*std::exp(0.568239867687225*x_56) - 0.0499146092319766*std::exp(0.658959865570068*x_56) - 0.00443441127383793*std::exp(0.678959846496582*x_56) - 0.000512154620624554*std::exp(0.747119843959808*x_56) + 0.000102470416489844*std::exp(0.824879884719849*x_56) + 0.794842460167307*std::exp(0.610959827899933*x_57) - 0.00246787416905514*std::exp(0.616639852523804*x_57) - 0.111452295985584*std::exp(0.626079857349396*x_57) - 4.5491342209281*std::exp(0.627359867095947*x_57) - 0.0282161665618643*std::exp(0.628399848937988*x_57) + 225.064120286292*std::exp(0.632639825344086*x_57) - 0.0161507624100969*std::exp(0.636399865150452*x_57) - 10.4291749054973*std::exp(0.641759812831879*x_57) + 0.506615766596135*std::exp(0.643279850482941*x_57) - 0.423353300396503*std::exp(0.663679838180542*x_57) - 0.229282988881324*std::exp(0.437759846448898*x_58) + 0.00180678372865996*std::exp(0.485119849443436*x_58) + 0.00746594554773901*std::exp(0.554479837417603*x_58) + 0.166968032031973*std::exp(0.566799819469452*x_58) - 0.00292810084674432*std::exp(0.60647988319397*x_58) - 0.0369069598631038*std::exp(0.655439853668213*x_58) - 0.1488655165714*std::exp(0.522799849510193*x_59) - 0.626471390475484*std::exp(0.691839873790741*x_59) + 0.954969434672346*std::exp(0.765759825706482*x_59) + 0.0360116787053461*std::exp(0.827119886875153*x_59) + 0.0247172514069087*std::exp(0.860399901866913*x_59) + 0.0161561213662403*std::exp(0.780719876289368*x_60) + 0.386328167706091*std::exp(0.787359893321991*x_60) + 19.4853496144661*std::exp(0.816559851169586*x_60) + 0.000860217655173478*std::exp(0.838639855384827*x_60) + 0.147518659884075*std::exp(0.847519874572754*x_60) + 0.0250607199291922*std::exp(0.854399859905243*x_60) - 0.000184819508249858*std::exp(0.860399901866913*x_60) + 0.00423323850244901*std::exp(0.872479856014252*x_60) - 0.0566436069530664*std::exp(1.03615987300873*x_60) + 0.868214115354236*std::exp(0.983999848365784*x_61) + 0.000260370826538551*std::exp(1.18831992149353*x_61) - 0.495289016080669*std::exp(1.23887979984283*x_61) - 0.0646058398809977*std::exp(1.32615983486176*x_61) - 0.00171929840590007*std::exp(0.599199831485748*x_66) + 14.4924152433953*std::exp(0.949999809265137*x_66) - 0.0226607794342816*std::exp(1.11047983169556*x_66) + 0.00138699328385914*std::exp(1.5058399438858*x_66) - 4.30732706700683e-6*std::exp(1.78991985321045*x_7) - 0.174497829833616*std::exp(0.455999851226807*x_8) + 0.0417004129567835*std::exp(0.519439876079559*x_8) - 0.00476715098512096*std::exp(0.636319875717163*x_8) - 0.0334953359195128*std::exp(0.878639876842499*x_8) + 0.228790462626106*std::exp(0.925199866294861*x_8) - 0.00203792181090107*std::exp(1.39863991737366*x_8) + 0.12985534026928*std::log(9.29800033569336 - 1.38431990146637*x_5) - 4.6102848563077*std::log(9.35847949981689 - 1.21983981132507*x_21) + 0.11036215360265*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 14.5710043277751*std::sin(0.208320006728172*x_101 - 7.40863990783691) - 2.48248799135412*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.482679227372897*std::sin(0.281839966773987*x_113 - 7.41663980484009) + 5.70701756103089*std::sin(0.30583992600441*x_113 - 1.2235199213028) + 1.63422515744311*std::sin(0.319439828395844*x_113 + 5.03800010681152) + 1.43704605186765*std::sin(0.296079933643341*x_114 - 4.47415971755981) + 7.42820175001974*std::sin(0.237999975681305*x_117 + 1.98111975193024) + 0.0209570802131747*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.486371085034068*std::sin(0.267359972000122*x_117 + 1.94591987133026) - 4.40708589824868*std::sin(0.261759966611862*x_120 + 8.34208011627197) + 17.230663256302*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.0151519781342993*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 265.465321195941*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 2.64868421891658*std::sin(0.128160044550896*x_18 - 4.62671995162964) + 9.81137367862232*std::sin(0.401599854230881*x_21 - 7.40983963012695) + 2.01414602340928*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 2.17357064969665*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.55264345884419*std::sin(0.602719843387604*x_3 + 2.19079995155334) + 0.474750813852903*std::sin(0.262639969587326*x_31 - 4.33039999008179) - 0.0065586528368997*std::sin(0.467679858207703*x_31 - 1.14271986484528) - 30.7456839804604*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.00973941377085895*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.00788430603725131*std::sin(0.299839943647385*x_42 - 4.29496002197266) + 0.269104068076614*std::sin(0.198640003800392*x_47 + 8.2055196762085) + 1.93811919154618*std::sin(0.422719866037369*x_5 - 7.41439962387085) + 0.00598335216556525*std::sin(0.511599838733673*x_6 + 5.09880018234253) - 0.00824363118532255*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 11.3608997587629*std::sin(0.644319832324982*x_64 + 8.4282398223877) - 6.88170862672543*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.194209960941695*std::sin(0.564559817314148*x_65 + 5.36751985549927) + 2.97842535228305*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.00477525662065848*std::sin(0.397599816322327*x_73 + 2.00783967971802) - 4.010700437019*std::sin(0.256959974765778*x_9 - 4.39328002929688) - 9.41342038980423*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.296766346215196*std::sin(0.329519838094711*x_9 - 4.33071994781494) + 0.115817579993859*std::sin(0.36575984954834*x_9 + 2.02055978775024) - 4.67900960646683*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 187.83102601453*std::sin(0.364799857139587*x_91 + 2.00895977020264) + 0.107232223222913*std::sin(0.379999846220016*x_91 - 1.18399977684021) - 9.89260274344289*std::sin(0.383119851350784*x_91 + 8.20567989349365) + 2.22019593057831*std::sin(0.393919825553894*x_91 - 4.39919996261597) + 6.25775956820611*std::sin(0.299039930105209*x_92 - 1.17503976821899) + 3.09675109521091*std::sin(0.306799918413162*x_92 + 8.20695972442627) + 3.47647132782012*std::sin(0.235759988427162*x_93 + 1.9755197763443) + 2.82476958995051*std::sin(0.316239923238754*x_94 + 1.95431983470917) + 0.00650822657641667*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.415860472317019*std::sin(0.301119923591614*x_97 - 7.45264005661011) - 4.26609651739865*std::sin(0.303199917078018*x_97 + 1.95719981193542) + 12.4046509002318*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.37014411526372*std::sin(0.259039968252182*x_98 + 1.97271978855133) - 4.7534016601108*std::sin(0.266639977693558*x_98 + 1.94559979438782) - 0.0788808314000869*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 54795.8051634119);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.550805558364634*x_1 + 69.3251712711703*x_10 - 111.800406736484*x_100 - 190.716235927103*x_101 - 279.465267705198*x_102 + 27.046456206601*x_103 - 1080.57241260628*x_104 - 312.017188156067*x_105 - 197.000036127689*x_106 - 76.3510589913579*x_107 - 207.519354823938*x_108 + 120.667425037931*x_109 - 271.598080290906*x_110 - 270.915402630987*x_111 - 91.4853324794203*x_112 + 150.874992803069*x_113 + 418.243669118605*x_114 + 167.498625574821*x_115 + 4.16024592340256*x_116 - 348.601903569324*x_117 - 371.909779302191*x_118 - 192.751750932337*x_119 + 13.328855870943*x_12 + 8.38844131928733*x_120 + 105.201787882394*x_13 + 9.20826724532342*x_14 - 0.152035574137702*x_15 - 153.411571277083*x_16 - 0.348442024292038*x_17 + 867.996914436932*x_18 + 0.0139862363839718*x_19 - 4.20105576973769*x_2 - 0.0255859832658095*x_20 + 45.5715593428766*x_21 - 195.338260802258*x_22 - 0.0180896432376625*x_23 - 73.1207724583059*x_24 + 0.0178362220532512*x_25 - 0.923241124923305*x_26 + 614.484344609045*x_27 - 3.69242771984617*x_28 + 1.13332332334078*x_29 + 2.83674441947443*x_3 - 0.011638817753479*x_30 - 61.0771894051052*x_31 - 12.9372903545427*x_32 + 706.135051468221*x_33 - 1009.94821411263*x_34 - 185.10253009695*x_35 + 1458.23800101406*x_36 - 3903.64760851061*x_37 - 277.247975200304*x_38 - 570.623366712953*x_39 + 1.67292600707651*x_4 - 28762.2547001035*x_40 - 15.1324023002377*x_41 - 248.589995676524*x_42 + 126.341928275916*x_43 - 527.300578654851*x_44 + 417.437014702027*x_45 - 2534.62295767727*x_46 + 836.659179284596*x_47 - 1850.50405142874*x_48 + 508.412113877363*x_5 + 0.052905574775022*x_50 - 60.7175853293447*x_52 + 63.2452521829899*x_53 + 472.726309481111*x_54 - 309.539954271633*x_58 - 415.943893630324*x_59 + 23.419395727564*x_6 + 1.10920327789329*x_60 + 248.318295861352*x_61 + 198.163565370332*x_62 + 121.351804915589*x_63 + 294.384000495462*x_64 - 46.1046286738709*x_65 + 8.50686764810515*x_66 + 151.906305493324*x_67 + 128.691358083364*x_68 + 240.130991134214*x_69 + 387.661072641568*x_7 - 98.9567436603366*x_70 - 136.072756975753*x_71 - 76.0619024743598*x_72 + 216.465143173617*x_73 - 189.764381077002*x_74 - 95.2691608896316*x_75 - 16.259651325787*x_76 - 54.4309763168281*x_77 - 80.6598822418039*x_78 - 252.068950285235*x_79 + 3.68991319570778*x_8 - 55.9542345006145*x_80 + 2.61387394023525*x_81 - 124.686358008526*x_82 + 170.81752731436*x_83 + 115.228407390176*x_84 - 135.270487153387*x_85 + 3689.81137906148*x_86 + 622.138656621779*x_87 + 424.065797018695*x_88 + 59.5868011644101*x_89 - 10.8458698398627*x_9 - 71.7771295457489*x_90 + 8.75893341689152*x_91 - 258.583140385944*x_92 - 249.892645413698*x_93 + 110.82648896462*x_94 - 79.0557648451491*x_95 - 364.623551887967*x_96 - 122.574754260446*x_97 - 395.657445363427*x_98 - 541.946210559841*x_99 - 0.00967946917129496*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 7.66331969794212e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.0154128786446807*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.00342788248204367*std::exp(1.13951992988586*x_1) - 1.42499163005573*std::exp(1.17007982730865*x_1) - 1.99217689336245*std::exp(1.22071981430054*x_1) + 0.000126829943344648*std::exp(1.40399980545044*x_1) - 6.78612373350376*std::exp(1.6639997959137*x_1) + 0.00228187375066916*std::exp(1.76023995876312*x_1) + 0.0141226147002525*std::exp(0.627359867095947*x_10) + 0.000559083168906267*std::exp(0.778879821300507*x_10) - 4.54260790994788*std::exp(0.80351984500885*x_10) - 0.00147326131383374*std::exp(0.810399830341339*x_10) + 1.56951860203021*std::exp(0.840799868106842*x_10) - 0.000929133533857085*std::exp(0.934159815311432*x_10) + 0.144161963592438*std::exp(0.94543981552124*x_10) + 0.00486660913947469*std::exp(0.969839811325073*x_10) - 0.24131885944092*std::exp(0.82207989692688*x_11) - 0.00232362457915219*std::exp(0.895919859409332*x_11) - 0.00400916050275471*std::exp(0.902079820632935*x_11) - 27.2514310113945*std::exp(0.914159834384918*x_11) - 5.45570887009883*std::exp(0.925199866294861*x_11) - 0.00445586484732297*std::exp(0.933279812335968*x_11) - 0.00235939765543854*std::exp(0.937199831008911*x_11) - 0.00028189933610333*std::exp(0.951599836349487*x_11) - 0.466069824269451*std::exp(0.983759820461273*x_11) - 0.00314308986064675*std::exp(1.06111979484558*x_11) - 0.0150116477716631*std::exp(0.537679851055145*x_12) - 0.00353430977717134*std::exp(0.696079850196838*x_12) + 0.00156062412101602*std::exp(0.854959905147552*x_12) + 0.000759244940177002*std::exp(0.925439834594727*x_12) + 1.52498769520895*std::exp(1.2235199213028*x_12) + 1.42075004076019e-5*std::exp(1.10399985313416*x_13) - 1.4607584272315e-5*std::exp(1.32895994186401*x_13) - 7.52043511170049e-6*std::exp(1.4015998840332*x_13) + 521.267594404036*std::exp(0.345279842615128*x_14) + 0.00133906058494836*std::exp(0.428239852190018*x_14) + 0.00265683947200731*std::exp(0.715599834918976*x_14) + 0.000664133189269022*std::exp(0.868079900741577*x_14) - 0.00731134109426986*std::exp(0.67935985326767*x_15) - 1.99617461174394*std::exp(0.82151985168457*x_15) + 0.390232192432768*std::exp(0.898239850997925*x_15) - 43.104657903423*std::exp(0.92087984085083*x_15) + 0.00188362605751606*std::exp(0.927359819412231*x_15) + 0.00054960204392381*std::exp(0.993359804153442*x_15) + 0.00105879688007712*std::exp(1.03111982345581*x_15) - 2.95194151724863e-5*std::exp(1.05295991897583*x_15) + 6.5125524884687*std::exp(0.357999831438065*x_16) + 0.0227335693974785*std::exp(0.539119839668274*x_16) - 10.9606689588496*std::exp(0.590719819068909*x_16) + 0.000626848615728802*std::exp(0.703679859638214*x_16) + 0.00202677628776738*std::exp(0.912239849567413*x_16) + 0.0492598412648576*std::exp(0.620319843292236*x_17) - 0.0303674385454905*std::exp(0.655279815196991*x_17) + 7.12269256357658*std::exp(0.659599840641022*x_17) + 127.455711876496*std::exp(0.695119857788086*x_17) + 0.0154899694018127*std::exp(0.7079998254776*x_17) + 0.0047734937096296*std::exp(0.857999861240387*x_17) + 2.95704119645506*std::exp(0.434639871120453*x_18) - 0.000555146590414605*std::exp(0.695919871330261*x_19) - 0.0197877424280265*std::exp(0.704799830913544*x_19) - 461.680247823109*std::exp(0.716879844665527*x_19) + 2.20799134204535*std::exp(0.719519853591919*x_19) - 0.0130715937205286*std::exp(0.728719890117645*x_19) - 18.9698684467584*std::exp(0.748239874839783*x_19) - 0.226450949576595*std::exp(0.766079843044281*x_19) - 3.31403015931884*std::exp(0.823999881744385*x_19) - 0.000754114335806628*std::exp(1.00991988182068*x_19) - 6.35265982110261*std::exp(0.735999822616577*x_2) - 0.0145647226849623*std::exp(0.754559874534607*x_2) - 0.101178149332824*std::exp(0.755999863147736*x_2) + 97.7365641830487*std::exp(0.924879848957062*x_2) + 0.000248144707512197*std::exp(1.01583981513977*x_2) + 0.00390878466120882*std::exp(1.11415982246399*x_2) - 0.00262174200155022*std::exp(0.26639986038208*x_20) - 0.0736760633206673*std::exp(0.403999865055084*x_20) - 0.583318523799409*std::exp(0.516959846019745*x_20) + 6.07188252921601*std::exp(0.532159864902496*x_20) + 20.2269331248205*std::exp(0.886239886283875*x_20) + 0.334155072788011*std::exp(0.916319847106934*x_20) + 0.000402285062106745*std::exp(1.04447984695435*x_20) + 0.0235165854314603*std::exp(0.525999844074249*x_22) - 3.42772507400428*std::exp(0.651039838790894*x_22) - 4.00503351794747e-6*std::exp(1.28135991096497*x_22) + 0.0200379644657893*std::exp(1.33199989795685*x_22) + 0.0253417827001774*std::exp(0.638159871101379*x_23) - 133.92893474055*std::exp(0.658639848232269*x_23) + 0.018720106276886*std::exp(0.673119843006134*x_23) - 0.00130414794363714*std::exp(0.69023984670639*x_23) - 0.00786436705309733*std::exp(0.733039855957031*x_23) + 0.0958426412427628*std::exp(0.734799861907959*x_23) + 3.19794343515894*std::exp(0.736159861087799*x_23) - 1.19784328455916*std::exp(0.747999846935272*x_23) + 0.796202508020075*std::exp(0.818959891796112*x_23) + 21.3429437067861*std::exp(0.305759847164154*x_24) - 0.0565833083877534*std::exp(0.42087984085083*x_24) + 3.82400948175139*std::exp(0.60511988401413*x_24) - 0.0234624910617476*std::exp(0.611999869346619*x_24) + 0.000450978329988111*std::exp(0.650239825248718*x_24) - 0.0073043803475955*std::exp(0.758959889411926*x_24) - 0.606982576207884*std::exp(0.766159892082214*x_24) - 0.00172478874055274*std::exp(0.412159860134125*x_25) - 0.026613426353198*std::exp(0.525519847869873*x_25) - 383.285727163765*std::exp(0.589919865131378*x_25) - 0.00642859665551688*std::exp(0.660079836845398*x_25) - 0.289772243135292*std::exp(0.767039835453033*x_25) + 0.631687311564109*std::exp(0.949439823627472*x_25) - 0.274243875250935*std::exp(0.987279832363129*x_25) + 0.000852149955712282*std::exp(0.993919789791107*x_25) + 0.00272635878835304*std::exp(0.42087984085083*x_26) + 1.0981692426902*std::exp(0.573839843273163*x_26) - 0.0169778822644924*std::exp(0.728879868984222*x_26) + 0.00648371456596136*std::exp(0.8193598985672*x_26) - 0.000871885652022633*std::exp(0.839599847793579*x_26) + 14.7435731486029*std::exp(0.860319912433624*x_26) - 0.001079962332398*std::exp(0.960159838199615*x_26) - 0.0711989187864851*std::exp(1.13951992988586*x_26) + 0.000132137464363814*std::exp(1.18455982208252*x_27) + 0.136055109917964*std::exp(1.20399987697601*x_27) + 0.0877560662229162*std::exp(1.23751986026764*x_27) + 0.00114375882150652*std::exp(1.25919985771179*x_27) - 0.00612066822017178*std::exp(1.28719985485077*x_27) - 344.974120458522*std::exp(0.516239881515503*x_28) + 0.162302047346166*std::exp(0.543999850749969*x_28) + 0.00350895669498681*std::exp(0.647999823093414*x_28) + 0.000620176752220339*std::exp(0.654319822788239*x_28) + 1.36825271112248*std::exp(0.736559867858887*x_28) - 0.173817578355091*std::exp(0.906079828739166*x_28) - 10.2834763016651*std::exp(0.932239830493927*x_29) + 0.00031703378624486*std::exp(1.12255990505219*x_29) + 0.146037828805982*std::exp(1.15015983581543*x_29) + 0.00540831638352536*std::exp(1.15143990516663*x_29) + 0.258821031202958*std::exp(1.16695988178253*x_29) + 78.5767776540801*std::exp(0.439999848604202*x_3) + 13.4019588801661*std::exp(0.526399850845337*x_3) - 0.0217993486407426*std::exp(0.633039832115173*x_3) - 0.019654326902368*std::exp(0.658079862594604*x_3) - 0.000229205422866975*std::exp(0.925759851932526*x_3) + 0.0235193371407044*std::exp(0.94135981798172*x_3) - 0.00762125711473581*std::exp(0.634159862995148*x_30) - 131.115415969894*std::exp(0.828479886054993*x_30) + 0.0591587860255557*std::exp(0.857279896736145*x_30) + 2.04320170668073*std::exp(0.885519862174988*x_30) + 0.465020534388316*std::exp(0.91239982843399*x_30) - 1.44444524673805*std::exp(0.947999835014343*x_30) + 7.77734681829811e-5*std::exp(1.02791976928711*x_30) + 0.00108501187505034*std::exp(1.02927982807159*x_30) - 0.000787969472968315*std::exp(1.09479975700378*x_30) + 60.8700149208304*std::exp(0.826799869537354*x_32) + 0.00385287584862902*std::exp(0.831519842147827*x_32) + 8.01394324363473e-5*std::exp(0.832079887390137*x_32) - 6.52986004663935*std::exp(0.333039849996567*x_33) + 0.047265200075488*std::exp(0.360239863395691*x_33) + 0.0800149251849475*std::exp(0.404719859361649*x_33) + 0.38222009803792*std::exp(0.417439848184586*x_33) - 16.5061289931392*std::exp(0.369439840316772*x_34) + 0.19283088358318*std::exp(0.426799863576889*x_36) + 0.494829211190301*std::exp(0.261359840631485*x_37) + 0.0319850740068308*std::exp(0.355199843645096*x_4) - 9.69781666348859*std::exp(0.535359859466553*x_4) + 0.0211248682004707*std::exp(0.541439831256866*x_4) + 0.00569154093225985*std::exp(0.586239874362946*x_4) + 3.98340720891299*std::exp(0.747519850730896*x_4) + 0.00767869066486775*std::exp(1.09559988975525*x_4) - 4.03371781723877*std::exp(1.10943984985352*x_4) - 3.64692185388347e-5*std::exp(1.15591979026794*x_4) + 81.3159182802855*std::exp(0.715999841690063*x_41) - 0.301369816957821*std::exp(0.747999846935272*x_41) - 0.010238647973243*std::exp(0.770959854125977*x_41) - 0.00569966365389348*std::exp(0.788479864597321*x_41) + 0.0077441323857641*std::exp(0.796479880809784*x_41) - 0.000878097122075192*std::exp(0.802159905433655*x_41) + 0.0314454694178741*std::exp(0.802399873733521*x_41) + 0.0113667596475986*std::exp(0.806319832801819*x_41) - 0.620461515886696*std::exp(0.812319874763489*x_41) - 0.0115973580938854*std::exp(0.585839867591858*x_42) - 0.237603928157783*std::exp(0.693759858608246*x_42) + 1.17984134087829*std::exp(0.720399856567383*x_42) - 0.00374103351174829*std::exp(0.851439893245697*x_42) + 0.00180058381372431*std::exp(0.704879820346832*x_43) - 0.00147859475647946*std::exp(0.761919856071472*x_43) - 0.000867358246543929*std::exp(0.818479895591736*x_43) + 0.0330977408604625*std::exp(0.875679850578308*x_44) + 0.000209407386074682*std::exp(0.960559844970703*x_44) + 0.000110449938309496*std::exp(0.99999988079071*x_44) - 3.66324789947934*std::exp(0.555919826030731*x_45) - 0.58714271651576*std::exp(0.518719851970673*x_46) + 1.06234281718221*std::exp(0.702239871025085*x_46) + 0.000960119527799028*std::exp(0.715279817581177*x_46) + 0.00458323792751181*std::exp(0.752959847450256*x_46) - 0.0068626971811739*std::exp(0.756079852581024*x_46) + 0.000319387709504832*std::exp(0.795919895172119*x_46) + 0.0268578843125298*std::exp(0.406479865312576*x_47) + 0.016369218269459*std::exp(0.552319884300232*x_47) - 0.0093072158596727*std::exp(0.586239874362946*x_48) - 0.68336940958818*std::exp(0.600879848003387*x_48) - 0.00020437211429421*std::exp(0.65559983253479*x_49) - 0.00854080282892655*std::exp(0.684479832649231*x_49) + 345.572698034048*std::exp(0.703759849071503*x_49) - 0.0594901388821898*std::exp(0.7079998254776*x_49) - 0.130395062980509*std::exp(0.708239853382111*x_49) + 0.0245550437916202*std::exp(0.709119856357574*x_49) - 0.0462620820835934*std::exp(0.714559853076935*x_49) + 15.0502363796052*std::exp(0.71919983625412*x_49) + 4.65792290493979*std::exp(0.719519853591919*x_49) - 1.71898761341339*std::exp(0.722239851951599*x_49) + 0.000960435052573028*std::exp(2.06119966506958*x_5) + 0.0446787889769028*std::exp(0.325439840555191*x_50) + 1.93884413803692*std::exp(0.535359859466553*x_50) - 0.103377697822524*std::exp(0.535439848899841*x_50) + 0.833501415496477*std::exp(0.538639843463898*x_50) - 0.0250874609963488*std::exp(0.539039850234985*x_50) + 333.764414689495*std::exp(0.550159871578217*x_50) - 0.0154157179171657*std::exp(0.591119825839996*x_50) + 5.99528614689896*std::exp(0.592239856719971*x_50) + 0.000198142603475314*std::exp(0.642959833145142*x_50) + 0.0099077341967107*std::exp(0.460479855537415*x_51) + 0.112899434148529*std::exp(0.483199834823608*x_51) + 0.980263817009168*std::exp(0.488399863243103*x_51) + 0.30073051138641*std::exp(0.493759840726852*x_51) + 230.84824787865*std::exp(0.494479864835739*x_51) - 0.297549507868152*std::exp(0.495999842882156*x_51) - 1555.59948562196*std::exp(0.49703985452652*x_51) + 0.00768916597721364*std::exp(0.498159825801849*x_51) - 22.5367243757543*std::exp(0.499919831752777*x_51) + 5.13760106361288*std::exp(0.50631982088089*x_51) + 0.167770444602155*std::exp(0.521999835968018*x_52) - 0.00848767135757803*std::exp(0.526719868183136*x_52) - 0.0157056549850188*std::exp(0.590079843997955*x_52) + 0.000638769661949701*std::exp(0.628719866275787*x_52) + 0.00180113000497057*std::exp(0.705759823322296*x_52) - 0.0846203889378335*std::exp(0.709279835224152*x_52) - 1.34719206482831*std::exp(0.720719873905182*x_52) + 0.0666172852606556*std::exp(0.887439906597137*x_52) + 13.5990458263058*std::exp(0.48039984703064*x_54) + 0.00315476095223125*std::exp(0.49823984503746*x_54) + 0.0330568781437319*std::exp(0.512639820575714*x_54) + 0.78425676382206*std::exp(0.519359886646271*x_54) + 0.0295462493596333*std::exp(0.533919811248779*x_54) + 12.2485605715969*std::exp(0.535759806632996*x_54) - 0.0906448273735334*std::exp(0.538879811763763*x_54) - 0.0319293081972486*std::exp(0.629039824008942*x_55) - 10.1885036664254*std::exp(0.631839871406555*x_55) - 0.00770354471618075*std::exp(0.651679813861847*x_55) + 9.93528432697328*std::exp(0.653599858283997*x_55) + 0.565017892273037*std::exp(0.653759837150574*x_55) + 0.285846517737934*std::exp(0.655519843101501*x_55) + 2804.34787582147*std::exp(0.655839860439301*x_55) - 0.206275897287323*std::exp(0.656479835510254*x_55) + 0.0706449344814792*std::exp(0.657599866390228*x_55) + 38.5225823931211*std::exp(0.658879816532135*x_55) + 25.5081837620971*std::exp(0.342799842357635*x_56) + 565.449037679262*std::exp(0.434559851884842*x_56) + 0.654039922884307*std::exp(0.468159854412079*x_56) - 0.0344442922369425*std::exp(0.510159850120544*x_56) + 18.9543986294871*std::exp(0.52839982509613*x_56) + 1.9629745813485*std::exp(0.568239867687225*x_56) - 0.0172254973953114*std::exp(0.658959865570068*x_56) + 0.00528193897598207*std::exp(0.678959846496582*x_56) + 0.00296145188881594*std::exp(0.747119843959808*x_56) + 8.96742064319674e-5*std::exp(0.824879884719849*x_56) + 0.273470036012522*std::exp(0.610959827899933*x_57) - 0.00215969316086369*std::exp(0.616639852523804*x_57) - 0.0384621108677592*std::exp(0.626079857349396*x_57) - 17.2653262658362*std::exp(0.627359867095947*x_57) + 0.033608986788211*std::exp(0.628399848937988*x_57) - 1650.54030305012*std::exp(0.632639825344086*x_57) + 0.0933891913088132*std::exp(0.636399865150452*x_57) - 15.8667021976724*std::exp(0.641759812831879*x_57) + 0.0666646133545712*std::exp(0.643279850482941*x_57) + 0.873696556234259*std::exp(0.663679838180542*x_57) - 0.030170916126933*std::exp(0.437759846448898*x_58) + 0.00158115778789512*std::exp(0.485119849443436*x_58) - 0.00889287581731953*std::exp(0.554479837417603*x_58) + 0.057446294103504*std::exp(0.566799819469452*x_58) + 0.0169312731625071*std::exp(0.60647988319397*x_58) - 0.0127365665237641*std::exp(0.655439853668213*x_58) - 0.0195889325962731*std::exp(0.522799849510193*x_59) - 2.3776464767761*std::exp(0.691839873790741*x_59) + 1.45286810942627*std::exp(0.765759825706482*x_59) + 0.0123900213764995*std::exp(0.827119886875153*x_59) - 0.0510102966330173*std::exp(0.860399901866913*x_59) + 0.00557546639740541*std::exp(0.780719876289368*x_60) + 1.46623105347011*std::exp(0.787359893321991*x_60) - 142.898631806739*std::exp(0.816559851169586*x_60) - 0.00497407051917201*std::exp(0.838639855384827*x_60) + 0.0507546278070316*std::exp(0.847519874572754*x_60) + 0.00329769287618444*std::exp(0.854399859905243*x_60) - 0.000161739781130831*std::exp(0.860399901866913*x_60) - 0.0050423170202166*std::exp(0.872479856014252*x_60) - 0.0861762556549489*std::exp(1.03615987300873*x_60) + 1.32088060052383*std::exp(0.983999848365784*x_61) + 0.00022785646870279*std::exp(1.18831992149353*x_61) - 1.87977009321416*std::exp(1.23887979984283*x_61) - 0.0222280039684302*std::exp(1.32615983486176*x_61) - 0.00150459737990931*std::exp(0.599199831485748*x_66) - 106.282224893662*std::exp(0.949999809265137*x_66) - 0.00298188923224705*std::exp(1.11047983169556*x_66) + 0.000478650430526148*std::exp(1.5058399438858*x_66) - 1.48645561520191e-6*std::exp(1.78991985321045*x_7) - 0.0229618403612441*std::exp(0.455999851226807*x_8) + 0.0143907838971985*std::exp(0.519439876079559*x_8) + 0.00567827362817181*std::exp(0.636319875717163*x_8) - 0.0115242594340426*std::exp(0.878639876842499*x_8) - 1.67786797396898*std::exp(0.925199866294861*x_8) - 0.00773452337537148*std::exp(1.39863991737366*x_8) - 0.154673966994066*std::log(9.29800033569336 - 1.38431990146637*x_5) + 9.51448824998521*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.131455141300559*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 22.1679843788927*std::sin(0.208320006728172*x_101 - 7.40863990783691) - 0.854114009275959*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.166572270159261*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 11.7778734328306*std::sin(0.30583992600441*x_113 - 1.2235199213028) + 0.562264392071439*std::sin(0.319439828395844*x_113 + 5.03800010681152) + 0.494423807546942*std::sin(0.296079933643341*x_114 - 4.47415971755981) + 28.1922494598062*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.121180952552355*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.167846327704835*std::sin(0.267359972000122*x_117 + 1.94591987133026) - 1.51628278520836*std::sin(0.261759966611862*x_120 + 8.34208011627197) + 65.3955254888294*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.0132598428074358*std::sin(0.270399957895279*x_120 - 7.43680000305176) + 1946.82835779726*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 0.914059106461392*std::sin(0.128160044550896*x_18 - 4.62671995162964) + 37.237100391136*std::sin(0.401599854230881*x_21 - 7.40983963012695) + 0.692978310997973*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 0.750097739739279*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.0727213105788521*std::sin(0.602719843387604*x_3 + 2.19079995155334) + 0.163340697896284*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0379243573127171*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 63.4514911957372*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.00852318387035064*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.00689973663986575*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.320536634514507*std::sin(0.198640003800392*x_47 + 8.2055196762085) + 0.666820850256454*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0345977735211214*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.0476674741598632*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 17.2842065458969*std::sin(0.644319832324982*x_64 + 8.4282398223877) - 26.1181444504827*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.0670217242570654*std::sin(0.564559817314148*x_65 + 5.36751985549927) + 11.3040158782375*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.00417893634704791*std::sin(0.397599816322327*x_73 + 2.00783967971802) - 1.37990412932414*std::sin(0.256959974765778*x_9 - 4.39328002929688) - 35.7267485227743*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.102413862442323*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.137953237103339*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 9.65631914509305*std::sin(0.359999865293503*x_91 - 7.40607976913452) - 1377.48601689987*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.127727002378854*std::sin(0.379999846220016*x_91 - 1.18399977684021) - 37.5453890100877*std::sin(0.383119851350784*x_91 + 8.20567989349365) + 0.763870944894293*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 12.9144687885107*std::sin(0.299039930105209*x_92 - 1.17503976821899) + 1.06545469821893*std::sin(0.306799918413162*x_92 + 8.20695972442627) + 1.19609958810624*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 5.82962613161053*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.0376327755552953*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.143513163639489*std::sin(0.301119923591614*x_97 - 7.45264005661011) - 1.46777459271657*std::sin(0.303199917078018*x_97 + 1.95719981193542) + 47.0793638097155*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.127736480190262*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 9.80984595359804*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.0939569453758376*std::sin(0.279279947280884*x_98 + 1.9366397857666) + 84320.3514926359);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.611732425801804*x_1 + 43.7905619217804*x_10 - 67.4885353044465*x_100 - 119.363367510663*x_101 - 177.822119559593*x_102 + 17.8721486462562*x_103 - 709.031363656176*x_104 - 195.282730764246*x_105 - 125.302808626681*x_106 - 48.576635079086*x_107 - 129.512956197651*x_108 + 76.7703806249204*x_109 - 171.007872186285*x_110 - 172.313263115454*x_111 - 60.7321082161943*x_112 + 95.513481173264*x_113 + 262.342758474779*x_114 + 104.939699281885*x_115 - 2.05294784139502*x_116 - 220.808583098429*x_117 - 232.049506648965*x_118 - 121.968758764815*x_119 + 6.99326744701778*x_12 + 4.21445369590905*x_120 + 69.456693326677*x_13 + 5.74882055262886*x_14 + 0.0370798709450067*x_15 - 96.5757082768956*x_16 + 1.21054620781267*x_17 + 544.228218136502*x_18 + 0.0818608562412191*x_19 - 1.89000175202074*x_2 - 0.0987655825102985*x_20 + 28.8909093430465*x_21 - 123.319715680218*x_22 + 0.0138875545380357*x_23 - 46.6870371052136*x_24 - 0.15276799105988*x_25 - 0.4071725417716*x_26 + 388.198906090114*x_27 - 1.72135902087579*x_28 + 1.14640653347494*x_29 + 2.03939403178907*x_3 - 0.0681215132347652*x_30 - 38.6346801768097*x_31 - 10.2603659098856*x_32 + 443.706678589459*x_33 - 648.650819411035*x_34 - 65.8135554905439*x_35 + 914.262782588439*x_36 - 2461.35675769117*x_37 - 199.566359601741*x_38 - 367.275583893054*x_39 + 1.87642289773246*x_4 - 18057.5766561398*x_40 - 6.8033457773488*x_41 - 159.342769229728*x_42 + 78.9268408992713*x_43 - 335.393497226458*x_44 + 276.107502775745*x_45 - 1599.04099637151*x_46 + 517.866868789001*x_47 - 1166.70215576524*x_48 + 320.714646536156*x_5 - 0.040616005821748*x_50 - 38.3458487370291*x_52 + 38.2329239191403*x_53 + 298.902855688727*x_54 - 200.973200843123*x_58 - 262.729554657747*x_59 + 13.7667680474694*x_6 + 1.24430758093651*x_60 + 156.847049972352*x_61 + 123.66011881362*x_62 + 75.8587543487542*x_63 + 187.275148582282*x_64 - 30.0769360619343*x_65 + 5.47169515391021*x_66 + 94.9597417542091*x_67 + 81.3806988266083*x_68 + 150.849761225266*x_69 + 243.400536298783*x_7 - 61.8301723994267*x_70 - 85.2997603731935*x_71 - 49.5416344992982*x_72 + 136.898083181796*x_73 - 121.541523129596*x_74 - 57.6307899772524*x_75 - 11.6965496373408*x_76 - 34.6532126862854*x_77 - 48.7847065828431*x_78 - 160.924416673581*x_79 + 2.49846072615247*x_8 - 36.1038160382608*x_80 + 2.19391641325726*x_81 - 79.4930213428382*x_82 + 104.675309415168*x_83 + 73.70246678774*x_84 - 87.0009015171215*x_85 + 2349.89491484164*x_86 + 393.704316909968*x_87 + 267.281063249107*x_88 + 37.9281097480474*x_89 - 6.61732860443622*x_9 - 48.0873106936552*x_90 + 3.91078888702051*x_91 - 165.507118728652*x_92 - 155.016310381788*x_93 + 69.6659451065472*x_94 - 51.4979818838838*x_95 - 231.916897156434*x_96 - 76.6350358986525*x_97 - 250.728473809476*x_98 - 341.341191052546*x_99 - 0.0108584576960133*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 7.57145034300049e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.0172902137271503*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) + 0.0026316110436189*std::exp(1.13951992988586*x_1) - 0.640659070301398*std::exp(1.17007982730865*x_1) - 1.5295258387204*std::exp(1.22071981430054*x_1) - 9.14910615550225e-5*std::exp(1.40399980545044*x_1) - 4.28658402297292*std::exp(1.6639997959137*x_1) - 0.00994674083410165*std::exp(1.76023995876312*x_1) + 0.0106646798258138*std::exp(0.627359867095947*x_10) - 0.000403304702910589*std::exp(0.778879821300507*x_10) - 2.04230179247942*std::exp(0.80351984500885*x_10) + 0.0126578810612917*std::exp(0.810399830341339*x_10) + 1.20502314034257*std::exp(0.840799868106842*x_10) - 0.000917994901805364*std::exp(0.934159815311432*x_10) + 0.161721325347563*std::exp(0.94543981552124*x_10) - 0.0212136626038272*std::exp(0.969839811325073*x_10) - 0.270712223998834*std::exp(0.82207989692688*x_11) - 0.00175468301713325*std::exp(0.895919859409332*x_11) + 0.00307786253173997*std::exp(0.902079820632935*x_11) - 17.2138842974322*std::exp(0.914159834384918*x_11) - 2.45282098422986*std::exp(0.925199866294861*x_11) - 0.00440244707991068*std::exp(0.933279812335968*x_11) - 0.0138094557381472*std::exp(0.937199831008911*x_11) + 0.000203353158028813*std::exp(0.951599836349487*x_11) - 0.357832600730958*std::exp(0.983759820461273*x_11) + 0.0137008019190272*std::exp(1.06111979484558*x_11) - 0.0113360323524097*std::exp(0.537679851055145*x_12) - 0.0206861672174023*std::exp(0.696079850196838*x_12) - 0.00119810282100315*std::exp(0.854959905147552*x_12) + 0.000750142965361115*std::exp(0.925439834594727*x_12) + 0.963287459266211*std::exp(1.2235199213028*x_12) - 1.02488360402611e-5*std::exp(1.10399985313416*x_13) + 1.12143518026031e-5*std::exp(1.32895994186401*x_13) - 4.40167919838562e-5*std::exp(1.4015998840332*x_13) + 329.268582421233*std::exp(0.345279842615128*x_14) - 0.000965955445320193*std::exp(0.428239852190018*x_14) + 0.0155503702427932*std::exp(0.715599834918976*x_14) - 0.000509860021301611*std::exp(0.868079900741577*x_14) - 0.0427929734502725*std::exp(0.67935985326767*x_15) - 0.897456057948293*std::exp(0.82151985168457*x_15) + 0.299607039623384*std::exp(0.898239850997925*x_15) - 27.2278763460045*std::exp(0.92087984085083*x_15) - 0.00144607382574338*std::exp(0.927359819412231*x_15) + 0.000415031490589027*std::exp(0.993359804153442*x_15) + 0.00104610381881635*std::exp(1.03111982345581*x_15) + 2.12943612477626e-5*std::exp(1.05295991897583*x_15) + 5.00011687733368*std::exp(0.357999831438065*x_16) - 0.0174527314167472*std::exp(0.539119839668274*x_16) - 4.92778472304664*std::exp(0.590719819068909*x_16) - 0.00045218852721142*std::exp(0.703679859638214*x_16) + 0.00200247890262524*std::exp(0.912239849567413*x_16) + 0.0371985249552071*std::exp(0.620319843292236*x_17) - 0.177739346950784*std::exp(0.655279815196991*x_17) + 5.46856172940763*std::exp(0.659599840641022*x_17) + 80.5098226354237*std::exp(0.695119857788086*x_17) - 0.0118917654723176*std::exp(0.7079998254776*x_17) + 0.00471626814613923*std::exp(0.857999861240387*x_17) + 3.31721772845733*std::exp(0.434639871120453*x_18) + 0.000400464981188739*std::exp(0.695919871330261*x_19) - 0.0149426959489875*std::exp(0.704799830913544*x_19) - 291.629102527271*std::exp(0.716879844665527*x_19) + 2.47693134370049*std::exp(0.719519853591919*x_19) + 0.0100351603571118*std::exp(0.728719890117645*x_19) - 8.52862432768448*std::exp(0.748239874839783*x_19) + 0.987104964248822*std::exp(0.766079843044281*x_19) - 2.54439993550044*std::exp(0.823999881744385*x_19) - 0.000745073867665727*std::exp(1.00991988182068*x_19) - 4.87735671131972*std::exp(0.735999822616577*x_2) + 0.0111814466411178*std::exp(0.754559874534607*x_2) + 0.441037909828495*std::exp(0.755999863147736*x_2) + 61.7371581981178*std::exp(0.924879848957062*x_2) - 0.000179003649381583*std::exp(1.01583981513977*x_2) + 0.00386192539661003*std::exp(1.11415982246399*x_2) + 0.00189124076318008*std::exp(0.26639986038208*x_20) + 0.32115567625625*std::exp(0.403999865055084*x_20) - 0.654368478465791*std::exp(0.516959846019745*x_20) + 2.72984523845568*std::exp(0.532159864902496*x_20) + 12.7767267104973*std::exp(0.886239886283875*x_20) + 0.256552929447001*std::exp(0.916319847106934*x_20) + 0.000397462391173635*std::exp(1.04447984695435*x_20) - 0.0180538586879274*std::exp(0.525999844074249*x_22) - 1.54106390019602*std::exp(0.651039838790894*x_22) + 2.88910298670351e-6*std::exp(1.28135991096497*x_22) + 0.0153844693751349*std::exp(1.33199989795685*x_22) + 0.148324393608333*std::exp(0.638159871101379*x_23) - 84.5987568776925*std::exp(0.658639848232269*x_23) + 0.0141364714669039*std::exp(0.673119843006134*x_23) + 0.000940770583362371*std::exp(0.69023984670639*x_23) - 0.00777008750367618*std::exp(0.733039855957031*x_23) - 0.41778030577633*std::exp(0.734799861907959*x_23) + 2.45527248666466*std::exp(0.736159861087799*x_23) - 0.538535910574036*std::exp(0.747999846935272*x_23) + 0.893182373722984*std::exp(0.818959891796112*x_23) + 9.59553037665906*std::exp(0.305759847164154*x_24) - 0.331179736021811*std::exp(0.42087984085083*x_24) + 2.93594475939264*std::exp(0.60511988401413*x_24) + 0.0180123300353324*std::exp(0.611999869346619*x_24) - 0.000325321332335551*std::exp(0.650239825248718*x_24) - 0.00551589626895931*std::exp(0.758959889411926*x_24) - 0.680914883795091*std::exp(0.766159892082214*x_24) + 0.00124420739038341*std::exp(0.412159860134125*x_25) - 0.0262943794638308*std::exp(0.525519847869873*x_25) - 242.109713706245*std::exp(0.589919865131378*x_25) - 0.0376263071924859*std::exp(0.660079836845398*x_25) - 0.325067375894385*std::exp(0.767039835453033*x_25) + 0.283999005476281*std::exp(0.949439823627472*x_25) - 0.210555144327139*std::exp(0.987279832363129*x_25) - 0.000654201900449875*std::exp(0.993919789791107*x_25) - 0.00196670796460471*std::exp(0.42087984085083*x_26) + 1.23192956698257*std::exp(0.573839843273163*x_26) + 0.0740069842809112*std::exp(0.728879868984222*x_26) + 0.00640598654491058*std::exp(0.8193598985672*x_26) + 0.000669353142254659*std::exp(0.839599847793579*x_26) + 9.31305817315287*std::exp(0.860319912433624*x_26) - 0.000815532586806173*std::exp(0.960159838199615*x_26) - 0.0546641145852663*std::exp(1.13951992988586*x_26) + 9.97834877141954e-5*std::exp(1.18455982208252*x_27) + 0.0611687383920902*std::exp(1.20399987697601*x_27) + 0.0673761307239442*std::exp(1.23751986026764*x_27) - 0.00498567134614992*std::exp(1.25919985771179*x_27) - 0.00686618406070886*std::exp(1.28719985485077*x_27) - 217.909459238984*std::exp(0.516239881515503*x_28) - 0.707478405114652*std::exp(0.543999850749969*x_28) - 0.00269385232384117*std::exp(0.647999823093414*x_28) - 0.000447375658429474*std::exp(0.654319822788239*x_28) + 1.05049801678446*std::exp(0.736559867858887*x_28) - 0.1949890833879*std::exp(0.906079828739166*x_28) - 6.49575323799449*std::exp(0.932239830493927*x_29) - 0.000243389211109968*std::exp(1.12255990505219*x_29) + 0.112122890960937*std::exp(1.15015983581543*x_29) - 0.0235749770994023*std::exp(1.15143990516663*x_29) + 0.116362817666832*std::exp(1.16695988178253*x_29) + 49.634514915449*std::exp(0.439999848604202*x_3) + 6.02535926196913*std::exp(0.526399850845337*x_3) - 0.0215380138437211*std::exp(0.633039832115173*x_3) - 0.0148419473344328*std::exp(0.658079862594604*x_3) + 0.000165341455647289*std::exp(0.925759851932526*x_3) - 0.102521338465743*std::exp(0.94135981798172*x_3) - 0.00752989201415634*std::exp(0.634159862995148*x_30) - 82.8215442767662*std::exp(0.828479886054993*x_30) - 0.257874526355245*std::exp(0.857279896736145*x_30) + 0.918598873306444*std::exp(0.885519862174988*x_30) + 0.521661437324202*std::exp(0.91239982843399*x_30) - 1.10899606097417*std::exp(0.947999835014343*x_30) - 5.61032905734318e-5*std::exp(1.02791976928711*x_30) + 0.000819345744411684*std::exp(1.02927982807159*x_30) + 0.000604930063373033*std::exp(1.09479975700378*x_30) + 38.4497017272976*std::exp(0.826799869537354*x_32) + 0.0029094957418547*std::exp(0.831519842147827*x_32) - 5.78100214560081e-5*std::exp(0.832079887390137*x_32) - 5.01340503337814*std::exp(0.333039849996567*x_33) + 0.276641238026409*std::exp(0.360239863395691*x_33) + 0.0604231989964759*std::exp(0.404719859361649*x_33) - 1.66610631094434*std::exp(0.417439848184586*x_33) - 12.6728459086013*std::exp(0.369439840316772*x_34) - 0.840554313423454*std::exp(0.426799863576889*x_36) - 2.15697205834*std::exp(0.261359840631485*x_37) - 0.0245551807648788*std::exp(0.355199843645096*x_4) - 4.36002154436586*std::exp(0.535359859466553*x_4) + 0.0159524252769218*std::exp(0.541439831256866*x_4) + 0.0333123508895269*std::exp(0.586239874362946*x_4) + 3.0583249271073*std::exp(0.747519850730896*x_4) - 0.033471591478835*std::exp(1.09559988975525*x_4) - 2.54797451794022*std::exp(1.10943984985352*x_4) + 2.63077269468865e-5*std::exp(1.15591979026794*x_4) + 51.3647451479158*std::exp(0.715999841690063*x_41) - 0.338077569170457*std::exp(0.747999846935272*x_41) + 0.00786028669864105*std::exp(0.770959854125977*x_41) - 0.00563133498643517*std::exp(0.788479864597321*x_41) + 0.00584797462621516*std::exp(0.796479880809784*x_41) + 0.000633431157725573*std::exp(0.802159905433655*x_41) - 0.137071533696612*std::exp(0.802399873733521*x_41) + 0.0665291685264876*std::exp(0.806319832801819*x_41) - 0.476369304172867*std::exp(0.812319874763489*x_41) - 0.0678788515822213*std::exp(0.585839867591858*x_42) - 0.266544802886407*std::exp(0.693759858608246*x_42) + 0.905842158131864*std::exp(0.720399856567383*x_42) + 0.0163072522229318*std::exp(0.851439893245697*x_42) + 0.00177899806759792*std::exp(0.704879820346832*x_43) - 0.00865415323152236*std::exp(0.761919856071472*x_43) - 0.000654984802035625*std::exp(0.818479895591736*x_43) + 0.0254113226681921*std::exp(0.875679850578308*x_44) + 0.000206896969931681*std::exp(0.960559844970703*x_44) + 8.34061718635294e-5*std::exp(0.99999988079071*x_44) - 1.64695212523613*std::exp(0.555919826030731*x_45) - 0.658658469383376*std::exp(0.518719851970673*x_46) + 0.815630777504253*std::exp(0.702239871025085*x_46) + 0.000725033400387615*std::exp(0.715279817581177*x_46) - 0.00351858606844138*std::exp(0.752959847450256*x_46) - 0.0401670794023544*std::exp(0.756079852581024*x_46) - 0.000230396070672511*std::exp(0.795919895172119*x_46) - 0.0206189988528878*std::exp(0.406479865312576*x_47) + 0.0958083494908576*std::exp(0.552319884300232*x_47) - 0.00702833570977272*std::exp(0.586239874362946*x_48) - 0.766605863756278*std::exp(0.600879848003387*x_48) + 0.000147427501707629*std::exp(0.65559983253479*x_49) + 0.00655683827077254*std::exp(0.684479832649231*x_49) + 218.287562140216*std::exp(0.703759849071503*x_49) - 0.348193293256933*std::exp(0.7079998254776*x_49) + 0.568395117009931*std::exp(0.708239853382111*x_49) + 0.0185427192984161*std::exp(0.709119856357574*x_49) - 0.0457074833187242*std::exp(0.714559853076935*x_49) + 6.76640496926781*std::exp(0.71919983625412*x_49) + 3.57619519712843*std::exp(0.719519853591919*x_49) - 1.92836548677421*std::exp(0.722239851951599*x_49) + 0.000431800029479644*std::exp(2.06119966506958*x_5) + 0.0337391474282202*std::exp(0.325439840555191*x_50) + 1.4885787583721*std::exp(0.535359859466553*x_50) + 0.450625792932312*std::exp(0.535439848899841*x_50) + 0.935024400571016*std::exp(0.538639843463898*x_50) - 0.146835859319009*std::exp(0.539039850234985*x_50) + 210.828635555427*std::exp(0.550159871578217*x_50) - 0.0152309113167843*std::exp(0.591119825839996*x_50) + 2.69540842770629*std::exp(0.592239856719971*x_50) - 0.000142933731997108*std::exp(0.642959833145142*x_50) - 0.00760624171507767*std::exp(0.460479855537415*x_51) + 0.0852559064496807*std::exp(0.483199834823608*x_51) - 4.272992813024*std::exp(0.488399863243103*x_51) + 1.760163097784*std::exp(0.493759840726852*x_51) + 103.786591266405*std::exp(0.494479864835739*x_51) - 0.293982426964769*std::exp(0.495999842882156*x_51) - 982.623978441532*std::exp(0.49703985452652*x_51) - 0.00554671822107789*std::exp(0.498159825801849*x_51) - 17.3029324693431*std::exp(0.499919831752777*x_51) + 5.76337636093427*std::exp(0.50631982088089*x_51) - 0.731315276136672*std::exp(0.521999835968018*x_52) - 0.04967798525282*std::exp(0.526719868183136*x_52) - 0.0118601112771934*std::exp(0.590079843997955*x_52) - 0.000460787988386237*std::exp(0.628719866275787*x_52) - 0.00138274098861408*std::exp(0.705759823322296*x_52) - 0.0949274074064466*std::exp(0.709279835224152*x_52) - 0.605681323009997*std::exp(0.720719873905182*x_52) + 0.0511464917854777*std::exp(0.887439906597137*x_52) + 10.4408860691937*std::exp(0.48039984703064*x_54) - 0.00227574357332668*std::exp(0.49823984503746*x_54) + 0.0249628718850158*std::exp(0.512639820575714*x_54) - 3.41859350230998*std::exp(0.519359886646271*x_54) - 0.0226828768254542*std::exp(0.533919811248779*x_54) + 5.506805277181*std::exp(0.535759806632996*x_54) - 0.0895581596958378*std::exp(0.538879811763763*x_54) - 0.0241113884511273*std::exp(0.629039824008942*x_55) - 4.5806285096841*std::exp(0.631839871406555*x_55) + 0.00555709058313397*std::exp(0.651679813861847*x_55) + 11.1454319088317*std::exp(0.653599858283997*x_55) - 2.46292615418455*std::exp(0.653759837150574*x_55) - 0.219446511599977*std::exp(0.655519843101501*x_55) + 1771.41963091612*std::exp(0.655839860439301*x_55) - 1.2073241943213*std::exp(0.656479835510254*x_55) + 0.06979802937814*std::exp(0.657599866390228*x_55) + 29.5763319717385*std::exp(0.658879816532135*x_55) + 19.5843181862754*std::exp(0.342799842357635*x_56) + 357.176630711075*std::exp(0.434559851884842*x_56) - 2.850975259336*std::exp(0.468159854412079*x_56) - 0.20160100099339*std::exp(0.510159850120544*x_56) + 8.52166928420093*std::exp(0.52839982509613*x_56) + 2.20207080292508*std::exp(0.568239867687225*x_56) + 0.0132241433056084*std::exp(0.658959865570068*x_56) + 0.00521861807254973*std::exp(0.678959846496582*x_56) + 0.00223633773802587*std::exp(0.747119843959808*x_56) - 6.46881022273287e-5*std::exp(0.824879884719849*x_56) - 1.19206225730557*std::exp(0.610959827899933*x_57) + 0.00155793351877168*std::exp(0.616639852523804*x_57) + 0.0295276504520496*std::exp(0.626079857349396*x_57) - 13.2557318205628*std::exp(0.627359867095947*x_57) + 0.0332060757707698*std::exp(0.628399848937988*x_57) - 1042.59515007024*std::exp(0.632639825344086*x_57) + 0.070522764065946*std::exp(0.636399865150452*x_57) - 7.13347816528044*std::exp(0.641759812831879*x_57) + 0.390185192097064*std::exp(0.643279850482941*x_57) + 0.980115430622627*std::exp(0.663679838180542*x_57) - 0.176589109459292*std::exp(0.437759846448898*x_58) - 0.00114059661847684*std::exp(0.485119849443436*x_58) - 0.00878626630641364*std::exp(0.554479837417603*x_58) - 0.250409734175509*std::exp(0.566799819469452*x_58) + 0.0127856357447962*std::exp(0.60647988319397*x_58) + 0.00977795747004183*std::exp(0.655439853668213*x_58) - 0.114653202702917*std::exp(0.522799849510193*x_59) - 1.82547630869943*std::exp(0.691839873790741*x_59) + 0.653191999604362*std::exp(0.765759825706482*x_59) - 0.0540083917985733*std::exp(0.827119886875153*x_59) - 0.0572235045381736*std::exp(0.860399901866913*x_59) - 0.00428032729289793*std::exp(0.780719876289368*x_60) + 1.12572246434984*std::exp(0.787359893321991*x_60) - 90.2646364939168*std::exp(0.816559851169586*x_60) - 0.00375616489183413*std::exp(0.838639855384827*x_60) - 0.221240604910673*std::exp(0.847519874572754*x_60) + 0.0193012583981771*std::exp(0.854399859905243*x_60) + 0.000116673901139617*std::exp(0.860399901866913*x_60) - 0.00498186875101769*std::exp(0.872479856014252*x_60) - 0.0387438063954074*std::exp(1.03615987300873*x_60) + 0.593852005627325*std::exp(0.983999848365784*x_61) - 0.000164368363290581*std::exp(1.18831992149353*x_61) - 1.44322371070782*std::exp(1.23887979984283*x_61) + 0.0968923870869373*std::exp(1.32615983486176*x_61) + 0.00108536839070201*std::exp(0.599199831485748*x_66) - 67.1351871917551*std::exp(0.949999809265137*x_66) - 0.0174528728863722*std::exp(1.11047983169556*x_66) - 0.000367463518835273*std::exp(1.5058399438858*x_66) + 1.14116310384203e-6*std::exp(1.78991985321045*x_7) - 0.134394690697472*std::exp(0.455999851226807*x_8) - 0.0110479125315937*std::exp(0.519439876079559*x_8) + 0.0056102013884684*std::exp(0.636319875717163*x_8) + 0.0502345153239777*std::exp(0.878639876842499*x_8) - 1.05985719275412*std::exp(0.925199866294861*x_8) - 0.00593830467175553*std::exp(1.39863991737366*x_8) - 0.152819705638139*std::log(9.29800033569336 - 1.38431990146637*x_5) + 10.6733816011378*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.129879231706407*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 9.96645872374834*std::sin(0.208320006728172*x_101 - 7.40863990783691) + 3.72310286252783*std::sin(0.231999978423119*x_108 - 1.19423997402191) - 0.127878778811123*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 13.2124539224376*std::sin(0.30583992600441*x_113 - 1.2235199213028) - 2.45092358266458*std::sin(0.319439828395844*x_113 + 5.03800010681152) - 2.15520489441495*std::sin(0.296079933643341*x_114 - 4.47415971755981) + 21.6450527782423*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.0915096876455104*std::sin(0.248959973454475*x_117 + 1.95943987369537) - 0.128856882326836*std::sin(0.267359972000122*x_117 + 1.94591987133026) + 6.60951198165741*std::sin(0.261759966611862*x_120 + 8.34208011627197) + 50.20846607805*std::sin(0.265119940042496*x_120 + 5.15704011917114) - 0.00956522618013309*std::sin(0.270399957895279*x_120 - 7.43680000305176) + 1229.7511306496*std::sin(0.271919965744019*x_120 + 5.14680004119873) - 0.701730018950394*std::sin(0.128160044550896*x_18 - 4.62671995162964) + 28.5893824976245*std::sin(0.401599854230881*x_21 - 7.40983963012695) - 3.0207086001708*std::sin(0.435999870300293*x_22 - 7.41879987716675) - 0.575855650253974*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.425634787482256*std::sin(0.602719843387604*x_3 + 2.19079995155334) - 0.712005907057386*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0286385444143468*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 71.1800741037638*std::sin(0.150160029530525*x_33 + 7.99456024169922) - 0.00614835203393575*std::sin(0.289919942617416*x_35 + 4.95607948303223) - 0.00497724916517545*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.316693979502226*std::sin(0.198640003800392*x_47 + 8.2055196762085) - 2.90668761947553*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0261264776473851*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.0359960503638965*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 7.77077104386823*std::sin(0.644319832324982*x_64 + 8.4282398223877) - 20.0526253113092*std::sin(0.427759855985641*x_65 - 0.986319839954376) + 0.0514530794568317*std::sin(0.564559817314148*x_65 + 5.36751985549927) + 8.67883992866112*std::sin(0.5136798620224*x_72 + 2.13903999328613) - 0.00301455092133347*std::sin(0.397599816322327*x_73 + 2.00783967971802) + 6.01503424379587*std::sin(0.256959974765778*x_9 - 4.39328002929688) - 27.4297855682977*std::sin(0.298719942569733*x_9 + 1.96815979480743) + 0.0786238888977907*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.136299427083095*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 10.8324879268321*std::sin(0.359999865293503*x_91 - 7.40607976913452) - 870.11522097062*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.126195786433325*std::sin(0.379999846220016*x_91 - 1.18399977684021) - 28.8260760412757*std::sin(0.383119851350784*x_91 + 8.20567989349365) - 3.32973124272793*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 14.4874900188114*std::sin(0.299039930105209*x_92 - 1.17503976821899) - 4.64434184868985*std::sin(0.306799918413162*x_92 + 8.20695972442627) - 5.21382596700612*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 6.53969216838757*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.0284183567117187*std::sin(0.278399974107742*x_95 - 7.43935966491699) - 0.110176130108522*std::sin(0.301119923591614*x_97 - 7.45264005661011) + 6.39806364061531*std::sin(0.303199917078018*x_97 + 1.95719981193542) + 36.1459384743387*std::sin(0.242159977555275*x_98 + 5.18111991882324) + 0.0980642521155776*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 11.0047147634338*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.0928305713885587*std::sin(0.279279947280884*x_98 + 1.9366397857666) + 238041.912754176);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0555595237069203*x_1 + 26.8090204171996*x_10 - 46.7163221282271*x_100 - 73.1071553946521*x_101 - 100.80300462214*x_102 + 9.20755369341533*x_103 - 374.267460878799*x_104 - 124.604891551382*x_105 - 77.5886316829197*x_106 - 32.4746434610366*x_107 - 80.5908259704946*x_108 + 48.2602379709727*x_109 - 102.056734402357*x_110 - 109.558103170639*x_111 - 39.2023212473694*x_112 + 57.0271808783044*x_113 + 166.606848786358*x_114 + 55.5040569354258*x_115 + 3.50661617038147*x_116 - 136.546787512648*x_117 - 143.7490277755*x_118 - 79.9161134934143*x_119 + 1.99100989101334*x_12 + 1.42335379596355*x_120 + 33.9512883216198*x_13 - 0.304402213923209*x_14 - 0.0375399823026417*x_15 - 59.527019007489*x_16 - 0.177567772841509*x_17 + 322.609898150026*x_18 + 0.0421312564027627*x_19 - 0.723561757496671*x_2 - 0.0349698026799221*x_20 + 18.7547129784169*x_21 - 75.6294997046071*x_22 + 0.0352098552265398*x_23 - 28.2487942713068*x_24 + 0.0129451319643856*x_25 - 0.154862564690203*x_26 + 237.538144704952*x_27 - 0.647238543728232*x_28 + 0.0276222282270649*x_29 - 0.669268897253653*x_3 - 0.035060040566653*x_30 - 22.5805496096805*x_31 - 0.141900910812569*x_32 + 270.236923268125*x_33 - 388.411787087101*x_34 - 124.940262332852*x_35 + 551.714254681718*x_36 - 1479.5901023737*x_37 - 63.3578427773836*x_38 - 258.037428420198*x_39 + 0.204340005971221*x_4 - 11200.034721302*x_40 - 2.60638522727595*x_41 - 98.8361417166073*x_42 + 61.038726428448*x_43 - 207.33590000627*x_44 + 133.410082780623*x_45 - 975.21956992374*x_46 + 323.186438098176*x_47 - 725.297289129651*x_48 + 196.070791424941*x_5 - 0.102975918542554*x_50 - 23.4592392721437*x_52 + 21.4118544489166*x_53 + 183.997046342214*x_54 - 108.195081847395*x_58 - 160.845107695674*x_59 + 10.7823012236752*x_6 + 0.133794758404659*x_60 + 96.0230325434971*x_61 + 76.3982844897178*x_62 + 44.9434111792607*x_63 + 110.964667251492*x_64 - 18.3769365553132*x_65 - 0.0368255835463527*x_66 + 56.0993133785542*x_67 + 51.9431503254607*x_68 + 94.9095981349724*x_69 + 154.458947406029*x_7 - 41.1942586606191*x_70 - 53.2166048363479*x_71 - 30.7619574799132*x_72 + 82.2273359804164*x_73 - 75.1764119844382*x_74 - 36.8801600318766*x_75 - 5.65162558565554*x_76 - 24.9358750245083*x_77 - 34.8484594582539*x_78 - 106.19770991078*x_79 + 0.589304215337065*x_8 - 22.9519892201985*x_80 + 4.78385803119903*x_81 - 50.2432020162423*x_82 + 67.2778791425178*x_83 + 49.0791953155319*x_84 - 51.6321511641269*x_85 + 1342.723766282*x_86 + 244.781719418135*x_87 + 158.31722529456*x_88 + 23.5903573189336*x_89 - 4.42278606377021*x_9 - 30.7286527869564*x_90 + 1.5195833440511*x_91 - 98.1422652418091*x_92 - 97.9508060082551*x_93 + 37.3213285430795*x_94 - 30.7328065960419*x_95 - 142.25121705467*x_96 - 49.2245055333081*x_97 - 152.736383728524*x_98 - 213.265559303623*x_99 - 0.00116756077544097*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 0.000105794126432223*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.00185913837047259*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) + 0.00667206336469162*std::exp(1.13951992988586*x_1) - 0.245438699016797*std::exp(1.17007982730865*x_1) + 0.383893043033665*std::exp(1.22071981430054*x_1) + 0.0011242101178547*std::exp(1.40399980545044*x_1) - 2.62428965394857*std::exp(1.6639997959137*x_1) + 0.00143179754087278*std::exp(1.76023995876312*x_1) + 0.00717324955942908*std::exp(0.627359867095947*x_10) + 0.00495566692400652*std::exp(0.778879821300507*x_10) - 0.782412859167049*std::exp(0.80351984500885*x_10) + 0.0115009487332899*std::exp(0.810399830341339*x_10) - 0.302446672400842*std::exp(0.840799868106842*x_10) - 0.00128269306811891*std::exp(0.934159815311432*x_10) + 0.0173891616391771*std::exp(0.94543981552124*x_10) + 0.003053630375583*std::exp(0.969839811325073*x_10) - 0.0291084593247045*std::exp(0.82207989692688*x_11) - 0.00118023038526882*std::exp(0.895919859409332*x_11) + 0.00780346848345007*std::exp(0.902079820632935*x_11) - 10.5385123034843*std::exp(0.914159834384918*x_11) - 0.939684177119754*std::exp(0.925199866294861*x_11) - 0.00615143759628317*std::exp(0.933279812335968*x_11) - 0.00710730069536615*std::exp(0.937199831008911*x_11) - 0.00249873237743789*std::exp(0.951599836349487*x_11) + 0.0898117851387072*std::exp(0.983759820461273*x_11) - 0.00197218112171914*std::exp(1.06111979484558*x_11) - 0.00762481297195356*std::exp(0.537679851055145*x_12) - 0.0106465318718223*std::exp(0.696079850196838*x_12) - 0.00303761376839184*std::exp(0.854959905147552*x_12) + 0.00104815743516066*std::exp(0.925439834594727*x_12) + 0.589734226503624*std::exp(1.2235199213028*x_12) + 0.00012593410740749*std::exp(1.10399985313416*x_13) + 2.84323422347466e-5*std::exp(1.32895994186401*x_13) - 2.26540844336434e-5*std::exp(1.4015998840332*x_13) + 201.581522626744*std::exp(0.345279842615128*x_14) + 0.0118693221673106*std::exp(0.428239852190018*x_14) + 0.00800329566461488*std::exp(0.715599834918976*x_14) - 0.00129267521410356*std::exp(0.868079900741577*x_14) - 0.0220242228026224*std::exp(0.67935985326767*x_15) - 0.343818510497238*std::exp(0.82151985168457*x_15) - 0.0751978523302041*std::exp(0.898239850997925*x_15) - 16.6691784905815*std::exp(0.92087984085083*x_15) - 0.00366630783784592*std::exp(0.927359819412231*x_15) + 0.000279157415472598*std::exp(0.993359804153442*x_15) + 0.00146169669819468*std::exp(1.03111982345581*x_15) - 0.000261657652246069*std::exp(1.05295991897583*x_15) - 1.25497068108994*std::exp(0.357999831438065*x_16) - 0.0442488376775276*std::exp(0.539119839668274*x_16) - 1.88785131987661*std::exp(0.590719819068909*x_16) + 0.00555633423449975*std::exp(0.703679859638214*x_16) + 0.00279801750794077*std::exp(0.912239849567413*x_16) + 0.0250203763361447*std::exp(0.620319843292236*x_17) - 0.0914769566687293*std::exp(0.655279815196991*x_17) - 1.37254484375108*std::exp(0.659599840641022*x_17) + 49.2889194405305*std::exp(0.695119857788086*x_17) - 0.0301498251201461*std::exp(0.7079998254776*x_17) + 0.00658993252200597*std::exp(0.857999861240387*x_17) + 0.356685397850394*std::exp(0.434639871120453*x_18) - 0.00492077341815649*std::exp(0.695919871330261*x_19) - 0.0100507177790101*std::exp(0.704799830913544*x_19) - 178.538256208459*std::exp(0.716879844665527*x_19) + 0.266333208760097*std::exp(0.719519853591919*x_19) + 0.0254426754819424*std::exp(0.728719890117645*x_19) - 3.26734538918666*std::exp(0.748239874839783*x_19) - 0.142090206628212*std::exp(0.766079843044281*x_19) + 0.638614536091192*std::exp(0.823999881744385*x_19) - 0.00104107450206081*std::exp(1.00991988182068*x_19) + 1.22415931948925*std::exp(0.735999822616577*x_2) + 0.0283489160297275*std::exp(0.754559874534607*x_2) - 0.0634858196525175*std::exp(0.755999863147736*x_2) + 37.7961063297069*std::exp(0.924879848957062*x_2) + 0.00219953414407229*std::exp(1.01583981513977*x_2) + 0.00539617913572505*std::exp(1.11415982246399*x_2) - 0.0232389040538964*std::exp(0.26639986038208*x_20) - 0.0462292036326654*std::exp(0.403999865055084*x_20) - 0.0703612786945015*std::exp(0.516959846019745*x_20) + 1.04581312417625*std::exp(0.532159864902496*x_20) + 7.82204000621275*std::exp(0.886239886283875*x_20) - 0.0643917757329329*std::exp(0.916319847106934*x_20) + 0.000555365016726949*std::exp(1.04447984695435*x_20) - 0.0457729076016464*std::exp(0.525999844074249*x_22) - 0.590386894214924*std::exp(0.651039838790894*x_22) - 3.55002855357953e-5*std::exp(1.28135991096497*x_22) - 0.00386132134179551*std::exp(1.33199989795685*x_22) + 0.0763379879570623*std::exp(0.638159871101379*x_23) - 51.7922059199636*std::exp(0.658639848232269*x_23) + 0.00950843713811278*std::exp(0.673119843006134*x_23) - 0.0115598594050633*std::exp(0.69023984670639*x_23) - 0.0108569637587769*std::exp(0.733039855957031*x_23) + 0.0601379712623881*std::exp(0.734799861907959*x_23) - 0.616244591965229*std::exp(0.736159861087799*x_23) - 0.206314964374007*std::exp(0.747999846935272*x_23) + 0.096039855204952*std::exp(0.818959891796112*x_23) + 3.67608077556038*std::exp(0.305759847164154*x_24) - 0.17044798960591*std::exp(0.42087984085083*x_24) - 0.736887693773712*std::exp(0.60511988401413*x_24) + 0.0456676178012268*std::exp(0.611999869346619*x_24) + 0.00399743458158096*std::exp(0.650239825248718*x_24) - 0.00371008798458229*std::exp(0.758959889411926*x_24) - 0.0732156934243971*std::exp(0.766159892082214*x_24) - 0.0152883846050624*std::exp(0.412159860134125*x_25) - 0.0367405289532807*std::exp(0.525519847869873*x_25) - 148.22199060946*std::exp(0.589919865131378*x_25) - 0.0193650991280193*std::exp(0.660079836845398*x_25) - 0.0349530226202527*std::exp(0.767039835453033*x_25) + 0.108800998311583*std::exp(0.949439823627472*x_25) + 0.052846871256363*std::exp(0.987279832363129*x_25) - 0.00165863285293894*std::exp(0.993919789791107*x_25) + 0.0241662185911392*std::exp(0.42087984085083*x_26) + 0.132463806627245*std::exp(0.573839843273163*x_26) - 0.0106530390072628*std::exp(0.728879868984222*x_26) + 0.00895093700352817*std::exp(0.8193598985672*x_26) + 0.00169704660166538*std::exp(0.839599847793579*x_26) + 5.70154745117444*std::exp(0.860319912433624*x_26) - 0.000548541434394262*std::exp(0.960159838199615*x_26) + 0.0137200515098424*std::exp(1.13951992988586*x_26) + 6.71161132799907e-5*std::exp(1.18455982208252*x_27) + 0.0234339546061378*std::exp(1.20399987697601*x_27) - 0.0169106184391679*std::exp(1.23751986026764*x_27) + 0.000717669444904367*std::exp(1.25919985771179*x_27) - 0.000738289673420656*std::exp(1.28719985485077*x_27) - 133.406352544044*std::exp(0.516239881515503*x_28) + 0.101838969925795*std::exp(0.543999850749969*x_28) - 0.00682986699093399*std::exp(0.647999823093414*x_28) + 0.0054971953887086*std::exp(0.654319822788239*x_28) - 0.263662679083342*std::exp(0.736559867858887*x_28) - 0.0209662929834397*std::exp(0.906079828739166*x_28) - 3.97676516445589*std::exp(0.932239830493927*x_29) - 0.000617077604513649*std::exp(1.12255990505219*x_29) - 0.0281415303455977*std::exp(1.15015983581543*x_29) + 0.00339353309793005*std::exp(1.15143990516663*x_29) + 0.0445789967020055*std::exp(1.16695988178253*x_29) + 30.3867469465889*std::exp(0.439999848604202*x_3) + 2.30833591050351*std::exp(0.526399850845337*x_3) - 0.0300945691572564*std::exp(0.633039832115173*x_3) - 0.00998295250459296*std::exp(0.658079862594604*x_3) - 0.0020316578929158*std::exp(0.925759851932526*x_3) + 0.0147575776578976*std::exp(0.94135981798172*x_3) - 0.0105213441504386*std::exp(0.634159862995148*x_30) - 50.7041785731338*std::exp(0.828479886054993*x_30) + 0.0371201098779327*std::exp(0.857279896736145*x_30) + 0.351918395967705*std::exp(0.885519862174988*x_30) + 0.0560918916232015*std::exp(0.91239982843399*x_30) + 0.27834500194903*std::exp(0.947999835014343*x_30) + 0.00068937758329171*std::exp(1.02791976928711*x_30) + 0.000551106230671366*std::exp(1.02927982807159*x_30) + 0.00153371134530635*std::exp(1.09479975700378*x_30) + 23.5392923361795*std::exp(0.826799869537354*x_32) + 0.00195697755481632*std::exp(0.831519842147827*x_32) + 0.00071034929456094*std::exp(0.832079887390137*x_32) + 1.25830585237707*std::exp(0.333039849996567*x_33) + 0.14237870779807*std::exp(0.360239863395691*x_33) + 0.0406416969529315*std::exp(0.404719859361649*x_33) + 0.239830006494602*std::exp(0.417439848184586*x_33) + 3.18073566107242*std::exp(0.369439840316772*x_34) + 0.120994767934798*std::exp(0.426799863576889*x_36) + 0.310488364015109*std::exp(0.261359840631485*x_37) - 0.0622560550473409*std::exp(0.355199843645096*x_4) - 1.67033928830653*std::exp(0.535359859466553*x_4) + 0.0107298793267592*std::exp(0.541439831256866*x_4) + 0.0171448389517182*std::exp(0.586239874362946*x_4) - 0.767603680258946*std::exp(0.747519850730896*x_4) + 0.00481811511607788*std::exp(1.09559988975525*x_4) - 1.55989550889934*std::exp(1.10943984985352*x_4) - 0.000323260133927531*std::exp(1.15591979026794*x_4) + 31.4460112170843*std::exp(0.715999841690063*x_41) - 0.0363519497768805*std::exp(0.747999846935272*x_41) + 0.0199286026881298*std::exp(0.770959854125977*x_41) - 0.00786853427742392*std::exp(0.788479864597321*x_41) + 0.00393344967652129*std::exp(0.796479880809784*x_41) - 0.00778338019448213*std::exp(0.802159905433655*x_41) + 0.0197309539017657*std::exp(0.802399873733521*x_41) + 0.0342405098865885*std::exp(0.806319832801819*x_41) + 0.119563107178198*std::exp(0.812319874763489*x_41) - 0.0349351501028601*std::exp(0.585839867591858*x_42) - 0.0286603554077551*std::exp(0.693759858608246*x_42) - 0.227355755483246*std::exp(0.720399856567383*x_42) - 0.00234737026133592*std::exp(0.851439893245697*x_42) + 0.00248575290017091*std::exp(0.704879820346832*x_43) - 0.00445402559278968*std::exp(0.761919856071472*x_43) - 0.000440554195660185*std::exp(0.818479895591736*x_43) - 0.00637794389584408*std::exp(0.875679850578308*x_44) + 0.000289092356204002*std::exp(0.960559844970703*x_44) + 5.61004451465635e-5*std::exp(0.99999988079071*x_44) - 0.6309530383621*std::exp(0.555919826030731*x_45) - 0.0708225619874511*std::exp(0.518719851970673*x_46) - 0.204713757192865*std::exp(0.702239871025085*x_46) + 0.0004876701040113*std::exp(0.715279817581177*x_46) - 0.00892085829313071*std::exp(0.752959847450256*x_46) - 0.0206727561737696*std::exp(0.756079852581024*x_46) + 0.00283102621569468*std::exp(0.795919895172119*x_46) - 0.0522764438143517*std::exp(0.406479865312576*x_47) + 0.0493096007453233*std::exp(0.552319884300232*x_47) - 0.00472738111758548*std::exp(0.586239874362946*x_48) - 0.0824296563842116*std::exp(0.600879848003387*x_48) - 0.00181153750161794*std::exp(0.65559983253479*x_49) + 0.0166239006029056*std::exp(0.684479832649231*x_49) + 133.637830925552*std::exp(0.703759849071503*x_49) - 0.179204342460122*std::exp(0.7079998254776*x_49) - 0.0818184312180701*std::exp(0.708239853382111*x_49) + 0.0124721562400801*std::exp(0.709119856357574*x_49) - 0.0638660104743361*std::exp(0.714559853076935*x_49) + 2.59223307631715*std::exp(0.71919983625412*x_49) - 0.897583043027605*std::exp(0.719519853591919*x_49) - 0.207348406753782*std::exp(0.722239851951599*x_49) + 0.000165424080269464*std::exp(2.06119966506958*x_5) + 0.0226935387070118*std::exp(0.325439840555191*x_50) - 0.373615806206201*std::exp(0.535359859466553*x_50) - 0.0648659609147847*std::exp(0.535439848899841*x_50) + 0.100538938839145*std::exp(0.538639843463898*x_50) - 0.075571885295944*std::exp(0.539039850234985*x_50) + 129.07140139539*std::exp(0.550159871578217*x_50) - 0.0212818005075538*std::exp(0.591119825839996*x_50) + 1.03262026322973*std::exp(0.592239856719971*x_50) + 0.00175631963344576*std::exp(0.642959833145142*x_50) - 0.0192845089372973*std::exp(0.460479855537415*x_51) + 0.0573446088741096*std::exp(0.483199834823608*x_51) + 0.615081935268637*std::exp(0.488399863243103*x_51) + 0.905901626106844*std::exp(0.493759840726852*x_51) + 39.7610010014073*std::exp(0.494479864835739*x_51) - 0.410774853405924*std::exp(0.495999842882156*x_51) - 601.572237130086*std::exp(0.49703985452652*x_51) + 0.0681561306540824*std::exp(0.498159825801849*x_51) + 4.34283307343092*std::exp(0.499919831752777*x_51) + 0.619709756349759*std::exp(0.50631982088089*x_51) + 0.105270201711227*std::exp(0.521999835968018*x_52) - 0.0255677258993212*std::exp(0.526719868183136*x_52) - 0.00797731759259972*std::exp(0.590079843997955*x_52) + 0.00566200140128647*std::exp(0.628719866275787*x_52) - 0.0035057367293544*std::exp(0.705759823322296*x_52) - 0.0102071141689638*std::exp(0.709279835224152*x_52) - 0.232038603415714*std::exp(0.720719873905182*x_52) - 0.0128371694514489*std::exp(0.887439906597137*x_52) - 2.62053992394389*std::exp(0.48039984703064*x_54) + 0.0279635399053497*std::exp(0.49823984503746*x_54) + 0.0167904627870636*std::exp(0.512639820575714*x_54) + 0.492094229807402*std::exp(0.519359886646271*x_54) - 0.0575091033456092*std::exp(0.533919811248779*x_54) + 2.10967609080175*std::exp(0.535759806632996*x_54) - 0.125137547506439*std::exp(0.538879811763763*x_54) - 0.0162177401862202*std::exp(0.629039824008942*x_55) - 1.75485457743883*std::exp(0.631839871406555*x_55) - 0.0682835826059049*std::exp(0.651679813861847*x_55) + 1.19841781276891*std::exp(0.653599858283997*x_55) + 0.354529354863922*std::exp(0.653759837150574*x_55) - 0.556374405748852*std::exp(0.655519843101501*x_55) + 1084.48083259325*std::exp(0.655839860439301*x_55) - 0.621372503633758*std::exp(0.656479835510254*x_55) + 0.0975271739261607*std::exp(0.657599866390228*x_55) - 7.42331237235156*std::exp(0.658879816532135*x_55) - 4.91543412601553*std::exp(0.342799842357635*x_56) + 218.667109190876*std::exp(0.434559851884842*x_56) + 0.410387626810536*std::exp(0.468159854412079*x_56) - 0.103757813610913*std::exp(0.510159850120544*x_56) + 3.26468088804503*std::exp(0.52839982509613*x_56) + 0.236778699721149*std::exp(0.568239867687225*x_56) + 0.0335278734647078*std::exp(0.658959865570068*x_56) + 0.00729185446853265*std::exp(0.678959846496582*x_56) + 0.00150419974683156*std::exp(0.747119843959808*x_56) + 0.000794864741896637*std::exp(0.824879884719849*x_56) + 0.171593071242568*std::exp(0.610959827899933*x_57) - 0.0191433413819862*std::exp(0.616639852523804*x_57) + 0.074863021761612*std::exp(0.626079857349396*x_57) + 3.32703318728587*std::exp(0.627359867095947*x_57) + 0.0463980825240233*std::exp(0.628399848937988*x_57) - 638.287188801844*std::exp(0.632639825344086*x_57) + 0.0474348404760633*std::exp(0.636399865150452*x_57) - 2.7328600834879*std::exp(0.641759812831879*x_57) + 0.200816276882836*std::exp(0.643279850482941*x_57) + 0.105387373072288*std::exp(0.663679838180542*x_57) - 0.0908849649292917*std::exp(0.437759846448898*x_58) + 0.0140152517315735*std::exp(0.485119849443436*x_58) - 0.0122768469233537*std::exp(0.554479837417603*x_58) + 0.0360455799123554*std::exp(0.566799819469452*x_58) + 0.0085998414834157*std::exp(0.60647988319397*x_58) + 0.0247905753304881*std::exp(0.655439853668213*x_58) - 0.0590084651233132*std::exp(0.522799849510193*x_59) + 0.45817313927744*std::exp(0.691839873790741*x_59) + 0.250240107450056*std::exp(0.765759825706482*x_59) + 0.00777431360215738*std::exp(0.827119886875153*x_59) - 0.00615298426373848*std::exp(0.860399901866913*x_59) - 0.0108521413105795*std::exp(0.780719876289368*x_60) - 0.282543132983067*std::exp(0.787359893321991*x_60) - 55.2609141449019*std::exp(0.816559851169586*x_60) - 0.00252646198437899*std::exp(0.838639855384827*x_60) + 0.0318467887457447*std::exp(0.847519874572754*x_60) + 0.00993376204218245*std::exp(0.854399859905243*x_60) - 0.00143364802988819*std::exp(0.860399901866913*x_60) - 0.00696105011110781*std::exp(0.872479856014252*x_60) - 0.0148428858303275*std::exp(1.03615987300873*x_60) + 0.227506751135383*std::exp(0.983999848365784*x_61) + 0.0020197008748812*std::exp(1.18831992149353*x_61) + 0.36223222129119*std::exp(1.23887979984283*x_61) - 0.013947310367708*std::exp(1.32615983486176*x_61) - 0.0133366266134432*std::exp(0.599199831485748*x_66) - 41.1008337219142*std::exp(0.949999809265137*x_66) - 0.00898245506220744*std::exp(1.11047983169556*x_66) - 0.000931649792178233*std::exp(1.5058399438858*x_66) + 2.89325147678807e-6*std::exp(1.78991985321045*x_7) - 0.0691687997528434*std::exp(0.455999851226807*x_8) - 0.0280103599037177*std::exp(0.519439876079559*x_8) + 0.00783900478922843*std::exp(0.636319875717163*x_8) - 0.00723107766729132*std::exp(0.878639876842499*x_8) - 0.648855184151648*std::exp(0.925199866294861*x_8) + 0.00149044481184341*std::exp(1.39863991737366*x_8) - 0.213531444138211*std::log(9.29800033569336 - 1.38431990146637*x_5) + 1.14766038121392*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.181477249900611*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 3.8181847044023*std::sin(0.208320006728172*x_101 - 7.40863990783691) - 0.535927256162917*std::sin(0.231999978423119*x_108 - 1.19423997402191) - 0.324217865438762*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 1.42067532784358*std::sin(0.30583992600441*x_113 - 1.2235199213028) + 0.352801627895554*std::sin(0.319439828395844*x_113 + 5.03800010681152) + 0.310233987128811*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 5.43265433463702*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.0615510111234456*std::sin(0.248959973454475*x_117 + 1.95943987369537) - 0.326697703274179*std::sin(0.267359972000122*x_117 + 1.94591987133026) - 0.951415459550469*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 12.6017360026296*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.117534148893958*std::sin(0.270399957895279*x_120 - 7.43680000305176) + 752.865953822387*std::sin(0.271919965744019*x_120 + 5.14680004119873) - 1.77913341817595*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 7.17559963200642*std::sin(0.401599854230881*x_21 - 7.40983963012695) + 0.434820130287271*std::sin(0.435999870300293*x_22 - 7.41879987716675) - 1.45999744024734*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.219061089619056*std::sin(0.602719843387604*x_3 + 2.19079995155334) + 0.102490687534208*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0192627842052659*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 7.65367097640848*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.0755487962124718*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.0611586943628259*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.44250918106801*std::sin(0.198640003800392*x_47 + 8.2055196762085) + 0.418407220522127*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0175731243070148*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.0242115709642792*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 2.97700918285158*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 5.03297372080524*std::sin(0.427759855985641*x_65 - 0.986319839954376) + 0.130451727384607*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 2.17828701279288*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.037041745815936*std::sin(0.397599816322327*x_73 + 2.00783967971802) - 0.865842528942326*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 6.88455440568703*std::sin(0.298719942569733*x_9 + 1.96815979480743) + 0.19933932485066*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.190448040576519*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 1.16476836378435*std::sin(0.359999865293503*x_91 - 7.40607976913452) - 532.693249426316*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.176330456918116*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 7.23500693487011*std::sin(0.383119851350784*x_91 + 8.20567989349365) + 0.479302827390465*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 1.55777418433624*std::sin(0.299039930105209*x_92 - 1.17503976821899) + 0.668536292322855*std::sin(0.306799918413162*x_92 + 8.20695972442627) + 0.750511481359233*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 0.703183479001002*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.0191146821181272*std::sin(0.278399974107742*x_95 - 7.43935966491699) - 0.279335399181817*std::sin(0.301119923591614*x_97 - 7.45264005661011) - 0.920978231942432*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 9.07220653809304*std::sin(0.242159977555275*x_98 + 5.18111991882324) + 0.248627511087835*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 1.18328713546665*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.129710012763087*std::sin(0.279279947280884*x_98 + 1.9366397857666) + 46789.4323338564);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.543252863064041*x_1 - 34.5789186479187*x_10 + 57.3546524854715*x_100 + 93.4487948197977*x_101 + 134.738545929672*x_102 - 10.8510814976961*x_103 + 514.707166236437*x_104 + 157.135315834945*x_105 + 99.6630092024441*x_106 + 39.7674136027704*x_107 + 103.121631747658*x_108 - 60.9316280628361*x_109 + 132.677711443149*x_110 + 140.243377911442*x_111 + 49.3639091846221*x_112 - 74.3678908624473*x_113 - 210.808492446681*x_114 - 76.2986857009914*x_115 - 1.41469726289813*x_116 + 175.894853312215*x_117 + 183.713839657973*x_118 + 99.7919272248535*x_119 - 4.60828507893856*x_12 - 2.65371618488561*x_120 - 48.5757974093455*x_13 - 2.76611771974303*x_14 + 0.148656998258095*x_15 + 76.2284538044749*x_16 - 0.925715946736817*x_17 - 422.475942636009*x_18 + 0.0285761884362337*x_19 + 1.12577699245163*x_2 - 0.060627299418679*x_20 - 24.1592639239754*x_21 + 97.298014465664*x_22 - 0.0418805527394385*x_23 + 36.4204746952288*x_24 - 0.0366528591568063*x_25 + 0.250655639719461*x_26 - 306.1984614289*x_27 + 0.975202845049627*x_28 - 1.17736832725841*x_29 + 0.0725815884354998*x_3 - 0.0237800248878639*x_30 + 30.2723999896405*x_31 + 5.54987788819897*x_32 - 349.38467385894*x_33 + 509.657673546468*x_34 + 119.272864965939*x_35 - 715.670230481657*x_36 + 1922.1031309459*x_37 + 118.27095668671*x_38 + 314.51896282215*x_39 - 1.58772415468107*x_4 + 14354.4641435557*x_40 + 4.05295722621715*x_41 + 127.077207527504*x_42 - 68.8992850017289*x_43 + 265.88121537877*x_44 - 195.883243539032*x_45 + 1258.97406764929*x_46 - 410.875571864224*x_47 + 929.964771360682*x_48 - 252.756215287689*x_5 + 0.1224852632783*x_50 + 30.3095599684106*x_52 - 28.4264166477896*x_53 - 234.249245346518*x_54 + 148.940482596606*x_58 + 207.408665728254*x_59 - 12.011332285836*x_6 - 1.05483599628462*x_60 - 123.833560119478*x_61 - 97.4478922764571*x_62 - 59.298853786967*x_63 - 145.178479424369*x_64 + 23.8643693301896*x_65 - 1.96861720124193*x_66 - 73.3600367697922*x_67 - 65.9417234598118*x_68 - 121.804202957494*x_69 - 194.876236823523*x_7 + 51.6982355939922*x_70 + 68.1915106280934*x_71 + 40.2325821209354*x_72 - 106.786413325071*x_73 + 97.1328948060201*x_74 + 47.0368838340404*x_75 + 8.11571511880559*x_76 + 29.7289012354567*x_77 + 42.3501896656762*x_78 + 134.879274821622*x_79 - 1.89214547381076*x_8 + 28.9450967858847*x_80 - 4.48617391514987*x_81 + 64.2358517553897*x_82 - 85.0099007196138*x_83 - 61.2405671863182*x_84 + 67.6981245005981*x_85 - 1776.01341922232*x_86 - 320.853124460402*x_87 - 208.281250351074*x_88 - 30.7015088366811*x_89 + 4.94911654246275*x_9 + 39.1524820375735*x_90 - 2.40782283939152*x_91 + 128.243452701214*x_92 + 124.376627774062*x_93 - 50.9060912824881*x_94 + 39.891619291619*x_95 + 182.792626201954*x_96 + 60.8009719696793*x_97 + 196.870214731091*x_98 + 269.773411335865*x_99 + 0.00920503275666618*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 4.85419332728336e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) - 0.0146574208035652*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.00793612185645171*std::exp(1.13951992988586*x_1) + 0.38165983230849*std::exp(1.17007982730865*x_1) + 0.184900534085625*std::exp(1.22071981430054*x_1) - 0.0056630759413098*std::exp(1.40399980545044*x_1) + 3.38487184687449*std::exp(1.6639997959137*x_1) - 0.00241538456511345*std::exp(1.76023995876312*x_1) + 0.00216220067328661*std::exp(0.627359867095947*x_10) - 0.024963587931445*std::exp(0.778879821300507*x_10) + 1.21666046072574*std::exp(0.80351984500885*x_10) - 0.00388441387857754*std::exp(0.810399830341339*x_10) - 0.145672218536223*std::exp(0.840799868106842*x_10) - 0.00058854308289075*std::exp(0.934159815311432*x_10) - 0.13709590615455*std::exp(0.94543981552124*x_10) - 0.00515135098796774*std::exp(0.969839811325073*x_10) + 0.229490684524574*std::exp(0.82207989692688*x_11) - 0.000355751589641426*std::exp(0.895919859409332*x_11) - 0.00928187779441187*std::exp(0.902079820632935*x_11) + 13.5928263674447*std::exp(0.914159834384918*x_11) + 1.46121906161963*std::exp(0.925199866294861*x_11) - 0.00282248819854925*std::exp(0.933279812335968*x_11) - 0.00482063867268007*std::exp(0.937199831008911*x_11) + 0.0125870697885582*std::exp(0.951599836349487*x_11) + 0.0432574836681114*std::exp(0.983759820461273*x_11) + 0.00332698981875945*std::exp(1.06111979484558*x_11) - 0.00229831342197923*std::exp(0.537679851055145*x_12) - 0.00722117797896033*std::exp(0.696079850196838*x_12) + 0.00361310612641451*std::exp(0.854959905147552*x_12) + 0.000480930180085081*std::exp(0.925439834594727*x_12) - 0.760653374305282*std::exp(1.2235199213028*x_12) - 0.000634378220337148*std::exp(1.10399985313416*x_13) - 3.38190032536834e-5*std::exp(1.32895994186401*x_13) - 1.53654896838939e-5*std::exp(1.4015998840332*x_13) - 260.004691083819*std::exp(0.345279842615128*x_14) - 0.0597903112041187*std::exp(0.428239852190018*x_14) + 0.00542836137704002*std::exp(0.715599834918976*x_14) + 0.00153757952513313*std::exp(0.868079900741577*x_14) - 0.0149382761091374*std::exp(0.67935985326767*x_15) + 0.534641503506138*std::exp(0.82151985168457*x_15) - 0.0362187419393463*std::exp(0.898239850997925*x_15) + 21.5003069110149*std::exp(0.92087984085083*x_15) + 0.00436090968775654*std::exp(0.927359819412231*x_15) + 8.41451766995042e-5*std::exp(0.993359804153442*x_15) + 0.000670676019375646*std::exp(1.03111982345581*x_15) + 0.00131806957770668*std::exp(1.05295991897583*x_15) - 0.604451561199513*std::exp(0.357999831438065*x_16) + 0.0526320193050866*std::exp(0.539119839668274*x_16) + 2.93562922657994*std::exp(0.590719819068909*x_16) - 0.0279893786984563*std::exp(0.703679859638214*x_16) + 0.00128382532893917*std::exp(0.912239849567413*x_16) + 0.00754178062699414*std::exp(0.620319843292236*x_17) - 0.062045687086782*std::exp(0.655279815196991*x_17) - 0.661080681901781*std::exp(0.659599840641022*x_17) - 63.5740325105081*std::exp(0.695119857788086*x_17) + 0.035861872561105*std::exp(0.7079998254776*x_17) + 0.00302368454226639*std::exp(0.857999861240387*x_17) - 2.81210266745843*std::exp(0.434639871120453*x_18) + 0.0247878160091425*std::exp(0.695919871330261*x_19) - 0.00302954310577744*std::exp(0.704799830913544*x_19) + 230.282932419746*std::exp(0.716879844665527*x_19) - 2.09976727755244*std::exp(0.719519853591919*x_19) - 0.0302629279642915*std::exp(0.728719890117645*x_19) + 5.08075742874417*std::exp(0.748239874839783*x_19) + 0.239700433997364*std::exp(0.766079843044281*x_19) + 0.30758611269689*std::exp(0.823999881744385*x_19) - 0.000477680290157314*std::exp(1.00991988182068*x_19) + 0.589611393295314*std::exp(0.735999822616577*x_2) - 0.0337197715028945*std::exp(0.754559874534607*x_2) + 0.107098011076897*std::exp(0.755999863147736*x_2) - 48.7503260337156*std::exp(0.924879848957062*x_2) - 0.011079893958929*std::exp(1.01583981513977*x_2) + 0.00247595000184092*std::exp(1.11415982246399*x_2) + 0.117063239655913*std::exp(0.26639986038208*x_20) + 0.0779867975214998*std::exp(0.403999865055084*x_20) + 0.554727333092521*std::exp(0.516959846019745*x_20) - 1.62625072247393*std::exp(0.532159864902496*x_20) - 10.089055132431*std::exp(0.886239886283875*x_20) - 0.0310140387792778*std::exp(0.916319847106934*x_20) + 0.000254820305182977*std::exp(1.04447984695435*x_20) + 0.0544448325195964*std::exp(0.525999844074249*x_22) + 0.918058007746274*std::exp(0.651039838790894*x_22) + 0.000178828503439402*std::exp(1.28135991096497*x_22) - 0.00185978983294991*std::exp(1.33199989795685*x_22) + 0.0517774430425224*std::exp(0.638159871101379*x_23) + 66.8028315556689*std::exp(0.658639848232269*x_23) + 0.00286608586688669*std::exp(0.673119843006134*x_23) + 0.0582314290202807*std::exp(0.69023984670639*x_23) - 0.00498154319239788*std::exp(0.733039855957031*x_23) - 0.10145032619337*std::exp(0.734799861907959*x_23) - 0.296811719434459*std::exp(0.736159861087799*x_23) + 0.320822001669455*std::exp(0.747999846935272*x_23) - 0.75717686967787*std::exp(0.818959891796112*x_23) - 5.71634537655702*std::exp(0.305759847164154*x_24) - 0.115609034370888*std::exp(0.42087984085083*x_24) - 0.354918982285218*std::exp(0.60511988401413*x_24) - 0.0543195949970043*std::exp(0.611999869346619*x_24) - 0.0201366054675881*std::exp(0.650239825248718*x_24) - 0.00111831530072332*std::exp(0.758959889411926*x_24) + 0.577231498736382*std::exp(0.766159892082214*x_24) + 0.0770134351785026*std::exp(0.412159860134125*x_25) - 0.0168578007589233*std::exp(0.525519847869873*x_25) + 191.180284671231*std::exp(0.589919865131378*x_25) - 0.0131346835821477*std::exp(0.660079836845398*x_25) + 0.275569139467196*std::exp(0.767039835453033*x_25) - 0.169186729464179*std::exp(0.949439823627472*x_25) + 0.0254534821544002*std::exp(0.987279832363129*x_25) + 0.00197286981800809*std::exp(0.993919789791107*x_25) - 0.121734477320904*std::exp(0.42087984085083*x_26) - 1.04434279116302*std::exp(0.573839843273163*x_26) + 0.017971246112079*std::exp(0.728879868984222*x_26) + 0.00410699347314862*std::exp(0.8193598985672*x_26) - 0.00201856125919994*std::exp(0.839599847793579*x_26) - 7.35399288796555*std::exp(0.860319912433624*x_26) - 0.00016534440199614*std::exp(0.960159838199615*x_26) + 0.00660820741059815*std::exp(1.13951992988586*x_26) + 2.02305111679296e-5*std::exp(1.18455982208252*x_27) - 0.0364400529383968*std::exp(1.20399987697601*x_27) - 0.00814493108916838*std::exp(1.23751986026764*x_27) - 0.00121067933879736*std::exp(1.25919985771179*x_27) + 0.00582066541690626*std::exp(1.28719985485077*x_27) + 172.070718733778*std::exp(0.516239881515503*x_28) - 0.17179822500315*std::exp(0.543999850749969*x_28) + 0.00812382223320124*std::exp(0.647999823093414*x_28) - 0.0276914737343596*std::exp(0.654319822788239*x_28) - 0.126992064757687*std::exp(0.736559867858887*x_28) + 0.165297959436442*std::exp(0.906079828739166*x_28) + 5.12932725491808*std::exp(0.932239830493927*x_29) + 0.000733986294288435*std::exp(1.12255990505219*x_29) - 0.013554254460484*std::exp(1.15015983581543*x_29) - 0.00572475313859348*std::exp(1.15143990516663*x_29) - 0.0693208221601751*std::exp(1.16695988178253*x_29) - 39.1935562840213*std::exp(0.439999848604202*x_3) - 3.58948731411807*std::exp(0.526399850845337*x_3) - 0.0138084090031416*std::exp(0.633039832115173*x_3) - 0.00300911692085854*std::exp(0.658079862594604*x_3) + 0.0102342371338012*std::exp(0.925759851932526*x_3) - 0.0248954368727445*std::exp(0.94135981798172*x_3) - 0.00482754953336945*std::exp(0.634159862995148*x_30) + 65.3994677427711*std::exp(0.828479886054993*x_30) - 0.062620124630065*std::exp(0.857279896736145*x_30) - 0.547236913043265*std::exp(0.885519862174988*x_30) - 0.442227685817837*std::exp(0.91239982843399*x_30) + 0.134063746281348*std::exp(0.947999835014343*x_30) - 0.00347265830863314*std::exp(1.02791976928711*x_30) + 0.000166117497117292*std::exp(1.02927982807159*x_30) - 0.00182428125508911*std::exp(1.09479975700378*x_30) - 30.3615448104967*std::exp(0.826799869537354*x_32) + 0.000589883030218651*std::exp(0.831519842147827*x_32) - 0.00357830083190406*std::exp(0.832079887390137*x_32) + 0.606057932983131*std::exp(0.333039849996567*x_33) + 0.0965706017511101*std::exp(0.360239863395691*x_33) + 0.0122504457410977*std::exp(0.404719859361649*x_33) - 0.404583524836206*std::exp(0.417439848184586*x_33) + 1.53198848791305*std::exp(0.369439840316772*x_34) - 0.204113281791956*std::exp(0.426799863576889*x_36) - 0.523781317316886*std::exp(0.261359840631485*x_37) + 0.0740508014015988*std::exp(0.355199843645096*x_4) + 2.59739566428245*std::exp(0.535359859466553*x_4) + 0.00323425974691019*std::exp(0.541439831256866*x_4) + 0.0116287571372083*std::exp(0.586239874362946*x_4) - 0.369713213150164*std::exp(0.747519850730896*x_4) - 0.0081279654085873*std::exp(1.09559988975525*x_4) + 2.01199070544475*std::exp(1.10943984985352*x_4) + 0.00162838481717542*std::exp(1.15591979026794*x_4) - 40.5598207900011*std::exp(0.715999841690063*x_41) + 0.286598261523891*std::exp(0.747999846935272*x_41) - 0.0237041842556181*std::exp(0.770959854125977*x_41) - 0.00361035039213083*std::exp(0.788479864597321*x_41) + 0.00118564222092814*std::exp(0.796479880809784*x_41) + 0.0392078601868052*std::exp(0.802159905433655*x_41) - 0.0332853215268404*std::exp(0.802399873733521*x_41) + 0.0232241652923437*std::exp(0.806319832801819*x_41) + 0.0575870877979078*std::exp(0.812319874763489*x_41) - 0.0236953159631379*std::exp(0.585839867591858*x_42) + 0.225957839536395*std::exp(0.693759858608246*x_42) - 0.109504981606573*std::exp(0.720399856567383*x_42) + 0.00395991872871984*std::exp(0.851439893245697*x_42) + 0.00114054773626919*std::exp(0.704879820346832*x_43) - 0.00302101303181215*std::exp(0.761919856071472*x_43) - 0.00013279428947562*std::exp(0.818479895591736*x_43) - 0.00307191092443503*std::exp(0.875679850578308*x_44) + 0.00013264537775196*std::exp(0.960559844970703*x_44) + 1.69101073736005e-5*std::exp(0.99999988079071*x_44) + 0.981138800769682*std::exp(0.555919826030731*x_45) + 0.558364084095996*std::exp(0.518719851970673*x_46) - 0.0985995545543561*std::exp(0.702239871025085*x_46) + 0.000146996227929774*std::exp(0.715279817581177*x_46) + 0.0106109631471846*std::exp(0.752959847450256*x_46) - 0.0140216225756613*std::exp(0.756079852581024*x_46) - 0.014260960826355*std::exp(0.795919895172119*x_46) + 0.0621804988436019*std::exp(0.406479865312576*x_47) + 0.0334450135819213*std::exp(0.552319884300232*x_47) - 0.00142495343994964*std::exp(0.586239874362946*x_48) + 0.649874253313135*std::exp(0.600879848003387*x_48) + 0.00912540661150579*std::exp(0.65559983253479*x_49) - 0.0197733884861416*std::exp(0.684479832649231*x_49) - 172.369285111748*std::exp(0.703759849071503*x_49) - 0.121548168651244*std::exp(0.7079998254776*x_49) + 0.13802438561632*std::exp(0.708239853382111*x_49) + 0.00375942651879289*std::exp(0.709119856357574*x_49) - 0.0293038916563429*std::exp(0.714559853076935*x_49) - 4.03095047836779*std::exp(0.71919983625412*x_49) - 0.432317248394237*std::exp(0.719519853591919*x_49) + 1.6347319269014*std::exp(0.722239851951599*x_49) - 0.000257236234499063*std::exp(2.06119966506958*x_5) + 0.00684041232150607*std::exp(0.325439840555191*x_50) - 0.179950544465323*std::exp(0.535359859466553*x_50) + 0.109426253588422*std::exp(0.535439848899841*x_50) - 0.792647581865923*std::exp(0.538639843463898*x_50) - 0.0512578218426148*std::exp(0.539039850234985*x_50) - 166.47939459066*std::exp(0.550159871578217*x_50) - 0.00976481185678353*std::exp(0.591119825839996*x_50) - 1.60573568097195*std::exp(0.592239856719971*x_50) - 0.00884725310994063*std::exp(0.642959833145142*x_50) + 0.0229380634599679*std::exp(0.460479855537415*x_51) + 0.0172851301059189*std::exp(0.483199834823608*x_51) - 1.03761835756637*std::exp(0.488399863243103*x_51) + 0.61444205045407*std::exp(0.493759840726852*x_51) - 61.8287867211041*std::exp(0.494479864835739*x_51) - 0.188477434396727*std::exp(0.495999842882156*x_51) + 775.922324831464*std::exp(0.49703985452652*x_51) - 0.343328473592145*std::exp(0.498159825801849*x_51) + 2.09170801423373*std::exp(0.499919831752777*x_51) - 4.88578301602387*std::exp(0.50631982088089*x_51) - 0.177586574303434*std::exp(0.521999835968018*x_52) - 0.0173417129126267*std::exp(0.526719868183136*x_52) - 0.00240456732013002*std::exp(0.590079843997955*x_52) - 0.0285216645945824*std::exp(0.628719866275787*x_52) + 0.00416991751427722*std::exp(0.705759823322296*x_52) + 0.0804727447621367*std::exp(0.709279835224152*x_52) + 0.36082253867666*std::exp(0.720719873905182*x_52) - 0.006182970832093*std::exp(0.887439906597137*x_52) - 1.26217247309542*std::exp(0.48039984703064*x_54) - 0.140863035794443*std::exp(0.49823984503746*x_54) + 0.0050610744324741*std::exp(0.512639820575714*x_54) - 0.830143070740057*std::exp(0.519359886646271*x_54) + 0.0684045140250438*std::exp(0.533919811248779*x_54) - 3.28056914523297*std::exp(0.535759806632996*x_54) - 0.0574173509044019*std::exp(0.538879811763763*x_54) - 0.00488844120915035*std::exp(0.629039824008942*x_55) + 2.72881785323208*std::exp(0.631839871406555*x_55) + 0.343970497774792*std::exp(0.651679813861847*x_55) - 9.44830920561173*std::exp(0.653599858283997*x_55) - 0.59807668833958*std::exp(0.653759837150574*x_55) + 0.661782546191072*std::exp(0.655519843101501*x_55) - 1398.78943362699*std::exp(0.655839860439301*x_55) - 0.421455690359337*std::exp(0.656479835510254*x_55) + 0.0447487750848309*std::exp(0.657599866390228*x_55) - 3.57540843013366*std::exp(0.658879816532135*x_55) - 2.36749899915033*std::exp(0.342799842357635*x_56) - 282.042091132724*std::exp(0.434559851884842*x_56) - 0.692307334811789*std::exp(0.468159854412079*x_56) - 0.0703753717936269*std::exp(0.510159850120544*x_56) - 5.07661410064241*std::exp(0.52839982509613*x_56) - 1.86675994334498*std::exp(0.568239867687225*x_56) - 0.0398799104354598*std::exp(0.658959865570068*x_56) + 0.00334575013740001*std::exp(0.678959846496582*x_56) + 0.000453404231709959*std::exp(0.747119843959808*x_56) - 0.00400403743476363*std::exp(0.824879884719849*x_56) - 0.289470573826428*std::exp(0.610959827899933*x_57) + 0.0964323255011101*std::exp(0.616639852523804*x_57) - 0.0890462261474353*std::exp(0.626079857349396*x_57) + 1.60245210069048*std::exp(0.627359867095947*x_57) + 0.0212890138783977*std::exp(0.628399848937988*x_57) + 823.278151611523*std::exp(0.632639825344086*x_57) + 0.0142980727444188*std::exp(0.636399865150452*x_57) + 4.24962699592527*std::exp(0.641759812831879*x_57) + 0.136206803671074*std::exp(0.643279850482941*x_57) - 0.830872569269916*std::exp(0.663679838180542*x_57) - 0.0616441593626348*std::exp(0.437759846448898*x_58) - 0.0706001784114277*std::exp(0.485119849443436*x_58) - 0.00563303374442073*std::exp(0.554479837417603*x_58) - 0.0608074360204553*std::exp(0.566799819469452*x_58) + 0.0025922119245325*std::exp(0.60647988319397*x_58) - 0.0294872839121174*std::exp(0.655439853668213*x_58) - 0.0400234211526184*std::exp(0.522799849510193*x_59) + 0.220677242511678*std::exp(0.691839873790741*x_59) - 0.389126074367395*std::exp(0.765759825706482*x_59) - 0.0131149527380499*std::exp(0.827119886875153*x_59) + 0.0485100415244532*std::exp(0.860399901866913*x_59) + 0.0129081381780572*std::exp(0.780719876289368*x_60) - 0.136085759142589*std::exp(0.787359893321991*x_60) + 71.2768547634158*std::exp(0.816559851169586*x_60) - 0.000761540185992367*std::exp(0.838639855384827*x_60) - 0.0537242450758864*std::exp(0.847519874572754*x_60) + 0.00673773061226574*std::exp(0.854399859905243*x_60) + 0.00722183294512502*std::exp(0.860399901866913*x_60) - 0.00319396587880256*std::exp(0.872479856014252*x_60) + 0.0230808480474759*std::exp(1.03615987300873*x_60) - 0.353775459351817*std::exp(0.983999848365784*x_61) - 0.0101740050650036*std::exp(1.18831992149353*x_61) + 0.174467686755891*std::exp(1.23887979984283*x_61) + 0.0235285487126018*std::exp(1.32615983486176*x_61) + 0.067181684378492*std::exp(0.599199831485748*x_66) + 53.0128428236006*std::exp(0.949999809265137*x_66) - 0.00609249166518588*std::exp(1.11047983169556*x_66) + 0.0011081558843388*std::exp(1.5058399438858*x_66) - 3.44139361785127e-6*std::exp(1.78991985321045*x_7) - 0.0469148281919206*std::exp(0.455999851226807*x_8) + 0.033317074087657*std::exp(0.519439876079559*x_8) + 0.00359680126143797*std::exp(0.636319875717163*x_8) + 0.0121985356784908*std::exp(0.878639876842499*x_8) + 0.836909005920472*std::exp(0.925199866294861*x_8) + 0.000717866725474437*std::exp(1.39863991737366*x_8) - 0.0979754686064662*std::log(9.29800033569336 - 1.38431990146637*x_5) - 9.0481383280559*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.0832679171547052*std::sin(0.170640021562576*x_1 + 4.96303987503052) + 5.93731852329161*std::sin(0.208320006728172*x_101 - 7.40863990783691) + 0.904087614070384*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.385642693649628*std::sin(0.281839966773987*x_113 - 7.41663980484009) + 11.2005843331355*std::sin(0.30583992600441*x_113 - 1.2235199213028) - 0.595162082794454*std::sin(0.319439828395844*x_113 + 5.03800010681152) - 0.523352193793938*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 2.61661602419005*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.0185530472054534*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.388592350175711*std::sin(0.267359972000122*x_117 + 1.94591987133026) + 1.60499941535569*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 6.06957526210739*std::sin(0.265119940042496*x_120 + 5.15704011917114) - 0.592064419553395*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 971.064595605669*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 2.11619986708301*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 3.45609858896623*std::sin(0.401599854230881*x_21 - 7.40983963012695) - 0.733523980392012*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 1.73660185201882*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.14858163535779*std::sin(0.602719843387604*x_3 + 2.19079995155334) - 0.172897646260162*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.00580629526868371*std::sin(0.467679858207703*x_31 - 1.14271986484528) - 60.3414344919017*std::sin(0.150160029530525*x_33 + 7.99456024169922) - 0.380568154858985*std::sin(0.289919942617416*x_35 + 4.95607948303223) - 0.308079713166931*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.203038220215191*std::sin(0.198640003800392*x_47 + 8.2055196762085) - 0.705836065177992*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0052969886093578*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.00729798602524261*std::sin(0.600559830665588*x_64 - 7.19495964050293) - 4.62928148682132*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 2.42411147037691*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.155166512714423*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 1.0491631441778*std::sin(0.5136798620224*x_72 + 2.13903999328613) - 0.18659342788574*std::sin(0.397599816322327*x_73 + 2.00783967971802) + 1.46064134105949*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 3.31591783089813*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.237105238114112*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.08738402016609*std::sin(0.36575984954834*x_9 + 2.02055978775024) - 9.1830174223813*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 687.080551603838*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.0809063939780344*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 3.48471187651445*std::sin(0.383119851350784*x_91 + 8.20567989349365) - 0.808564492008045*std::sin(0.393919825553894*x_91 - 4.39919996261597) + 12.281469792344*std::sin(0.299039930105209*x_92 - 1.17503976821899) - 1.12779369680331*std::sin(0.306799918413162*x_92 + 8.20695972442627) - 1.26608252652153*std::sin(0.235759988427162*x_93 + 1.9755197763443) + 5.54388867312369*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.00576165351603403*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.332257001403635*std::sin(0.301119923591614*x_97 - 7.45264005661011) + 1.55365304293178*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 4.36959164712292*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.295731337819894*std::sin(0.259039968252182*x_98 + 1.97271978855133) - 9.32901915825188*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.0595153530418147*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 133635.45087843);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.770399208194046*x_1 - 25.9178173877077*x_10 + 37.0556026186619*x_100 + 69.9289387577641*x_101 + 106.066908873457*x_102 - 9.63631696256047*x_103 + 442.077399519404*x_104 + 112.933145341602*x_105 + 75.8577781336561*x_106 + 28.0095134242226*x_107 + 74.7148944797901*x_108 - 46.003288252027*x_109 + 101.43161958045*x_110 + 103.706565601247*x_111 + 37.2231855214338*x_112 - 56.7532000880581*x_113 - 152.693337000853*x_114 - 61.7046442977586*x_115 + 5.18333948393181*x_116 + 132.531848169989*x_117 + 133.807392138134*x_118 + 70.5137894669723*x_119 - 3.45996030639758*x_12 - 1.52918382544744*x_120 - 45.3046570601935*x_13 - 5.13621393826397*x_14 + 0.113036906977039*x_15 + 56.7277752171565*x_16 - 2.14899965327245*x_17 - 320.12748909778*x_18 + 0.000905666662168134*x_19 + 0.361645282630126*x_2 + 0.00290781564775415*x_20 - 18.4219326822076*x_21 + 72.7931054949262*x_22 + 0.00657866759725036*x_23 + 27.4864681542906*x_24 + 0.0339622468236585*x_25 + 0.0795015072032035*x_26 - 229.81444067238*x_27 + 0.304878515438393*x_28 - 1.62223924571591*x_29 - 1.43703705097089*x_3 - 0.000753661595370743*x_30 + 23.1754324485084*x_31 + 8.92976148542887*x_32 - 260.435761169804*x_33 + 391.542178235312*x_34 - 1.01483479688909*x_35 - 534.417766570487*x_36 + 1448.52378479125*x_37 + 143.668949532668*x_38 + 219.100934407315*x_39 - 2.27452111364111*x_4 + 10491.6663846651*x_40 + 1.29945894064393*x_41 + 96.6354723424625*x_42 - 42.4284757477748*x_43 + 200.725418500946*x_44 - 178.489373208349*x_45 + 941.80809131599*x_46 - 288.922456579609*x_47 + 686.81188959748*x_48 - 189.566734725862*x_5 - 0.0192401909708042*x_50 + 22.700862325419*x_52 - 22.6345785622862*x_53 - 174.625531152308*x_54 + 125.482434591488*x_58 + 155.514099514558*x_59 - 6.38482389787583*x_6 - 1.50947058421372*x_60 - 92.8345842460895*x_61 - 71.58007582136*x_62 - 44.806339542091*x_63 - 111.810703211165*x_64 + 18.5144461702434*x_65 - 3.57027766326681*x_66 - 55.5161918838416*x_67 - 47.5659185277876*x_68 - 88.2840764420279*x_69 - 141.222815893319*x_7 + 36.2431761004972*x_70 + 50.5840425286544*x_71 + 31.6023393975222*x_72 - 80.764024653818*x_73 + 73.633878452325*x_74 + 32.5076306166063*x_75 + 8.46345596981834*x_76 + 20.5038075366168*x_77 + 26.9903198116467*x_78 + 99.0883840194352*x_79 - 1.82143506005958*x_8 + 21.5242578023597*x_80 - 1.68337613430911*x_81 + 48.1831031183147*x_82 - 58.4929315667039*x_83 - 43.5214202159155*x_84 + 53.0891061085535*x_85 - 1395.67287039858*x_86 - 238.764727492198*x_87 - 157.657324472582*x_88 - 23.1236521968932*x_89 + 3.46100423141536*x_9 + 30.7033681349563*x_90 - 0.751515815186452*x_91 + 100.164272158492*x_92 + 88.6736515439538*x_93 - 41.6403391202645*x_94 + 31.6113139305138*x_95 + 138.809586326286*x_96 + 43.7081799504349*x_97 + 147.870108633364*x_98 + 197.490795486086*x_99 + 0.0131724042617542*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) - 2.48045764282041e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) - 0.0209747729707301*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) + 0.00124661935647531*std::exp(1.13951992988586*x_1) + 0.122367756108995*std::exp(1.17007982730865*x_1) + 1.21553200588012*std::exp(1.22071981430054*x_1) + 0.00695920189976133*std::exp(1.40399980545044*x_1) + 2.53705129710198*std::exp(1.6639997959137*x_1) + 0.00254835943130467*std::exp(1.76023995876312*x_1) + 0.00225187528729159*std::exp(0.627359867095947*x_10) + 0.0306770826239689*std::exp(0.778879821300507*x_10) + 0.390085615310985*std::exp(0.80351984500885*x_10) + 0.00128168598629001*std::exp(0.810399830341339*x_10) - 0.95764593041329*std::exp(0.840799868106842*x_10) + 0.000300741253934041*std::exp(0.934159815311432*x_10) - 0.196184277257618*std::exp(0.94543981552124*x_10) + 0.00543494980623576*std::exp(0.969839811325073*x_10) + 0.328401229064091*std::exp(0.82207989692688*x_11) - 0.00037050594934397*std::exp(0.895919859409332*x_11) + 0.00145801296051743*std::exp(0.902079820632935*x_11) + 10.1881841697052*std::exp(0.914159834384918*x_11) + 0.468495981546098*std::exp(0.925199866294861*x_11) + 0.00144227103286388*std::exp(0.933279812335968*x_11) - 0.00015278075821578*std::exp(0.937199831008911*x_11) - 0.0154679119426929*std::exp(0.951599836349487*x_11) + 0.284373737222827*std::exp(0.983759820461273*x_11) - 0.00351015155306833*std::exp(1.06111979484558*x_11) - 0.00239363314485453*std::exp(0.537679851055145*x_12) - 0.00022886117831007*std::exp(0.696079850196838*x_12) - 0.000567552781529707*std::exp(0.854959905147552*x_12) - 0.000245751839785635*std::exp(0.925439834594727*x_12) - 0.570129894787052*std::exp(1.2235199213028*x_12) + 0.000779570353972053*std::exp(1.10399985313416*x_13) + 5.31234585800488e-6*std::exp(1.32895994186401*x_13) - 4.86979282966446e-7*std::exp(1.4015998840332*x_13) - 194.880417518879*std::exp(0.345279842615128*x_14) + 0.0734747073200625*std::exp(0.428239852190018*x_14) + 0.000172041346254301*std::exp(0.715599834918976*x_14) - 0.000241525575441212*std::exp(0.868079900741577*x_14) - 0.000473439580386934*std::exp(0.67935985326767*x_15) + 0.171416731781994*std::exp(0.82151985168457*x_15) - 0.238101205373483*std::exp(0.898239850997925*x_15) + 16.1150507328803*std::exp(0.92087984085083*x_15) - 0.000685019021498325*std::exp(0.927359819412231*x_15) + 8.76349944274025e-5*std::exp(0.993359804153442*x_15) - 0.000342710589783559*std::exp(1.03111982345581*x_15) - 0.00161974029736786*std::exp(1.05295991897583*x_15) - 3.97365114317069*std::exp(0.357999831438065*x_16) - 0.00826752603134031*std::exp(0.539119839668274*x_16) + 0.941221293977341*std::exp(0.590719819068909*x_16) + 0.0343953956171716*std::exp(0.703679859638214*x_16) - 0.000656025447382783*std::exp(0.912239849567413*x_16) + 0.00785456670415688*std::exp(0.620319843292236*x_17) - 0.00196641726559179*std::exp(0.655279815196991*x_17) - 4.34592972537629*std::exp(0.659599840641022*x_17) - 47.6504248725751*std::exp(0.695119857788086*x_17) - 0.00563324320149903*std::exp(0.7079998254776*x_17) - 0.00154508090771491*std::exp(0.857999861240387*x_17) - 4.02411964634177*std::exp(0.434639871120453*x_18) - 0.0304610812303289*std::exp(0.695919871330261*x_19) - 0.00315518968057436*std::exp(0.704799830913544*x_19) + 172.603170467277*std::exp(0.716879844665527*x_19) - 3.00476751867*std::exp(0.719519853591919*x_19) + 0.00475375157618503*std::exp(0.728719890117645*x_19) + 1.62899218953438*std::exp(0.748239874839783*x_19) - 0.252896731430555*std::exp(0.766079843044281*x_19) + 2.02206427578073*std::exp(0.823999881744385*x_19) + 0.000244091169563799*std::exp(1.00991988182068*x_19) + 3.87609220885287*std::exp(0.735999822616577*x_2) + 0.00529675836784938*std::exp(0.754559874534607*x_2) - 0.112994108906613*std::exp(0.755999863147736*x_2) - 36.5396633884935*std::exp(0.924879848957062*x_2) + 0.0136157840522088*std::exp(1.01583981513977*x_2) - 0.00126519252350104*std::exp(1.11415982246399*x_2) - 0.143855870599048*std::exp(0.26639986038208*x_20) - 0.0822802272779393*std::exp(0.403999865055084*x_20) + 0.793814957502218*std::exp(0.516959846019745*x_20) - 0.521408424292649*std::exp(0.532159864902496*x_20) - 7.56201462513348*std::exp(0.886239886283875*x_20) - 0.203885602355057*std::exp(0.916319847106934*x_20) - 0.000130211330888769*std::exp(1.04447984695435*x_20) - 0.00855228577719086*std::exp(0.525999844074249*x_22) + 0.294347711956763*std::exp(0.651039838790894*x_22) - 0.000219757544091688*std::exp(1.28135991096497*x_22) - 0.0122262170703854*std::exp(1.33199989795685*x_22) + 0.00164098526017777*std::exp(0.638159871101379*x_23) + 50.0704954620041*std::exp(0.658639848232269*x_23) + 0.00298495325370862*std::exp(0.673119843006134*x_23) - 0.0715590388798542*std::exp(0.69023984670639*x_23) + 0.00254553250180059*std::exp(0.733039855957031*x_23) + 0.10703550039108*std::exp(0.734799861907959*x_23) - 1.95123365368875*std::exp(0.736159861087799*x_23) + 0.102861933930096*std::exp(0.747999846935272*x_23) - 1.08352029685321*std::exp(0.818959891796112*x_23) - 1.83277436517846*std::exp(0.305759847164154*x_24) - 0.00366400328402099*std::exp(0.42087984085083*x_24) - 2.33322950956052*std::exp(0.60511988401413*x_24) + 0.00853261325670235*std::exp(0.611999869346619*x_24) + 0.0247453335390682*std::exp(0.650239825248718*x_24) - 0.00116469605259674*std::exp(0.758959889411926*x_24) + 0.826018424374158*std::exp(0.766159892082214*x_24) - 0.0946397417155989*std::exp(0.412159860134125*x_25) + 0.00861421412669957*std::exp(0.525519847869873*x_25) + 143.294698041032*std::exp(0.589919865131378*x_25) - 0.000416278226363982*std::exp(0.660079836845398*x_25) + 0.394339510035627*std::exp(0.767039835453033*x_25) - 0.0542446406338545*std::exp(0.949439823627472*x_25) + 0.167330626559706*std::exp(0.987279832363129*x_25) - 0.000309901706075167*std::exp(0.993919789791107*x_25) + 0.149596229084321*std::exp(0.42087984085083*x_26) - 1.49445480496371*std::exp(0.573839843273163*x_26) - 0.0189606223304912*std::exp(0.728879868984222*x_26) - 0.00209864392755579*std::exp(0.8193598985672*x_26) + 0.000317078994434053*std::exp(0.839599847793579*x_26) - 5.51201287355074*std::exp(0.860319912433624*x_26) - 0.000172201857740223*std::exp(0.960159838199615*x_26) + 0.0434422088005246*std::exp(1.13951992988586*x_26) + 2.10695467405853e-5*std::exp(1.18455982208252*x_27) - 0.0116834079279278*std::exp(1.20399987697601*x_27) - 0.0535445961447977*std::exp(1.23751986026764*x_27) + 0.00127733121916553*std::exp(1.25919985771179*x_27) + 0.0083293737209546*std::exp(1.28719985485077*x_27) + 128.971571127546*std::exp(0.516239881515503*x_28) + 0.181256282453562*std::exp(0.543999850749969*x_28) - 0.00127610364705276*std::exp(0.647999823093414*x_28) + 0.0340293082092724*std::exp(0.654319822788239*x_28) - 0.834843014213717*std::exp(0.736559867858887*x_28) + 0.236541422817104*std::exp(0.906079828739166*x_28) + 3.84456693016802*std::exp(0.932239830493927*x_29) - 0.00011529580044234*std::exp(1.12255990505219*x_29) - 0.0891053678889431*std::exp(1.15015983581543*x_29) + 0.0060399196315724*std::exp(1.15143990516663*x_29) - 0.0222256384908615*std::exp(1.16695988178253*x_29) - 29.3766107866779*std::exp(0.439999848604202*x_3) - 1.15086124089501*std::exp(0.526399850845337*x_3) + 0.00705599701901478*std::exp(0.633039832115173*x_3) - 0.00313391634475461*std::exp(0.658079862594604*x_3) - 0.0125765790962861*std::exp(0.925759851932526*x_3) + 0.0262660125710162*std::exp(0.94135981798172*x_3) + 0.00246684285704828*std::exp(0.634159862995148*x_30) + 49.018637033418*std::exp(0.828479886054993*x_30) + 0.0660675684921437*std::exp(0.857279896736145*x_30) - 0.175455071350006*std::exp(0.885519862174988*x_30) - 0.632827933079765*std::exp(0.91239982843399*x_30) + 0.881332091543371*std::exp(0.947999835014343*x_30) + 0.00426745651111156*std::exp(1.02791976928711*x_30) + 0.000173007016030827*std::exp(1.02927982807159*x_30) + 0.000286561164934778*std::exp(1.09479975700378*x_30) - 22.7567837507989*std::exp(0.826799869537354*x_32) + 0.000614347703501053*std::exp(0.831519842147827*x_32) + 0.00439727777013436*std::exp(0.832079887390137*x_32) + 3.9842113956112*std::exp(0.333039849996567*x_33) + 0.00306061722495498*std::exp(0.360239863395691*x_33) + 0.0127585179134886*std::exp(0.404719859361649*x_33) + 0.426857178835372*std::exp(0.417439848184586*x_33) + 10.0712583060244*std::exp(0.369439840316772*x_34) + 0.215350389425315*std::exp(0.426799863576889*x_36) + 0.552617201916654*std::exp(0.261359840631485*x_37) - 0.0116320243135753*std::exp(0.355199843645096*x_4) + 0.832776866360336*std::exp(0.535359859466553*x_4) + 0.00336839669265222*std::exp(0.541439831256866*x_4) + 0.00036855081933409*std::exp(0.586239874362946*x_4) - 2.43048645480219*std::exp(0.747519850730896*x_4) + 0.00857543664286795*std::exp(1.09559988975525*x_4) + 1.50804043991181*std::exp(1.10943984985352*x_4) - 0.00200107835930038*std::exp(1.15591979026794*x_4) - 30.4006622999667*std::exp(0.715999841690063*x_41) + 0.41012218655873*std::exp(0.747999846935272*x_41) + 0.00372349309360566*std::exp(0.770959854125977*x_41) + 0.00184486290916485*std::exp(0.788479864597321*x_41) + 0.00123481527402323*std::exp(0.796479880809784*x_41) - 0.0481814861614734*std::exp(0.802159905433655*x_41) + 0.0351177879754927*std::exp(0.802399873733521*x_41) + 0.000736044707603074*std::exp(0.806319832801819*x_41) + 0.378576236623361*std::exp(0.812319874763489*x_41) - 0.000750976910907535*std::exp(0.585839867591858*x_42) + 0.323345726969903*std::exp(0.693759858608246*x_42) - 0.719883317830027*std::exp(0.720399856567383*x_42) - 0.00417792528166594*std::exp(0.851439893245697*x_42) - 0.000582811634948566*std::exp(0.704879820346832*x_43) - 9.5745126925974e-5*std::exp(0.761919856071472*x_43) - 0.000138301769330712*std::exp(0.818479895591736*x_43) - 0.0201946742140528*std::exp(0.875679850578308*x_44) - 6.77808275950532e-5*std::exp(0.960559844970703*x_44) + 1.76114332820812e-5*std::exp(0.99999988079071*x_44) + 0.314572672621765*std::exp(0.555919826030731*x_45) + 0.79901914913124*std::exp(0.518719851970673*x_46) - 0.648191282513232*std::exp(0.702239871025085*x_46) + 0.000153092715717724*std::exp(0.715279817581177*x_46) - 0.00166678792102629*std::exp(0.752959847450256*x_46) - 0.000444388031126597*std::exp(0.756079852581024*x_46) + 0.017524911674103*std::exp(0.795919895172119*x_46) - 0.00976741724179908*std::exp(0.406479865312576*x_47) + 0.00105997459683951*std::exp(0.552319884300232*x_47) - 0.00148405163156584*std::exp(0.586239874362946*x_48) + 0.929970225010546*std::exp(0.600879848003387*x_48) - 0.0112139670534239*std::exp(0.65559983253479*x_49) + 0.00310603708912192*std::exp(0.684479832649231*x_49) - 129.195354552966*std::exp(0.703759849071503*x_49) - 0.00385223258310547*std::exp(0.7079998254776*x_49) - 0.145623082102812*std::exp(0.708239853382111*x_49) + 0.00391534411058626*std::exp(0.709119856357574*x_49) + 0.0149740764577327*std::exp(0.714559853076935*x_49) - 1.2924031382628*std::exp(0.71919983625412*x_49) - 2.84204399254937*std::exp(0.719519853591919*x_49) + 2.33930181129964*std::exp(0.722239851951599*x_49) - 8.24750684796581e-5*std::exp(2.06119966506958*x_5) + 0.00712411001069122*std::exp(0.325439840555191*x_50) - 1.18299088401692*std::exp(0.535359859466553*x_50) - 0.115450528827608*std::exp(0.535439848899841*x_50) - 1.13427889519226*std::exp(0.538639843463898*x_50) - 0.00162451687781242*std::exp(0.539039850234985*x_50) - 124.78072526645*std::exp(0.550159871578217*x_50) + 0.00498974815541957*std::exp(0.591119825839996*x_50) - 0.514830892725086*std::exp(0.592239856719971*x_50) + 0.0108721516872557*std::exp(0.642959833145142*x_50) - 0.003603149551693*std::exp(0.460479855537415*x_51) + 0.0180020096210464*std::exp(0.483199834823608*x_51) + 1.09474266159969*std::exp(0.488399863243103*x_51) + 0.0194735446321765*std::exp(0.493759840726852*x_51) - 19.8235424677538*std::exp(0.494479864835739*x_51) + 0.0963106042812236*std::exp(0.495999842882156*x_51) + 581.574378504687*std::exp(0.49703985452652*x_51) + 0.421907138527972*std::exp(0.498159825801849*x_51) + 13.7508420450513*std::exp(0.499919831752777*x_51) - 6.99155676286674*std::exp(0.50631982088089*x_51) + 0.187363299424739*std::exp(0.521999835968018*x_52) - 0.000549611831014599*std::exp(0.526719868183136*x_52) - 0.00250429379276769*std::exp(0.590079843997955*x_52) + 0.0350495074563781*std::exp(0.628719866275787*x_52) - 0.00065501764995927*std::exp(0.705759823322296*x_52) + 0.115156518622074*std::exp(0.709279835224152*x_52) + 0.115686904079876*std::exp(0.720719873905182*x_52) - 0.0406467129746197*std::exp(0.887439906597137*x_52) - 8.29749381512265*std::exp(0.48039984703064*x_54) + 0.173102800751089*std::exp(0.49823984503746*x_54) + 0.00527097627081399*std::exp(0.512639820575714*x_54) + 0.875845177702904*std::exp(0.519359886646271*x_54) - 0.0107450960048682*std::exp(0.533919811248779*x_54) - 1.05181591322947*std::exp(0.535759806632996*x_54) + 0.0293398505743139*std::exp(0.538879811763763*x_54) - 0.00509118329684486*std::exp(0.629039824008942*x_55) + 0.874913441926664*std::exp(0.631839871406555*x_55) - 0.422696104799636*std::exp(0.651679813861847*x_55) - 13.5205329232796*std::exp(0.653599858283997*x_55) + 0.631002777523355*std::exp(0.653759837150574*x_55) - 0.103953914365444*std::exp(0.655519843101501*x_55) - 1048.42980990041*std::exp(0.655839860439301*x_55) - 0.0133572176426274*std::exp(0.656479835510254*x_55) - 0.0228663000589925*std::exp(0.657599866390228*x_55) - 23.5046556377629*std::exp(0.658879816532135*x_55) - 15.5638858567262*std::exp(0.342799842357635*x_56) - 211.398033815182*std::exp(0.434559851884842*x_56) + 0.730421131074071*std::exp(0.468159854412079*x_56) - 0.00223041040667129*std::exp(0.510159850120544*x_56) - 1.62766375588819*std::exp(0.52839982509613*x_56) - 2.67133396299778*std::exp(0.568239867687225*x_56) + 0.00626440334241212*std::exp(0.658959865570068*x_56) - 0.00170965409487014*std::exp(0.678959846496582*x_56) + 0.000472208614656068*std::exp(0.747119843959808*x_56) + 0.00492045404502871*std::exp(0.824879884719849*x_56) + 0.305406881185855*std::exp(0.610959827899933*x_57) - 0.118503094392641*std::exp(0.616639852523804*x_57) + 0.0139875308298382*std::exp(0.626079857349396*x_57) + 10.5344845319759*std::exp(0.627359867095947*x_57) - 0.0108785319459731*std::exp(0.628399848937988*x_57) + 617.068827687046*std::exp(0.632639825344086*x_57) + 0.0148910677287474*std::exp(0.636399865150452*x_57) + 1.36251519224916*std::exp(0.641759812831879*x_57) + 0.00431680948355443*std::exp(0.643279850482941*x_57) - 1.18897886207953*std::exp(0.663679838180542*x_57) - 0.00195369162604375*std::exp(0.437759846448898*x_58) + 0.0867586627508055*std::exp(0.485119849443436*x_58) + 0.00287843945668175*std::exp(0.554479837417603*x_58) + 0.06415508541138*std::exp(0.566799819469452*x_58) + 0.00269972072638586*std::exp(0.60647988319397*x_58) + 0.00463191210513545*std::exp(0.655439853668213*x_58) - 0.00126846441836449*std::exp(0.522799849510193*x_59) + 1.45072729275133*std::exp(0.691839873790741*x_59) - 0.12476158225986*std::exp(0.765759825706482*x_59) + 0.0138369740304913*std::exp(0.827119886875153*x_59) + 0.069417882000673*std::exp(0.860399901866913*x_59) - 0.00202763203487637*std::exp(0.780719876289368*x_60) - 0.894624759200032*std::exp(0.787359893321991*x_60) + 53.4238946144593*std::exp(0.816559851169586*x_60) - 0.000793124128718804*std::exp(0.838639855384827*x_60) + 0.0566819415037653*std::exp(0.847519874572754*x_60) + 0.000213539255167476*std::exp(0.854399859905243*x_60) - 0.00887471650960219*std::exp(0.860399901866913*x_60) + 0.00163209343774061*std::exp(0.872479856014252*x_60) + 0.00740018033225834*std::exp(1.03615987300873*x_60) - 0.113427469863581*std::exp(0.983999848365784*x_61) + 0.0125025615249261*std::exp(1.18831992149353*x_61) + 1.14694669916662*std::exp(1.23887979984283*x_61) - 0.0248238727210107*std::exp(1.32615983486176*x_61) - 0.0825577672631092*std::exp(0.599199831485748*x_66) + 39.7345328665455*std::exp(0.949999809265137*x_66) - 0.000193089662850197*std::exp(1.11047983169556*x_66) - 0.000174070988373964*std::exp(1.5058399438858*x_66) + 5.40579892151773e-7*std::exp(1.78991985321045*x_7) - 0.00148687414871933*std::exp(0.455999851226807*x_8) - 0.00523350198120134*std::exp(0.519439876079559*x_8) - 0.00183793940148506*std::exp(0.636319875717163*x_8) - 0.0128701051970697*std::exp(0.878639876842499*x_8) + 0.62728551480832*std::exp(0.925199866294861*x_8) + 0.00471923991504779*std::exp(1.39863991737366*x_8) + 0.0500647550537153*std::log(9.29800033569336 - 1.38431990146637*x_5) - 12.9478882937285*std::log(9.35847949981689 - 1.21983981132507*x_21) + 0.0425493027538145*std::sin(0.170640021562576*x_1 + 4.96303987503052) + 1.90362276429529*std::sin(0.208320006728172*x_101 - 7.40863990783691) - 0.953860611398657*std::sin(0.231999978423119*x_108 - 1.19423997402191) - 0.0605774023235389*std::sin(0.281839966773987*x_113 - 7.41663980484009) + 16.02803908515*std::sin(0.30583992600441*x_113 - 1.2235199213028) + 0.627927713354803*std::sin(0.319439828395844*x_113 + 5.03800010681152) + 0.552164453732081*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 17.2015756483911*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.0193225120230905*std::sin(0.248959973454475*x_117 + 1.95943987369537) - 0.0610407393270376*std::sin(0.267359972000122*x_117 + 1.94591987133026) - 1.69335991313169*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 39.9012530151654*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.727572060844395*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 727.838690296659*std::sin(0.271919965744019*x_120 + 5.14680004119873) - 0.332416231024919*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 22.7203153908692*std::sin(0.401599854230881*x_21 - 7.40983963012695) + 0.773906888583732*std::sin(0.435999870300293*x_22 - 7.41879987716675) - 0.272788336970606*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.00470900568332435*std::sin(0.602719843387604*x_3 + 2.19079995155334) + 0.182416230467534*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.00604710422478616*std::sin(0.467679858207703*x_31 - 1.14271986484528) - 86.3486084051005*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.467669982484953*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.378590883712104*std::sin(0.299839943647385*x_42 - 4.29496002197266) + 0.103751060405186*std::sin(0.198640003800392*x_47 + 8.2055196762085) + 0.744694662552347*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.00551667469807358*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.00760066102109885*std::sin(0.600559830665588*x_64 - 7.19495964050293) - 1.48423999589604*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 15.9360549856483*std::sin(0.427759855985641*x_65 - 0.986319839954376) + 0.0243738165473505*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 6.8971752160941*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.229299651158321*std::sin(0.397599816322327*x_73 + 2.00783967971802) - 1.54105445195126*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 21.7987701996509*std::sin(0.298719942569733*x_9 + 1.96815979480743) + 0.0372448892168216*std::sin(0.329519838094711*x_9 - 4.33071994781494) + 0.0446526015894502*std::sin(0.36575984954834*x_9 + 2.02055978775024) - 13.1409003126838*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 514.985111258982*std::sin(0.364799857139587*x_91 + 2.00895977020264) + 0.041342581509453*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 22.9084185079333*std::sin(0.383119851350784*x_91 + 8.20567989349365) + 0.853078627224723*std::sin(0.393919825553894*x_91 - 4.39919996261597) + 17.5747864575628*std::sin(0.299039930105209*x_92 - 1.17503976821899) + 1.18988244991111*std::sin(0.306799918413162*x_92 + 8.20695972442627) + 1.33578453463357*std::sin(0.235759988427162*x_93 + 1.9755197763443) + 7.93330612883052*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.00600061101034256*std::sin(0.278399974107742*x_95 - 7.43935966491699) - 0.0521914880802254*std::sin(0.301119923591614*x_97 - 7.45264005661011) - 1.63918675399187*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 28.725598473635*std::sin(0.242159977555275*x_98 + 5.18111991882324) + 0.0464539754695062*std::sin(0.259039968252182*x_98 + 1.97271978855133) - 13.3498288345744*std::sin(0.266639977693558*x_98 + 1.94559979438782) - 0.0304119144756731*std::sin(0.279279947280884*x_98 + 1.9366397857666) + 213943.481966021);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.537080582081965*x_1 + 8.33560992086456*x_10 - 21.0530561089013*x_100 - 20.1813464954806*x_101 - 23.946736285757*x_102 - 4.69277131248266*x_103 - 46.3538217683093*x_104 - 42.4092474805568*x_105 - 24.8560173982346*x_106 - 11.8441575106889*x_107 - 26.4847960562242*x_108 + 13.3922583337684*x_109 - 27.3189607829706*x_110 - 41.8859270030844*x_111 - 14.997122416216*x_112 + 15.9457798298545*x_113 + 56.4333606950513*x_114 + 7.25615243887093*x_115 + 4.09444959717343*x_116 - 44.3794865877733*x_117 - 45.4117881762135*x_118 - 30.7419220980239*x_119 + 0.830781682771455*x_12 + 0.222153211859223*x_120 + 0.0366968726921773*x_13 - 1.86333639447987*x_14 - 0.359817433844238*x_15 - 18.0521879717179*x_16 + 1.19233998952867*x_17 + 88.7027098643212*x_18 - 0.0522606557611019*x_19 + 0.183401309401106*x_2 + 0.0583263366951544*x_20 + 7.51720043520652*x_21 - 23.2584844401715*x_22 - 0.0203691961065875*x_23 - 8.14016293225542*x_24 + 0.215914456751519*x_25 + 0.0344403774842138*x_26 + 73.8193362428956*x_27 + 0.177099478395471*x_28 + 1.2281564358612*x_29 - 3.25284280910286*x_3 + 0.0434893441939693*x_30 - 7.87977981901305*x_31 + 1.17763752939472*x_32 + 83.0344911326259*x_33 - 125.590642993248*x_34 - 154.703940587294*x_35 + 164.778929242357*x_36 - 438.081018592351*x_37 + 30.6387311601462*x_38 - 118.711583831336*x_39 + 1.56489172502227*x_4 - 3680.83668869272*x_40 + 0.653066112316842*x_41 - 32.0420425616366*x_42 + 24.3925224702224*x_43 - 65.1665201183889*x_44 + 16.0111506425837*x_45 - 298.500636585981*x_46 + 106.07009592808*x_47 - 239.523819670449*x_48 + 59.5056245145459*x_5 + 0.0595724312285223*x_50 - 7.32742635041082*x_52 + 1.99243135040653*x_53 + 54.2320182330375*x_54 - 20.2248363921094*x_58 - 49.992440202962*x_59 + 4.42916567664789*x_6 + 1.04036041271127*x_60 + 29.8539157841662*x_61 + 22.1809290067388*x_62 + 13.9971063367402*x_63 + 30.663169280343*x_64 - 5.9450670202197*x_65 - 3.20784544477231*x_66 + 14.7217653863064*x_67 + 18.9888311605235*x_68 + 36.156680320599*x_69 + 50.5186726288266*x_7 - 17.551263782151*x_70 - 17.5107566868344*x_71 - 11.7075028424655*x_72 + 24.0838415116667*x_73 - 25.87693057678*x_74 - 13.9723967356076*x_75 + 0.503216037241799*x_76 - 10.1823424109518*x_77 - 16.9753937651122*x_78 - 46.2970721560056*x_79 + 1.0904367439781*x_8 - 7.5822205661106*x_80 + 6.08808889206704*x_81 - 17.7500491797975*x_82 + 24.7089043030577*x_83 + 20.3421406908396*x_84 - 14.709116131298*x_85 + 288.213073086997*x_86 + 101.667633066061*x_87 + 47.7290788241084*x_88 + 9.47356218939345*x_89 - 0.602294047879171*x_9 - 10.9664062688028*x_90 - 0.365826075410868*x_91 - 26.2425306957633*x_92 - 33.5413138438144*x_93 + 5.24284846645651*x_94 - 7.6990993026993*x_95 - 42.1902928092999*x_96 - 13.3584763519631*x_97 - 46.0533456891859*x_98 - 64.784796447694*x_99 - 0.0090787114883042*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) - 8.7440480184405e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.0144562760563636*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.00385984453036155*std::exp(1.13951992988586*x_1) + 0.0614980837450982*std::exp(1.17007982730865*x_1) + 1.78089206771411*std::exp(1.22071981430054*x_1) + 0.00253862650479187*std::exp(1.40399980545044*x_1) - 0.815958753220306*std::exp(1.6639997959137*x_1) + 0.0152240904172412*std::exp(1.76023995876312*x_1) + 0.000916391316737992*std::exp(0.627359867095947*x_10) + 0.0111906014742249*std::exp(0.778879821300507*x_10) + 0.196044436875881*std::exp(0.80351984500885*x_10) - 0.0101248825883903*std::exp(0.810399830341339*x_10) - 1.40305975729275*std::exp(0.840799868106842*x_10) + 0.00106016564045623*std::exp(0.934159815311432*x_10) + 0.135214530041017*std::exp(0.94543981552124*x_10) + 0.0324687978653544*std::exp(0.969839811325073*x_10) - 0.226341368806451*std::exp(0.82207989692688*x_11) - 0.000150775860765781*std::exp(0.895919859409332*x_11) - 0.00451437186629381*std::exp(0.902079820632935*x_11) - 3.27669293174617*std::exp(0.914159834384918*x_11) + 0.235450955574449*std::exp(0.925199866294861*x_11) + 0.00508425822286076*std::exp(0.933279812335968*x_11) + 0.00881607212185617*std::exp(0.937199831008911*x_11) - 0.00564249346363318*std::exp(0.951599836349487*x_11) + 0.416639735059595*std::exp(0.983759820461273*x_11) - 0.0209699087050578*std::exp(1.06111979484558*x_11) - 0.00097407908945044*std::exp(0.537679851055145*x_12) + 0.0132062222850401*std::exp(0.696079850196838*x_12) + 0.00175728500291605*std::exp(0.854959905147552*x_12) - 0.000866318315866226*std::exp(0.925439834594727*x_12) + 0.183363449787341*std::exp(1.2235199213028*x_12) + 0.000284377144311808*std::exp(1.10399985313416*x_13) - 1.64483480838805e-5*std::exp(1.32895994186401*x_13) + 2.81006884022556e-5*std::exp(1.4015998840332*x_13) + 62.6768495723347*std::exp(0.345279842615128*x_14) + 0.0268026193407225*std::exp(0.428239852190018*x_14) - 0.00992748651225438*std::exp(0.715599834918976*x_14) + 0.000747823436614229*std::exp(0.868079900741577*x_14) + 0.0273193924076326*std::exp(0.67935985326767*x_15) + 0.0861485154393972*std::exp(0.82151985168457*x_15) - 0.34884523477091*std::exp(0.898239850997925*x_15) - 5.18287380278953*std::exp(0.92087984085083*x_15) + 0.00212098978697054*std::exp(0.927359819412231*x_15) + 3.56626978362745e-5*std::exp(0.993359804153442*x_15) - 0.00120811490660575*std::exp(1.03111982345581*x_15) - 0.000590860232107728*std::exp(1.05295991897583*x_15) - 5.82184900644544*std::exp(0.357999831438065*x_16) + 0.0255983231496715*std::exp(0.539119839668274*x_16) + 0.47302743631362*std::exp(0.590719819068909*x_16) + 0.0125469937809318*std::exp(0.703679859638214*x_16) - 0.00231260470415107*std::exp(0.912239849567413*x_16) + 0.00319638337213861*std::exp(0.620319843292236*x_17) + 0.113470286687776*std::exp(0.655279815196991*x_17) - 6.36727929608209*std::exp(0.659599840641022*x_17) + 15.32518531015*std::exp(0.695119857788086*x_17) + 0.017441926315808*std::exp(0.7079998254776*x_17) - 0.00544668105441739*std::exp(0.857999861240387*x_17) + 2.77351199808138*std::exp(0.434639871120453*x_18) - 0.0111118069700756*std::exp(0.695919871330261*x_19) - 0.00128399136588831*std::exp(0.704799830913544*x_19) - 55.5121088553576*std::exp(0.716879844665527*x_19) + 2.07095203345966*std::exp(0.719519853591919*x_19) - 0.0147188008310047*std::exp(0.728719890117645*x_19) + 0.818678884679918*std::exp(0.748239874839783*x_19) - 1.5108240455517*std::exp(0.766079843044281*x_19) + 2.96255319623492*std::exp(0.823999881744385*x_19) + 0.000860464162216572*std::exp(1.00991988182068*x_19) + 5.67891411750729*std::exp(0.735999822616577*x_2) - 0.0164000853256405*std::exp(0.754559874534607*x_2) - 0.675035283279952*std::exp(0.755999863147736*x_2) + 11.7517758571227*std::exp(0.924879848957062*x_2) + 0.004966861254542*std::exp(1.01583981513977*x_2) - 0.00446002543526036*std::exp(1.11415982246399*x_2) - 0.0524767539773746*std::exp(0.26639986038208*x_20) - 0.491548250314594*std::exp(0.403999865055084*x_20) - 0.547114773510855*std::exp(0.516959846019745*x_20) - 0.262043041093175*std::exp(0.532159864902496*x_20) + 2.43207223772174*std::exp(0.886239886283875*x_20) - 0.298715500866084*std::exp(0.916319847106934*x_20) - 0.00045901776760107*std::exp(1.04447984695435*x_20) + 0.0264800103637993*std::exp(0.525999844074249*x_22) + 0.147929657417036*std::exp(0.651039838790894*x_22) - 8.01646990696248e-5*std::exp(1.28135991096497*x_22) - 0.017912792829371*std::exp(1.33199989795685*x_22) - 0.0946915342846879*std::exp(0.638159871101379*x_23) - 16.1035210825135*std::exp(0.658639848232269*x_23) + 0.0012147143574089*std::exp(0.673119843006134*x_23) - 0.0261038083640109*std::exp(0.69023984670639*x_23) + 0.00897344830405428*std::exp(0.733039855957031*x_23) + 0.639438109001054*std::exp(0.734799861907959*x_23) - 2.85877831213095*std::exp(0.736159861087799*x_23) + 0.051695087236717*std::exp(0.747999846935272*x_23) + 0.746786081825127*std::exp(0.818959891796112*x_23) - 0.921093227330406*std::exp(0.305759847164154*x_24) + 0.211427915294314*std::exp(0.42087984085083*x_24) - 3.41844550833048*std::exp(0.60511988401413*x_24) - 0.0264190993325277*std::exp(0.611999869346619*x_24) + 0.00902677641732859*std::exp(0.650239825248718*x_24) - 0.000473968232282687*std::exp(0.758959889411926*x_24) - 0.569310113013332*std::exp(0.766159892082214*x_24) - 0.0345233491119314*std::exp(0.412159860134125*x_25) + 0.0303666148797216*std::exp(0.525519847869873*x_25) - 46.0860067315941*std::exp(0.589919865131378*x_25) + 0.0240209494261051*std::exp(0.660079836845398*x_25) - 0.271787486089188*std::exp(0.767039835453033*x_25) - 0.0272616051687028*std::exp(0.949439823627472*x_25) + 0.245158320870411*std::exp(0.987279832363129*x_25) + 0.000959532995321043*std::exp(0.993919789791107*x_25) + 0.0545707622282661*std::exp(0.42087984085083*x_26) + 1.0300112065319*std::exp(0.573839843273163*x_26) - 0.113272180203708*std::exp(0.728879868984222*x_26) - 0.00739808773968449*std::exp(0.8193598985672*x_26) - 0.000981755670647697*std::exp(0.839599847793579*x_26) + 1.77275688401501*std::exp(0.860319912433624*x_26) - 7.00768324293338e-5*std::exp(0.960159838199615*x_26) + 0.0636477564412769*std::exp(1.13951992988586*x_26) + 8.57416473711561e-6*std::exp(1.18455982208252*x_27) - 0.00587170364176542*std::exp(1.20399987697601*x_27) - 0.078448898163057*std::exp(1.23751986026764*x_27) + 0.00763087252703013*std::exp(1.25919985771179*x_27) - 0.0057407880435594*std::exp(1.28719985485077*x_27) - 41.4794460397016*std::exp(0.516239881515503*x_28) + 1.08283862898935*std::exp(0.543999850749969*x_28) + 0.00395113524963831*std::exp(0.647999823093414*x_28) + 0.0124134498472811*std::exp(0.654319822788239*x_28) - 1.22313957559944*std::exp(0.736559867858887*x_28) - 0.163029564695692*std::exp(0.906079828739166*x_28) - 1.23647797054607*std::exp(0.932239830493927*x_29) + 0.000356984561806646*std::exp(1.12255990505219*x_29) - 0.130549456613664*std::exp(1.15015983581543*x_29) + 0.036082932985969*std::exp(1.15143990516663*x_29) - 0.0111698883812319*std::exp(1.16695988178253*x_29) + 9.44801657684907*std::exp(0.439999848604202*x_3) - 0.578385705696099*std::exp(0.526399850845337*x_3) + 0.0248736264176172*std::exp(0.633039832115173*x_3) - 0.0012753342700299*std::exp(0.658079862594604*x_3) - 0.00458777277815984*std::exp(0.925759851932526*x_3) + 0.156915129541527*std::exp(0.94135981798172*x_3) + 0.00869605351190381*std::exp(0.634159862995148*x_30) - 15.7652255608842*std::exp(0.828479886054993*x_30) + 0.394692610475567*std::exp(0.857279896736145*x_30) - 0.0881780545340221*std::exp(0.885519862174988*x_30) + 0.436158966275602*std::exp(0.91239982843399*x_30) + 1.29125133954414*std::exp(0.947999835014343*x_30) + 0.00155671273275259*std::exp(1.02791976928711*x_30) + 7.0404488259243e-5*std::exp(1.02927982807159*x_30) - 0.000887264857024898*std::exp(1.09479975700378*x_30) + 7.31896785761352*std::exp(0.826799869537354*x_32) + 0.000250006252177229*std::exp(0.831519842147827*x_32) + 0.0016040698426321*std::exp(0.832079887390137*x_32) + 5.837320972394*std::exp(0.333039849996567*x_33) - 0.176610081712577*std::exp(0.360239863395691*x_33) + 0.00519202599555557*std::exp(0.404719859361649*x_33) + 2.55007680863574*std::exp(0.417439848184586*x_33) + 14.7555341548675*std::exp(0.369439840316772*x_34) + 1.2865193817344*std::exp(0.426799863576889*x_36) + 3.30137662087753*std::exp(0.261359840631485*x_37) + 0.0360156491960224*std::exp(0.355199843645096*x_4) + 0.41852676797302*std::exp(0.535359859466553*x_4) + 0.00137075507595628*std::exp(0.541439831256866*x_4) - 0.021266883616519*std::exp(0.586239874362946*x_4) - 3.56093794906681*std::exp(0.747519850730896*x_4) + 0.051230301822654*std::exp(1.09559988975525*x_4) - 0.485011398296053*std::exp(1.10943984985352*x_4) - 0.000729967406357273*std::exp(1.15591979026794*x_4) + 9.77736892261005*std::exp(0.715999841690063*x_41) - 0.282665254780399*std::exp(0.747999846935272*x_41) - 0.0115288635432619*std::exp(0.770959854125977*x_41) + 0.00650346516170897*std::exp(0.788479864597321*x_41) + 0.000502502958878913*std::exp(0.796479880809784*x_41) - 0.0175759806327755*std::exp(0.802159905433655*x_41) + 0.209796299856607*std::exp(0.802399873733521*x_41) - 0.0424727780050317*std::exp(0.806319832801819*x_41) + 0.55465706667217*std::exp(0.812319874763489*x_41) + 0.0433344269640218*std::exp(0.585839867591858*x_42) - 0.222857005281797*std::exp(0.693759858608246*x_42) - 1.05471059931075*std::exp(0.720399856567383*x_42) - 0.024959239055221*std::exp(0.851439893245697*x_42) - 0.00205451318084251*std::exp(0.704879820346832*x_43) + 0.00552488385417947*std::exp(0.761919856071472*x_43) - 5.62813319278433e-5*std::exp(0.818479895591736*x_43) - 0.0295874851043818*std::exp(0.875679850578308*x_44) - 0.000238939299341098*std::exp(0.960559844970703*x_44) + 7.1668997950684e-6*std::exp(0.99999988079071*x_44) + 0.158094069712132*std::exp(0.555919826030731*x_45) - 0.550701617141742*std::exp(0.518719851970673*x_46) - 0.94967364726314*std::exp(0.702239871025085*x_46) + 6.23004462686278e-5*std::exp(0.715279817581177*x_46) + 0.0051607912285561*std::exp(0.752959847450256*x_46) + 0.0256429996699486*std::exp(0.756079852581024*x_46) + 0.00639286026053361*std::exp(0.795919895172119*x_46) + 0.0302423605254391*std::exp(0.406479865312576*x_47) - 0.0611648521856029*std::exp(0.552319884300232*x_47) - 0.000603928661783693*std::exp(0.586239874362946*x_48) - 0.640955986303726*std::exp(0.600879848003387*x_48) - 0.00409070959511336*std::exp(0.65559983253479*x_49) - 0.00961706571237954*std::exp(0.684479832649231*x_49) + 41.5514185871252*std::exp(0.703759849071503*x_49) + 0.222289512628655*std::exp(0.7079998254776*x_49) - 0.869963216937391*std::exp(0.708239853382111*x_49) + 0.00159333306121845*std::exp(0.709119856357574*x_49) + 0.052786244488874*std::exp(0.714559853076935*x_49) - 0.649520093826996*std::exp(0.71919983625412*x_49) - 4.16391635756311*std::exp(0.719519853591919*x_49) - 1.61229839343152*std::exp(0.722239851951599*x_49) - 4.14493068233347e-5*std::exp(2.06119966506958*x_5) + 0.00289912704763311*std::exp(0.325439840555191*x_50) - 1.73321563836438*std::exp(0.535359859466553*x_50) - 0.689710120165419*std::exp(0.535439848899841*x_50) + 0.781770027102976*std::exp(0.538639843463898*x_50) + 0.0937412415360542*std::exp(0.539039850234985*x_50) + 40.1315988883001*std::exp(0.550159871578217*x_50) + 0.0175897369572912*std::exp(0.591119825839996*x_50) - 0.25873738607391*std::exp(0.592239856719971*x_50) + 0.00396601978717293*std::exp(0.642959833145142*x_50) + 0.0111562499145683*std::exp(0.460479855537415*x_51) + 0.00732584321772194*std::exp(0.483199834823608*x_51) + 6.54007478657449*std::exp(0.488399863243103*x_51) - 1.12370285335919*std::exp(0.493759840726852*x_51) - 9.96267246839561*std::exp(0.494479864835739*x_51) + 0.339511763467356*std::exp(0.495999842882156*x_51) - 187.04418997425*std::exp(0.49703985452652*x_51) + 0.153906246701182*std::exp(0.498159825801849*x_51) + 20.1465411062461*std::exp(0.499919831752777*x_51) + 4.8187350951918*std::exp(0.50631982088089*x_51) + 1.11932240651568*std::exp(0.521999835968018*x_52) + 0.0317148415666763*std::exp(0.526719868183136*x_52) - 0.00101911198155797*std::exp(0.590079843997955*x_52) + 0.0127856052878295*std::exp(0.628719866275787*x_52) + 0.00202809805603691*std::exp(0.705759823322296*x_52) - 0.0793684120068228*std::exp(0.709279835224152*x_52) + 0.0581405031974139*std::exp(0.720719873905182*x_52) - 0.0595520384201974*std::exp(0.887439906597137*x_52) - 12.1567682675369*std::exp(0.48039984703064*x_54) + 0.0631456543968774*std::exp(0.49823984503746*x_54) + 0.00214500195129166*std::exp(0.512639820575714*x_54) + 5.23236479636909*std::exp(0.519359886646271*x_54) + 0.0332694978841536*std::exp(0.533919811248779*x_54) - 0.528608721554046*std::exp(0.535759806632996*x_54) + 0.103428116588985*std::exp(0.538879811763763*x_54) - 0.00207183594556939*std::exp(0.629039824008942*x_55) + 0.439703250531069*std::exp(0.631839871406555*x_55) - 0.154194051354286*std::exp(0.651679813861847*x_55) + 9.31864943858215*std::exp(0.653599858283997*x_55) + 3.76965792993642*std::exp(0.653759837150574*x_55) + 0.321867252974166*std::exp(0.655519843101501*x_55) + 337.192819673192*std::exp(0.655839860439301*x_55) + 0.770765870388059*std::exp(0.656479835510254*x_55) - 0.0806077162005284*std::exp(0.657599866390228*x_55) - 34.4369828002473*std::exp(0.658879816532135*x_55) - 22.8028556475421*std::exp(0.342799842357635*x_56) + 67.9891952922254*std::exp(0.434559851884842*x_56) + 4.36359063228463*std::exp(0.468159854412079*x_56) + 0.128703766339351*std::exp(0.510159850120544*x_56) - 0.818011256816004*std::exp(0.52839982509613*x_56) + 1.8411422741846*std::exp(0.568239867687225*x_56) - 0.0193961555719409*std::exp(0.658959865570068*x_56) - 0.00602683038903651*std::exp(0.678959846496582*x_56) + 0.000192163338974315*std::exp(0.747119843959808*x_56) + 0.00179491775554732*std::exp(0.824879884719849*x_56) + 1.82452361943335*std::exp(0.610959827899933*x_57) - 0.0432283903611603*std::exp(0.616639852523804*x_57) - 0.043308885014801*std::exp(0.626079857349396*x_57) + 15.4342130439166*std::exp(0.627359867095947*x_57) - 0.038348732130563*std::exp(0.628399848937988*x_57) - 198.459807204442*std::exp(0.632639825344086*x_57) + 0.00605985830591623*std::exp(0.636399865150452*x_57) + 0.684756148688977*std::exp(0.641759812831879*x_57) - 0.249097492300558*std::exp(0.643279850482941*x_57) + 0.819470450497297*std::exp(0.663679838180542*x_57) + 0.112735965446264*std::exp(0.437759846448898*x_58) + 0.0316484338221381*std::exp(0.485119849443436*x_58) + 0.010147003679039*std::exp(0.554479837417603*x_58) + 0.383267293079079*std::exp(0.566799819469452*x_58) + 0.00109864016237469*std::exp(0.60647988319397*x_58) - 0.0143415554325035*std::exp(0.655439853668213*x_58) + 0.0731955641987036*std::exp(0.522799849510193*x_59) + 2.12547980273587*std::exp(0.691839873790741*x_59) - 0.0627011434871268*std::exp(0.765759825706482*x_59) + 0.0826631208900425*std::exp(0.827119886875153*x_59) - 0.047844335042396*std::exp(0.860399901866913*x_59) + 0.00627805462730148*std::exp(0.780719876289368*x_60) - 1.31072660327557*std::exp(0.787359893321991*x_60) - 17.1820311601824*std::exp(0.816559851169586*x_60) - 0.000322758577597545*std::exp(0.838639855384827*x_60) + 0.338622170749403*std::exp(0.847519874572754*x_60) - 0.012322084903814*std::exp(0.854399859905243*x_60) - 0.00323738136618263*std::exp(0.860399901866913*x_60) + 0.00575341547616937*std::exp(0.872479856014252*x_60) + 0.00371909173031407*std::exp(1.03615987300873*x_60) - 0.0570049845030409*std::exp(0.983999848365784*x_61) + 0.00456077212906513*std::exp(1.18831992149353*x_61) + 1.68040682495872*std::exp(1.23887979984283*x_61) - 0.148299677890129*std::exp(1.32615983486176*x_61) - 0.0301160016865951*std::exp(0.599199831485748*x_66) - 12.7793001011105*std::exp(0.949999809265137*x_66) + 0.0111420601229639*std::exp(1.11047983169556*x_66) + 0.000538967206693762*std::exp(1.5058399438858*x_66) - 1.67377020828954e-6*std::exp(1.78991985321045*x_7) + 0.0857986953613589*std::exp(0.455999851226807*x_8) + 0.0162042277715719*std::exp(0.519439876079559*x_8) - 0.00647905858343765*std::exp(0.636319875717163*x_8) - 0.0768869739459333*std::exp(0.878639876842499*x_8) - 0.201745667169134*std::exp(0.925199866294861*x_8) + 0.00691422100750289*std::exp(1.39863991737366*x_8) + 0.176487037981984*std::log(9.29800033569336 - 1.38431990146637*x_5) + 8.92397013222987*std::log(9.35847949981689 - 1.21983981132507*x_21) + 0.149993751156126*std::sin(0.170640021562576*x_1 + 4.96303987503052) + 0.95669934548307*std::sin(0.208320006728172*x_101 - 7.40863990783691) - 5.69843484988441*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.187562750255317*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 11.0468779795831*std::sin(0.30583992600441*x_113 - 1.2235199213028) + 3.75128726590615*std::sin(0.319439828395844*x_113 + 5.03800010681152) + 3.29867186925831*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 25.202256687781*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.00786321619827463*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.188997357210021*std::sin(0.267359972000122*x_117 + 1.94591987133026) - 10.1162591547183*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 58.4598551439296*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.265408842049685*std::sin(0.270399957895279*x_120 - 7.43680000305176) + 234.085274885198*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 1.02924358141903*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 33.2878354990453*std::sin(0.401599854230881*x_21 - 7.40983963012695) + 4.62337780989261*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 0.844620745645602*std::sin(0.0904000774025917*x_3 + 1.69007980823517) - 0.271728810690836*std::sin(0.602719843387604*x_3 + 2.19079995155334) + 1.08976824544262*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0024608440060056*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 59.513365028023*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.170599938057921*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.138105039300137*std::sin(0.299839943647385*x_42 - 4.29496002197266) + 0.365740675626102*std::sin(0.198640003800392*x_47 + 8.2055196762085) + 4.44886178011772*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.00224498790812841*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.0030930575065643*std::sin(0.600559830665588*x_64 - 7.19495964050293) - 0.745931105283455*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 23.3481255757209*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.0754674167344278*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 10.105142910723*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.0836455358465758*std::sin(0.397599816322327*x_73 + 2.00783967971802) - 9.20637490386778*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 31.9376674136788*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.115319468754228*std::sin(0.329519838094711*x_9 - 4.33071994781494) + 0.157408248262804*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 9.0569982718959*std::sin(0.359999865293503*x_91 - 7.40607976913452) - 165.627951547489*std::sin(0.364799857139587*x_91 + 2.00895977020264) + 0.145739847229925*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 33.5634278713326*std::sin(0.383119851350784*x_91 + 8.20567989349365) + 5.09635571589528*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 12.1129303767298*std::sin(0.299039930105209*x_92 - 1.17503976821899) + 7.10844701921071*std::sin(0.306799918413162*x_92 + 8.20695972442627) + 7.98007701872833*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 5.46780952518807*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.00244192378504852*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.161597867666254*std::sin(0.301119923591614*x_97 - 7.45264005661011) - 9.79262463801672*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 42.0862554129098*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.143833097246693*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 9.20099641636754*std::sin(0.266639977693558*x_98 + 1.94559979438782) - 0.107207329775493*std::sin(0.279279947280884*x_98 + 1.9366397857666) + 4443.05376991744);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.37340827954396*x_1 - 21.6020767926438*x_10 + 33.7090041595734*x_100 + 64.6242120401992*x_101 + 73.8779466886012*x_102 - 16.2941602190787*x_103 + 319.593854887417*x_104 + 101.644011879485*x_105 + 67.8691259597996*x_106 + 27.512894437644*x_107 + 61.7058633364662*x_108 - 48.3476237467003*x_109 + 85.9695123410584*x_110 + 85.7956271094316*x_111 + 30.8427272360156*x_112 - 46.3227551165252*x_113 - 136.792161007576*x_114 - 41.2223705504569*x_115 - 4.93273332319189*x_116 + 114.853206221408*x_117 + 111.403847233318*x_118 + 61.0287678170222*x_119 + 6.64381550103499*x_12 + 3.86126942965438*x_120 - 35.2282606347922*x_13 + 2.38988624990991*x_14 - 0.0208433181026756*x_15 + 49.5264366358107*x_16 + 3.79373158219228*x_17 - 254.455379353571*x_18 + 0.0574820375547195*x_19 - 1.23038684602124*x_2 - 0.111722346362082*x_20 - 18.6372747202714*x_21 + 61.4609935234885*x_22 - 0.0632049675305541*x_23 + 22.1405815086071*x_24 - 0.219256669785298*x_25 - 0.264040654136768*x_26 - 191.145346960233*x_27 - 1.08345200504406*x_28 + 2.74073159012298*x_29 - 1.22979838332047*x_3 - 0.0478343809464506*x_30 + 13.3944904190211*x_31 - 10.8645806481679*x_32 - 212.656649082493*x_33 + 282.580238033964*x_34 + 27.4854793274594*x_35 - 421.763826418999*x_36 + 1141.9234367691*x_37 + 35.8570370994237*x_38 + 215.620959478011*x_39 + 4.08899495341232*x_4 + 8522.0060664352*x_40 - 4.41931813819284*x_41 + 85.3511384345271*x_42 - 64.8120490382454*x_43 + 175.648355607085*x_44 - 85.7842934192483*x_45 + 773.827636658214*x_46 - 225.129580988768*x_47 + 576.200732791256*x_48 - 160.447130395759*x_5 + 0.184851358974211*x_50 + 18.9630384262577*x_52 - 25.3660272768234*x_53 - 151.7956647639*x_54 + 85.8896234720896*x_58 + 129.51536898502*x_59 - 9.26130233833568*x_6 + 2.71210727563048*x_60 - 77.3397793818137*x_61 - 64.7415335667033*x_62 - 32.0328104222665*x_63 - 88.4632592999754*x_64 + 15.175696602031*x_65 + 2.16637737946756*x_66 - 44.8538021066643*x_67 - 39.8189344271482*x_68 - 65.9240943674599*x_69 - 128.715683320348*x_7 + 31.8595050085073*x_70 + 44.8628059802453*x_71 + 25.9096496361497*x_72 - 63.7365943693443*x_73 + 59.9843883340332*x_74 + 26.9380393752337*x_75 + 8.07646879766427*x_76 + 26.0792295701788*x_77 + 25.904864802236*x_78 + 87.5855199363519*x_79 + 3.74340959649483*x_8 + 19.4601896881374*x_80 - 4.15310439484382*x_81 + 43.1735125193899*x_82 - 48.5639156780015*x_83 - 38.1452506618175*x_84 + 43.0847710487379*x_85 - 1078.5902776762*x_86 - 162.513830888376*x_87 - 113.036746813146*x_88 - 16.6359524280595*x_89 + 5.24465709899542*x_9 + 29.4787336271511*x_90 + 2.46782853923049*x_91 + 83.574594905654*x_92 + 74.9402809841265*x_93 - 30.1389076078847*x_94 + 28.3695487000066*x_95 + 123.245269217624*x_96 + 48.2608355740397*x_97 + 121.21860930318*x_98 + 175.636264739344*x_99 - 0.0236672206861578*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 0.000131745754810451*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.0376859509377232*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.0119769747877085*std::exp(1.13951992988586*x_1) - 0.416159393104381*std::exp(1.17007982730865*x_1) + 0.168380212969972*std::exp(1.22071981430054*x_1) - 0.000276485560526122*std::exp(1.40399980545044*x_1) + 2.11459075149078*std::exp(1.6639997959137*x_1) - 0.0155564914488546*std::exp(1.76023995876312*x_1) - 0.00225733829707348*std::exp(0.627359867095947*x_10) - 0.00121878492774942*std::exp(0.778879821300507*x_10) - 1.32663863495194*std::exp(0.80351984500885*x_10) - 0.00407522387931286*std::exp(0.810399830341339*x_10) - 0.132656832508547*std::exp(0.840799868106842*x_10) - 0.00159734166865796*std::exp(0.934159815311432*x_10) + 0.352489681666667*std::exp(0.94543981552124*x_10) - 0.0331777178474289*std::exp(0.969839811325073*x_10) - 0.590047512012071*std::exp(0.82207989692688*x_11) + 0.000371404790250895*std::exp(0.895919859409332*x_11) - 0.014007952289176*std::exp(0.902079820632935*x_11) + 8.49168483284214*std::exp(0.914159834384918*x_11) - 1.59330373908633*std::exp(0.925199866294861*x_11) - 0.00766040437803423*std::exp(0.933279812335968*x_11) - 0.00969688920686759*std::exp(0.937199831008911*x_11) + 0.000614532293392841*std::exp(0.951599836349487*x_11) + 0.0393925542108424*std::exp(0.983759820461273*x_11) + 0.0214277632694596*std::exp(1.06111979484558*x_11) + 0.0023994400567019*std::exp(0.537679851055145*x_12) - 0.0145256609257795*std::exp(0.696079850196838*x_12) + 0.00545279946101153*std::exp(0.854959905147552*x_12) + 0.00130527371520851*std::exp(0.925439834594727*x_12) - 0.475193940320495*std::exp(1.2235199213028*x_12) - 3.09719346258517e-5*std::exp(1.10399985313416*x_13) - 5.10387008467505e-5*std::exp(1.32895994186401*x_13) - 3.09082387606434e-5*std::exp(1.4015998840332*x_13) - 162.429639874766*std::exp(0.345279842615128*x_14) - 0.00291911284231845*std::exp(0.428239852190018*x_14) + 0.0109193454274663*std::exp(0.715599834918976*x_14) + 0.00232047233393288*std::exp(0.868079900741577*x_14) - 0.0300488831890338*std::exp(0.67935985326767*x_15) - 0.582969610089039*std::exp(0.82151985168457*x_15) - 0.032982703437879*std::exp(0.898239850997925*x_15) + 13.4316311532521*std::exp(0.92087984085083*x_15) + 0.00658136383569675*std::exp(0.927359819412231*x_15) - 8.78475953802589e-5*std::exp(0.993359804153442*x_15) + 0.00182025544613739*std::exp(1.03111982345581*x_15) + 6.43514601925632e-5*std::exp(1.05295991897583*x_15) - 0.550445584747064*std::exp(0.357999831438065*x_16) + 0.079430782395402*std::exp(0.539119839668274*x_16) - 3.20099097126239*std::exp(0.590719819068909*x_16) - 0.00136651161637623*std::exp(0.703679859638214*x_16) + 0.00348437990829927*std::exp(0.912239849567413*x_16) - 0.00787362174462889*std::exp(0.620319843292236*x_17) - 0.12480714575316*std::exp(0.655279815196991*x_17) - 0.602015059390845*std::exp(0.659599840641022*x_17) - 39.7158495988044*std::exp(0.695119857788086*x_17) + 0.0541217424925491*std::exp(0.7079998254776*x_17) + 0.00820646347335567*std::exp(0.857999861240387*x_17) + 7.23024634265136*std::exp(0.434639871120453*x_18) + 0.00121020330197462*std::exp(0.695919871330261*x_19) + 0.00316284411516314*std::exp(0.704799830913544*x_19) + 143.86191889971*std::exp(0.716879844665527*x_19) + 5.39874836528064*std::exp(0.719519853591919*x_19) - 0.0456719707417163*std::exp(0.728719890117645*x_19) - 5.54002477878707*std::exp(0.748239874839783*x_19) + 1.54381120324481*std::exp(0.766079843044281*x_19) + 0.280104194499105*std::exp(0.823999881744385*x_19) - 0.00129645331658165*std::exp(1.00991988182068*x_19) + 0.536931342375746*std::exp(0.735999822616577*x_2) - 0.0508889430432747*std::exp(0.754559874534607*x_2) + 0.689773925680787*std::exp(0.755999863147736*x_2) - 30.4552116672432*std::exp(0.924879848957062*x_2) - 0.000540948192034302*std::exp(1.01583981513977*x_2) + 0.0067198786672146*std::exp(1.11415982246399*x_2) + 0.00571532074948353*std::exp(0.26639986038208*x_20) + 0.502280658032516*std::exp(0.403999865055084*x_20) - 1.42626914645542*std::exp(0.516959846019745*x_20) + 1.77325318623858*std::exp(0.532159864902496*x_20) - 6.30281548000665*std::exp(0.886239886283875*x_20) - 0.0282430252597079*std::exp(0.916319847106934*x_20) + 0.000691597783274713*std::exp(1.04447984695435*x_20) + 0.0821666297724629*std::exp(0.525999844074249*x_22) - 1.00104446681592*std::exp(0.651039838790894*x_22) + 8.73085572644733e-6*std::exp(1.28135991096497*x_22) - 0.00169362305901441*std::exp(1.33199989795685*x_22) + 0.104152201127139*std::exp(0.638159871101379*x_23) + 41.7329388441841*std::exp(0.658639848232269*x_23) - 0.00299219469772441*std::exp(0.673119843006134*x_23) + 0.0028430043071585*std::exp(0.69023984670639*x_23) - 0.0135202107488087*std::exp(0.733039855957031*x_23) - 0.653399526810565*std::exp(0.734799861907959*x_23) - 0.270292461714654*std::exp(0.736159861087799*x_23) - 0.349822219178089*std::exp(0.747999846935272*x_23) + 1.94679069014096*std::exp(0.818959891796112*x_23) + 6.23306573367712*std::exp(0.305759847164154*x_24) - 0.232551757915553*std::exp(0.42087984085083*x_24) - 0.323208010835686*std::exp(0.60511988401413*x_24) - 0.0819776247801388*std::exp(0.611999869346619*x_24) - 0.000983119546249948*std::exp(0.650239825248718*x_24) + 0.00116752158470509*std::exp(0.758959889411926*x_24) - 1.48413000026557*std::exp(0.766159892082214*x_24) + 0.0037599889201637*std::exp(0.412159860134125*x_25) - 0.0457530950188069*std::exp(0.525519847869873*x_25) + 119.433786601537*std::exp(0.589919865131378*x_25) - 0.0264208915273335*std::exp(0.660079836845398*x_25) - 0.708520633274399*std::exp(0.767039835453033*x_25) + 0.184480106877524*std::exp(0.949439823627472*x_25) + 0.0231792880814534*std::exp(0.987279832363129*x_25) + 0.00297740035966113*std::exp(0.993919789791107*x_25) - 0.0059433822795673*std::exp(0.42087984085083*x_26) + 2.68512801245098*std::exp(0.573839843273163*x_26) + 0.115745351902042*std::exp(0.728879868984222*x_26) + 0.0111466297001478*std::exp(0.8193598985672*x_26) - 0.00304635661424837*std::exp(0.839599847793579*x_26) - 4.59417255686653*std::exp(0.860319912433624*x_26) + 0.000172619616413894*std::exp(0.960159838199615*x_26) + 0.00601778343501697*std::exp(1.13951992988586*x_26) - 2.11206610898538e-5*std::exp(1.18455982208252*x_27) + 0.0397339961709075*std::exp(1.20399987697601*x_27) - 0.00741720535423019*std::exp(1.23751986026764*x_27) - 0.00779748411633221*std::exp(1.25919985771179*x_27) - 0.0149656146375409*std::exp(1.28719985485077*x_27) + 107.495694636947*std::exp(0.516239881515503*x_28) - 1.10648120253446*std::exp(0.543999850749969*x_28) + 0.012260246985469*std::exp(0.647999823093414*x_28) - 0.00135196714940538*std::exp(0.654319822788239*x_28) - 0.115645695752797*std::exp(0.736559867858887*x_28) - 0.425000474020117*std::exp(0.906079828739166*x_28) + 3.20438364147661*std::exp(0.932239830493927*x_29) + 0.00110771173883495*std::exp(1.12255990505219*x_29) - 0.0123432215271407*std::exp(1.15015983581543*x_29) - 0.036870763576793*std::exp(1.15143990516663*x_29) + 0.0755869725802254*std::exp(1.16695988178253*x_29) - 24.4849245068916*std::exp(0.439999848604202*x_3) + 3.91395356740564*std::exp(0.526399850845337*x_3) - 0.0374768606067947*std::exp(0.633039832115173*x_3) + 0.00314151917060541*std::exp(0.658079862594604*x_3) + 0.000499661106406041*std::exp(0.925759851932526*x_3) - 0.160341196354444*std::exp(0.94135981798172*x_3) - 0.013102262606309*std::exp(0.634159862995148*x_30) + 40.8562320517333*std::exp(0.828479886054993*x_30) - 0.403310283341178*std::exp(0.857279896736145*x_30) + 0.596703562538704*std::exp(0.885519862174988*x_30) + 1.13701933610177*std::exp(0.91239982843399*x_30) + 0.122085543246468*std::exp(0.947999835014343*x_30) - 0.000169543881969568*std::exp(1.02791976928711*x_30) - 0.00017342672800433*std::exp(1.02927982807159*x_30) - 0.00275315462553399*std::exp(1.09479975700378*x_30) - 18.9674069689025*std::exp(0.826799869537354*x_32) - 0.000615838100208475*std::exp(0.831519842147827*x_32) - 0.000174701614721992*std::exp(0.832079887390137*x_32) + 0.55190843191715*std::exp(0.333039849996567*x_33) + 0.194255261471491*std::exp(0.360239863395691*x_33) - 0.0127894698532151*std::exp(0.404719859361649*x_33) - 2.60575489111245*std::exp(0.417439848184586*x_33) + 1.39510980397108*std::exp(0.369439840316772*x_34) - 1.31460909730748*std::exp(0.426799863576889*x_36) - 3.37345849667099*std::exp(0.261359840631485*x_37) + 0.111755413719554*std::exp(0.355199843645096*x_4) - 2.83218329988165*std::exp(0.535359859466553*x_4) - 0.00337656836369682*std::exp(0.541439831256866*x_4) + 0.0233916659657854*std::exp(0.586239874362946*x_4) - 0.33668042050765*std::exp(0.747519850730896*x_4) - 0.0523488583149637*std::exp(1.09559988975525*x_4) + 1.25692703602572*std::exp(1.10943984985352*x_4) + 7.95018279103002e-5*std::exp(1.15591979026794*x_4) - 25.3384546903468*std::exp(0.715999841690063*x_41) - 0.736877801857135*std::exp(0.747999846935272*x_41) - 0.0357736968166552*std::exp(0.770959854125977*x_41) - 0.00979871021757755*std::exp(0.788479864597321*x_41) - 0.00123781091412766*std::exp(0.796479880809784*x_41) + 0.00191422599893149*std::exp(0.802159905433655*x_41) - 0.214376968033803*std::exp(0.802399873733521*x_41) + 0.0467162492468315*std::exp(0.806319832801819*x_41) + 0.0524418501854725*std::exp(0.812319874763489*x_41) - 0.0476639858777315*std::exp(0.585839867591858*x_42) - 0.580964152485224*std::exp(0.693759858608246*x_42) - 0.0997210322586148*std::exp(0.720399856567383*x_42) + 0.025504196197675*std::exp(0.851439893245697*x_42) + 0.00309551582067353*std::exp(0.704879820346832*x_43) - 0.00607687708021044*std::exp(0.761919856071472*x_43) + 0.000138637286987027*std::exp(0.818479895591736*x_43) - 0.00279744468148276*std::exp(0.875679850578308*x_44) + 0.000360007610653395*std::exp(0.960559844970703*x_44) - 1.76541583090114e-5*std::exp(0.99999988079071*x_44) - 1.06982735230424*std::exp(0.555919826030731*x_45) - 1.43561966055517*std::exp(0.518719851970673*x_46) - 0.0897899731696752*std::exp(0.702239871025085*x_46) - 0.000153464115949443*std::exp(0.715279817581177*x_46) + 0.0160137710062778*std::exp(0.752959847450256*x_46) - 0.0282050014217535*std::exp(0.756079852581024*x_46) - 0.00069625584904374*std::exp(0.795919895172119*x_46) + 0.0938410826355346*std::exp(0.406479865312576*x_47) + 0.0672758555964886*std::exp(0.552319884300232*x_47) + 0.00148765191468356*std::exp(0.586239874362946*x_48) - 1.67090305683871*std::exp(0.600879848003387*x_48) + 0.000445525221303568*std::exp(0.65559983253479*x_49) - 0.0298414489658516*std::exp(0.684479832649231*x_49) - 107.682214461071*std::exp(0.703759849071503*x_49) - 0.24449854152904*std::exp(0.7079998254776*x_49) + 0.888957893325296*std::exp(0.708239853382111*x_49) - 0.0039248426664327*std::exp(0.709119856357574*x_49) - 0.0795325415543178*std::exp(0.714559853076935*x_49) + 4.39532212380013*std::exp(0.71919983625412*x_49) - 0.39369096858046*std::exp(0.719519853591919*x_49) - 4.20308784329581*std::exp(0.722239851951599*x_49) + 0.000280488713171834*std::exp(2.06119966506958*x_5) - 0.00714139297609133*std::exp(0.325439840555191*x_50) - 0.163872490422889*std::exp(0.535359859466553*x_50) + 0.7047691712597*std::exp(0.535439848899841*x_50) + 2.03799005851277*std::exp(0.538639843463898*x_50) - 0.103106964272197*std::exp(0.539039850234985*x_50) - 104.002693171458*std::exp(0.550159871578217*x_50) - 0.0265022923875584*std::exp(0.591119825839996*x_50) + 1.75088371872261*std::exp(0.592239856719971*x_50) - 0.000431945070235568*std::exp(0.642959833145142*x_50) + 0.0346174885804646*std::exp(0.460479855537415*x_51) - 0.0180456821792953*std::exp(0.483199834823608*x_51) - 6.68287002401109*std::exp(0.488399863243103*x_51) + 1.2359724285208*std::exp(0.493759840726852*x_51) + 67.4177059781267*std::exp(0.494479864835739*x_51) - 0.511539203017912*std::exp(0.495999842882156*x_51) + 484.732730274226*std::exp(0.49703985452652*x_51) - 0.0167621565469855*std::exp(0.498159825801849*x_51) + 1.90482003012805*std::exp(0.499919831752777*x_51) + 12.5619221486397*std::exp(0.50631982088089*x_51) - 1.14376156264499*std::exp(0.521999835968018*x_52) - 0.0348834833284768*std::exp(0.526719868183136*x_52) + 0.00251036916539769*std::exp(0.590079843997955*x_52) - 0.00139249914786544*std::exp(0.628719866275787*x_52) + 0.00629312374969657*std::exp(0.705759823322296*x_52) - 0.206904881259338*std::exp(0.709279835224152*x_52) - 0.393438543966789*std::exp(0.720719873905182*x_52) - 0.00563054049921149*std::exp(0.887439906597137*x_52) - 1.14940105974073*std::exp(0.48039984703064*x_54) - 0.00687728644515228*std::exp(0.49823984503746*x_54) - 0.00528376356640271*std::exp(0.512639820575714*x_54) - 5.34660764493501*std::exp(0.519359886646271*x_54) + 0.103234193559839*std::exp(0.533919811248779*x_54) + 3.57711120989439*std::exp(0.535759806632996*x_54) - 0.155834177258663*std::exp(0.538879811763763*x_54) + 0.00510353441784565*std::exp(0.629039824008942*x_55) - 2.97548519796958*std::exp(0.631839871406555*x_55) + 0.016793501776654*std::exp(0.651679813861847*x_55) + 24.2927130181399*std::exp(0.653599858283997*x_55) - 3.85196420574002*std::exp(0.653759837150574*x_55) + 0.998743846685318*std::exp(0.655519843101501*x_55) - 873.849094866582*std::exp(0.655839860439301*x_55) - 0.847773378697617*std::exp(0.656479835510254*x_55) + 0.121450893133124*std::exp(0.657599866390228*x_55) - 3.25595615987647*std::exp(0.658879816532135*x_55) - 2.15596989838074*std::exp(0.342799842357635*x_56) - 176.196802839399*std::exp(0.434559851884842*x_56) - 4.45886476610529*std::exp(0.468159854412079*x_56) - 0.141562608092242*std::exp(0.510159850120544*x_56) + 5.53550692083531*std::exp(0.52839982509613*x_56) + 4.79965913377435*std::exp(0.568239867687225*x_56) - 0.0601856537060699*std::exp(0.658959865570068*x_56) + 0.00908056905730245*std::exp(0.678959846496582*x_56) - 0.000473354184437625*std::exp(0.747119843959808*x_56) - 0.000195487142675002*std::exp(0.824879884719849*x_56) - 1.8643600573867*std::exp(0.610959827899933*x_57) + 0.00470806781426372*std::exp(0.616639852523804*x_57) - 0.134386092451618*std::exp(0.626079857349396*x_57) + 1.45927769934667*std::exp(0.627359867095947*x_57) + 0.0577796765286506*std::exp(0.628399848937988*x_57) + 514.316772999737*std::exp(0.632639825344086*x_57) - 0.0149271931967624*std::exp(0.636399865150452*x_57) - 4.6337655729901*std::exp(0.641759812831879*x_57) + 0.273984916543366*std::exp(0.643279850482941*x_57) + 2.13627099205543*std::exp(0.663679838180542*x_57) - 0.12399945819993*std::exp(0.437759846448898*x_58) - 0.00344687765158472*std::exp(0.485119849443436*x_58) - 0.0152883956714344*std::exp(0.554479837417603*x_58) - 0.39163550688441*std::exp(0.566799819469452*x_58) - 0.00270627020131452*std::exp(0.60647988319397*x_58) - 0.044501390271159*std::exp(0.655439853668213*x_58) - 0.0805085605764708*std::exp(0.522799849510193*x_59) + 0.20096037729418*std::exp(0.691839873790741*x_59) + 0.424300534772894*std::exp(0.765759825706482*x_59) - 0.0844679779230194*std::exp(0.827119886875153*x_59) - 0.124725016043259*std::exp(0.860399901866913*x_59) + 0.0194806037900193*std::exp(0.780719876289368*x_60) - 0.123926895181374*std::exp(0.787359893321991*x_60) + 44.5279421781486*std::exp(0.816559851169586*x_60) + 0.000795048233884792*std::exp(0.838639855384827*x_60) - 0.34601560811081*std::exp(0.847519874572754*x_60) + 0.0135531890459107*std::exp(0.854399859905243*x_60) + 0.000352587984083626*std::exp(0.860399901866913*x_60) - 0.00866861736174738*std::exp(0.872479856014252*x_60) - 0.0251672062466563*std::exp(1.03615987300873*x_60) + 0.38575445461097*std::exp(0.983999848365784*x_61) - 0.000496720425850856*std::exp(1.18831992149353*x_61) + 0.158879509989578*std::exp(1.23887979984283*x_61) + 0.151537635926872*std::exp(1.32615983486176*x_61) + 0.00327997820530379*std::exp(0.599199831485748*x_66) + 33.1180831110433*std::exp(0.949999809265137*x_66) - 0.0122552675449178*std::exp(1.11047983169556*x_66) + 0.00167239809665811*std::exp(1.5058399438858*x_66) - 5.19365571007174e-6*std::exp(1.78991985321045*x_7) - 0.0943708753187597*std::exp(0.455999851226807*x_8) + 0.0502812032836522*std::exp(0.519439876079559*x_8) + 0.00976193705405061*std::exp(0.636319875717163*x_8) + 0.0785657152537435*std::exp(0.878639876842499*x_8) + 0.522832214576421*std::exp(0.925199866294861*x_8) + 0.000653727436306198*std::exp(1.39863991737366*x_8) - 0.265911371760102*std::log(9.29800033569336 - 1.38431990146637*x_5) + 23.2638266771947*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.225994183943641*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 6.47401341235006*std::sin(0.208320006728172*x_101 - 7.40863990783691) + 5.82285381816236*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.582001247265462*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 28.7980182399965*std::sin(0.30583992600441*x_113 - 1.2235199213028) - 3.83319243875335*std::sin(0.319439828395844*x_113 + 5.03800010681152) - 3.37069468981735*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 2.38282904693901*std::sin(0.237999975681305*x_117 + 1.98111975193024) + 0.019369388096907*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.586452787007959*std::sin(0.267359972000122*x_117 + 1.94591987133026) + 10.3371363885588*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 5.52727649124931*std::sin(0.265119940042496*x_120 + 5.15704011917114) - 0.0289060688227205*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 606.641641356066*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 3.19371009067866*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 3.14730630353867*std::sin(0.401599854230881*x_21 - 7.40983963012695) - 4.72432410694077*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 2.62083130452546*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.298877338474878*std::sin(0.602719843387604*x_3 + 2.19079995155334) - 1.11356211943292*std::sin(0.262639969587326*x_31 - 4.33039999008179) - 0.00606177439312031*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 155.144917393688*std::sin(0.150160029530525*x_33 + 7.99456024169922) - 0.0185802911183003*std::sin(0.289919942617416*x_35 + 4.95607948303223) - 0.0150412237208998*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.551058059992661*std::sin(0.198640003800392*x_47 + 8.2055196762085) - 4.54599771433037*std::sin(0.422719866037369*x_5 - 7.41439962387085) + 0.00553005805371903*std::sin(0.511599838733673*x_6 + 5.09880018234253) - 0.00761910009085612*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 5.0477383548912*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 2.20752421113071*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.234172993345166*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 0.955423490421588*std::sin(0.5136798620224*x_72 + 2.13903999328613) - 0.00910995879874199*std::sin(0.397599816322327*x_73 + 2.00783967971802) + 9.40738583007719*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 3.01965028559083*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.357832642982631*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.237165537483776*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 23.6106166752027*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 429.231665385567*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.219584866628976*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 3.17336307765761*std::sin(0.383119851350784*x_91 + 8.20567989349365) - 5.20762895790874*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 31.5771017452695*std::sin(0.299039930105209*x_92 - 1.17503976821899) - 7.26365203032119*std::sin(0.306799918413162*x_92 + 8.20695972442627) - 8.15431309856504*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 14.2539891116943*std::sin(0.316239923238754*x_94 + 1.95431983470917) + 0.00601516838695741*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.501433042590678*std::sin(0.301119923591614*x_97 - 7.45264005661011) + 10.006435673203*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 3.97918143272453*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.446309525114551*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 23.9860042913857*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.161528282469385*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 31430.043339799);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.341362903410918*x_1 + 33.5447567022242*x_10 - 50.6689137486086*x_100 - 89.4529328374833*x_101 - 120.548239774238*x_102 + 14.8455990231809*x_103 - 514.751505948459*x_104 - 153.567342272988*x_105 - 103.950261156856*x_106 - 43.7335990250551*x_107 - 94.4041585852975*x_108 + 67.8130653287548*x_109 - 125.453670430414*x_110 - 143.96697961762*x_111 - 59.1078567064149*x_112 + 71.1908772504147*x_113 + 207.07538307732*x_114 + 58.2545349975885*x_115 - 6.37675544654531*x_116 - 177.338486593861*x_117 - 168.417922827474*x_118 - 101.668558819911*x_119 - 7.13703595407222*x_12 - 5.04541891032641*x_120 + 50.2650526762527*x_13 - 3.03829319885159*x_14 + 0.159498234039163*x_15 - 73.9830393071243*x_16 + 2.59999777445937*x_17 + 381.290073708604*x_18 - 0.0209308043658063*x_19 + 2.9268157644783*x_2 + 0.0464983055316843*x_20 + 27.8436813956339*x_21 - 94.4748391463074*x_22 + 0.0309183646681607*x_23 - 36.0359728198939*x_24 - 0.204585422646708*x_25 + 0.64089278983229*x_26 + 297.031544769526*x_27 + 2.58931078929379*x_28 + 0.724699769787723*x_29 - 0.87534476482005*x_3 + 0.0174178249787425*x_30 - 25.9084008015303*x_31 + 0.744046924748504*x_32 + 326.953279350347*x_33 - 502.358501355848*x_34 - 21.1941553539269*x_35 + 648.520302099591*x_36 - 1781.25786277196*x_37 - 108.667594375238*x_38 - 370.775626181868*x_39 + 1.02024414654066*x_4 - 13479.173991359*x_40 + 10.5237766368721*x_41 - 135.360022735573*x_42 + 87.0061989354002*x_43 - 272.452962676305*x_44 + 173.189300594423*x_45 - 1202.9183337188*x_46 + 351.706864867133*x_47 - 907.012813897481*x_48 + 245.13463371699*x_5 - 0.0904248819273088*x_50 - 29.378638983694*x_52 + 24.0028469122729*x_53 + 227.99647048897*x_54 - 142.91452730936*x_58 - 201.23080834172*x_59 + 11.5460655241456*x_6 + 0.676552893898291*x_60 + 120.145081938194*x_61 + 92.0617924986871*x_62 + 51.1659039516317*x_63 + 139.872186069827*x_64 - 26.5700635120832*x_65 - 3.18439050632955*x_66 + 65.0296491491581*x_67 + 65.7657420774448*x_68 + 113.314355480286*x_69 + 192.908869455818*x_7 - 52.062543942991*x_70 - 66.536323158088*x_71 - 45.5865961136557*x_72 + 100.641381501877*x_73 - 100.514455147664*x_74 - 38.4097913588952*x_75 - 12.4975164149318*x_76 - 37.3533432605896*x_77 - 39.0583084875676*x_78 - 148.399896809683*x_79 - 0.821047741328567*x_8 - 31.9777848523378*x_80 + 10.6724569455292*x_81 - 68.3147328509388*x_82 + 73.2114768909035*x_83 + 66.6914427804516*x_84 - 69.7215018736241*x_85 + 1657.79666306084*x_86 + 303.849565364668*x_87 + 186.055270436468*x_88 + 30.0022077538414*x_89 - 4.9800963801563*x_9 - 51.2144482018395*x_90 - 6.06870518085949*x_91 - 129.593463191211*x_92 - 112.987469189812*x_93 + 41.4800798512154*x_94 - 44.4875669860193*x_95 - 186.923769645519*x_96 - 63.2402048520667*x_97 - 191.051492261237*x_98 - 264.173088478116*x_99 - 0.00590394295595376*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 4.11120664116093e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.00940100688321723*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) + 0.00585885079252237*std::exp(1.13951992988586*x_1) + 0.991005481256808*std::exp(1.17007982730865*x_1) + 0.392882203567003*std::exp(1.22071981430054*x_1) + 0.00906082953195586*std::exp(1.40399980545044*x_1) - 3.28363948357441*std::exp(1.6639997959137*x_1) - 0.0138010221223187*std::exp(1.76023995876312*x_1) + 0.00769305030865398*std::exp(0.627359867095947*x_10) + 0.0399413352561363*std::exp(0.778879821300507*x_10) + 3.15914089809975*std::exp(0.80351984500885*x_10) + 0.00288828697687324*std::exp(0.810399830341339*x_10) - 0.309528701472015*std::exp(0.840799868106842*x_10) - 0.000498460211172496*std::exp(0.934159815311432*x_10) + 0.0879308559597562*std::exp(0.94543981552124*x_10) - 0.0294337845706287*std::exp(0.969839811325073*x_10) - 0.147191210088271*std::exp(0.82207989692688*x_11) - 0.00126575433552848*std::exp(0.895919859409332*x_11) + 0.00685235661139406*std::exp(0.902079820632935*x_11) - 13.1863016895976*std::exp(0.914159834384918*x_11) + 3.79415379036148*std::exp(0.925199866294861*x_11) - 0.00239047591311492*std::exp(0.933279812335968*x_11) + 0.0035309063418748*std::exp(0.937199831008911*x_11) - 0.0201391072348183*std::exp(0.951599836349487*x_11) + 0.0919147994262746*std::exp(0.983759820461273*x_11) + 0.0190097513880865*std::exp(1.06111979484558*x_11) - 0.00817733571115081*std::exp(0.537679851055145*x_12) + 0.00528919606985235*std::exp(0.696079850196838*x_12) - 0.00266737961879982*std::exp(0.854959905147552*x_12) + 0.00040731862474193*std::exp(0.925439834594727*x_12) + 0.737904288899224*std::exp(1.2235199213028*x_12) + 0.00101499484958893*std::exp(1.10399985313416*x_13) + 2.49669167887184e-5*std::exp(1.32895994186401*x_13) + 1.12545470952524e-5*std::exp(1.4015998840332*x_13) + 252.228653898887*std::exp(0.345279842615128*x_14) + 0.0956635268708423*std::exp(0.428239852190018*x_14) - 0.00397603656146308*std::exp(0.715599834918976*x_14) - 0.00113511979557987*std::exp(0.868079900741577*x_14) + 0.0109416318939966*std::exp(0.67935985326767*x_15) + 1.38823270260651*std::exp(0.82151985168457*x_15) - 0.0769586697730438*std::exp(0.898239850997925*x_15) - 20.8572908741481*std::exp(0.92087984085083*x_15) - 0.0032194464301805*std::exp(0.927359819412231*x_15) + 0.000299386215894521*std::exp(0.993359804153442*x_15) + 0.000568021815164838*std::exp(1.03111982345581*x_15) - 0.00210888991753394*std::exp(1.05295991897583*x_15) - 1.28435681642546*std::exp(0.357999831438065*x_16) - 0.0388556468254042*std::exp(0.539119839668274*x_16) + 7.62255916972402*std::exp(0.590719819068909*x_16) + 0.0447825513414205*std::exp(0.703679859638214*x_16) + 0.00108732200441205*std::exp(0.912239849567413*x_16) + 0.0268334472822575*std::exp(0.620319843292236*x_17) + 0.0454457437895672*std::exp(0.655279815196991*x_17) - 1.40468407149583*std::exp(0.659599840641022*x_17) + 61.6727051200789*std::exp(0.695119857788086*x_17) - 0.0264750673284026*std::exp(0.7079998254776*x_17) + 0.00256087698466229*std::exp(0.857999861240387*x_17) + 1.80363222748302*std::exp(0.434639871120453*x_18) - 0.0396601030351679*std::exp(0.695919871330261*x_19) - 0.0107790307407292*std::exp(0.704799830913544*x_19) - 223.395792660511*std::exp(0.716879844665527*x_19) + 1.34675308118488*std::exp(0.719519853591919*x_19) + 0.0223416402488193*std::exp(0.728719890117645*x_19) + 13.1925291439943*std::exp(0.748239874839783*x_19) + 1.36960012087004*std::exp(0.766079843044281*x_19) + 0.653568202712715*std::exp(0.823999881744385*x_19) - 0.000404566165547736*std::exp(1.00991988182068*x_19) + 1.25282398231906*std::exp(0.735999822616577*x_2) + 0.0248936588382649*std::exp(0.754559874534607*x_2) + 0.611936517884954*std::exp(0.755999863147736*x_2) + 47.29233561656*std::exp(0.924879848957062*x_2) + 0.0177276503854871*std::exp(1.01583981513977*x_2) + 0.00209697912803312*std::exp(1.11415982246399*x_2) - 0.187299282222833*std::exp(0.26639986038208*x_20) + 0.445600892457658*std::exp(0.403999865055084*x_20) - 0.355792164706294*std::exp(0.516959846019745*x_20) - 4.22266962211223*std::exp(0.532159864902496*x_20) + 9.78731877704614*std::exp(0.886239886283875*x_20) - 0.0658995603088552*std::exp(0.916319847106934*x_20) + 0.000215817306880361*std::exp(1.04447984695435*x_20) - 0.0401939581984701*std::exp(0.525999844074249*x_22) + 2.3837995009464*std::exp(0.651039838790894*x_22) - 0.000286122701145421*std::exp(1.28135991096497*x_22) - 0.00395173724810607*std::exp(1.33199989795685*x_22) - 0.0379247055044809*std::exp(0.638159871101379*x_23) - 64.8049395173744*std::exp(0.658639848232269*x_23) + 0.0101974543969438*std::exp(0.673119843006134*x_23) - 0.093169340694541*std::exp(0.69023984670639*x_23) - 0.00421906423477326*std::exp(0.733039855957031*x_23) - 0.57966678115515*std::exp(0.734799861907959*x_23) - 0.630674448576335*std::exp(0.736159861087799*x_23) + 0.833035953087219*std::exp(0.747999846935272*x_23) + 0.485639667377437*std::exp(0.818959891796112*x_23) - 14.8428760937728*std::exp(0.305759847164154*x_24) + 0.0846785458017422*std::exp(0.42087984085083*x_24) - 0.754142504441881*std::exp(0.60511988401413*x_24) + 0.0401015014580414*std::exp(0.611999869346619*x_24) + 0.0322182417090926*std::exp(0.650239825248718*x_24) - 0.0039789349692158*std::exp(0.758959889411926*x_24) - 0.370225933031179*std::exp(0.766159892082214*x_24) - 0.123220245508725*std::exp(0.412159860134125*x_25) - 0.0142775323854356*std::exp(0.525519847869873*x_25) - 185.462599361661*std::exp(0.589919865131378*x_25) + 0.00962057949324385*std::exp(0.660079836845398*x_25) - 0.176745104862052*std::exp(0.767039835453033*x_25) - 0.439304747478361*std::exp(0.949439823627472*x_25) + 0.0540843227237147*std::exp(0.987279832363129*x_25) - 0.00145647333872317*std::exp(0.993919789791107*x_25) + 0.194773186621146*std::exp(0.42087984085083*x_26) + 0.66982274028551*std::exp(0.573839843273163*x_26) + 0.102684089623131*std::exp(0.728879868984222*x_26) + 0.00347837379016437*std::exp(0.8193598985672*x_26) + 0.0014902050960324*std::exp(0.839599847793579*x_26) + 7.13405484793954*std::exp(0.860319912433624*x_26) - 0.00058829081801974*std::exp(0.960159838199615*x_26) + 0.0140413174139417*std::exp(1.13951992988586*x_26) + 7.19796002783126e-5*std::exp(1.18455982208252*x_27) - 0.0946190537809872*std::exp(1.20399987697601*x_27) - 0.0173065940022217*std::exp(1.23751986026764*x_27) - 0.0069175785003792*std::exp(1.25919985771179*x_27) - 0.00373327042885543*std::exp(1.28719985485077*x_27) - 166.924548863788*std::exp(0.516239881515503*x_28) - 0.981620541129932*std::exp(0.543999850749969*x_28) - 0.00599742080454678*std::exp(0.647999823093414*x_28) + 0.0443059082371468*std::exp(0.654319822788239*x_28) - 0.269836550144409*std::exp(0.736559867858887*x_28) - 0.106019147247637*std::exp(0.906079828739166*x_28) - 4.97592294785861*std::exp(0.932239830493927*x_29) - 0.000541866198601322*std::exp(1.12255990505219*x_29) - 0.0288004866317844*std::exp(1.15015983581543*x_29) - 0.0327100892552201*std::exp(1.15143990516663*x_29) - 0.179996187469985*std::exp(1.16695988178253*x_29) + 38.0213830059015*std::exp(0.439999848604202*x_3) - 9.32034576884045*std::exp(0.526399850845337*x_3) - 0.0116948829537766*std::exp(0.633039832115173*x_3) - 0.0107063549386464*std::exp(0.658079862594604*x_3) - 0.0163746131996136*std::exp(0.925759851932526*x_3) - 0.142247524467971*std::exp(0.94135981798172*x_3) - 0.00408864096750535*std::exp(0.634159862995148*x_30) - 63.4435465210322*std::exp(0.828479886054993*x_30) - 0.357798810924043*std::exp(0.857279896736145*x_30) - 1.42093753249251*std::exp(0.885519862174988*x_30) + 0.28363690815996*std::exp(0.91239982843399*x_30) + 0.284862671262336*std::exp(0.947999835014343*x_30) + 0.00555619689429373*std::exp(1.02791976928711*x_30) + 0.000591041469119739*std::exp(1.02927982807159*x_30) + 0.00134677766678614*std::exp(1.09479975700378*x_30) + 29.4535131113214*std::exp(0.826799869537354*x_32) + 0.00209878753797419*std::exp(0.831519842147827*x_32) + 0.00572522321578468*std::exp(0.832079887390137*x_32) + 1.28777008339744*std::exp(0.333039849996567*x_33) - 0.0707337291413481*std::exp(0.360239863395691*x_33) + 0.0435867477769525*std::exp(0.404719859361649*x_33) - 2.31170897472713*std::exp(0.417439848184586*x_33) + 3.25521511307173*std::exp(0.369439840316772*x_34) - 1.1662622830984*std::exp(0.426799863576889*x_36) - 2.99278121254701*std::exp(0.261359840631485*x_37) - 0.0546680865448117*std::exp(0.355199843645096*x_4) + 6.7443129257994*std::exp(0.535359859466553*x_4) + 0.0115074068987381*std::exp(0.541439831256866*x_4) - 0.00851755443870736*std::exp(0.586239874362946*x_4) - 0.785577730148732*std::exp(0.747519850730896*x_4) - 0.0464415613288005*std::exp(1.09559988975525*x_4) - 1.95181750443034*std::exp(1.10943984985352*x_4) - 0.00260538926084736*std::exp(1.15591979026794*x_4) + 39.3467862352687*std::exp(0.715999841690063*x_41) - 0.183818985987552*std::exp(0.747999846935272*x_41) + 0.0174996404067588*std::exp(0.770959854125977*x_41) - 0.00305774729358648*std::exp(0.788479864597321*x_41) + 0.00421848229276515*std::exp(0.796479880809784*x_41) - 0.0627319395231762*std::exp(0.802159905433655*x_41) - 0.190185639742563*std::exp(0.802399873733521*x_41) - 0.017010682211097*std::exp(0.806319832801819*x_41) + 0.122362772303141*std::exp(0.812319874763489*x_41) + 0.0173557794076394*std::exp(0.585839867591858*x_42) - 0.144925306659809*std::exp(0.693759858608246*x_42) - 0.232679471089205*std::exp(0.720399856567383*x_42) + 0.022626180015802*std::exp(0.851439893245697*x_42) + 0.000965974593874523*std::exp(0.704879820346832*x_43) + 0.00221275951117522*std::exp(0.761919856071472*x_43) - 0.000472478416207805*std::exp(0.818479895591736*x_43) - 0.00652728851824022*std::exp(0.875679850578308*x_44) + 0.000112342570879507*std::exp(0.960559844970703*x_44) + 6.01656952368384e-5*std::exp(0.99999988079071*x_44) + 2.5475930321391*std::exp(0.555919826030731*x_45) - 0.358124711589843*std::exp(0.518719851970673*x_46) - 0.209507292424052*std::exp(0.702239871025085*x_46) + 0.000523008521187439*std::exp(0.715279817581177*x_46) - 0.00783355535219864*std::exp(0.752959847450256*x_46) + 0.0102702233951611*std::exp(0.756079852581024*x_46) + 0.0228173057095923*std::exp(0.795919895172119*x_46) - 0.0459048224710799*std::exp(0.406479865312576*x_47) - 0.0244970051851742*std::exp(0.552319884300232*x_47) - 0.00506994500392936*std::exp(0.586239874362946*x_48) - 0.416817693269501*std::exp(0.600879848003387*x_48) - 0.0146005023724816*std::exp(0.65559983253479*x_49) + 0.0145977260554162*std::exp(0.684479832649231*x_49) + 167.2141859288*std::exp(0.703759849071503*x_49) + 0.0890287011068059*std::exp(0.7079998254776*x_49) + 0.788643608485096*std::exp(0.708239853382111*x_49) + 0.0133759357760259*std::exp(0.709119856357574*x_49) - 0.0248186147247746*std::exp(0.714559853076935*x_49) - 10.4666346326652*std::exp(0.71919983625412*x_49) - 0.918600662940738*std::exp(0.719519853591919*x_49) - 1.04848774576199*std::exp(0.722239851951599*x_49) - 0.000667931222482913*std::exp(2.06119966506958*x_5) + 0.0243379982123922*std::exp(0.325439840555191*x_50) - 0.382364317075896*std::exp(0.535359859466553*x_50) + 0.625239627821058*std::exp(0.535439848899841*x_50) + 0.50838994615441*std::exp(0.538639843463898*x_50) + 0.0375441057718097*std::exp(0.539039850234985*x_50) + 161.500446105286*std::exp(0.550159871578217*x_50) - 0.0082702019982716*std::exp(0.591119825839996*x_50) - 4.16940093398831*std::exp(0.592239856719971*x_50) + 0.0141554612874744*std::exp(0.642959833145142*x_50) - 0.0169340508767651*std::exp(0.460479855537415*x_51) + 0.0615000157660375*std::exp(0.483199834823608*x_51) - 5.9287428238678*std::exp(0.488399863243103*x_51) - 0.450051845818318*std::exp(0.493759840726852*x_51) - 160.54261243438*std::exp(0.494479864835739*x_51) - 0.159628928589552*std::exp(0.495999842882156*x_51) - 752.716586406679*std::exp(0.49703985452652*x_51) + 0.549319981742208*std::exp(0.498159825801849*x_51) + 4.44452395940808*std::exp(0.499919831752777*x_51) + 3.13365362017676*std::exp(0.50631982088089*x_51) - 1.01469400607575*std::exp(0.521999835968018*x_52) + 0.0127020439115639*std::exp(0.526719868183136*x_52) - 0.00855538414766439*std::exp(0.590079843997955*x_52) + 0.0456342001303553*std::exp(0.628719866275787*x_52) - 0.00307844624555692*std::exp(0.705759823322296*x_52) - 0.0516137755447546*std::exp(0.709279835224152*x_52) + 0.936900043755569*std::exp(0.720719873905182*x_52) - 0.0131377619708675*std::exp(0.887439906597137*x_52) - 2.68190194778835*std::exp(0.48039984703064*x_54) + 0.225378569511474*std::exp(0.49823984503746*x_54) + 0.0180071631213041*std::exp(0.512639820575714*x_54) - 4.74327071947442*std::exp(0.519359886646271*x_54) - 0.0504997086053972*std::exp(0.533919811248779*x_54) - 8.51821891998332*std::exp(0.535759806632996*x_54) - 0.0486290055711795*std::exp(0.538879811763763*x_54) - 0.0173929388782065*std::exp(0.629039824008942*x_55) + 7.08555949822513*std::exp(0.631839871406555*x_55) - 0.550347210007315*std::exp(0.651679813861847*x_55) + 6.05997610815101*std::exp(0.653599858283997*x_55) - 3.41729003564695*std::exp(0.653759837150574*x_55) - 0.488561701213922*std::exp(0.655519843101501*x_55) + 1356.95542438495*std::exp(0.655839860439301*x_55) + 0.308697803538482*std::exp(0.656479835510254*x_55) + 0.0378994920285824*std::exp(0.657599866390228*x_55) - 7.59713512797345*std::exp(0.658879816532135*x_55) - 5.03053292046263*std::exp(0.342799842357635*x_56) + 273.606974907622*std::exp(0.434559851884842*x_56) - 3.95570501740463*std::exp(0.468159854412079*x_56) + 0.0515468724063828*std::exp(0.510159850120544*x_56) - 13.1817707132874*std::exp(0.52839982509613*x_56) + 1.19730635504656*std::exp(0.568239867687225*x_56) + 0.0294413882607621*std::exp(0.658959865570068*x_56) + 0.00283364696400381*std::exp(0.678959846496582*x_56) + 0.00161319974033648*std::exp(0.747119843959808*x_56) + 0.00640639486596255*std::exp(0.824879884719849*x_56) - 1.65397670037325*std::exp(0.610959827899933*x_57) - 0.154290154642275*std::exp(0.616639852523804*x_57) + 0.0657384755516199*std::exp(0.626079857349396*x_57) + 3.40493831206729*std::exp(0.627359867095947*x_57) + 0.0180305005053473*std::exp(0.628399848937988*x_57) - 798.656128471144*std::exp(0.632639825344086*x_57) + 0.050872148130641*std::exp(0.636399865150452*x_57) + 11.034442950902*std::exp(0.641759812831879*x_57) - 0.0997655081709978*std::exp(0.643279850482941*x_57) + 0.532906767668358*std::exp(0.663679838180542*x_57) + 0.0451516423470208*std::exp(0.437759846448898*x_58) + 0.112959138839248*std::exp(0.485119849443436*x_58) - 0.00477083712545639*std::exp(0.554479837417603*x_58) - 0.347441472401876*std::exp(0.566799819469452*x_58) + 0.00922301847025549*std::exp(0.60647988319397*x_58) + 0.0217690201640986*std::exp(0.655439853668213*x_58) + 0.0293154001299041*std::exp(0.522799849510193*x_59) + 0.46890162726587*std::exp(0.691839873790741*x_59) - 1.01039208204215*std::exp(0.765759825706482*x_59) - 0.0749362049775657*std::exp(0.827119886875153*x_59) - 0.0311134708069248*std::exp(0.860399901866913*x_59) - 0.00952944737523368*std::exp(0.780719876289368*x_60) - 0.289159104869159*std::exp(0.787359893321991*x_60) - 69.1451567899872*std::exp(0.816559851169586*x_60) - 0.00270953895967287*std::exp(0.838639855384827*x_60) - 0.306969542451453*std::exp(0.847519874572754*x_60) - 0.00493509208303029*std::exp(0.854399859905243*x_60) - 0.0115548154222537*std::exp(0.860399901866913*x_60) - 0.0027050949245821*std::exp(0.872479856014252*x_60) + 0.0599309777734642*std::exp(1.03615987300873*x_60) - 0.918601827263858*std::exp(0.983999848365784*x_61) + 0.0162782428677678*std::exp(1.18831992149353*x_61) + 0.370714176477986*std::exp(1.23887979984283*x_61) + 0.134437400146845*std::exp(1.32615983486176*x_61) - 0.107489603906387*std::exp(0.599199831485748*x_66) - 51.4273720562968*std::exp(0.949999809265137*x_66) + 0.00446248286152184*std::exp(1.11047983169556*x_66) - 0.000818097314864008*std::exp(1.5058399438858*x_66) + 2.5406126682566e-6*std::exp(1.78991985321045*x_7) + 0.0343630534538121*std::exp(0.455999851226807*x_8) - 0.0245963670233096*std::exp(0.519439876079559*x_8) + 0.00304627200359888*std::exp(0.636319875717163*x_8) + 0.0696999820195665*std::exp(0.878639876842499*x_8) - 0.811879320789353*std::exp(0.925199866294861*x_8) + 0.00152534476099035*std::exp(1.39863991737366*x_8) - 0.0829792655644359*std::log(9.29800033569336 - 1.38431990146637*x_5) + 5.80331368269547*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.0705228636193705*std::sin(0.170640021562576*x_1 + 4.96303987503052) + 15.4166477644776*std::sin(0.208320006728172*x_101 - 7.40863990783691) + 5.1657749836261*std::sin(0.231999978423119*x_108 - 1.19423997402191) - 0.284701147763095*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 7.18385395514125*std::sin(0.30583992600441*x_113 - 1.2235199213028) - 3.40063656514495*std::sin(0.319439828395844*x_113 + 5.03800010681152) - 2.99032928695348*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 5.55986425110301*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.0660112298057109*std::sin(0.248959973454475*x_117 + 1.95943987369537) - 0.286878734976106*std::sin(0.267359972000122*x_117 + 1.94591987133026) + 9.17064419370917*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 12.8968156608365*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.947293455554288*std::sin(0.270399957895279*x_120 - 7.43680000305176) + 942.022679581292*std::sin(0.271919965744019*x_120 + 5.14680004119873) - 1.5622869069627*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 7.34362199705203*std::sin(0.401599854230881*x_21 - 7.40983963012695) - 4.19120864928021*std::sin(0.435999870300293*x_22 - 7.41879987716675) - 1.28204824989234*std::sin(0.0904000774025917*x_3 + 1.69007980823517) - 0.108829529486241*std::sin(0.602719843387604*x_3 + 2.19079995155334) - 0.987902413304211*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0206586382849407*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 38.7019141091719*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.608902866958676*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.492922537537752*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.171961028965723*std::sin(0.198640003800392*x_47 + 8.2055196762085) - 4.03300546461606*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0188465392503164*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.0259660328191022*std::sin(0.600559830665588*x_64 - 7.19495964050293) - 12.0202414280067*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 5.15082479822741*std::sin(0.427759855985641*x_65 - 0.986319839954376) + 0.114551850694023*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 2.22929333343611*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.298546454149253*std::sin(0.397599816322327*x_73 + 2.00783967971802) + 8.34581116062915*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 7.04576171557775*std::sin(0.298719942569733*x_9 + 1.96815979480743) + 0.175043205908783*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.0740089526346134*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 5.88982271529736*std::sin(0.359999865293503*x_91 - 7.40607976913452) - 666.531830363296*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.0685227970557633*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 7.40442036910018*std::sin(0.383119851350784*x_91 + 8.20567989349365) - 4.61997505602188*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 7.87711450746965*std::sin(0.299039930105209*x_92 - 1.17503976821899) - 6.44398659484808*std::sin(0.306799918413162*x_92 + 8.20695972442627) - 7.23414118380113*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 3.55575078823888*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.0204998041613353*std::sin(0.278399974107742*x_95 - 7.43935966491699) - 0.245289101050314*std::sin(0.301119923591614*x_97 - 7.45264005661011) + 8.87726133784499*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 9.28463946034157*std::sin(0.242159977555275*x_98 + 5.18111991882324) + 0.218323989260727*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 5.98346561074778*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.0504058858350994*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 198380.255678992);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.02343273874533*x_1 - 36.0300747886079*x_10 + 54.024970965573*x_100 + 95.2731932222806*x_101 + 138.370533493562*x_102 - 12.7672288108567*x_103 + 573.789585894231*x_104 + 161.35862527543*x_105 + 107.992361662392*x_106 + 43.4653783056083*x_107 + 103.181030391548*x_108 - 66.8003537824776*x_109 + 136.386215857575*x_110 + 151.269011179695*x_111 + 59.2810173702712*x_112 - 77.3201414936549*x_113 - 217.736243784918*x_114 - 72.4900113153002*x_115 + 7.95349342002192*x_116 + 186.80163972202*x_117 + 183.892399790879*x_118 + 105.713808634461*x_119 + 0.732607215729481*x_12 + 1.16217176232657*x_120 - 55.6760903672132*x_13 - 1.38670963248235*x_14 - 0.0251664355819763*x_15 + 78.8868388553365*x_16 - 3.88131560694428*x_17 - 424.258647699239*x_18 - 0.0807938507801953*x_19 - 1.28403794255305*x_2 + 0.109666646130912*x_20 - 27.1834892147243*x_21 + 101.26737115187*x_22 - 0.000940357453577345*x_23 + 38.6624214739454*x_24 + 0.1850158812471*x_25 - 0.292268213922698*x_26 - 319.466520268242*x_27 - 1.13472255612298*x_28 - 1.93714962608458*x_29 + 0.220234590318118*x_3 + 0.0672335915836587*x_30 + 30.8025771043346*x_31 + 6.99946118405595*x_32 - 356.515079421087*x_33 + 549.642082685932*x_34 + 31.3887653664532*x_35 - 720.64289011957*x_36 + 1968.22794866901*x_37 + 155.877599047969*x_38 + 360.42788287541*x_39 - 3.03737046567903*x_4 + 14635.2044304879*x_40 - 4.64453985276747*x_41 + 139.694965282681*x_42 - 75.7354658342486*x_43 + 285.404496427089*x_44 - 217.622493934259*x_45 + 1301.53363961532*x_46 - 394.920121566243*x_47 + 967.603727351109*x_48 - 262.61076523361*x_5 + 0.00275020081501144*x_50 + 31.5172161755244*x_52 - 25.8974162810794*x_53 - 244.362566099395*x_54 + 162.371768228644*x_58 + 216.229233148538*x_59 - 10.6931918114963*x_6 - 2.01313059064301*x_60 - 129.064709545761*x_61 - 98.2332363336699*x_62 - 58.9256694731825*x_63 - 152.580105305277*x_64 + 27.2547027036513*x_65 - 0.426540373637113*x_66 - 72.7928850839182*x_67 - 69.2901440418888*x_68 - 124.848852552323*x_69 - 201.763283258429*x_7 + 53.9622682568551*x_70 + 70.5076194554008*x_71 + 46.7476840580108*x_72 - 110.462311621297*x_73 + 106.030968298881*x_74 + 43.3158376072534*x_75 + 11.8707369034021*x_76 + 34.0746489726535*x_77 + 40.7495627457968*x_78 + 150.463402018747*x_79 - 1.48442734409245*x_8 + 32.3572912619506*x_80 - 7.90590417878109*x_81 + 70.3020954451148*x_82 - 80.7435321072434*x_83 - 67.5379158993482*x_84 + 74.1184701298614*x_85 - 1842.7230075541*x_86 - 337.129812387302*x_87 - 211.001128970159*x_88 - 32.9357628550574*x_89 + 4.85627396340428*x_9 + 49.0099103890361*x_90 + 2.74835883816948*x_91 + 138.261001346535*x_92 + 122.925591458833*x_93 - 49.8278604007075*x_94 + 45.3628335012604*x_95 + 195.655200072679*x_96 + 62.9209700854238*x_97 + 205.948386215843*x_98 + 279.324807599686*x_99 + 0.0175675963804666*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) - 0.000181544912065774*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) - 0.0279733553874876*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.000178192283818279*std::exp(1.13951992988586*x_1) - 0.437368124659886*std::exp(1.17007982730865*x_1) + 0.302449996939707*std::exp(1.22071981430054*x_1) + 0.000921333082020644*std::exp(1.40399980545044*x_1) + 3.52692306646443*std::exp(1.6639997959137*x_1) + 0.013994973446164*std::exp(1.76023995876312*x_1) + 0.0138075783633714*std::exp(0.627359867095947*x_10) + 0.00406135811095128*std::exp(0.778879821300507*x_10) - 1.39424812099519*std::exp(0.80351984500885*x_10) - 0.0102245037187356*std::exp(0.810399830341339*x_10) - 0.238282502905471*std::exp(0.840799868106842*x_10) + 0.00220112787082004*std::exp(0.934159815311432*x_10) - 0.261644429564174*std::exp(0.94543981552124*x_10) + 0.0298474294030661*std::exp(0.969839811325073*x_10) + 0.437977769919947*std::exp(0.82207989692688*x_11) - 0.00227179096397256*std::exp(0.895919859409332*x_11) - 0.00020840897257189*std::exp(0.902079820632935*x_11) + 14.1632696960311*std::exp(0.914159834384918*x_11) - 1.67450327909092*std::exp(0.925199866294861*x_11) + 0.0105559943179905*std::exp(0.933279812335968*x_11) + 0.013629458052282*std::exp(0.937199831008911*x_11) - 0.00204780651400183*std::exp(0.951599836349487*x_11) + 0.0707581828670168*std::exp(0.983759820461273*x_11) - 0.0192769030827228*std::exp(1.06111979484558*x_11) - 0.0146767795744553*std::exp(0.537679851055145*x_12) + 0.0204165358648597*std::exp(0.696079850196838*x_12) + 8.11262281488554e-5*std::exp(0.854959905147552*x_12) - 0.00179865986718304*std::exp(0.925439834594727*x_12) - 0.79257533306571*std::exp(1.2235199213028*x_12) + 0.000103207805610817*std::exp(1.10399985313416*x_13) - 7.59348903058055e-7*std::exp(1.32895994186401*x_13) + 4.344306041568e-5*std::exp(1.4015998840332*x_13) - 270.916177585638*std::exp(0.345279842615128*x_14) + 0.00972736234999583*std::exp(0.428239852190018*x_14) - 0.0153476808167125*std::exp(0.715599834918976*x_14) + 3.45237651451836e-5*std::exp(0.868079900741577*x_14) + 0.0422351935972211*std::exp(0.67935985326767*x_15) - 0.612679490894961*std::exp(0.82151985168457*x_15) - 0.0592446011196621*std::exp(0.898239850997925*x_15) + 22.4025995106853*std::exp(0.92087984085083*x_15) + 9.79169008291961e-5*std::exp(0.927359819412231*x_15) + 0.000537341947735175*std::exp(0.993359804153442*x_15) - 0.00250830180738427*std::exp(1.03111982345581*x_15) - 0.000214438428679321*std::exp(1.05295991897583*x_15) - 0.988728203188068*std::exp(0.357999831438065*x_16) + 0.00118176357313828*std::exp(0.539119839668274*x_16) - 3.36412307724389*std::exp(0.590719819068909*x_16) + 0.00455362788833225*std::exp(0.703679859638214*x_16) - 0.00480145599352369*std::exp(0.912239849567413*x_16) + 0.0481609909261063*std::exp(0.620319843292236*x_17) + 0.175422624862312*std::exp(0.655279815196991*x_17) - 1.08135896527753*std::exp(0.659599840641022*x_17) - 66.2420120562349*std::exp(0.695119857788086*x_17) + 0.00080521810139147*std::exp(0.7079998254776*x_17) - 0.0113084606922238*std::exp(0.857999861240387*x_17) - 5.36683420344887*std::exp(0.434639871120453*x_18) - 0.00403276155166336*std::exp(0.695919871330261*x_19) - 0.0193463328150063*std::exp(0.704799830913544*x_19) + 239.947100778491*std::exp(0.716879844665527*x_19) - 4.00735825717065*std::exp(0.719519853591919*x_19) - 0.000679503206544291*std::exp(0.728719890117645*x_19) - 5.82236106697623*std::exp(0.748239874839783*x_19) - 1.38884766313373*std::exp(0.766079843044281*x_19) + 0.503132234333029*std::exp(0.823999881744385*x_19) + 0.00178650540728867*std::exp(1.00991988182068*x_19) + 0.964453482947772*std::exp(0.735999822616577*x_2) - 0.000757120820800727*std::exp(0.754559874534607*x_2) - 0.620536308299111*std::exp(0.755999863147736*x_2) - 50.7962065224823*std::exp(0.924879848957062*x_2) + 0.00180260214686101*std::exp(1.01583981513977*x_2) - 0.00925995515747253*std::exp(1.11415982246399*x_2) - 0.0190451684740357*std::exp(0.26639986038208*x_20) - 0.451863101316744*std::exp(0.403999865055084*x_20) + 1.05868454209733*std::exp(0.516959846019745*x_20) + 1.86362349009339*std::exp(0.532159864902496*x_20) - 10.5124574504229*std::exp(0.886239886283875*x_20) - 0.0507310375292734*std::exp(0.916319847106934*x_20) - 0.000953017870899414*std::exp(1.04447984695435*x_20) + 0.00122246724839332*std::exp(0.525999844074249*x_22) - 1.05206069695181*std::exp(0.651039838790894*x_22) - 2.90938383900352e-5*std::exp(1.28135991096497*x_22) - 0.00304214064099845*std::exp(1.33199989795685*x_22) - 0.146391077182754*std::exp(0.638159871101379*x_23) + 69.6063124919726*std::exp(0.658639848232269*x_23) + 0.0183025126631914*std::exp(0.673119843006134*x_23) - 0.00947374580982802*std::exp(0.69023984670639*x_23) + 0.0186307746692458*std::exp(0.733039855957031*x_23) + 0.587813071958669*std::exp(0.734799861907959*x_23) - 0.485508081837393*std::exp(0.736159861087799*x_23) - 0.367650209274273*std::exp(0.747999846935272*x_23) - 1.44505489407335*std::exp(0.818959891796112*x_23) + 6.55072146872434*std::exp(0.305759847164154*x_24) + 0.326863013681717*std::exp(0.42087984085083*x_24) - 0.58055670653876*std::exp(0.60511988401413*x_24) - 0.00121965525021914*std::exp(0.611999869346619*x_24) + 0.00327605014821605*std::exp(0.650239825248718*x_24) - 0.00714143989522645*std::exp(0.758959889411926*x_24) + 1.10163323216302*std::exp(0.766159892082214*x_24) - 0.0125294144605089*std::exp(0.412159860134125*x_25) + 0.0630475086189829*std::exp(0.525519847869873*x_25) + 199.203451818364*std::exp(0.589919865131378*x_25) + 0.0371358716278464*std::exp(0.660079836845398*x_25) + 0.525917456791922*std::exp(0.767039835453033*x_25) + 0.193881766743735*std::exp(0.949439823627472*x_25) + 0.0416353886578727*std::exp(0.987279832363129*x_25) + 4.42974773958668e-5*std::exp(0.993919789791107*x_25) + 0.0198051381158593*std::exp(0.42087984085083*x_26) - 1.993104546501*std::exp(0.573839843273163*x_26) - 0.104127150502517*std::exp(0.728879868984222*x_26) - 0.015359993281412*std::exp(0.8193598985672*x_26) - 4.53234019474543e-5*std::exp(0.839599847793579*x_26) - 7.66261422013084*std::exp(0.860319912433624*x_26) - 0.00105587137017964*std::exp(0.960159838199615*x_26) + 0.0108093376852379*std::exp(1.13951992988586*x_26) + 0.000129189844279186*std::exp(1.18455982208252*x_27) + 0.0417589598564079*std::exp(1.20399987697601*x_27) - 0.0133230247017692*std::exp(1.23751986026764*x_27) + 0.00701479401790111*std::exp(1.25919985771179*x_27) + 0.0111086080205307*std::exp(1.28719985485077*x_27) + 179.291924308937*std::exp(0.516239881515503*x_28) + 0.995415650055817*std::exp(0.543999850749969*x_28) + 0.000182406780446675*std::exp(0.647999823093414*x_28) + 0.00450516134796356*std::exp(0.654319822788239*x_28) - 0.207726547612582*std::exp(0.736559867858887*x_28) + 0.315467409042211*std::exp(0.906079828739166*x_28) + 5.34458715993038*std::exp(0.932239830493927*x_29) + 1.64804291612842e-5*std::exp(1.12255990505219*x_29) - 0.0221712946388515*std::exp(1.15015983581543*x_29) + 0.0331697773173013*std::exp(1.15143990516663*x_29) + 0.0794391115373418*std::exp(1.16695988178253*x_29) - 40.8383726085604*std::exp(0.439999848604202*x_3) + 4.11342038686776*std::exp(0.526399850845337*x_3) + 0.0516429039641595*std::exp(0.633039832115173*x_3) - 0.0192158934194327*std::exp(0.658079862594604*x_3) - 0.00166502115428711*std::exp(0.925759851932526*x_3) + 0.144246586235988*std::exp(0.94135981798172*x_3) + 0.0180548444703007*std::exp(0.634159862995148*x_30) + 68.1440544135992*std::exp(0.828479886054993*x_30) + 0.362827101758878*std::exp(0.857279896736145*x_30) + 0.627113366776675*std::exp(0.885519862174988*x_30) - 0.843981515121653*std::exp(0.91239982843399*x_30) + 0.219294010442081*std::exp(0.947999835014343*x_30) + 0.000564971230380069*std::exp(1.02791976928711*x_30) + 0.00106080827155033*std::exp(1.02927982807159*x_30) - 4.09611708402556e-5*std::exp(1.09479975700378*x_30) - 31.6357125379833*std::exp(0.826799869537354*x_32) + 0.00376692888203875*std::exp(0.831519842147827*x_32) + 0.00058215834786999*std::exp(0.832079887390137*x_32) + 0.991355816696281*std::exp(0.333039849996567*x_33) - 0.273035391162937*std::exp(0.360239863395691*x_33) + 0.0782300142841614*std::exp(0.404719859361649*x_33) + 2.34419635225755*std::exp(0.417439848184586*x_33) + 2.505941455347*std::exp(0.369439840316772*x_34) + 1.18265223681002*std::exp(0.426799863576889*x_36) + 3.03483997261626*std::exp(0.261359840631485*x_37) + 0.00166268634214551*std::exp(0.355199843645096*x_4) - 2.97651986014789*std::exp(0.535359859466553*x_4) + 0.0206536310226375*std::exp(0.541439831256866*x_4) - 0.0328781450682009*std::exp(0.586239874362946*x_4) - 0.60475628552838*std::exp(0.747519850730896*x_4) + 0.0470942232998728*std::exp(1.09559988975525*x_4) + 2.09642691054833*std::exp(1.10943984985352*x_4) - 0.000264924012651833*std::exp(1.15591979026794*x_4) - 42.2619744520043*std::exp(0.715999841690063*x_41) + 0.546966286257805*std::exp(0.747999846935272*x_41) - 0.000532237635076639*std::exp(0.770959854125977*x_41) + 0.0135025677857136*std::exp(0.788479864597321*x_41) + 0.00757138228594796*std::exp(0.796479880809784*x_41) - 0.00637877701795197*std::exp(0.802159905433655*x_41) + 0.192858395157163*std::exp(0.802399873733521*x_41) - 0.0656620021004982*std::exp(0.806319832801819*x_41) + 0.0941977513173552*std::exp(0.812319874763489*x_41) + 0.066994092875168*std::exp(0.585839867591858*x_42) + 0.431235415333307*std::exp(0.693759858608246*x_42) - 0.179122150812466*std::exp(0.720399856567383*x_42) - 0.0229441548388791*std::exp(0.851439893245697*x_42) - 0.00426560345926083*std::exp(0.704879820346832*x_43) + 0.00854135171462445*std::exp(0.761919856071472*x_43) - 0.000848009891401879*std::exp(0.818479895591736*x_43) - 0.00502486082200375*std::exp(0.875679850578308*x_44) - 0.000496088470654051*std::exp(0.960559844970703*x_44) + 0.000107986106737773*std::exp(0.99999988079071*x_44) - 1.12434896470016*std::exp(0.555919826030731*x_45) + 1.0656251989591*std::exp(0.518719851970673*x_46) - 0.161283660540491*std::exp(0.702239871025085*x_46) + 0.000938701925929566*std::exp(0.715279817581177*x_46) + 0.000238251351341246*std::exp(0.752959847450256*x_46) + 0.0396435264486766*std::exp(0.756079852581024*x_46) + 0.00232013399200195*std::exp(0.795919895172119*x_46) + 0.00139615863999035*std::exp(0.406479865312576*x_47) - 0.0945595471106676*std::exp(0.552319884300232*x_47) - 0.00909959770586576*std::exp(0.586239874362946*x_48) + 1.2402702827966*std::exp(0.600879848003387*x_48) - 0.00148462409566869*std::exp(0.65559983253479*x_49) - 0.000443978219702765*std::exp(0.684479832649231*x_49) - 179.603020472388*std::exp(0.703759849071503*x_49) + 0.343654809756318*std::exp(0.7079998254776*x_49) - 0.799726734832708*std::exp(0.708239853382111*x_49) + 0.0240072889167436*std::exp(0.709119856357574*x_49) + 0.109595396706481*std::exp(0.714559853076935*x_49) + 4.61932092946993*std::exp(0.71919983625412*x_49) - 0.707160480095039*std::exp(0.719519853591919*x_49) + 3.11984883065938*std::exp(0.722239851951599*x_49) + 0.000294783259733993*std::exp(2.06119966506958*x_5) + 0.0436821292000616*std::exp(0.325439840555191*x_50) - 0.294353079573214*std::exp(0.535359859466553*x_50) - 0.634026372198516*std::exp(0.535439848899841*x_50) - 1.51274994432683*std::exp(0.538639843463898*x_50) + 0.144921945014157*std::exp(0.539039850234985*x_50) - 173.46595186905*std::exp(0.550159871578217*x_50) + 0.0365200104395247*std::exp(0.591119825839996*x_50) + 1.84011400738266*std::exp(0.592239856719971*x_50) + 0.0014393709460504*std::exp(0.642959833145142*x_50) + 0.000515035679672362*std::exp(0.460479855537415*x_51) + 0.110380961123171*std::exp(0.483199834823608*x_51) + 6.01206183525958*std::exp(0.488399863243103*x_51) - 1.73722046410211*std::exp(0.493759840726852*x_51) + 70.8535145934556*std::exp(0.494479864835739*x_51) + 0.704898156025564*std::exp(0.495999842882156*x_51) + 808.485067982623*std::exp(0.49703985452652*x_51) + 0.0558565493379087*std::exp(0.498159825801849*x_51) + 3.42149948691218*std::exp(0.499919831752777*x_51) - 9.32440614791818*std::exp(0.50631982088089*x_51) + 1.02895390972868*std::exp(0.521999835968018*x_52) + 0.049030463543528*std::exp(0.526719868183136*x_52) - 0.0153553054130865*std::exp(0.590079843997955*x_52) + 0.0046402261628877*std::exp(0.628719866275787*x_52) + 9.3628492435362e-5*std::exp(0.705759823322296*x_52) + 0.153580409432626*std::exp(0.709279835224152*x_52) - 0.413489352865599*std::exp(0.720719873905182*x_52) - 0.01011375937064*std::exp(0.887439906597137*x_52) - 2.06459144378843*std::exp(0.48039984703064*x_54) + 0.0229171878068196*std::exp(0.49823984503746*x_54) + 0.0323194709411591*std::exp(0.512639820575714*x_54) + 4.80992981379695*std::exp(0.519359886646271*x_54) + 0.00153590844471382*std::exp(0.533919811248779*x_54) + 3.75941153196308*std::exp(0.535759806632996*x_54) + 0.214738623251806*std::exp(0.538879811763763*x_54) - 0.0312170539506303*std::exp(0.629039824008942*x_55) - 3.12712485300745*std::exp(0.631839871406555*x_55) - 0.0559610010749258*std::exp(0.651679813861847*x_55) - 18.0318839693243*std::exp(0.653599858283997*x_55) + 3.46531458922732*std::exp(0.653759837150574*x_55) + 0.0148592152980862*std::exp(0.655519843101501*x_55) - 1457.49172842131*std::exp(0.655839860439301*x_55) + 1.19158747267291*std::exp(0.656479835510254*x_55) - 0.167358650348054*std::exp(0.657599866390228*x_55) - 5.84845400312016*std::exp(0.658879816532135*x_55) - 3.87262302182526*std::exp(0.342799842357635*x_56) - 293.878410152628*std::exp(0.434559851884842*x_56) + 4.01129613363265*std::exp(0.468159854412079*x_56) + 0.198973257052208*std::exp(0.510159850120544*x_56) + 5.81761296542527*std::exp(0.52839982509613*x_56) - 3.56266904103713*std::exp(0.568239867687225*x_56) - 0.000895436391666027*std::exp(0.658959865570068*x_56) - 0.0125129732900084*std::exp(0.678959846496582*x_56) + 0.00289539011663678*std::exp(0.747119843959808*x_56) + 0.000651421981362937*std::exp(0.824879884719849*x_56) + 1.67722070127431*std::exp(0.610959827899933*x_57) - 0.0156886986120491*std::exp(0.616639852523804*x_57) - 0.00199938341290854*std::exp(0.626079857349396*x_57) + 2.62120190915956*std::exp(0.627359867095947*x_57) - 0.0796200705645101*std::exp(0.628399848937988*x_57) + 857.828253000487*std::exp(0.632639825344086*x_57) + 0.0913059376508562*std::exp(0.636399865150452*x_57) - 4.86991617239286*std::exp(0.641759812831879*x_57) - 0.385099370253821*std::exp(0.643279850482941*x_57) - 1.58570146640322*std::exp(0.663679838180542*x_57) + 0.174287380002723*std::exp(0.437759846448898*x_58) + 0.0114860334986014*std::exp(0.485119849443436*x_58) + 0.0210673235869392*std::exp(0.554479837417603*x_58) + 0.352324207385841*std::exp(0.566799819469452*x_58) + 0.0165535834507178*std::exp(0.60647988319397*x_58) - 0.000662087422413583*std::exp(0.655439853668213*x_58) + 0.113158769355587*std::exp(0.522799849510193*x_59) + 0.36097154425423*std::exp(0.691839873790741*x_59) + 0.445924163339169*std::exp(0.765759825706482*x_59) + 0.0759893136553527*std::exp(0.827119886875153*x_59) + 0.0925803147505492*std::exp(0.860399901866913*x_59) + 0.000289830557468069*std::exp(0.780719876289368*x_60) - 0.222601506478902*std::exp(0.787359893321991*x_60) + 74.2680947883599*std::exp(0.816559851169586*x_60) - 0.00486311281133903*std::exp(0.838639855384827*x_60) + 0.311283509099067*std::exp(0.847519874572754*x_60) - 0.0190496784726654*std::exp(0.854399859905243*x_60) - 0.00117492925649013*std::exp(0.860399901866913*x_60) + 0.0119453061613598*std::exp(0.872479856014252*x_60) - 0.0264498026030805*std::exp(1.03615987300873*x_60) + 0.405413659256466*std::exp(0.983999848365784*x_61) + 0.00165522192182813*std::exp(1.18831992149353*x_61) + 0.285384526260811*std::exp(1.23887979984283*x_61) - 0.136326703091345*std::exp(1.32615983486176*x_61) - 0.0109298743236451*std::exp(0.599199831485748*x_66) + 55.2376062172208*std::exp(0.949999809265137*x_66) + 0.0172253855189614*std::exp(1.11047983169556*x_66) + 2.48817787111555e-5*std::exp(1.5058399438858*x_66) - 7.72707122414004e-8*std::exp(1.78991985321045*x_7) + 0.132642939305033*std::exp(0.455999851226807*x_8) + 0.000748078926862247*std::exp(0.519439876079559*x_8) - 0.0134518945723833*std::exp(0.636319875717163*x_8) - 0.0706795039466293*std::exp(0.878639876842499*x_8) + 0.872031146537575*std::exp(0.925199866294861*x_8) + 0.00117424641305966*std::exp(1.39863991737366*x_8) + 0.36642438060287*std::log(9.29800033569336 - 1.38431990146637*x_5) - 17.2681669195369*std::log(9.35847949981689 - 1.21983981132507*x_21) + 0.311418719414936*std::sin(0.170640021562576*x_1 + 4.96303987503052) - 6.80394856417982*std::sin(0.208320006728172*x_101 - 7.40863990783691) - 5.23837170058529*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.00865895881669146*std::sin(0.281839966773987*x_113 - 7.41663980484009) + 21.3760613342093*std::sin(0.30583992600441*x_113 - 1.2235199213028) + 3.44842708079524*std::sin(0.319439828395844*x_113 + 5.03800010681152) + 3.03235358912456*std::sin(0.296079933643341*x_114 - 4.47415971755981) - 4.28011477858785*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.118477741836624*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.00872518839864211*std::sin(0.267359972000122*x_117 + 1.94591987133026) - 9.29952295110266*std::sin(0.261759966611862*x_120 + 8.34208011627197) - 9.92827321201567*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.0963237191369411*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 1011.81677658817*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 0.0475157128572695*std::sin(0.128160044550896*x_18 - 4.62671995162964) - 5.65329360904982*std::sin(0.401599854230881*x_21 - 7.40983963012695) + 4.25010939292334*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 0.038992477143319*std::sin(0.0904000774025917*x_3 + 1.69007980823517) - 0.420086902161988*std::sin(0.602719843387604*x_3 + 2.19079995155334) + 1.00178580391051*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0370783701594915*std::sin(0.467679858207703*x_31 - 1.14271986484528) - 115.160260065823*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.0619151208051859*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.0501218833336844*std::sin(0.299839943647385*x_42 - 4.29496002197266) + 0.759354919545141*std::sin(0.198640003800392*x_47 + 8.2055196762085) + 4.08968291517045*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0338259932194084*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.046604145111636*std::sin(0.600559830665588*x_64 - 7.19495964050293) + 5.30498624958058*std::sin(0.644319832324982*x_64 + 8.4282398223877) + 3.96522654962956*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.00348400336749156*std::sin(0.564559817314148*x_65 + 5.36751985549927) - 1.71616264558156*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.0303571238988194*std::sin(0.397599816322327*x_73 + 2.00783967971802) - 8.46309820711171*std::sin(0.256959974765778*x_9 - 4.39328002929688) + 5.42399373137035*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.00532379979151694*std::sin(0.329519838094711*x_9 - 4.33071994781494) + 0.326812782009342*std::sin(0.36575984954834*x_9 + 2.02055978775024) - 17.52558061397*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 715.914916604088*std::sin(0.364799857139587*x_91 + 2.00895977020264) + 0.302586716061457*std::sin(0.379999846220016*x_91 - 1.18399977684021) + 5.70009763140806*std::sin(0.383119851350784*x_91 + 8.20567989349365) + 4.68490142671429*std::sin(0.393919825553894*x_91 - 4.39919996261597) + 23.4389067344215*std::sin(0.299039930105209*x_92 - 1.17503976821899) + 6.53454653452756*std::sin(0.306799918413162*x_92 + 8.20695972442627) + 7.33580548424546*std::sin(0.235759988427162*x_93 + 1.9755197763443) + 10.5803858782737*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.0367932927817975*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.00746027278381511*std::sin(0.301119923591614*x_97 - 7.45264005661011) - 9.00201706777109*std::sin(0.303199917078018*x_97 + 1.95719981193542) - 7.14753468309663*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.00664015037016118*std::sin(0.259039968252182*x_98 + 1.97271978855133) - 17.8042216176932*std::sin(0.266639977693558*x_98 + 1.94559979438782) - 0.222585068332797*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 92798.5269593014);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.32928797773236*x_1 - 1.21383018430541*x_10 + 11.2148405167739*x_100 + 7.05386474027205*x_101 + 0.464518724683446*x_102 - 2.79862399711056*x_103 - 60.1261361408206*x_104 + 13.1519486555347*x_105 - 0.0617232426398661*x_106 + 2.95611579168091*x_107 + 8.6140474139392*x_108 - 2.31405912485038*x_109 + 5.79687346504388*x_110 - 0.15454992831974*x_111 - 4.60429025568396*x_112 - 1.86891372271033*x_113 - 14.9903384060601*x_114 - 3.89056662804345*x_115 - 14.2139441133951*x_116 + 2.97655797359069*x_117 + 16.5127676644509*x_118 + 5.53698129451509*x_119 - 1.82152211280175*x_12 - 2.47398723698032*x_120 + 8.994021878054*x_13 + 3.54909619923009*x_14 - 0.0832823609480398*x_15 + 4.11777059035609*x_16 + 5.14650490617871*x_17 - 23.011841591371*x_18 + 0.118375406121901*x_19 + 2.17177634785845*x_2 - 0.175324722364482*x_20 + 1.07969651264506*x_21 + 3.91025397535486*x_22 - 0.0366993249343805*x_23 + 0.77759870507352*x_24 - 0.174263726758562*x_25 + 0.490257155602787*x_26 - 10.4530879907123*x_27 + 1.7888311379375*x_28 + 2.60121935678885*x_29 + 0.463382808318978*x_3 - 0.0985075427386426*x_30 - 0.529748478901766*x_31 - 9.55016528630969*x_32 - 18.5347793472451*x_33 - 15.725468110444*x_34 + 133.061986716285*x_35 - 43.2843516925893*x_36 + 74.573503005823*x_37 - 82.7071057805353*x_38 - 0.656286681276139*x_39 + 4.01375689929251*x_4 + 935.464344310211*x_40 + 7.82021228352462*x_41 - 1.95002017407687*x_42 - 14.4960616405933*x_43 + 3.66343935938171*x_44 + 43.1041262334535*x_45 + 53.4118526310001*x_46 - 54.788354357179*x_47 + 42.3087244797557*x_48 - 10.5736908137048*x_5 + 0.107332071395764*x_50 + 1.06706961925915*x_52 - 4.63258457915181*x_53 - 11.0835342973797*x_54 - 14.7583146877723*x_58 + 7.2616686665216*x_59 - 5.51427352903993*x_6 + 2.66424313917762*x_60 - 4.33937112064677*x_61 - 9.0403404837721*x_62 - 2.44538721118805*x_63 - 1.12866275825211*x_64 - 1.66681952164146*x_65 + 1.09212595465074*x_66 - 4.90358549886894*x_67 - 2.85285545883705*x_68 - 5.33685686354207*x_69 - 15.0081374617376*x_7 + 3.41504630543038*x_70 + 3.53622720141047*x_71 - 4.530532281718*x_72 - 3.42998143790407*x_73 - 2.15646957786295*x_74 + 7.72880611401739*x_75 - 3.67658780701905*x_76 + 1.66167902719116*x_77 + 7.44359886060814*x_78 - 4.41332726073815*x_79 + 1.76554568360976*x_8 - 0.0142407331376631*x_80 + 1.2435772064307*x_81 - 0.56328205878591*x_82 - 12.6937685633483*x_83 - 0.998156093199299*x_84 - 2.72066914071751*x_85 - 27.9295032768324*x_86 + 6.75553353723088*x_87 - 6.24392326905475*x_88 + 1.1510454887789*x_89 + 1.75858125557565*x_9 - 5.87924479768024*x_90 - 4.649902433794*x_91 - 1.81304723098814*x_92 + 13.3707341404533*x_93 - 1.53169410077237*x_94 - 2.10867977154713*x_95 + 3.00893447712957*x_96 + 7.56388260002484*x_97 + 6.47341675370411*x_98 + 20.0720854111118*x_99 - 0.0232495340074039*std::pow(-7.7422399520874*x_2 - 5.70232009887695, 2) + 1.29169688708379e-5*std::pow(-7.38912010192871*x_32 - 3.27551984786987, 2) + 0.0370208572247101*std::pow(-5.13872003555298*x_61 - 6.57087993621826, 2) - 0.00695430923609785*std::exp(1.13951992988586*x_1) + 0.736415595368261*std::exp(1.17007982730865*x_1) - 0.866113313885423*std::exp(1.22071981430054*x_1) + 0.00192934491754233*std::exp(1.40399980545044*x_1) + 0.118819783220409*std::exp(1.6639997959137*x_1) - 0.011498854156894*std::exp(1.76023995876312*x_1) + 0.0100735186271231*std::exp(0.627359867095947*x_10) + 0.00850480763427921*std::exp(0.778879821300507*x_10) + 2.34755575960682*std::exp(0.80351984500885*x_10) + 0.00821464897270003*std::exp(0.810399830341339*x_10) + 0.682359564624205*std::exp(0.840799868106842*x_10) - 0.00015661083455655*std::exp(0.934159815311432*x_10) + 0.346268831048729*std::exp(0.94543981552124*x_10) - 0.0245238934524825*std::exp(0.969839811325073*x_10) - 0.579634164840156*std::exp(0.82207989692688*x_11) - 0.00165741797658136*std::exp(0.895919859409332*x_11) - 0.00813357577436069*std::exp(0.902079820632935*x_11) + 0.477151500971529*std::exp(0.914159834384918*x_11) + 2.81943346963561*std::exp(0.925199866294861*x_11) - 0.000751061808643945*std::exp(0.933279812335968*x_11) - 0.0199692503399748*std::exp(0.937199831008911*x_11) - 0.00428827008060368*std::exp(0.951599836349487*x_11) - 0.202627227203046*std::exp(0.983759820461273*x_11) + 0.0158387079473572*std::exp(1.06111979484558*x_11) - 0.0107076569503065*std::exp(0.537679851055145*x_12) - 0.029913362233225*std::exp(0.696079850196838*x_12) + 0.00316611283954761*std::exp(0.854959905147552*x_12) + 0.000127975128849722*std::exp(0.925439834594727*x_12) - 0.026701356249065*std::exp(1.2235199213028*x_12) + 0.00021612537212841*std::exp(1.10399985313416*x_13) - 2.96351052739338e-5*std::exp(1.32895994186401*x_13) - 6.36507589404932e-5*std::exp(1.4015998840332*x_13) - 9.12699281640315*std::exp(0.345279842615128*x_14) + 0.020369872174672*std::exp(0.428239852190018*x_14) + 0.022486710710823*std::exp(0.715599834918976*x_14) + 0.00134735878383413*std::exp(0.868079900741577*x_14) - 0.0618810484514458*std::exp(0.67935985326767*x_15) + 1.03159491197077*std::exp(0.82151985168457*x_15) + 0.169656268225388*std::exp(0.898239850997925*x_15) + 0.754729254727313*std::exp(0.92087984085083*x_15) + 0.00382140232570891*std::exp(0.927359819412231*x_15) + 0.000392025594727331*std::exp(0.993359804153442*x_15) + 0.00017846634199757*std::exp(1.03111982345581*x_15) - 0.000449051163549711*std::exp(1.05295991897583*x_15) + 2.8313792999175*std::exp(0.357999831438065*x_16) + 0.0461206801745725*std::exp(0.539119839668274*x_16) + 5.66431927508932*std::exp(0.590719819068909*x_16) + 0.00953565978925307*std::exp(0.703679859638214*x_16) + 0.000341624873411896*std::exp(0.912239849567413*x_16) + 0.0351365479468755*std::exp(0.620319843292236*x_17) - 0.25702110074615*std::exp(0.655279815196991*x_17) + 3.09664211073851*std::exp(0.659599840641022*x_17) - 2.23165103527357*std::exp(0.695119857788086*x_17) + 0.0314252422135769*std::exp(0.7079998254776*x_17) + 0.000804599991684857*std::exp(0.857999861240387*x_17) + 7.10264464317507*std::exp(0.434639871120453*x_18) - 0.00844492415956414*std::exp(0.695919871330261*x_19) - 0.0141143970977184*std::exp(0.704799830913544*x_19) + 8.08366441841511*std::exp(0.716879844665527*x_19) + 5.30346952776844*std::exp(0.719519853591919*x_19) - 0.0265189677351468*std::exp(0.728719890117645*x_19) + 9.80336071569124*std::exp(0.748239874839783*x_19) + 1.14113519299997*std::exp(0.766079843044281*x_19) - 1.44079858227814*std::exp(0.823999881744385*x_19) - 0.000127110335789366*std::exp(1.00991988182068*x_19) - 2.76186480626996*std::exp(0.735999822616577*x_2) - 0.0295481499204869*std::exp(0.754559874534607*x_2) + 0.5098585242507*std::exp(0.755999863147736*x_2) - 1.71129172190049*std::exp(0.924879848957062*x_2) + 0.00377479258941802*std::exp(1.01583981513977*x_2) + 0.000658848277009785*std::exp(1.11415982246399*x_2) - 0.0398821009645401*std::exp(0.26639986038208*x_20) + 0.371269579103579*std::exp(0.403999865055084*x_20) - 1.40109789247964*std::exp(0.516959846019745*x_20) - 3.13786333438595*std::exp(0.532159864902496*x_20) - 0.354157970512572*std::exp(0.886239886283875*x_20) + 0.145276334851754*std::exp(0.916319847106934*x_20) + 6.78074754708632e-5*std::exp(1.04447984695435*x_20) + 0.0477092222747341*std::exp(0.525999844074249*x_22) + 1.77140001940422*std::exp(0.651039838790894*x_22) - 6.09248167953603e-5*std::exp(1.28135991096497*x_22) + 0.00871164998690988*std::exp(1.33199989795685*x_22) + 0.214485422427456*std::exp(0.638159871101379*x_23) + 2.34499216603529*std::exp(0.658639848232269*x_23) + 0.0133528629991275*std::exp(0.673119843006134*x_23) - 0.0198387789225939*std::exp(0.69023984670639*x_23) - 0.00132558458237075*std::exp(0.733039855957031*x_23) - 0.48297174781859*std::exp(0.734799861907959*x_23) + 1.39032903928965*std::exp(0.736159861087799*x_23) + 0.619028531081271*std::exp(0.747999846935272*x_23) + 1.91243310551466*std::exp(0.818959891796112*x_23) - 11.0297325719236*std::exp(0.305759847164154*x_24) - 0.478904540595139*std::exp(0.42087984085083*x_24) + 1.66251578140677*std::exp(0.60511988401413*x_24) - 0.0475994784381572*std::exp(0.611999869346619*x_24) + 0.00686031015972225*std::exp(0.650239825248718*x_24) - 0.00521014083105869*std::exp(0.758959889411926*x_24) - 1.45793759943954*std::exp(0.766159892082214*x_24) - 0.0262375926588323*std::exp(0.412159860134125*x_25) - 0.0044858470388872*std::exp(0.525519847869873*x_25) + 6.71103693382874*std::exp(0.589919865131378*x_25) - 0.0544097582079186*std::exp(0.660079836845398*x_25) - 0.696016434574209*std::exp(0.767039835453033*x_25) - 0.32644710173762*std::exp(0.949439823627472*x_25) - 0.119229508382393*std::exp(0.987279832363129*x_25) + 0.00172879739564969*std::exp(0.993919789791107*x_25) + 0.0414735379752714*std::exp(0.42087984085083*x_26) + 2.63774001466189*std::exp(0.573839843273163*x_26) + 0.0855552118056774*std::exp(0.728879868984222*x_26) + 0.00109286761504171*std::exp(0.8193598985672*x_26) - 0.00176883614722617*std::exp(0.839599847793579*x_26) - 0.258148574091318*std::exp(0.860319912433624*x_26) - 0.0007703262393619*std::exp(0.960159838199615*x_26) - 0.0309542449270856*std::exp(1.13951992988586*x_26) + 9.42523206121243e-5*std::exp(1.18455982208252*x_27) - 0.070311363701984*std::exp(1.20399987697601*x_27) + 0.0381525845335916*std::exp(1.23751986026764*x_27) - 0.0057636474740584*std::exp(1.25919985771179*x_27) - 0.014701496684852*std::exp(1.28719985485077*x_27) + 6.04023030219189*std::exp(0.516239881515503*x_28) - 0.817875034169433*std::exp(0.543999850749969*x_28) + 0.0071187883717839*std::exp(0.647999823093414*x_28) + 0.00943416699022524*std::exp(0.654319822788239*x_28) + 0.594857762787737*std::exp(0.736559867858887*x_28) - 0.417499929751896*std::exp(0.906079828739166*x_28) + 0.180055724431242*std::exp(0.932239830493927*x_29) + 0.000643181614126763*std::exp(1.12255990505219*x_29) + 0.063491002370927*std::exp(1.15015983581543*x_29) - 0.0272536731316803*std::exp(1.15143990516663*x_29) - 0.133755061971627*std::exp(1.16695988178253*x_29) - 1.37581866374186*std::exp(0.439999848604202*x_3) - 6.92594350708747*std::exp(0.526399850845337*x_3) - 0.00367440637864333*std::exp(0.633039832115173*x_3) - 0.0140192331488751*std::exp(0.658079862594604*x_3) - 0.00348668702374058*std::exp(0.925759851932526*x_3) - 0.118519014283096*std::exp(0.94135981798172*x_3) - 0.00128460699524424*std::exp(0.634159862995148*x_30) + 2.29572962624908*std::exp(0.828479886054993*x_30) - 0.298113886628163*std::exp(0.857279896736145*x_30) - 1.05589785199222*std::exp(0.885519862174988*x_30) + 1.11695285527273*std::exp(0.91239982843399*x_30) - 0.627983018750297*std::exp(0.947999835014343*x_30) + 0.00118309479292854*std::exp(1.02791976928711*x_30) + 0.000773928027206884*std::exp(1.02927982807159*x_30) - 0.00159859137888523*std::exp(1.09479975700378*x_30) - 1.06578692955572*std::exp(0.826799869537354*x_32) + 0.00274821748330097*std::exp(0.831519842147827*x_32) + 0.00121908598701836*std::exp(0.832079887390137*x_32) - 2.83890388601846*std::exp(0.333039849996567*x_33) + 0.400038802488757*std::exp(0.360239863395691*x_33) + 0.0570738391159266*std::exp(0.404719859361649*x_33) - 1.92608954017851*std::exp(0.417439848184586*x_33) - 7.17615896926632*std::exp(0.369439840316772*x_34) - 0.971716426738231*std::exp(0.426799863576889*x_36) - 2.49355115741158*std::exp(0.261359840631485*x_37) + 0.064889650315656*std::exp(0.355199843645096*x_4) + 5.01169500324426*std::exp(0.535359859466553*x_4) + 0.0150681554251535*std::exp(0.541439831256866*x_4) + 0.0481715345586309*std::exp(0.586239874362946*x_4) + 1.73181509622049*std::exp(0.747519850730896*x_4) - 0.0386945789815607*std::exp(1.09559988975525*x_4) + 0.0706272822952423*std::exp(1.10943984985352*x_4) - 0.00055477200083138*std::exp(1.15591979026794*x_4) - 1.42377889968762*std::exp(0.715999841690063*x_41) - 0.723873146778004*std::exp(0.747999846935272*x_41) - 0.0207716351241504*std::exp(0.770959854125977*x_41) - 0.00096071129606349*std::exp(0.788479864597321*x_41) + 0.00552381152461146*std::exp(0.796479880809784*x_41) - 0.0133576675578938*std::exp(0.802159905433655*x_41) - 0.158460504935985*std::exp(0.802399873733521*x_41) + 0.0962049226564267*std::exp(0.806319832801819*x_41) - 0.269750131854997*std::exp(0.812319874763489*x_41) - 0.0981566403294929*std::exp(0.585839867591858*x_42) - 0.570711111346831*std::exp(0.693759858608246*x_42) + 0.512944556787006*std::exp(0.720399856567383*x_42) + 0.0188518750150098*std::exp(0.851439893245697*x_42) + 0.000303498822807265*std::exp(0.704879820346832*x_43) - 0.0125143927202998*std::exp(0.761919856071472*x_43) - 0.000618677889215012*std::exp(0.818479895591736*x_43) + 0.0143894822363853*std::exp(0.875679850578308*x_44) + 3.52968268826965e-5*std::exp(0.960559844970703*x_44) + 7.87828270147041e-5*std::exp(0.99999988079071*x_44) + 1.89311489694231*std::exp(0.555919826030731*x_45) - 1.41028338571654*std::exp(0.518719851970673*x_46) + 0.46186122373856*std::exp(0.702239871025085*x_46) + 0.000684843575557948*std::exp(0.715279817581177*x_46) + 0.00929823411901999*std::exp(0.752959847450256*x_46) - 0.0580838578449925*std::exp(0.756079852581024*x_46) + 0.00485854552803941*std::exp(0.795919895172119*x_46) + 0.0544878752159901*std::exp(0.406479865312576*x_47) + 0.138544266473707*std::exp(0.552319884300232*x_47) - 0.00663874320152573*std::exp(0.586239874362946*x_48) - 1.64141442538572*std::exp(0.600879848003387*x_48) - 0.00310892120269604*std::exp(0.65559983253479*x_49) - 0.0173271354277827*std::exp(0.684479832649231*x_49) - 6.05071093304356*std::exp(0.703759849071503*x_49) - 0.50350710206055*std::exp(0.7079998254776*x_49) + 0.657088855837091*std::exp(0.708239853382111*x_49) + 0.0175148650780855*std::exp(0.709119856357574*x_49) - 0.00779774168020673*std::exp(0.714559853076935*x_49) - 7.77775009351216*std::exp(0.71919983625412*x_49) + 2.02506567386747*std::exp(0.719519853591919*x_49) - 4.12891040501284*std::exp(0.722239851951599*x_49) - 0.00049633930202485*std::exp(2.06119966506958*x_5) + 0.0318689295536815*std::exp(0.325439840555191*x_50) + 0.842926512749671*std::exp(0.535359859466553*x_50) + 0.520942523655426*std::exp(0.535439848899841*x_50) + 2.00202295827056*std::exp(0.538639843463898*x_50) - 0.212332918054598*std::exp(0.539039850234985*x_50) - 5.84395701544581*std::exp(0.550159871578217*x_50) - 0.00259840847447771*std::exp(0.591119825839996*x_50) - 3.09827940329658*std::exp(0.592239856719971*x_50) + 0.00301415750005404*std::exp(0.642959833145142*x_50) + 0.0201002945094866*std::exp(0.460479855537415*x_51) + 0.0805300276914395*std::exp(0.483199834823608*x_51) - 4.93976087141683*std::exp(0.488399863243103*x_51) + 2.54529492004079*std::exp(0.493759840726852*x_51) - 119.299121704053*std::exp(0.494479864835739*x_51) - 0.050153691639645*std::exp(0.495999842882156*x_51) + 27.23734504675*std::exp(0.49703985452652*x_51) + 0.116968066901707*std::exp(0.498159825801849*x_51) - 9.79800393139872*std::exp(0.499919831752777*x_51) + 12.3402253296254*std::exp(0.50631982088089*x_51) - 0.845431467780247*std::exp(0.521999835968018*x_52) - 0.0718371630794072*std::exp(0.526719868183136*x_52) - 0.0112026852959408*std::exp(0.590079843997955*x_52) + 0.00971700347932774*std::exp(0.628719866275787*x_52) + 0.00365403863597803*std::exp(0.705759823322296*x_52) - 0.203253357752748*std::exp(0.709279835224152*x_52) + 0.696209876304422*std::exp(0.720719873905182*x_52) + 0.0289623466125906*std::exp(0.887439906597137*x_52) + 5.91228353543532*std::exp(0.48039984703064*x_54) + 0.0479904181042528*std::exp(0.49823984503746*x_54) + 0.0235791377732247*std::exp(0.512639820575714*x_54) - 3.95203904076771*std::exp(0.519359886646271*x_54) + 0.0599418900414715*std::exp(0.533919811248779*x_54) - 6.32988351333965*std::exp(0.535759806632996*x_54) - 0.0152787102670508*std::exp(0.538879811763763*x_54) - 0.022774853502899*std::exp(0.629039824008942*x_55) + 5.26527513226794*std::exp(0.631839871406555*x_55) - 0.11718679716536*std::exp(0.651679813861847*x_55) + 23.8639874506971*std::exp(0.653599858283997*x_55) - 2.84724706499562*std::exp(0.653759837150574*x_55) + 0.579910510008552*std::exp(0.655519843101501*x_55) - 49.101964503627*std::exp(0.655839860439301*x_55) - 1.74585874599754*std::exp(0.656479835510254*x_55) + 0.0119076125693242*std::exp(0.657599866390228*x_55) + 16.747971330807*std::exp(0.658879816532135*x_55) + 11.0898673922973*std::exp(0.342799842357635*x_56) - 9.90057575100383*std::exp(0.434559851884842*x_56) - 3.29584828425649*std::exp(0.468159854412079*x_56) - 0.291526395678692*std::exp(0.510159850120544*x_56) - 9.79536613210509*std::exp(0.52839982509613*x_56) + 4.71495321459097*std::exp(0.568239867687225*x_56) - 0.0349461909094315*std::exp(0.658959865570068*x_56) + 0.0008903013839909*std::exp(0.678959846496582*x_56) + 0.00211237376353424*std::exp(0.747119843959808*x_56) + 0.00136412955688242*std::exp(0.824879884719849*x_56) - 1.3780745141866*std::exp(0.610959827899933*x_57) - 0.0328533855135489*std::exp(0.616639852523804*x_57) - 0.0780299249605575*std::exp(0.626079857349396*x_57) - 7.50622547487596*std::exp(0.627359867095947*x_57) + 0.00566498923750113*std::exp(0.628399848937988*x_57) + 28.8996854031288*std::exp(0.632639825344086*x_57) + 0.0666135682512441*std::exp(0.636399865150452*x_57) + 8.19968812376311*std::exp(0.641759812831879*x_57) + 0.564229751532758*std::exp(0.643279850482941*x_57) + 2.09856939847069*std::exp(0.663679838180542*x_57) - 0.255357792585889*std::exp(0.437759846448898*x_58) + 0.0240526697517967*std::exp(0.485119849443436*x_58) - 0.0014989456871464*std::exp(0.554479837417603*x_58) - 0.289484270353048*std::exp(0.566799819469452*x_58) + 0.0120769063805427*std::exp(0.60647988319397*x_58) - 0.0258392820280059*std::exp(0.655439853668213*x_58) - 0.165794985006528*std::exp(0.522799849510193*x_59) - 1.03369900339161*std::exp(0.691839873790741*x_59) - 0.750821767109509*std::exp(0.765759825706482*x_59) - 0.0624359909339364*std::exp(0.827119886875153*x_59) - 0.122523829076717*std::exp(0.860399901866913*x_59) + 0.011311215499988*std::exp(0.780719876289368*x_60) + 0.637454555804685*std::exp(0.787359893321991*x_60) + 2.50204463115548*std::exp(0.816559851169586*x_60) - 0.00354795433359853*std::exp(0.838639855384827*x_60) - 0.255763520119966*std::exp(0.847519874572754*x_60) + 0.0279107061232705*std::exp(0.854399859905243*x_60) - 0.00246039552222464*std::exp(0.860399901866913*x_60) - 0.000849911716517898*std::exp(0.872479856014252*x_60) + 0.0445346746438537*std::exp(1.03615987300873*x_60) - 0.682612482297245*std::exp(0.983999848365784*x_61) + 0.0034661666498286*std::exp(1.18831992149353*x_61) - 0.817243644478022*std::exp(1.23887979984283*x_61) + 0.112011707815512*std::exp(1.32615983486176*x_61) - 0.0228880281053758*std::exp(0.599199831485748*x_66) + 1.86091963806966*std::exp(0.949999809265137*x_66) - 0.0252378366264625*std::exp(1.11047983169556*x_66) + 0.000971061034707841*std::exp(1.5058399438858*x_66) - 3.01564364239382e-6*std::exp(1.78991985321045*x_7) - 0.19434228790695*std::exp(0.455999851226807*x_8) + 0.0291952719777343*std::exp(0.519439876079559*x_8) + 0.000957105883431841*std::exp(0.636319875717163*x_8) + 0.0580732297128206*std::exp(0.878639876842499*x_8) + 0.0293781718059726*std::exp(0.925199866294861*x_8) - 0.00336263998156337*std::exp(1.39863991737366*x_8) - 0.0260711923231897*std::log(9.29800033569336 - 1.38431990146637*x_5) + 22.8532592249046*std::log(9.35847949981689 - 1.21983981132507*x_21) - 0.0221575248719807*std::sin(0.170640021562576*x_1 + 4.96303987503052) + 11.4561019659169*std::sin(0.208320006728172*x_101 - 7.40863990783691) + 4.30406477270892*std::sin(0.231999978423119*x_108 - 1.19423997402191) + 0.3379331359562*std::sin(0.281839966773987*x_113 - 7.41663980484009) - 28.2897816053336*std::sin(0.30583992600441*x_113 - 1.2235199213028) - 2.8333715833964*std::sin(0.319439828395844*x_113 + 5.03800010681152) - 2.49150824098455*std::sin(0.296079933643341*x_114 - 4.47415971755981) + 12.2567843683321*std::sin(0.237999975681305*x_117 + 1.98111975193024) - 0.0864371512427399*std::sin(0.248959973454475*x_117 + 1.95943987369537) + 0.340517877470215*std::sin(0.267359972000122*x_117 + 1.94591987133026) + 7.64087610132112*std::sin(0.261759966611862*x_120 + 8.34208011627197) + 28.4311777147512*std::sin(0.265119940042496*x_120 + 5.15704011917114) + 0.201709546289219*std::sin(0.270399957895279*x_120 - 7.43680000305176) - 34.0874603123957*std::sin(0.271919965744019*x_120 + 5.14680004119873) + 1.85439545249931*std::sin(0.128160044550896*x_18 - 4.62671995162964) + 16.1890987325006*std::sin(0.401599854230881*x_21 - 7.40983963012695) - 3.4920672231405*std::sin(0.435999870300293*x_22 - 7.41879987716675) + 1.52175918129347*std::sin(0.0904000774025917*x_3 + 1.69007980823517) + 0.615491861938905*std::sin(0.602719843387604*x_3 + 2.19079995155334) - 0.823109018386259*std::sin(0.262639969587326*x_31 - 4.33039999008179) + 0.0270510615717993*std::sin(0.467679858207703*x_31 - 1.14271986484528) + 152.40687028072*std::sin(0.150160029530525*x_33 + 7.99456024169922) + 0.129655198511398*std::sin(0.289919942617416*x_35 + 4.95607948303223) + 0.104959219151676*std::sin(0.299839943647385*x_42 - 4.29496002197266) - 0.0540283048754822*std::sin(0.198640003800392*x_47 + 8.2055196762085) - 3.36025413484269*std::sin(0.422719866037369*x_5 - 7.41439962387085) - 0.0246782429046777*std::sin(0.511599838733673*x_6 + 5.09880018234253) + 0.034000728551258*std::sin(0.600559830665588*x_64 - 7.19495964050293) - 8.9322343973816*std::sin(0.644319832324982*x_64 + 8.4282398223877) - 11.3550522134432*std::sin(0.427759855985641*x_65 - 0.986319839954376) - 0.135970179392566*std::sin(0.564559817314148*x_65 + 5.36751985549927) + 4.91450266546813*std::sin(0.5136798620224*x_72 + 2.13903999328613) + 0.063570237353181*std::sin(0.397599816322327*x_73 + 2.00783967971802) + 6.95363462984797*std::sin(0.256959974765778*x_9 - 4.39328002929688) - 15.5324623332942*std::sin(0.298719942569733*x_9 + 1.96815979480743) - 0.207771903855492*std::sin(0.329519838094711*x_9 - 4.33071994781494) - 0.0232528165277207*std::sin(0.36575984954834*x_9 + 2.02055978775024) + 23.1939289621345*std::sin(0.359999865293503*x_91 - 7.40607976913452) + 24.1187158302346*std::sin(0.364799857139587*x_91 + 2.00895977020264) - 0.021529125479864*std::sin(0.379999846220016*x_91 - 1.18399977684021) - 16.3231294394539*std::sin(0.383119851350784*x_91 + 8.20567989349365) - 3.84931050083402*std::sin(0.393919825553894*x_91 - 4.39919996261597) - 31.019818956236*std::sin(0.299039930105209*x_92 - 1.17503976821899) - 5.36905610225115*std::sin(0.306799918413162*x_92 + 8.20695972442627) - 6.02740388977323*std::sin(0.235759988427162*x_93 + 1.9755197763443) - 14.0024301538425*std::sin(0.316239923238754*x_94 + 1.95431983470917) - 0.0268430792450801*std::sin(0.278399974107742*x_95 - 7.43935966491699) + 0.291152023042721*std::sin(0.301119923591614*x_97 - 7.45264005661011) + 7.39643285343591*std::sin(0.303199917078018*x_97 + 1.95719981193542) + 20.4680939432177*std::sin(0.242159977555275*x_98 + 5.18111991882324) - 0.259145110320166*std::sin(0.259039968252182*x_98 + 1.97271978855133) + 23.5626916176291*std::sin(0.266639977693558*x_98 + 1.94559979438782) + 0.0158369869254524*std::sin(0.279279947280884*x_98 + 1.9366397857666) - 3224.28940913363);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
