
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7014.50723747714*x_1 - 190.278721592592*x_10 - 50.9455569442292*x_100 + 315.570302182678*x_101 - 6.05196325900606*x_102 - 31.434228527479*x_103 - 174.40981244689*x_104 + 52.8606058361009*x_105 + 10.8568907922599*x_106 - 167.143325639464*x_107 + 17.7550892040746*x_108 + 196.741067895962*x_109 + 50.2582976188527*x_11 + 127.744323417641*x_110 + 31.4281327810336*x_111 - 173.435365383036*x_112 + 409.565542095285*x_113 - 80.9070834852304*x_114 + 5.35108512497938*x_115 + 1039.34502811167*x_116 - 114.099677556502*x_117 + 51.778945346377*x_118 - 128.515733640347*x_119 - 1145.79461935212*x_12 - 78.391713454228*x_120 + 372.161476713971*x_13 - 107.265567322284*x_14 + 91.2469324477925*x_15 - 45.7470154871486*x_16 - 185.847865545953*x_17 + 5.807785288439*x_18 + 41.5380548455827*x_19 - 26.9766306802051*x_2 + 213.441220241586*x_20 + 856.449955983609*x_21 + 84.2818526570315*x_22 + 33.6596665239533*x_23 + 142.12905576857*x_24 + 321.333043118556*x_25 + 141.830375453505*x_26 + 156.16650770077*x_27 - 0.553089999659505*x_28 + 132.337873322125*x_29 - 233.322840290333*x_3 - 669.374230909614*x_30 + 1673.86555579687*x_31 + 1.51560388826804*x_32 + 46.7969810773843*x_33 + 64.2438409584996*x_34 - 169.760444397148*x_35 - 1.35978643074755*x_36 - 1290.53906975346*x_37 + 118.693078437117*x_38 - 163.666671102355*x_39 - 46.1023589731038*x_4 - 76.6557434202279*x_40 + 7.97758377639662*x_41 + 194102.627295714*x_42 + 252.470415613147*x_43 + 294.215073204374*x_44 - 7.53573839982533*x_45 - 114.691343948853*x_46 + 1122.41958028133*x_47 + 574.598402325454*x_48 + 114.786710674415*x_49 + 76.3351387388748*x_5 - 926.83322732795*x_50 - 108.022920221779*x_51 - 10.4111737574173*x_52 + 0.0961178927960624*x_53 + 365.206843860852*x_54 - 17.1791951561008*x_55 + 79.3307849545359*x_56 + 3268.71652603547*x_57 + 149.550937794049*x_58 + 112.854810784845*x_59 - 55.722193258704*x_6 + 172.728918403514*x_60 + 63.2572419636214*x_61 + 32.6077194905244*x_62 + 3.25867290663247*x_63 - 74.5697135200612*x_64 - 8.35151861351209*x_65 - 64.5173958030312*x_66 - 119.545977015155*x_67 + 249.949072201416*x_68 + 13.0266369066034*x_69 - 37.146520146848*x_7 + 107.886484785724*x_70 - 97.3721612384333*x_72 - 91.4926489944646*x_73 + 333.764112132176*x_74 - 0.0436646951903762*x_75 + 67.2032374227255*x_76 + 8.45145861244504*x_77 + 8.44487566237982*x_78 + 38.6946224174283*x_79 + 715.468839017144*x_8 - 46.4127923278878*x_80 + 63.0503129079509*x_81 - 182.053268196076*x_82 - 97.7012978919186*x_83 - 274.743653836182*x_84 - 285.148988709893*x_85 + 138.511724838137*x_86 + 13.0304556623143*x_87 - 181.085243868959*x_88 + 2.01927329344519*x_89 - 68.5215149164216*x_9 - 134.852867716748*x_90 + 300.311510599768*x_91 - 81.6693007750428*x_92 - 269.009910646688*x_93 + 27.5823775967412*x_94 - 4.50602091321693*x_95 + 132.766149492446*x_96 + 723.551037863769*x_97 - 77.2255513549013*x_98 + 33.6178413951053*x_99 + 0.0024792591495224*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 0.870096308472053*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 105.431174998909*std::exp(0.723999857902527*x_108) - 0.11421528290597*std::exp(0.889599919319153*x_50) + 0.0122328226511506*std::exp(2.49287986755371*x_71) + 2.57989621263648*std::exp(2.52551984786987*x_71) + 0.526409229847044*std::exp(2.58607983589172*x_71) - 0.0281934748577358*std::exp(2.63183999061584*x_71) + 0.00776862003993721*std::exp(2.72359991073608*x_71) - 0.119355799439565*std::exp(1.85487985610962*x_89) - 7.59052146372412*std::exp(1.90791976451874*x_89) - 54.9930620125545*std::sin(0.408079862594604*x_107 + 2.0079197883606) - 0.660674239427514*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 8123.03561062546*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 1.35179085659151*std::sin(0.412159860134125*x_24 + 2.02311968803406) + 0.745729224620237*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 1069.3631589214*std::sin(0.323119848966599*x_28 - 4.28615999221802) - 78.2902816017464*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 1043.69627362693*std::sin(0.354239851236343*x_36 + 5.17072010040283) - 0.760380150781282*std::sin(0.418559849262238*x_45 + 5.21848011016846) + 150.682624440805*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 1159.70124539204*std::sin(0.321759849786758*x_53 - 4.29120016098022) - 1.14303550733489*std::sin(0.349839836359024*x_53 - 1.06535983085632) + 0.571368109009267*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 3.9682264035355*std::sin(0.269759953022003*x_75 + 1.87255990505219) + 1.31137496467828*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 628.246903916898*std::sin(0.411759853363037*x_75 - 0.997599840164185) - 0.656863915523592*std::sin(0.386559844017029*x_80 - 7.4223198890686) + 35.1613088313391*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.179980890342142*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.45313256744856*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 1.35984717605097*std::sin(0.399119853973389*x_87 + 5.19600009918213) - 69.1732240755941*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 504.930969516507*std::sin(0.378879845142365*x_95 + 5.1814398765564) - 0.624059992809439*std::sin(0.379839837551117*x_95 - 7.4236798286438) - 53.7573489066078*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.734422649665317*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 605909.857982285 - 0.00631566355141315*std::exp(-4.1954402923584*x_45) - 9.06204895743034e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9653.02125034073*x_1 - 280.040225823761*x_10 - 87.5120170307259*x_100 + 528.360746179112*x_101 - 20.8282969189784*x_102 - 47.2027314017796*x_103 - 283.445487603192*x_104 + 75.0667316663019*x_105 + 33.7519073245526*x_106 - 239.862983576431*x_107 + 1.12149020177239*x_108 + 293.692459276414*x_109 + 56.8843514327577*x_11 + 189.990090938458*x_110 + 48.3441894721341*x_111 - 229.133075273552*x_112 + 535.447393049086*x_113 - 105.342472449857*x_114 - 1.91639530479443*x_115 + 1404.18249391439*x_116 - 156.480204880967*x_117 + 66.5423986644837*x_118 - 185.11836550267*x_119 - 1637.9397790308*x_12 - 119.05558463774*x_120 + 535.966531022355*x_13 - 148.655835572047*x_14 + 119.452439258098*x_15 - 67.4874350742118*x_16 - 276.555015019459*x_17 - 0.969619393209044*x_18 + 63.4620328834056*x_19 - 51.6687207760394*x_2 + 334.458061876206*x_20 + 1183.19261112284*x_21 + 148.382055020462*x_22 + 42.2531712535463*x_23 + 216.503462169502*x_24 + 444.949115375365*x_25 + 187.412037596114*x_26 + 230.432553972041*x_27 + 1.67991485986318*x_28 + 175.75783408949*x_29 - 360.230216173907*x_3 - 884.722850061166*x_30 + 2876.52264354668*x_31 - 6.2328296207454*x_32 + 64.2013783938942*x_33 + 70.8224298788725*x_34 - 249.652541852878*x_35 - 1.21395318537913*x_36 - 1946.53951755867*x_37 + 187.774156951686*x_38 - 241.909396437883*x_39 - 64.1946597055654*x_4 - 113.45490750077*x_40 + 12.1485198439812*x_41 + 265360.730987505*x_42 + 339.20611680388*x_43 + 470.07073958697*x_44 - 0.630816956631949*x_45 - 172.885186953977*x_46 + 1476.61215740777*x_47 + 806.303984583202*x_48 + 149.546648969561*x_49 + 93.4445631584615*x_5 - 1346.90878360107*x_50 - 185.115889271578*x_51 - 51.1046670284764*x_52 + 0.130308561821599*x_53 + 536.042159231878*x_54 - 26.4312675193835*x_55 + 97.37922111225*x_56 + 4430.97560182681*x_57 + 194.544714312458*x_58 + 145.973609924222*x_59 - 80.7565182902648*x_6 + 238.872564745712*x_60 + 85.4809886687764*x_61 + 49.9383371364665*x_62 - 21.8337467430944*x_63 - 114.83654015882*x_64 + 2.08508869750126*x_65 - 89.5777405715318*x_66 - 167.234864212683*x_67 + 340.31828289363*x_68 + 4.94480242933446*x_69 - 52.9105572065835*x_7 + 137.464263655326*x_70 - 138.127644269016*x_72 - 101.457633826158*x_73 + 476.896399681431*x_74 - 2.13282879236871*x_75 + 103.58697590788*x_76 - 0.0216205622285728*x_77 + 3.24744652938422*x_78 + 62.4112722148751*x_79 + 912.350583567595*x_8 - 68.4402727105386*x_80 + 70.5136287241575*x_81 - 247.281105278844*x_82 - 150.176869196656*x_83 - 349.631132967887*x_84 - 407.904209925772*x_85 + 206.555945949547*x_86 + 26.2521653724551*x_87 - 250.787096761242*x_88 - 0.261850378422382*x_89 - 96.5341579252265*x_9 - 222.276619982308*x_90 + 424.870759197086*x_91 - 108.087801347429*x_92 - 359.96439486954*x_93 + 43.5193080920278*x_94 - 1.4725514424194*x_95 + 186.457906651945*x_96 + 974.3857198652*x_97 - 127.022461837995*x_98 + 35.1524532819158*x_99 - 0.00390858188043656*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 1.22911234621038*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 148.933810665383*std::exp(0.723999857902527*x_108) + 0.180061767774945*std::exp(0.889599919319153*x_50) - 0.0192851920986525*std::exp(2.49287986755371*x_71) + 3.64440379302533*std::exp(2.52551984786987*x_71) - 0.0337904002138722*std::exp(2.58607983589172*x_71) + 0.0702204399883662*std::exp(2.63183999061584*x_71) + 0.000392537768946456*std::exp(2.72359991073608*x_71) + 0.297275053681786*std::exp(1.85487985610962*x_89) - 10.722495377117*std::exp(1.90791976451874*x_89) + 3.53002468237581*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 1.04156088789469*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 11474.7336134078*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 0.0683041472231583*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 1.17565109545896*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 1510.59997429588*std::sin(0.323119848966599*x_28 - 4.28615999221802) + 5.02548169405853*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 1474.34251026917*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 1.19874845683634*std::sin(0.418559849262238*x_45 + 5.21848011016846) - 9.6723725505551*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 1638.21304003692*std::sin(0.321759849786758*x_53 - 4.29120016098022) + 2.84691605601637*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 0.900768698731286*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 0.200509064815948*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 2.06739841068533*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 887.471902310116*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 1.03555386641316*std::sin(0.386559844017029*x_80 - 7.4223198890686) - 2.25701722175299*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.00909418877287145*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.0228961702527383*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 0.0687112220511559*std::sin(0.399119853973389*x_87 + 5.19600009918213) + 4.44025445047259*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 713.27378656112*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 0.983838087547333*std::sin(0.379839837551117*x_95 - 7.4236798286438) + 3.45070380798385*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.0371093742365212*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 840417.625647348 - 0.00892161013668075*std::exp(-4.1954402923584*x_45) - 4.57892967032278e-6*std::exp(-4.70208024978638*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3007.07343932231*x_1 - 126.8532596838*x_10 - 58.4010219477332*x_100 + 338.046494896287*x_101 - 28.4454455157703*x_102 - 21.2018410256933*x_103 - 167.892397167466*x_104 + 25.1855064213177*x_105 + 43.7093056990751*x_106 - 92.4480531191918*x_107 - 46.4727485015004*x_108 + 142.402232474441*x_109 - 2.83783565445861*x_11 + 92.7006027061677*x_110 + 26.190453279138*x_111 - 60.8325794562832*x_112 + 125.107369740426*x_113 - 24.6285818362436*x_114 - 15.1993625790412*x_115 + 429.899785789322*x_116 - 48.9047247185819*x_117 + 13.8221438380604*x_118 - 71.819314972918*x_119 - 627.375222764123*x_12 - 62.8611504871624*x_120 + 219.915089630071*x_13 - 48.8814868697844*x_14 + 27.0137938553924*x_15 - 33.2876105274977*x_16 - 130.264540454522*x_17 - 20.3619478741652*x_18 + 35.7067654950315*x_19 - 40.5085401488631*x_2 + 170.90548204106*x_20 + 387.163793556654*x_21 + 100.534564764285*x_22 + 4.92773808594644*x_23 + 106.984571864136*x_24 + 154.503389273299*x_25 + 44.3045247208281*x_26 + 99.5599157873576*x_27 + 3.0162554941388*x_28 + 48.4225624770933*x_29 - 182.152314878209*x_3 - 181.230797027282*x_30 + 2061.04178416243*x_31 - 19.7874021954617*x_32 + 19.486095990608*x_33 - 13.7277115923212*x_34 - 112.154285316894*x_35 + 3.29238110070848*x_36 - 900.514364006799*x_37 + 95.9360723073243*x_38 - 103.797507410306*x_39 - 20.2463372117607*x_4 - 53.6193384636383*x_40 + 10.5508412692914*x_41 + 80711.1396086476*x_42 + 96.4897402199688*x_43 + 258.523894392765*x_44 + 19.2818297353551*x_45 - 84.9494179409107*x_46 + 368.02998458373*x_47 + 279.624893737216*x_48 + 33.4849517039217*x_49 + 8.738963935898*x_5 - 604.45463822606*x_50 - 130.033575530917*x_51 - 76.3216994684792*x_52 + 0.878485248011831*x_53 + 248.237564775639*x_54 - 13.0729684752211*x_55 + 9.78739967837139*x_56 + 1366.76291856742*x_57 + 39.4974343882216*x_58 + 26.9974831065261*x_59 - 34.6087480804552*x_6 + 81.3178428373448*x_60 + 28.350118852988*x_61 + 19.8901187915224*x_62 - 50.1256295791207*x_63 - 58.9520958209556*x_64 + 27.2202457281887*x_65 - 28.6239934560891*x_66 - 57.3216918577596*x_67 + 106.419609392382*x_68 - 24.2985921103697*x_69 - 17.237835168967*x_7 + 25.3196887279745*x_70 - 50.0948621487211*x_72 + 12.3302409727798*x_73 + 183.091992281805*x_74 - 0.119829450632488*x_75 + 41.0048204455884*x_76 - 22.2324409507592*x_77 - 12.1750459011662*x_78 + 34.5894259645981*x_79 + 178.758930912068*x_8 - 27.0609072491165*x_80 - 9.50090704451325*x_81 - 77.8026368656686*x_82 - 78.5631108255425*x_83 - 75.7441889031155*x_84 - 165.569252490925*x_85 + 97.5032490834097*x_86 + 21.7502956111792*x_87 - 87.7744785946895*x_88 - 6.4321081928631*x_89 + 14.3943514667655*x_9 - 131.138310474991*x_90 + 164.827660390182*x_91 - 31.6747450055582*x_92 - 104.950934932182*x_93 + 19.491825616081*x_94 + 11.6369541450664*x_95 + 68.5396641245851*x_96 + 272.815953998837*x_97 - 76.0302095075154*x_98 - 12.6602703428159*x_99 - 0.0297111413938132*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 0.459156588733956*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 55.6368509869004*std::exp(0.723999857902527*x_108) + 1.36874211814742*std::exp(0.889599919319153*x_50) - 0.146596665178705*std::exp(2.49287986755371*x_71) + 1.3614312953034*std::exp(2.52551984786987*x_71) - 1.41488015992574*std::exp(2.58607983589172*x_71) + 0.0833762302944975*std::exp(2.63183999061584*x_71) - 0.00204162594426002*std::exp(2.72359991073608*x_71) + 0.352969496355876*std::exp(1.85487985610962*x_89) - 4.00557720801706*std::exp(1.90791976451874*x_89) + 147.810083796855*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 7.91744007344383*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 4286.58906470815*std::sin(0.110480062663555*x_115 + 4.87599992752075) + 0.355256309337149*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 8.93672871529334*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 564.311255417639*std::sin(0.323119848966599*x_28 - 4.28615999221802) + 210.42823695454*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 550.766640435961*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 9.1123036400869*std::sin(0.418559849262238*x_45 + 5.21848011016846) - 405.004022875482*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 611.983366208972*std::sin(0.321759849786758*x_53 - 4.29120016098022) + 3.38028540913228*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 6.84720622205237*std::sin(0.398399859666824*x_66 + 2.00167989730835) - 1.04286654985139*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 15.7153587608496*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 331.530777083417*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 7.8717776132337*std::sin(0.386559844017029*x_80 - 7.4223198890686) - 94.5063943444511*std::sin(0.416479855775833*x_80 + 5.21888017654419) + 0.0472997331964385*std::sin(0.574159860610962*x_80 + 5.38335990905762) + 0.119085140106764*std::sin(0.636639833450317*x_86 - 0.962959825992584) - 0.357373543896069*std::sin(0.399119853973389*x_87 + 5.19600009918213) + 185.923454212788*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 266.455999470287*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 7.47865937619112*std::sin(0.379839837551117*x_95 - 7.4236798286438) + 144.488740139047*std::sin(0.381839841604233*x_96 + 5.189040184021) - 0.193009354029499*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 288521.91050624 - 0.00333282477309968*std::exp(-4.1954402923584*x_45) + 2.38154449111066e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-10601.1249541156*x_1 + 290.118695227795*x_10 + 81.3091033072705*x_100 - 498.145775544833*x_101 + 11.7790655959541*x_102 + 48.1297584905086*x_103 + 270.853757524314*x_104 - 82.3366199278783*x_105 - 20.7397779989285*x_106 + 254.084599679033*x_107 - 21.6248848666801*x_108 - 301.521461710132*x_109 - 72.8708591676091*x_11 - 194.889907656513*x_110 - 49.6052898387628*x_111 + 258.961697187308*x_112 - 610.794772841382*x_113 + 119.235093340599*x_114 - 5.8217202202306*x_115 - 1557.35024085019*x_116 + 173.084461778989*x_117 - 76.4044067106608*x_118 + 196.684124642659*x_119 + 1737.96391690461*x_12 + 119.22137984663*x_120 - 566.148299816289*x_13 + 162.583145834431*x_14 - 135.342472072419*x_15 + 70.1545603364345*x_16 + 283.891468822363*x_17 - 7.52600125347456*x_18 - 63.4661170340421*x_19 + 44.5495923413029*x_2 - 333.895619030547*x_20 - 1289.13719702837*x_21 - 135.973929218803*x_22 - 49.2173360706455*x_23 - 219.817881545952*x_24 - 484.594105232424*x_25 - 212.204451859162*x_26 - 239.880954557712*x_27 + 0.681028156530144*x_28 - 197.125434998844*x_29 + 363.436656076683*x_3 + 1007.21450521631*x_30 - 2657.05939506338*x_31 + 0.470937442570644*x_32 - 71.7140338936985*x_33 - 94.4164613172574*x_34 + 260.675840903508*x_35 + 2.32362645296556*x_36 + 1986.83713921927*x_37 - 185.722328788666*x_38 + 252.38470846395*x_39 + 70.7034004167844*x_4 + 116.374580835397*x_40 - 11.4866228647808*x_41 - 292379.958781017*x_42 - 379.504289051544*x_43 - 459.873916964393*x_44 + 9.16511931831479*x_45 + 176.503703405246*x_46 - 1671.47457520829*x_47 - 876.066634600116*x_48 - 168.871384571577*x_49 - 111.865116544025*x_5 + 1411.14940624184*x_50 + 171.097463634307*x_51 + 24.3389278055602*x_52 + 0.34489139668844*x_53 - 556.996453303038*x_54 + 26.4366355414018*x_55 - 116.539932300996*x_56 - 4910.56298050313*x_57 - 224.26090811854*x_58 - 169.029862941579*x_59 + 84.4485658849107*x_6 - 262.043797892655*x_60 - 94.6446010579607*x_61 - 51.3783368561182*x_62 + 2.39424722811243*x_63 + 115.704723351695*x_64 + 8.81634814956945*x_65 + 97.6584842236362*x_66 + 180.158922415499*x_67 - 376.008239111061*x_68 - 17.6344712732413*x_69 + 57.1170712928667*x_7 - 157.674333523251*x_70 + 149.069889275441*x_72 + 131.400469528186*x_73 - 508.352885299405*x_74 + 0.882565956268156*x_75 - 103.329293747248*x_76 - 9.88109209728509*x_77 - 11.2283891265781*x_78 - 60.4777848445638*x_79 - 1057.11811164687*x_8 + 71.3022632571291*x_80 - 92.3851869102987*x_81 + 273.275616578591*x_82 + 150.608653466136*x_83 + 409.796315499354*x_84 + 433.185582680565*x_85 - 212.113333084568*x_86 - 21.5554416393439*x_87 + 274.872923872312*x_88 - 2.82365823429513*x_89 + 110.766969344248*x_9 + 212.76893125459*x_90 - 454.376306556815*x_91 + 121.602545924724*x_92 + 401.394911622521*x_93 - 42.8011698583952*x_94 + 5.94607034514333*x_95 - 201.223563002765*x_96 - 1085.57839110273*x_97 + 122.441174817561*x_98 - 47.9328648043726*x_99 - 0.0155838489764438*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) + 1.31898186871106*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) - 159.82346651334*std::exp(0.723999857902527*x_108) + 0.717921609748349*std::exp(0.889599919319153*x_50) - 0.0768917040350041*std::exp(2.49287986755371*x_71) - 3.91087319241643*std::exp(2.52551984786987*x_71) - 0.620154213493095*std::exp(2.58607983589172*x_71) + 0.00659084044550591*std::exp(2.63183999061584*x_71) - 0.00626801760376498*std::exp(2.72359991073608*x_71) + 0.027902024646534*std::exp(1.85487985610962*x_89) + 11.5064965650705*std::exp(1.90791976451874*x_89) + 64.7864383568697*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 4.15279200314685*std::sin(0.374559849500656*x_11 - 7.41007995605469) - 12313.7365197239*std::sin(0.110480062663555*x_115 + 4.87599992752075) + 1.09067618729782*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 4.6874210854646*std::sin(0.323119848966599*x_26 - 4.27631998062134) - 1621.05114566201*std::sin(0.323119848966599*x_28 - 4.28615999221802) + 92.2325165631908*std::sin(0.340079843997955*x_28 - 4.25447988510132) + 1582.14262944369*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 4.77951223321845*std::sin(0.418559849262238*x_45 + 5.21848011016846) - 177.516766706988*std::sin(0.217199996113777*x_53 - 4.38791990280151) + 1757.99494940951*std::sin(0.321759849786758*x_53 - 4.29120016098022) + 0.267209511789751*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 3.59144154917084*std::sin(0.398399859666824*x_66 + 2.00167989730835) - 3.20171572624455*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 8.24289360996108*std::sin(0.354239851236343*x_75 + 1.96751987934113) + 952.361557303243*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 4.12884149668951*std::sin(0.386559844017029*x_80 - 7.4223198890686) - 41.4229701671888*std::sin(0.416479855775833*x_80 + 5.21888017654419) + 0.145215415763204*std::sin(0.574159860610962*x_80 + 5.38335990905762) + 0.365604559755217*std::sin(0.636639833450317*x_86 - 0.962959825992584) - 1.0971763317165*std::sin(0.399119853973389*x_87 + 5.19600009918213) + 81.4918583092595*std::sin(0.360399842262268*x_94 + 5.18871974945068) + 765.426524924006*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 3.92264628006168*std::sin(0.379839837551117*x_95 - 7.4236798286438) + 63.3306647004234*std::sin(0.381839841604233*x_96 + 5.189040184021) - 0.592560077985631*std::sin(0.418879866600037*x_96 - 7.37895965576172) + 914525.506388218 + 0.00957393524381422*std::exp(-4.1954402923584*x_45) + 7.31160516273784e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-122.590451068059*x_1 + 134.2441063917*x_10 + 106.758780682015*x_100 - 582.704789394725*x_101 + 66.6242468185928*x_102 + 15.5564032296913*x_103 + 229.649272124192*x_104 - 25.8943233132727*x_105 - 106.710392691314*x_106 + 49.6272860136259*x_107 + 168.486642025578*x_108 - 189.001716005542*x_109 + 64.7498738824138*x_11 - 119.979738013498*x_110 - 57.5857107365027*x_111 - 21.6410130535048*x_112 + 121.869749177136*x_113 - 40.0832983700843*x_114 + 42.0935453462925*x_115 - 27.9867565880559*x_116 + 17.6010745003107*x_117 + 27.1381004144296*x_118 + 54.0324054750477*x_119 + 316.929825595752*x_12 + 79.8423113801333*x_120 - 190.449928698866*x_13 + 16.112259218628*x_14 + 45.5933806617815*x_15 + 55.3873540196037*x_16 + 146.295400009732*x_17 + 68.1045640785405*x_18 - 58.514370459456*x_19 + 80.4038708469691*x_2 - 226.785385498886*x_20 - 21.793386117458*x_21 - 181.657141485858*x_22 + 40.0471430644285*x_23 - 141.86388939609*x_24 - 72.8359569893412*x_25 + 49.2520143359794*x_26 - 97.3768684607958*x_27 + 4.5524127772109*x_28 + 20.5295858534478*x_29 + 257.521208292615*x_3 - 344.192384607376*x_30 - 4262.71799915654*x_31 + 81.0438056733767*x_32 - 13.4921445486786*x_33 + 111.356728254663*x_34 + 141.641158898442*x_35 - 14.917862225268*x_36 + 899.487969572637*x_37 - 111.70261780679*x_38 + 107.641024553573*x_39 + 9.98333586788455*x_4 + 56.4781441026284*x_40 - 26.9843611843679*x_41 + 6928.70480369177*x_42 + 7.86036933281386*x_43 - 357.044141374084*x_44 - 70.5191287014806*x_45 + 114.019451415811*x_46 + 305.806620698585*x_47 - 163.66876560531*x_48 + 72.2136081641964*x_49 + 75.635399110346*x_5 + 737.382580967839*x_50 + 255.473903555976*x_51 + 179.381675818283*x_52 + 1.30967947317976*x_53 - 310.004335690159*x_54 + 13.0770754213512*x_55 + 72.8241142242331*x_56 - 195.888964089674*x_57 + 57.6562403193074*x_58 + 55.7490241378689*x_59 + 29.4196226517851*x_6 - 53.3209009296135*x_60 - 14.4737171429303*x_61 - 11.0330269894229*x_62 + 145.730686173246*x_63 + 84.3697614645783*x_64 - 104.464648638022*x_65 + 0.513195123765025*x_66 + 3.91537257323186*x_67 - 17.6530998808582*x_68 + 79.8892959106605*x_69 + 2.38634011780427*x_7 + 88.3343137024513*x_70 + 37.3499103744837*x_72 - 160.219129457324*x_73 - 127.644195036365*x_74 - 12.2486858672481*x_75 + 22.0705888350786*x_76 + 80.2741743575986*x_77 + 30.658598689005*x_78 - 43.9146226180247*x_79 + 354.239665258703*x_8 + 12.2305039081943*x_80 + 97.9600639474393*x_81 + 13.3705754741254*x_82 + 108.732009244192*x_83 - 22.8444784998023*x_84 + 150.060005398429*x_85 - 114.288297346065*x_86 - 38.9286282420092*x_87 + 71.1204756416877*x_88 + 17.1264491717154*x_89 - 222.297680288124*x_9 + 197.81603764357*x_90 - 122.265215313134*x_91 + 3.42658490274237*x_92 - 19.1414044539389*x_93 - 2.91214114187656*x_94 - 49.243649619453*x_95 - 45.6633614172639*x_96 + 104.421982873033*x_97 + 131.480509698015*x_98 + 94.4343857865593*x_99 - 0.0467524877385443*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) + 0.28611148386558*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) - 34.6686563670191*std::exp(0.723999857902527*x_108) + 2.15380817073697*std::exp(0.889599919319153*x_50) - 0.230679754117628*std::exp(2.49287986755371*x_71) - 0.848340495677808*std::exp(2.52551984786987*x_71) + 4.75199994561885*std::exp(2.58607983589172*x_71) + 0.12522766586952*std::exp(2.63183999061584*x_71) - 0.00647200669900505*std::exp(2.72359991073608*x_71) + 0.530145654170979*std::exp(1.85487985610962*x_89) + 2.49597123692359*std::exp(1.90791976451874*x_89) - 496.433217496976*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 12.4586267167582*std::sin(0.374559849500656*x_11 - 7.41007995605469) - 2671.07646523666*std::sin(0.110480062663555*x_115 + 4.87599992752075) + 1.12617162823486*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 14.0625462396894*std::sin(0.323119848966599*x_26 - 4.27631998062134) - 351.635878937892*std::sin(0.323119848966599*x_28 - 4.28615999221802) - 706.741813820561*std::sin(0.340079843997955*x_28 - 4.25447988510132) + 343.195904458856*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 14.338825242566*std::sin(0.418559849262238*x_45 + 5.21848011016846) + 1360.24177113397*std::sin(0.217199996113777*x_53 - 4.38791990280151) + 381.341514645138*std::sin(0.321759849786758*x_53 - 4.29120016098022) + 5.07704954113725*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 10.774541465662*std::sin(0.398399859666824*x_66 + 2.00167989730835) - 3.3059137575041*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 24.7291784598501*std::sin(0.354239851236343*x_75 + 1.96751987934113) + 206.584779366862*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 12.3867737514753*std::sin(0.386559844017029*x_80 - 7.4223198890686) + 317.408069959109*std::sin(0.416479855775833*x_80 + 5.21888017654419) + 0.149941369509514*std::sin(0.574159860610962*x_80 + 5.38335990905762) + 0.377502953804926*std::sin(0.636639833450317*x_86 - 0.962959825992584) - 1.13288331618495*std::sin(0.399119853973389*x_87 + 5.19600009918213) - 624.440337303767*std::sin(0.360399842262268*x_94 + 5.18871974945068) + 166.035124538968*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 11.7681756534245*std::sin(0.379839837551117*x_95 - 7.4236798286438) - 485.278191560282*std::sin(0.381839841604233*x_96 + 5.189040184021) - 0.611844611282262*std::sin(0.418879866600037*x_96 - 7.37895965576172) + 116691.464538355 + 0.00207676305794672*std::exp(-4.1954402923584*x_45) + 7.54955722608297e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5541.46856891795*x_1 - 113.104194830875*x_10 - 8.28391306310175*x_100 + 78.6822322478529*x_101 + 15.2312281657846*x_102 - 19.9873609114486*x_103 - 70.0576702817276*x_104 + 33.4016745594832*x_105 - 22.9941616493759*x_106 - 117.713103005106*x_107 + 61.974799476312*x_108 + 102.643181086969*x_109 + 59.5326284493186*x_11 + 68.4954218307679*x_110 + 8.36291908267959*x_111 - 145.730987309678*x_112 + 363.104784209635*x_113 - 76.603557232867*x_114 + 17.6105786765473*x_115 + 828.07474545342*x_116 - 85.2376623979733*x_117 + 49.6250853423989*x_118 - 85.2520615939451*x_119 - 814.924848245908*x_12 - 40.4210259438676*x_120 + 240.986320769765*x_13 - 80.2293752348952*x_14 + 86.0725371049819*x_15 - 21.2948280321679*x_16 - 106.241266140182*x_17 + 23.2921443580864*x_18 + 17.0064256398391*x_19 + 3.10776873243515*x_2 + 99.111740397999*x_20 + 672.838791446451*x_21 + 11.6727113945575*x_22 + 38.4024341294989*x_23 + 71.0659138575122*x_24 + 236.382189353868*x_25 + 126.739169752723*x_26 + 94.6352529649777*x_27 + 0.194813133154308*x_28 + 112.524537206801*x_29 - 108.124369410881*x_3 - 622.457861206596*x_30 + 101.108991601675*x_31 + 24.4135991249798*x_32 + 32.8891963972311*x_33 + 82.0420608271172*x_34 - 94.4212500545398*x_35 - 4.35848046791646*x_36 - 749.271086330008*x_37 + 59.2154502789167*x_38 - 97.2904738449388*x_39 - 32.9956792040152*x_4 - 45.024982453237*x_40 + 0.208038413590937*x_41 + 156091.350228036*x_42 + 204.05852082467*x_43 + 126.362191822328*x_44 - 25.8903962381084*x_45 - 58.0617142505675*x_46 + 988.634773390381*x_47 + 406.452394088983*x_48 + 112.719321682865*x_49 + 82.9746013175847*x_5 - 534.341057713841*x_50 - 12.3097854861131*x_51 + 47.5884289384623*x_52 + 0.621588068479246*x_53 + 203.691053960348*x_54 - 9.73613873755607*x_55 + 84.6730765929477*x_56 + 2566.28414229533*x_57 + 134.75483485549*x_58 + 105.352043012519*x_59 - 36.1642903992928*x_6 + 122.242627390838*x_60 + 47.2327510965674*x_61 + 20.8959133095882*x_62 + 46.7220185327968*x_63 - 34.3910422936204*x_64 - 37.0257774620578*x_65 - 50.9051005499019*x_66 - 93.6336905931998*x_67 + 195.123383039397*x_68 + 33.2297986359066*x_69 - 27.7618636714086*x_7 + 112.355765627192*x_70 - 65.430683388049*x_72 - 120.307918573905*x_73 + 227.672315417065*x_74 - 2.25647587273864*x_75 + 56.1791294742321*x_76 + 30.0810834060058*x_77 + 16.2410851359815*x_78 + 17.1897192004026*x_79 + 679.944352517307*x_8 - 32.3007884367271*x_80 + 78.3351157933033*x_81 - 142.632185379123*x_82 - 46.1149467759231*x_83 - 231.749991664474*x_84 - 184.715126826449*x_85 + 77.2932653148271*x_86 - 1.65818803831966*x_87 - 123.791269338526*x_88 + 6.44384449440063*x_89 - 103.766526741299*x_9 - 46.7813294556461*x_90 + 206.349446006262*x_91 - 65.3432211029912*x_92 - 221.989312299958*x_93 + 19.6735039654832*x_94 - 16.866339584292*x_95 + 92.7614683589318*x_96 + 606.547274729925*x_97 - 21.8063587204369*x_98 + 53.1721738519933*x_99 - 0.0180825906223992*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 0.610309677118726*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 73.9523495793555*std::exp(0.723999857902527*x_108) + 0.833034418369709*std::exp(0.889599919319153*x_50) - 0.089220654565208*std::exp(2.49287986755371*x_71) + 1.80961073987198*std::exp(2.52551984786987*x_71) + 1.81072465829966*std::exp(2.58607983589172*x_71) - 0.029508506630067*std::exp(2.63183999061584*x_71) + 0.00265607009870829*std::exp(2.72359991073608*x_71) - 0.124922926913813*std::exp(1.85487985610962*x_89) - 5.32420222747907*std::exp(1.90791976451874*x_89) - 189.1632740757*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 4.81865794813508*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 5697.72241586745*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 0.462173623557601*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 5.439010394119*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 750.080971369784*std::sin(0.323119848966599*x_28 - 4.28615999221802) - 269.300261780549*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 732.077506323233*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 5.54586759783658*std::sin(0.418559849262238*x_45 + 5.21848011016846) + 518.312993356046*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 813.446610148595*std::sin(0.321759849786758*x_53 - 4.29120016098022) - 1.19635025539745*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 4.16729957894852*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 1.35672583305034*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 9.56457361196338*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 440.66979867284*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 4.7908671755139*std::sin(0.386559844017029*x_80 - 7.4223198890686) + 120.946680470429*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.0615349777333843*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.154924794489082*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 0.464928057306697*std::sin(0.399119853973389*x_87 + 5.19600009918213) - 237.939715768586*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 354.172582933976*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 4.55161025662217*std::sin(0.379839837551117*x_95 - 7.4236798286438) - 184.912709942978*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.251097109855038*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 449357.055512011 - 0.00442998153804633*std::exp(-4.1954402923584*x_45) - 3.09828993374941e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4368.71031827472*x_1 + 103.859913999656*x_10 + 23.2171567310511*x_100 - 148.035117599562*x_101 - 1.00299909317171*x_102 + 18.9100711595403*x_103 + 90.7774001910284*x_104 - 31.6794825405082*x_105 + 1.10642737321181*x_106 + 100.66494995537*x_107 - 27.652432703111*x_108 - 101.279579521047*x_109 - 35.4629810169309*x_11 - 65.2202532511907*x_110 - 13.1566708683079*x_111 + 105.467047468736*x_112 - 259.164699311416*x_113 + 52.4728542506898*x_114 - 5.2679951079285*x_115 - 621.000133421595*x_116 + 68.4725633780867*x_117 - 33.6723751055809*x_118 + 76.0118112007249*x_119 + 687.6625635803*x_12 + 39.4353930464647*x_120 - 210.415778591262*x_13 + 64.9287070431088*x_14 - 60.4577191043268*x_15 + 21.2495555694445*x_16 + 100.436681624478*x_17 - 11.3603719219356*x_18 - 18.3312368293198*x_19 + 11.5123895459028*x_2 - 118.786447385873*x_20 - 527.125402147594*x_21 - 40.5405591741742*x_22 - 25.1917835393232*x_23 - 75.918669985871*x_24 - 187.474003914359*x_25 - 92.4911995501247*x_26 - 89.600756260446*x_27 - 1.55081936519462*x_28 - 81.1129053415485*x_29 + 124.568180593823*x_3 + 463.039760650215*x_30 - 612.148917511488*x_31 - 9.84834087862831*x_32 - 27.6799631971638*x_33 - 50.9944989872955*x_34 + 90.5149662163411*x_35 + 3.51597702826903*x_36 + 743.520548756739*x_37 - 69.6410609906978*x_38 + 94.1039973834281*x_39 + 28.2699405573497*x_4 + 41.0718230578572*x_40 - 0.00741289275721968*x_41 - 120923.615324752*x_42 - 154.004550814315*x_43 - 159.120558826695*x_44 + 11.5560745023364*x_45 + 59.6902018481628*x_46 - 706.130284385326*x_47 - 342.884722933903*x_48 - 77.0029188757884*x_49 - 53.5630690223549*x_5 + 482.217004875283*x_50 + 42.6835792148423*x_51 - 3.78119206832478*x_52 + 0.23434754245481*x_53 - 189.239739393732*x_54 + 9.9078778234393*x_55 - 55.0294122925446*x_56 - 1951.75830043947*x_57 - 97.8252039016297*x_58 - 75.6457488636422*x_59 + 31.2503275290055*x_6 - 99.574847244813*x_60 - 35.2960169083404*x_61 - 22.4079129015669*x_62 - 11.1350142396915*x_63 + 38.8640005227168*x_64 + 15.3471544177414*x_65 + 40.748219827621*x_66 + 74.528745025383*x_67 - 149.872626774022*x_68 - 15.7528625436268*x_69 + 24.4236995096544*x_7 - 73.940984438279*x_70 + 57.4069003142184*x_72 + 70.3146236404509*x_73 - 196.026521732343*x_74 + 3.89364414635535*x_75 - 52.116997533612*x_76 - 12.6030515860872*x_77 - 6.09643506246128*x_78 - 21.6722312786644*x_79 - 460.021662886732*x_8 + 29.6902854717023*x_80 - 48.2326597226136*x_81 + 108.279078878141*x_82 + 50.1046000642042*x_83 + 159.958817185386*x_84 + 158.90468889206*x_85 - 74.5551952184534*x_86 - 6.08934520045431*x_87 + 101.772301711149*x_88 - 3.02488975794794*x_89 + 91.6461235879119*x_9 + 71.1765089694596*x_90 - 170.529756258417*x_91 + 46.8636966813289*x_92 + 162.379834184875*x_93 - 19.9749754716317*x_94 + 9.12263187715328*x_95 - 76.6205373676497*x_96 - 455.220043969745*x_97 + 37.9085718935268*x_98 - 31.079741500008*x_99 - 0.00194325625425748*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) + 0.507566737827858*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) - 61.5027980678682*std::exp(0.723999857902527*x_108) + 0.0895225345368072*std::exp(0.889599919319153*x_50) - 0.00958815020553635*std::exp(2.49287986755371*x_71) - 1.50497076223879*std::exp(2.52551984786987*x_71) - 0.731415016634782*std::exp(2.58607983589172*x_71) - 0.083608484822233*std::exp(2.63183999061584*x_71) + 0.00779959055575704*std::exp(2.72359991073608*x_71) - 0.353952735384453*std::exp(1.85487985610962*x_89) + 4.42789629175692*std::exp(1.90791976451874*x_89) + 76.4096620767791*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 0.517839915218885*std::sin(0.374559849500656*x_11 - 7.41007995605469) - 4738.53600572667*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 1.35717992954062*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 0.584506456295632*std::sin(0.323119848966599*x_26 - 4.27631998062134) - 623.8081518587*std::sin(0.323119848966599*x_28 - 4.28615999221802) + 108.779794071471*std::sin(0.340079843997955*x_28 - 4.25447988510132) + 608.83549065756*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 0.595989928646072*std::sin(0.418559849262238*x_45 + 5.21848011016846) - 209.364745169775*std::sin(0.217199996113777*x_53 - 4.38791990280151) + 676.506465143158*std::sin(0.321759849786758*x_53 - 4.29120016098022) - 3.38970160111573*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 0.447841304338605*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 3.98404620396023*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 1.02786253799998*std::sin(0.354239851236343*x_75 + 1.96751987934113) + 366.484983865201*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 0.514853363466734*std::sin(0.386559844017029*x_80 - 7.4223198890686) - 48.8545941552871*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.180698405291123*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.454939033626144*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 1.36526836646341*std::sin(0.399119853973389*x_87 + 5.19600009918213) + 96.1121727531889*std::sin(0.360399842262268*x_94 + 5.18871974945068) + 294.549192463311*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 0.489141477724278*std::sin(0.379839837551117*x_95 - 7.4236798286438) + 74.6927105670109*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.737350511778919*std::sin(0.418879866600037*x_96 - 7.37895965576172) + 357886.817270097 + 0.00368421370691522*std::exp(-4.1954402923584*x_45) - 9.09817587947742e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7381.08147490569*x_1 - 200.644682229602*x_10 - 58.2022765354894*x_100 + 352.019502224847*x_101 - 9.78270111275511*x_102 - 34.6231088977653*x_103 - 193.98837826367*x_104 + 57.6454270661653*x_105 + 16.0479663037821*x_106 - 178.721700534867*x_107 + 16.966016687264*x_108 + 206.863475035355*x_109 + 49.1431889514183*x_11 + 132.670757112314*x_110 + 32.9726017149694*x_111 - 176.636867431922*x_112 + 420.062330366261*x_113 - 82.6458978616628*x_114 + 1.90203884331412*x_115 + 1064.74871745275*x_116 - 119.640938820071*x_117 + 52.5357761090315*x_118 - 138.175376074194*x_119 - 1220.37509274246*x_12 - 81.6287425622006*x_120 + 392.219883146047*x_13 - 113.074526001958*x_14 + 94.4543828741967*x_15 - 46.4311819263301*x_16 - 196.478400666785*x_17 + 6.76404269222114*x_18 + 42.3472895666141*x_19 - 33.030010715703*x_2 + 239.33743899648*x_20 + 900.832753803227*x_21 + 98.9236060561411*x_22 + 35.1373785308485*x_23 + 153.577095277331*x_24 + 332.634628714232*x_25 + 148.101504139693*x_26 + 168.569445682279*x_27 + 1.41263912563405*x_28 + 134.951097434606*x_29 - 255.515092235339*x_3 - 716.90456115599*x_30 + 1814.16360075377*x_31 + 1.61275580467798*x_32 + 49.3933423038419*x_33 + 66.7272841279808*x_34 - 178.922999785513*x_35 - 3.19214713417091*x_36 - 1412.23714509715*x_37 + 134.811110319343*x_38 - 177.375652882119*x_39 - 49.6128544265352*x_4 - 80.4783495896511*x_40 + 5.34128828764138*x_41 + 203741.851097979*x_42 + 260.756001356863*x_43 + 328.293048450286*x_44 - 7.30749767656041*x_45 - 122.113339032554*x_46 + 1150.11923145426*x_47 + 609.225745895603*x_48 + 118.409825733576*x_49 + 77.6832929513765*x_5 - 957.03545624713*x_50 - 117.737166558742*x_51 - 24.116533273714*x_52 - 0.288279703721629*x_53 + 379.804946287793*x_54 - 18.8637287291208*x_55 + 80.5677321142264*x_56 + 3362.42388470323*x_57 + 156.072413307178*x_58 + 117.951168069339*x_59 - 58.3616614450635*x_6 + 179.46614944222*x_60 + 63.4550226912919*x_61 + 38.7580000612711*x_62 - 4.88454364191893*x_63 - 80.7331597506008*x_64 - 7.06520894274343*x_65 - 68.5677900470578*x_66 - 126.710263202947*x_67 + 258.200697940635*x_68 + 12.2193805783076*x_69 - 41.3218945059397*x_7 + 110.166383634312*x_70 - 104.250528917688*x_72 - 90.6894548438853*x_73 + 354.122684370977*x_74 - 3.37274604629737*x_75 + 81.1191680965576*x_76 + 7.08217378285724*x_77 + 5.76835377122288*x_78 + 43.8807386976483*x_79 + 722.411654949285*x_8 - 51.7124796484458*x_80 + 64.0381499032085*x_81 - 186.808457933197*x_82 - 104.649809529339*x_83 - 269.592237699627*x_84 - 297.60738909243*x_85 + 146.965561737197*x_86 + 16.6207136602264*x_87 - 187.417048662069*x_88 + 1.89635355893481*x_89 - 105.036906866031*x_9 - 153.573013213739*x_90 + 311.197697064887*x_91 - 81.5982487191381*x_92 - 274.663755055748*x_93 + 33.1493790872623*x_94 - 6.15496441549168*x_95 + 138.558978437255*x_96 + 753.713659378641*x_97 - 86.8467716577572*x_98 + 35.6093076681626*x_99 + 0.0103036652090777*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 0.913229949023077*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 110.657757804738*std::exp(0.723999857902527*x_108) - 0.474672458927869*std::exp(0.889599919319153*x_50) + 0.0508389408117177*std::exp(2.49287986755371*x_71) + 2.70779046389497*std::exp(2.52551984786987*x_71) + 0.407622595152058*std::exp(2.58607983589172*x_71) + 0.0851246025615325*std::exp(2.63183999061584*x_71) + 0.00144237445802983*std::exp(2.72359991073608*x_71) + 0.360371151196328*std::exp(1.85487985610962*x_89) - 7.96680949209888*std::exp(1.90791976451874*x_89) - 42.5836276834069*std::sin(0.408079862594604*x_107 + 2.0079197883606) - 2.74572594665408*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 8525.72218083648*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 0.250982619065202*std::sin(0.412159860134125*x_24 + 2.02311968803406) + 3.09920980571645*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 1122.37513663732*std::sin(0.323119848966599*x_28 - 4.28615999221802) - 60.6237238107737*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 1095.43585632913*std::sin(0.354239851236343*x_36 + 5.17072010040283) - 3.16009825224913*std::sin(0.418559849262238*x_45 + 5.21848011016846) + 116.68040554063*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 1217.19159005648*std::sin(0.321759849786758*x_53 - 4.29120016098022) + 3.45116888807004*std::sin(0.349839836359024*x_53 - 1.06535983085632) + 2.37457456091648*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 0.73676771147446*std::sin(0.269759953022003*x_75 + 1.87255990505219) + 5.45000251474886*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 659.391244913392*std::sin(0.411759853363037*x_75 - 0.997599840164185) - 2.7298904492428*std::sin(0.386559844017029*x_80 - 7.4223198890686) + 27.2269997221324*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.0334164675101128*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.0841316524722922*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 0.252478409740292*std::sin(0.399119853973389*x_87 + 5.19600009918213) - 53.5639717428993*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 529.96211920665*std::sin(0.378879845142365*x_95 + 5.1814398765564) - 2.59355914347502*std::sin(0.379839837551117*x_95 - 7.4236798286438) - 41.6267588548422*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.136357868685827*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 628754.217752467 - 0.0066287525265247*std::exp(-4.1954402923584*x_45) - 1.68252120536442e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2920.4794298058*x_1 - 93.0803699260178*x_10 - 34.3335767765538*x_100 + 202.796479711404*x_101 - 11.7994859121293*x_102 - 15.8354357036559*x_103 - 104.401759608388*x_104 + 24.1147749817917*x_105 + 18.7607321726784*x_106 - 76.6180390485153*x_107 - 10.9865033903994*x_108 + 99.8442080114973*x_109 + 11.6804460661296*x_11 + 64.3903118485661*x_110 + 17.4779857856526*x_111 - 65.238140092387*x_112 + 149.188952194903*x_113 - 28.7203400751243*x_114 - 4.52863917044643*x_115 + 414.320910174653*x_116 - 47.327758260213*x_117 + 17.872493431198*x_118 - 59.6725448496018*x_119 - 520.067584449052*x_12 - 41.1281903734209*x_120 + 173.082281780753*x_13 - 45.4665165305638*x_14 + 32.9540864766494*x_15 - 22.9915984160628*x_16 - 93.2316084113482*x_17 - 4.64483096431862*x_18 + 22.3182875575946*x_19 - 22.1447364921921*x_2 + 119.239662297678*x_20 + 357.518477217487*x_21 + 59.497856019208*x_22 + 10.57170773059*x_23 + 75.1829036778756*x_24 + 136.304062488028*x_25 + 52.8354872469682*x_26 + 76.6818108203348*x_27 + 1.2008199825522*x_28 + 50.2684261401653*x_29 - 127.132748957634*x_3 - 248.141645528469*x_30 + 1143.4731028367*x_31 - 6.31174836766692*x_32 + 19.6111025021266*x_33 + 13.1852086389787*x_34 - 83.5727977568435*x_35 + 0.194073896244176*x_36 - 662.066323961206*x_37 + 67.3940475071888*x_38 - 80.8912041783809*x_39 - 19.8335794776105*x_4 - 37.8277156732941*x_40 + 4.5947424648792*x_41 + 79217.5271717584*x_42 + 99.2686405225247*x_43 + 171.303382997285*x_44 + 4.59640643819146*x_45 - 59.3634758594244*x_46 + 414.904577586085*x_47 + 251.957400439501*x_48 + 40.5006387003623*x_49 + 22.6527587832529*x_5 - 444.218008661872*x_50 - 73.2432874108113*x_51 - 31.2821259831745*x_52 - 0.0700904179219171*x_53 + 178.600036849225*x_54 - 9.185571407679*x_55 + 23.8774369515679*x_56 + 1315.41891830098*x_57 + 53.6340195230469*x_58 + 39.8180026707538*x_59 - 26.2635034664117*x_6 + 73.4157600246052*x_60 + 25.4256490017976*x_61 + 17.0896597799058*x_62 - 18.6572665983889*x_63 - 40.4428283319819*x_64 + 7.29911313315566*x_65 - 27.3568539045362*x_66 - 51.3460159887553*x_67 + 101.64878181752*x_68 - 4.38664606531082*x_69 - 16.6381477917861*x_7 + 35.7151175395267*x_70 - 43.731850480979*x_72 - 19.1252194961842*x_73 + 152.361116236762*x_74 - 1.16740868946303*x_75 + 34.6398482120354*x_76 - 5.55614767857304*x_77 - 2.50101680448274*x_78 + 22.8057584428011*x_79 + 242.868031833743*x_8 - 22.4596708801179*x_80 + 13.9238531615578*x_81 - 73.6633270020446*x_82 - 52.6467923804516*x_83 - 95.7081080091575*x_84 - 131.017195512038*x_85 + 69.8621041213445*x_86 + 11.5271524796404*x_87 - 77.3584567959542*x_88 - 1.38749312296258*x_89 - 26.294128347769*x_9 - 83.4844617519768*x_90 + 134.503694700771*x_91 - 31.026236817108*x_92 - 104.257686243718*x_93 + 15.1019416037172*x_94 + 2.12338146787201*x_95 + 58.336529596406*x_96 + 284.261154502314*x_97 - 48.0133975667553*x_98 + 4.88830681919118*x_99 - 0.00185708875777144*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 0.386612973498374*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 46.8466072880308*std::exp(0.723999857902527*x_108) + 0.0855529434634622*std::exp(0.889599919319153*x_50) - 0.00916299428627292*std::exp(2.49287986755371*x_71) + 1.14633441881407*std::exp(2.52551984786987*x_71) - 0.361911852259646*std::exp(2.58607983589172*x_71) + 0.057740541180538*std::exp(2.63183999061584*x_71) - 0.00573357373760729*std::exp(2.72359991073608*x_71) + 0.244441967066905*std::exp(1.85487985610962*x_89) - 3.37272327777939*std::exp(1.90791976451874*x_89) + 37.8083054132166*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 0.494877956919665*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 3609.33717414795*std::sin(0.110480062663555*x_115 + 4.87599992752075) + 0.997679448118997*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 0.55858838300572*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 475.153918703812*std::sin(0.323119848966599*x_28 - 4.28615999221802) + 53.8253875917986*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 463.749260682033*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 0.569562657425503*std::sin(0.418559849262238*x_45 + 5.21848011016846) - 103.595880586216*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 515.29416052589*std::sin(0.321759849786758*x_53 - 4.29120016098022) + 2.34094907119896*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 0.42798321103086*std::sin(0.398399859666824*x_66 + 2.00167989730835) - 2.92872074772946*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 0.982285254284974*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 279.151171254808*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 0.492023834273066*std::sin(0.386559844017029*x_80 - 7.4223198890686) - 24.1737676421838*std::sin(0.416479855775833*x_80 + 5.21888017654419) + 0.132833592173627*std::sin(0.574159860610962*x_80 + 5.38335990905762) + 0.334431208505678*std::sin(0.636639833450317*x_86 - 0.962959825992584) - 1.00362535632883*std::sin(0.399119853973389*x_87 + 5.19600009918213) + 47.5573151695003*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 224.357765497247*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 0.467452060041641*std::sin(0.379839837551117*x_95 - 7.4236798286438) + 36.9587397261472*std::sin(0.381839841604233*x_96 + 5.189040184021) - 0.54203531576749*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 257012.427317502 - 0.00280626114770554*std::exp(-4.1954402923584*x_45) + 6.68817957940109e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8101.93450658871*x_1 + 286.775561993886*x_10 + 116.563876768063*x_100 - 678.014042507674*x_101 + 44.9261371195574*x_102 + 46.0292113629254*x_103 + 330.935424491971*x_104 - 73.2154029838476*x_105 - 72.1298200465803*x_106 + 220.632852826298*x_107 + 66.5784120969988*x_108 - 319.391236628402*x_109 - 20.4815382567175*x_11 - 205.468140367497*x_110 - 62.8234593168356*x_111 + 180.248795051144*x_112 - 394.016279603923*x_113 + 71.1520853134228*x_114 + 19.4683874739583*x_115 - 1171.72534085925*x_116 + 136.912609224222*x_117 - 44.1431959980227*x_118 + 176.430451516039*x_119 + 1495.96824780973*x_12 + 130.811152566491*x_120 - 522.024487743946*x_13 + 130.166358173018*x_14 - 81.1062521949134*x_15 + 77.5892644083718*x_16 + 288.98497480865*x_17 + 27.7407152819712*x_18 - 75.6120142712447*x_19 + 76.4300085255003*x_2 - 373.092778147342*x_20 - 993.941275541976*x_21 - 199.038413229788*x_22 - 19.4572327454788*x_23 - 237.869354037222*x_24 - 397.712762419012*x_25 - 136.213690994774*x_26 - 231.913619932111*x_27 - 0.333852940835778*x_28 - 136.94011703095*x_29 + 405.226324933378*x_3 + 604.712376615927*x_30 - 4099.86978451819*x_31 + 37.0456717790251*x_32 - 58.6565332364874*x_33 - 14.1780568401525*x_34 + 264.128787244657*x_35 - 4.48378267585263*x_36 + 1996.48027862737*x_37 - 204.331915667108*x_38 + 245.841542862383*x_39 + 57.596266060113*x_4 + 116.87201599558*x_40 - 20.0045843137273*x_41 - 218192.919343446*x_42 - 277.697703391212*x_43 - 540.032217245562*x_44 - 27.7714701307063*x_45 + 189.545650719044*x_46 - 1098.94391221987*x_47 - 737.383624458522*x_48 - 95.4355393007645*x_49 - 47.0673926054902*x_5 + 1408.33340423851*x_50 + 256.967953578987*x_51 + 117.873252200301*x_52 + 0.536283105203383*x_53 - 567.700434725312*x_54 + 27.5368278809869*x_55 - 51.3861754018069*x_56 - 3743.37089716937*x_57 - 138.416564252845*x_58 - 99.1742481311936*x_59 + 78.9544725427839*x_6 - 218.991676363289*x_60 - 75.8728185531497*x_61 - 47.3858048299618*x_62 + 78.8413530811733*x_63 + 129.807540242999*x_64 - 43.5022632854553*x_65 + 75.1786639591735*x_66 + 141.381853542135*x_67 - 288.960065585771*x_68 + 28.1391624580193*x_69 + 45.6725425749216*x_7 - 78.7874348113221*x_70 + 130.093853893622*x_72 + 19.4922078179491*x_73 - 448.981602185658*x_74 - 1.92143883400136*x_75 - 81.5013997702371*x_76 + 32.3909169927327*x_77 + 10.6868459939823*x_78 - 70.5263027045108*x_79 - 610.235933607635*x_8 + 62.8686480147693*x_80 - 19.0807015587568*x_81 + 209.872917434569*x_82 + 168.800646184012*x_83 + 275.773671286421*x_84 + 398.442119025062*x_85 - 217.868104001585*x_86 - 38.3391438479251*x_87 + 235.407879244045*x_88 + 7.11851401459546*x_89 + 3.11760048451269*x_9 + 267.553619764277*x_90 - 401.399515623024*x_91 + 89.8574004676176*x_92 + 289.491315099046*x_93 - 38.9382963438545*x_94 - 17.8385279586486*x_95 - 172.99715390563*x_96 - 768.174499130845*x_97 + 159.655198535325*x_98 + 8.06841231488719*x_99 - 0.0153537225121665*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) + 1.13666972525956*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) - 137.732367730936*std::exp(0.723999857902527*x_108) + 0.707320072096812*std::exp(0.889599919319153*x_50) - 0.0757562453939087*std::exp(2.49287986755371*x_71) - 3.37030497734823*std::exp(2.52551984786987*x_71) + 1.96143837754577*std::exp(2.58607983589172*x_71) - 0.0487131462642073*std::exp(2.63183999061584*x_71) + 0.00263643242007983*std::exp(2.72359991073608*x_71) - 0.206224899375454*std::exp(1.85487985610962*x_89) + 9.91604706598431*std::exp(1.90791976451874*x_89) - 204.90807572185*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 4.091467785875*std::sin(0.374559849500656*x_11 - 7.41007995605469) - 10611.7088026926*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 0.458756538634131*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 4.61820200854675*std::sin(0.323119848966599*x_26 - 4.27631998062134) - 1396.98642117952*std::sin(0.323119848966599*x_28 - 4.28615999221802) - 291.715179399781*std::sin(0.340079843997955*x_28 - 4.25447988510132) + 1363.45591292215*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 4.70893324770191*std::sin(0.418559849262238*x_45 + 5.21848011016846) + 561.454217839966*std::sin(0.217199996113777*x_53 - 4.38791990280151) + 1515.00159597019*std::sin(0.321759849786758*x_53 - 4.29120016098022) - 1.97495541556877*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 3.5384067856398*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 1.34669486816378*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 8.12117092356048*std::sin(0.354239851236343*x_75 + 1.96751987934113) + 820.724359725663*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 4.06787095618757*std::sin(0.386559844017029*x_80 - 7.4223198890686) + 131.013547324326*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.0610800183112947*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.153779356600513*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 0.461490607452048*std::sin(0.399119853973389*x_87 + 5.19600009918213) - 257.744372073162*std::sin(0.360399842262268*x_94 + 5.18871974945068) + 659.627837524385*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 3.8647206212334*std::sin(0.379839837551117*x_95 - 7.4236798286438) - 200.303720455617*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.249240621071*std::sin(0.418879866600037*x_96 - 7.37895965576172) + 746059.375141465 + 0.00825060798892836*std::exp(-4.1954402923584*x_45) - 3.07538269871583e-5*std::exp(-4.70208024978638*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5100.57292862999*x_1 - 136.804538396934*x_10 - 37.0188027666867*x_100 + 228.680527911344*x_101 - 4.32602139828265*x_102 - 22.7320823467986*x_103 - 125.252553268368*x_104 + 39.3842251505769*x_105 + 8.06222596206595*x_106 - 121.052338530716*x_107 + 13.2417574507281*x_108 + 141.366803121282*x_109 + 36.2279879709146*x_11 + 91.4971340451107*x_110 + 22.9739320226145*x_111 - 124.788089673449*x_112 + 295.608966244654*x_113 - 57.7256930421273*x_114 + 3.69186177332446*x_115 + 747.764319070139*x_116 - 82.9339500407874*x_117 + 37.1413908199465*x_118 - 93.5036165155925*x_119 - 827.731853804984*x_12 - 55.6860136319235*x_120 + 268.280003584937*x_13 - 77.836283353035*x_14 + 65.6988826413723*x_15 - 32.8553696610123*x_16 - 133.66111012618*x_17 + 4.84275961776248*x_18 + 29.3867766996725*x_19 - 19.9267771495751*x_2 + 156.2354916264*x_20 + 617.351677134225*x_21 + 62.1072393560231*x_22 + 24.2926764876072*x_23 + 103.079541463817*x_24 + 231.500039795511*x_25 + 102.764713255022*x_26 + 113.480150019111*x_27 - 0.412741662828066*x_28 + 94.9774590849946*x_29 - 170.158423048132*x_3 - 490.231261072658*x_30 + 1199.25352703027*x_31 + 1.07487657148062*x_32 + 34.3642924608938*x_33 + 47.4007153924156*x_34 - 122.950458002857*x_35 - 1.28095609924376*x_36 - 936.493777972204*x_37 + 87.2948431320727*x_38 - 119.511871534463*x_39 - 33.8538236401476*x_4 - 54.6589294934441*x_40 + 5.12954214354627*x_41 + 140535.748177534*x_42 + 182.638114193902*x_43 + 214.598002137471*x_44 - 5.53203306258621*x_45 - 82.6679772455576*x_46 + 807.738737860295*x_47 + 418.694404836666*x_48 + 81.9428488035158*x_49 + 54.9915847814772*x_5 - 665.174654496839*x_50 - 77.6845528843736*x_51 - 7.94479290017379*x_52 - 0.254110153408947*x_53 + 261.851076399266*x_54 - 12.4486213505481*x_55 + 57.2666699511201*x_56 + 2356.91255855982*x_57 + 108.796020596456*x_58 + 82.3339746507712*x_59 - 39.9879819005728*x_6 + 125.109782747551*x_60 + 45.2128200847408*x_61 + 24.489949034868*x_62 + 1.28972584491664*x_63 - 54.0963038948024*x_64 - 6.03153580323871*x_65 - 46.9660432550951*x_66 - 86.3004851649956*x_67 + 180.450144469028*x_68 + 10.0781109629399*x_69 - 27.3883203339134*x_7 + 76.9223907269187*x_70 - 70.9402960997819*x_72 - 66.001519948613*x_73 + 242.08316082792*x_74 - 0.58574359917693*x_75 + 49.6130861953755*x_76 + 6.16029699677307*x_77 + 6.04122342704881*x_78 + 28.1887362781809*x_79 + 513.963396161863*x_8 - 33.9787880932061*x_80 + 46.3422110345153*x_81 - 131.153393496931*x_82 - 70.2751444806769*x_83 - 198.657778328809*x_84 - 205.415678377069*x_85 + 99.782550784547*x_86 + 9.5925723954916*x_87 - 130.861525877423*x_88 + 1.75967964744272*x_89 - 57.0087789346294*x_9 - 98.5512145402909*x_90 + 216.372821244306*x_91 - 58.311948503938*x_92 - 192.897689255356*x_93 + 20.3712482576897*x_94 - 3.66104921137558*x_95 + 95.8876230840119*x_96 + 523.300090700312*x_97 - 56.5284222573814*x_98 + 24.5215665772495*x_99 + 0.00834808332137366*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) - 0.628405764625803*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) + 76.1450858893217*std::exp(0.723999857902527*x_108) - 0.384582103269431*std::exp(0.889599919319153*x_50) + 0.0411899751452223*std::exp(2.49287986755371*x_71) + 1.86326690088367*std::exp(2.52551984786987*x_71) + 0.38413615363328*std::exp(2.58607983589172*x_71) - 0.00283115516309464*std::exp(2.63183999061584*x_71) + 0.000247248451838115*std::exp(2.72359991073608*x_71) - 0.0119855672113399*std::exp(1.85487985610962*x_89) - 5.48206836171554*std::exp(1.90791976451874*x_89) - 40.1300397490318*std::sin(0.408079862594604*x_107 + 2.0079197883606) - 2.22460149036398*std::sin(0.374559849500656*x_11 - 7.41007995605469) + 5866.66367191198*std::sin(0.110480062663555*x_115 + 4.87599992752075) - 0.0430228528082152*std::sin(0.412159860134125*x_24 + 2.02311968803406) + 2.51099595760789*std::sin(0.323119848966599*x_26 - 4.27631998062134) + 772.321370636238*std::sin(0.323119848966599*x_28 - 4.28615999221802) - 57.1306997221529*std::sin(0.340079843997955*x_28 - 4.25447988510132) - 753.784090886877*std::sin(0.354239851236343*x_36 + 5.17072010040283) - 2.56032809473089*std::sin(0.418559849262238*x_45 + 5.21848011016846) + 109.957501673893*std::sin(0.217199996113777*x_53 - 4.38791990280151) - 837.565842714394*std::sin(0.321759849786758*x_53 - 4.29120016098022) - 0.114782264141653*std::sin(0.349839836359024*x_53 - 1.06535983085632) + 1.92389270081102*std::sin(0.398399859666824*x_66 + 2.00167989730835) + 0.126294995735847*std::sin(0.269759953022003*x_75 + 1.87255990505219) + 4.41562047791844*std::sin(0.354239851236343*x_75 + 1.96751987934113) - 453.735951050035*std::sin(0.411759853363037*x_75 - 0.997599840164185) - 2.21177148772489*std::sin(0.386559844017029*x_80 - 7.4223198890686) + 25.6582315912414*std::sin(0.416479855775833*x_80 + 5.21888017654419) - 0.0057281726057875*std::sin(0.574159860610962*x_80 + 5.38335990905762) - 0.0144216508470135*std::sin(0.636639833450317*x_86 - 0.962959825992584) + 0.0432792577428914*std::sin(0.399119853973389*x_87 + 5.19600009918213) - 50.477717190735*std::sin(0.360399842262268*x_94 + 5.18871974945068) - 364.6740353829*std::sin(0.378879845142365*x_95 + 5.1814398765564) - 2.10131515235616*std::sin(0.379839837551117*x_95 - 7.4236798286438) - 39.2283038891752*std::sin(0.381839841604233*x_96 + 5.189040184021) + 0.0233741465268088*std::sin(0.418879866600037*x_96 - 7.37895965576172) - 435774.166466918 - 0.00456133343458791*std::exp(-4.1954402923584*x_45) - 2.8841384488975e-6*std::exp(-4.70208024978638*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4879.83862734083*x_1 + 120.256252793648*x_10 + 27.6752750556605*x_100 - 174.239019784613*x_101 - 0.567697355660022*x_102 + 21.1240170978939*x_103 + 104.431724708897*x_104 - 35.6315921798707*x_105 + 0.494790326315258*x_106 + 113.116836483964*x_107 - 27.5196623757581*x_108 - 119.560813365929*x_109 - 39.5060602937182*x_11 - 76.9663878439621*x_110 - 16.6974418020887*x_111 + 120.540581700045*x_112 - 292.533313852859*x_113 + 58.9730235485223*x_114 - 6.02431183075815*x_115 - 709.620243310225*x_116 + 78.0231831050636*x_117 - 37.7286384062376*x_118 + 86.0695092956254*x_119 + 775.538918011429*x_12 + 46.6023091170166*x_120 - 242.183863115476*x_13 + 73.545148074638*x_14 - 67.1138459642534*x_15 + 26.0166502591837*x_16 + 116.155735419898*x_17 - 10.8557559684647*x_18 - 22.8665798748106*x_19 + 13.3651374592081*x_2 - 134.478779891758*x_20 - 595.337543769832*x_21 - 46.3492862983852*x_22 - 26.9614438440814*x_23 - 87.7280819585777*x_24 - 214.998407680581*x_25 - 103.11125790579*x_26 - 101.797373338988*x_27 - 0.836806298929098*x_28 - 92.2894954425263*x_29 + 143.382877463083*x_3 + 505.335130127321*x_30 - 793.69026303767*x_31 - 8.4605682728706*x_32 - 31.6636341748327*x_33 - 55.1999022976624*x_34 + 105.451838907066*x_35 + 3.22550186121177*x_36 + 839.889550553033*x_37 - 76.5989448075825*x_38 + 106.542506410734*x_39 + 31.895795637549*x_4 + 48.0283649778654*x_40 - 1.55210970782101*x_41 - 135872.994168924*x_42 - 174.917084446787*x_43 - 179.756732039148*x_44 + 11.6643769095296*x_45 + 70.0597345312094*x_46 - 797.915780880556*x_47 - 388.486414342815*x_48 - 85.5283381726446*x_49 - 59.1253015935225*x_5 + 569.578026345282*x_50 + 53.1422755016355*x_51 - 3.72302285544056*x_52 + 0.0195993640519427*x_53 - 223.89151967112*x_54 + 11.0611620174663*x_55 - 60.8445536915446*x_56 - 2229.04766941206*x_57 - 109.489788434362*x_58 - 83.7425546812024*x_59 + 35.9195876017885*x_6 - 114.841958469953*x_60 - 41.431327457833*x_61 - 23.7667626407309*x_62 - 12.27758578028*x_63 + 45.182948815366*x_64 + 14.7085093831039*x_65 + 45.2245414691521*x_66 + 83.2990928392133*x_67 - 170.658666466264*x_68 - 16.052030496524*x_69 + 26.7694039530961*x_7 - 81.7156093420244*x_70 + 65.5155300603382*x_72 + 76.1948319578257*x_73 - 222.248615338998*x_74 + 2.6231886257428*x_75 - 53.1940741160452*x_76 - 12.5927865121745*x_77 - 7.54417235496312*x_78 - 24.2286231346374*x_79 - 518.509435070963*x_8 + 32.4879120607166*x_80 - 52.2888945091629*x_81 + 123.616964555749*x_82 + 58.7804990342542*x_83 + 185.545449799054*x_84 + 183.870068078759*x_85 - 86.4095718744122*x_86 - 6.67428897718028*x_87 + 118.790353522588*x_88 - 2.96925690801255*x_89 + 83.5420356963886*x_9 + 80.6788783912913*x_90 - 195.662054430778*x_91 + 54.7963328172858*x_92 + 185.729555849356*x_93 - 20.6835760019138*x_94 + 8.39670905218649*x_95 - 87.9176045911425*x_96 - 511.17004631716*x_97 + 44.1642577916337*x_98 - 32.3905859157309*x_99 - 0.00296483730284461*std::pow(-4.59191989898682*x_108 - 5.58791971206665, 2) + 0.579317586674519*std::pow(-5.66943979263306*x_77 - 8.21135997772217, 2) - 70.1969808007622*std::exp(0.723999857902527*x_108) + 0.136585048553639*std::exp(0.889599919319153*x_50) - 0.0146286962063649*std::exp(2.49287986755371*x_71) - 1.71771703111794*std::exp(2.52551984786987*x_71) - 0.749532121321034*std::exp(2.58607983589172*x_71) - 0.0418935257127089*std::exp(2.63183999061584*x_71) - 0.00325622681016507*std::exp(2.72359991073608*x_71) - 0.177354344507498*std::exp(1.85487985610962*x_89) + 5.05383430908675*std::exp(1.90791976451874*x_89) + 78.3023246765373*std::sin(0.408079862594604*x_107 + 2.0079197883606) + 0.790071352750891*std::sin(0.374559849500656*x_11 - 7.41007995605469) - 5408.38679649434*std::sin(0.110480062663555*x_115 + 4.87599992752075) + 0.566604828958124*std::sin(0.412159860134125*x_24 + 2.02311968803406) - 0.891784879931322*std::sin(0.323119848966599*x_26 - 4.27631998062134) - 711.991165199713*std::sin(0.323119848966599*x_28 - 4.28615999221802) + 111.474262836974*std::sin(0.340079843997955*x_28 - 4.25447988510132) + 694.901932776289*std::sin(0.354239851236343*x_36 + 5.17072010040283) + 0.90930528009274*std::sin(0.418559849262238*x_45 + 5.21848011016846) - 214.550696947609*std::sin(0.217199996113777*x_53 - 4.38791990280151) + 772.139038175826*std::sin(0.321759849786758*x_53 - 4.29120016098022) - 1.69847057373046*std::sin(0.349839836359024*x_53 - 1.06535983085632) - 0.683274067405496*std::sin(0.398399859666824*x_66 + 2.00167989730835) - 1.66328706225432*std::sin(0.269759953022003*x_75 + 1.87255990505219) - 1.5682158172306*std::sin(0.354239851236343*x_75 + 1.96751987934113) + 418.292178313*std::sin(0.411759853363037*x_75 - 0.997599840164185) + 0.785514753474674*std::sin(0.386559844017029*x_80 - 7.4223198890686) - 50.064719428334*std::sin(0.416479855775833*x_80 + 5.21888017654419) + 0.0754392153865977*std::sin(0.574159860610962*x_80 + 5.38335990905762) + 0.189931082624664*std::sin(0.636639833450317*x_86 - 0.962959825992584) - 0.569981645339963*std::sin(0.399119853973389*x_87 + 5.19600009918213) + 98.492865322784*std::sin(0.360399842262268*x_94 + 5.18871974945068) + 336.187371270663*std::sin(0.378879845142365*x_95 + 5.1814398765564) + 0.746285980733716*std::sin(0.379839837551117*x_95 - 7.4236798286438) + 76.5428443841543*std::sin(0.381839841604233*x_96 + 5.189040184021) - 0.307834172547845*std::sin(0.418879866600037*x_96 - 7.37895965576172) + 407259.552801741 + 0.00420502297415551*std::exp(-4.1954402923584*x_45) + 3.79836915932519e-5*std::exp(-4.70208024978638*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
