
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.08009194654019e-6*x_1 - 5.48270680051176e-5*x_10 + 0.000113174003660676*x_100 + 0.000347597015150811*x_101 + 0.00121087138850847*x_102 - 0.000598174560808581*x_103 - 0.000404112890152449*x_104 + 0.000272661332488726*x_105 + 0.00112128148054451*x_106 - 9.07021747549602e-6*x_107 - 0.000148268808445838*x_108 + 2.89635441127524e-5*x_109 + 0.000330568982690728*x_11 - 0.000274961311449341*x_110 - 4.24213530238343e-6*x_111 - 0.000173511687559573*x_112 + 2.53540053958796e-5*x_113 - 0.000242299133641231*x_114 + 1.06913698277374e-5*x_115 + 0.000276299513839966*x_116 + 6.6344304392652e-5*x_117 - 5.28258585299217e-5*x_118 + 1.09964800131414e-5*x_119 + 0.000596580802290393*x_12 + 2.74326735188481e-5*x_120 - 9.25045763038618e-5*x_13 + 0.000801299848298653*x_14 - 9.87985081705538e-5*x_15 - 4.98619886527837e-6*x_16 + 0.000223142083611311*x_17 + 0.000325660470798044*x_18 + 0.000310418822547085*x_19 - 0.000130915041598618*x_2 + 3.25355054669998e-6*x_20 - 8.19302243339477e-5*x_21 - 3.62882393030032e-5*x_22 - 7.37860618937087e-5*x_23 - 0.000105193102700569*x_24 - 0.000283514405741421*x_25 - 7.39019230145447e-5*x_26 + 0.000107114059018865*x_27 + 0.000898865406651846*x_28 + 0.00031352878480722*x_29 + 2.46412862833652e-5*x_3 - 0.000592921467940168*x_30 - 3.57744457049131e-5*x_31 - 2.02487511024385e-5*x_32 + 0.000167177946025064*x_33 + 0.000923149851851452*x_34 + 6.2006515290593e-5*x_35 + 9.78886299314995e-5*x_36 - 6.5537701595771e-5*x_37 + 0.000517477418215104*x_38 - 0.000119820069344068*x_39 - 9.14655240172001e-6*x_4 - 0.000304680394387016*x_40 + 6.15337546231905e-5*x_41 + 2.35438533781128e-5*x_42 - 0.000802947550964806*x_43 + 2.78655442988329e-5*x_44 - 0.000477929159267912*x_45 + 0.00132930715447023*x_46 + 4.07873258594966e-5*x_47 + 0.000906302349347208*x_48 + 0.00143034424494381*x_49 - 0.000300093946256689*x_5 + 0.00120667470688994*x_50 + 0.00057138939425595*x_51 + 0.000262578624514295*x_52 - 0.000218237335913667*x_53 + 0.000894925486465306*x_54 + 0.000473895129152381*x_55 + 1.60121377966024e-5*x_56 + 0.00102986433950722*x_57 - 1.36118369734811e-5*x_58 + 1.11973817863073e-5*x_59 - 9.66049388365467e-5*x_6 + 0.00191817123579284*x_60 - 0.000274046513034724*x_61 + 1.95146526668952e-5*x_62 + 2.91016553090108e-6*x_63 + 3.66678279879943e-6*x_64 + 9.71613903527342e-7*x_65 + 3.44166883977213e-5*x_66 + 8.8281189112031e-6*x_67 + 6.27031829568019e-6*x_68 - 2.12873791352327e-5*x_69 - 0.000392269882188759*x_7 - 2.29833881939054e-5*x_70 + 4.85426928518678e-6*x_71 + 5.5586160693784e-5*x_72 - 4.91199557257498e-5*x_73 + 4.71653624274358e-5*x_74 - 0.000182640835984044*x_75 + 2.93114218390186e-5*x_76 + 3.1248648489346e-6*x_77 - 0.000196835115183035*x_78 + 0.000101996919289854*x_79 - 3.64480471772601e-5*x_8 + 2.49176586417878e-5*x_80 - 0.000267771461890788*x_81 + 8.25455429494071e-6*x_82 + 5.29718903989306e-5*x_83 + 2.27459711018128e-5*x_84 - 2.0541163022775e-5*x_85 + 2.45100391317764e-6*x_86 - 2.9764386597023e-5*x_87 - 0.000310487518965438*x_88 - 1.60448018544815e-5*x_89 + 1.76554842048216e-5*x_9 + 0.000344572147410652*x_90 + 9.38624090210716e-5*x_91 - 6.20801442787214e-6*x_92 + 0.000585077367968818*x_93 + 7.98493002702793e-5*x_94 + 0.000257412090488259*x_95 + 0.000548681479448465*x_96 - 0.000606171967623652*x_97 - 1.87797265449442e-5*x_98 + 0.000921581284331547*x_99 - 1.61344503816497e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) + 6.32482285282345e-9*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00249132746685048*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 8.47307228968188e-5*std::sin(0.284959942102432*x_10 + 8.18303966522217) - 0.00209122258294806*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.00024708528886805*std::sin(0.279119968414307*x_100 + 1.78559982776642) + 2.88517363551998e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) - 0.00168475105894683*std::sin(0.25927996635437*x_107 + 8.18303966522217) + 0.00329712553231167*std::sin(0.297439932823181*x_107 + 4.77040004730225) + 1.11538378045291e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) - 5.74870260186167e-5*std::sin(0.272719949483871*x_108 - 1.22631990909576) - 0.000235320095134819*std::sin(0.244239971041679*x_109 - 7.61184024810791) + 0.000165716127734695*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 5.64643418204286e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) + 8.93156427334684e-5*std::sin(0.251519978046417*x_11 + 7.98832035064697) + 2.87567115736487e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) - 7.02448390365555e-5*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 4.89479973579725e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) - 1.70779378890243e-5*std::sin(0.219279989600182*x_115 + 8.16695976257324) - 9.51182005011882e-6*std::sin(0.243999972939491*x_116 + 1.98391973972321) - 0.00038637006159635*std::sin(0.282799929380417*x_116 + 8.1476001739502) + 5.50949992542235e-6*std::sin(0.274159938097*x_117 - 1.41383981704712) + 9.99268087290615e-6*std::sin(0.265279948711395*x_118 + 4.94767951965332) - 7.58855646317528e-6*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 4.33018269651628e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000229195863317185*std::sin(0.284319937229156*x_119 + 1.74959993362427) + 0.000135195176439679*std::sin(0.326479852199554*x_12 - 1.30671977996826) + 5.50979436489715e-6*std::sin(0.332799851894379*x_12 + 1.83999991416931) + 7.00177446918939e-5*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.00135045607582402*std::sin(0.376479834318161*x_12 - 7.77008008956909) + 1.09907703959116e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) + 0.000158079806083621*std::sin(0.309599906206131*x_120 + 1.76591992378235) + 0.00251350901599987*std::sin(0.365439832210541*x_120 + 4.6199197769165) + 0.000478039679694276*std::sin(0.30583992600441*x_13 - 1.21431982517242) + 4.63733112658558e-5*std::sin(0.359359860420227*x_13 - 4.56663990020752) - 0.00332023071580816*std::sin(0.383359849452972*x_13 + 8.02447986602783) + 0.000356493463941036*std::sin(0.269039958715439*x_14 - 7.42424011230469) + 0.000134264276224797*std::sin(0.290399938821793*x_14 + 4.97815942764282) + 3.836787022067e-5*std::sin(0.342319846153259*x_14 + 1.82951986789703) + 0.00266646168970721*std::sin(0.297839939594269*x_15 + 1.80775988101959) - 0.000130015599391504*std::sin(0.350399851799011*x_15 - 7.56120014190674) - 0.000804351510128231*std::sin(0.274879962205887*x_16 - 1.19007980823517) + 0.000103888414731404*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 9.60755765165019e-6*std::sin(0.39743983745575*x_16 - 4.60031986236572) + 0.000209038012795207*std::sin(0.363599836826324*x_17 - 7.59863996505737) + 0.00191250782699083*std::sin(0.368079841136932*x_17 - 1.18871986865997) + 2.77542391790207e-5*std::sin(0.39055985212326*x_17 - 4.4017596244812) + 0.000124896676887491*std::sin(0.371279835700989*x_18 + 8.21751976013184) + 0.00143835906146893*std::sin(0.196479991078377*x_19 - 1.39183986186981) + 3.72572047104547e-5*std::sin(0.286639958620071*x_19 - 4.57791996002197) + 0.00510199397043142*std::sin(0.324719846248627*x_19 + 1.82007992267609) - 0.000321302823813175*std::sin(0.368159830570221*x_19 + 8.2324800491333) + 0.000111323827979247*std::sin(0.341359823942184*x_2 + 1.9651198387146) + 0.000259339064237951*std::sin(0.262639969587326*x_20 - 1.36751985549927) + 0.000155079074575348*std::sin(0.303999930620193*x_20 + 8.18367958068848) + 0.000356717800399166*std::sin(0.183680012822151*x_21 - 4.60888004302979) + 0.000684848078314016*std::sin(0.322159916162491*x_21 - 4.58671998977661) + 0.000270234985155609*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 7.85406165864049e-6*std::sin(0.402559846639633*x_21 + 7.99271965026855) - 2.82514241096674e-6*std::sin(0.31143993139267*x_22 - 1.34287977218628) - 0.000783891417294126*std::sin(0.336239844560623*x_22 + 1.80423986911774) - 0.000142815858704304*std::sin(0.359199851751328*x_22 - 4.37824010848999) + 0.000577653817836638*std::sin(0.284639924764633*x_23 + 1.84703981876373) - 1.06999305139851e-5*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 4.87319970249489e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) - 3.24163560214883e-5*std::sin(0.374559849500656*x_24 + 5.01847982406616) - 0.00218280913006911*std::sin(0.297839939594269*x_26 - 4.39423990249634) - 3.90874269283637e-5*std::sin(0.371679842472076*x_26 - 7.57416009902954) + 0.000520862089280108*std::sin(0.14824004471302*x_27 - 7.64807987213135) + 0.000298570172772262*std::sin(0.24975997209549*x_27 - 1.37239980697632) + 3.81323830461076e-5*std::sin(0.237519979476929*x_28 - 4.59055995941162) + 0.000963320562363724*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.00409260236245235*std::sin(0.132480040192604*x_29 + 1.57615983486176) + 1.12034434296614e-5*std::sin(0.246799975633621*x_29 + 1.81951987743378) + 4.62287755767191e-5*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 5.67426165630453e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) + 1.10683713281419e-5*std::sin(0.329519838094711*x_3 + 4.96783971786499) + 0.000102948803503054*std::sin(0.420159846544266*x_3 - 7.4061598777771) + 0.000108566809793186*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 6.99085432755803e-5*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 3.37334839186562e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) + 2.43367091302715e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) - 1.87094939369159e-5*std::sin(0.253359973430634*x_34 + 8.17903995513916) - 1.66070943714375e-5*std::sin(0.252959966659546*x_35 - 4.41495990753174) + 0.000558907623386906*std::sin(0.196479991078377*x_36 - 1.38119983673096) - 0.00690025253910527*std::sin(0.246479973196983*x_37 + 8.1879997253418) - 0.00191760768370295*std::sin(0.251679986715317*x_37 - 4.41239976882935) - 0.000514456792971539*std::sin(0.210720002651215*x_38 + 1.80111992359161) + 0.000264144886654776*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 5.99933242569748e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 9.34397064880101e-5*std::sin(0.334319829940796*x_4 - 1.40255987644196) + 2.39621982811373e-5*std::sin(0.358399868011475*x_4 + 8.20823955535889) - 0.00031078015328672*std::sin(0.364639848470688*x_4 + 8.21175956726074) - 0.00020154495910397*std::sin(0.230719983577728*x_41 + 8.20055961608887) + 9.66414806385202e-5*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.00321390066538764*std::sin(0.247039973735809*x_42 - 7.60703992843628) - 0.000108061156905655*std::sin(0.278799951076508*x_42 - 1.23991978168488) - 0.00909293678808398*std::sin(0.175760015845299*x_44 + 8.01152038574219) + 2.11365185404533e-5*std::sin(0.266639977693558*x_44 - 4.617919921875) + 0.00260372741975263*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 0.000132029323118346*std::sin(0.241359978914261*x_48 - 4.40191984176636) - 0.000150402185646954*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 6.24295689544891e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) - 0.000225824499144419*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.000331771223880073*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 9.47721623156886e-5*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 2.247084918965e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) - 0.000112600055187636*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.000145256645172637*std::sin(0.23479999601841*x_57 + 1.57991981506348) + 0.0193568771856875*std::sin(0.124480053782463*x_6 + 1.72319996356964) + 4.74262129264922e-5*std::sin(0.282399952411652*x_6 + 1.81655991077423) + 7.51538536501856e-5*std::sin(0.363519847393036*x_7 - 4.3854398727417) + 0.000241966211347242*std::sin(0.408159852027893*x_7 - 7.60512018203735) + 5.91052247500695e-6*std::sin(0.350399851799011*x_8 - 1.36039984226227) + 0.000218176779259985*std::sin(0.358639866113663*x_8 - 1.3698399066925) - 3.22632427009062e-5*std::sin(0.363359838724136*x_8 - 7.57208013534546) - 1.20282420084259e-5*std::sin(0.303199917078018*x_9 + 8.1802396774292) - 9.57386355425326e-5*std::sin(0.304719924926758*x_9 + 4.98575973510742) + 0.00178180668500812*std::sin(0.330319851636887*x_9 + 5.06711959838867) - 0.000371921841452906*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 5.58584852415145e-5*std::sin(0.40175986289978*x_9 + 1.58287978172302) - 8.6374261674017e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) + 0.0078152629671505*std::sin(0.313279926776886*x_92 - 7.58616018295288) - 1.63970720834433e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) + 1.11449570430775e-5*std::sin(0.261599957942963*x_93 - 4.42095994949341) - 0.00284542058925129*std::sin(0.333759844303131*x_94 + 8.03415966033936) + 2.83612017708172e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) - 0.00182301457568488*std::sin(0.28383994102478*x_95 + 8.19295978546143) + 9.03361326064133e-5*std::sin(0.320959836244583*x_95 - 4.5601601600647) - 1.83403861408163e-5*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 4.00564637510094e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) - 0.000137778167307615*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 6.68618096902597e-5*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 6.32931077394908e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.00176410910894093*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.114065003132351);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.92480499237219e-5*x_1 - 0.000100737608983041*x_10 + 0.000359791715158824*x_100 + 0.000788315774218918*x_101 + 0.00162543278373797*x_102 - 0.00120060040828374*x_103 - 0.000662460322512797*x_104 + 0.000258076308451292*x_105 + 0.00163671824299948*x_106 - 0.000170107935494375*x_107 - 4.05280866099553e-5*x_108 - 0.000152766578034025*x_109 + 0.00053518511337738*x_11 - 0.00107085074487046*x_110 + 0.000140914050159498*x_111 - 0.000382048142736775*x_112 + 6.17495993907496e-5*x_113 - 0.000994465138722244*x_114 + 0.000144660316986895*x_115 + 0.000482681580311948*x_116 + 6.05280477163672e-6*x_117 - 0.000918832369948497*x_118 + 5.10642266408552e-5*x_119 + 0.000776662166827892*x_12 + 0.000100640404485288*x_120 + 6.06511551726676e-5*x_13 + 0.00131542153629571*x_14 + 9.57651750313034e-5*x_15 + 0.000286028484171677*x_16 + 0.000640002996179749*x_17 + 0.000956190424888935*x_18 + 0.000831991620707281*x_19 - 0.000173040471959916*x_2 - 4.96911154752622e-5*x_20 - 8.28028188230659e-5*x_21 + 0.000112135913280075*x_22 - 0.000141279299896264*x_23 + 0.000310678426650961*x_24 - 0.000369262328104706*x_25 + 0.000215662903897407*x_26 + 0.000437071163436633*x_27 + 0.00135885328442719*x_28 - 0.000395870613369124*x_29 + 9.16201866941014e-5*x_3 - 0.000939608774147108*x_30 - 9.93897579134649e-5*x_31 - 6.85857294401764e-6*x_32 + 6.19003164306679e-6*x_33 + 0.00174916494447895*x_34 + 0.00021751255692802*x_35 - 0.000164230439513152*x_36 - 2.35805802661854e-5*x_37 + 0.000639958438596606*x_38 - 0.000217711682843414*x_39 - 4.11318481419402e-5*x_4 - 0.000789793164691933*x_40 - 0.000339159499617885*x_41 + 5.5678093104323e-5*x_42 + 0.00119840185904994*x_43 - 0.000118789763570865*x_44 - 0.00196664621843341*x_45 + 0.00158956939401256*x_46 - 0.000128681930927709*x_47 + 0.00120042870998802*x_48 + 0.00229055994360304*x_49 - 0.000127299633840839*x_5 + 0.0020340821266842*x_50 + 0.000258772321250412*x_51 - 0.000185599406009628*x_52 - 0.00049780236060705*x_53 + 0.00200876264082347*x_54 + 0.00123371045493496*x_55 - 0.000362342530699137*x_56 + 0.00142507325709093*x_57 - 4.46539913121947e-5*x_58 - 1.9746071476243e-5*x_59 + 0.000206871871099307*x_6 + 0.0027917166157068*x_60 - 0.000416853787857934*x_61 + 3.79627631737049e-5*x_62 + 2.44203593575713e-5*x_63 + 5.42430672399331e-6*x_64 + 3.95078959073889e-6*x_65 + 4.02541947068691e-5*x_66 + 3.03558101373073e-5*x_67 - 5.12938316807673e-6*x_68 - 6.87668099045114e-5*x_69 - 0.000843239973897237*x_7 - 3.13445998620115e-5*x_70 + 4.70693124224117e-5*x_71 + 8.60450623385411e-5*x_72 - 5.90675305170958e-5*x_73 + 9.76249910721436e-5*x_74 - 0.000255971851007144*x_75 + 6.93584027205491e-5*x_76 + 4.58365402765381e-5*x_77 - 0.000281470362649701*x_78 + 0.000163491391539969*x_79 - 0.000195552913983587*x_8 + 2.86011871679865e-6*x_80 - 0.000425171329513635*x_81 + 5.78060748292348e-5*x_82 - 1.6476800642555e-5*x_83 + 1.50436246041497e-5*x_84 - 3.64591147286974e-5*x_85 + 2.80886801830897e-5*x_86 - 5.28085247046853e-5*x_87 - 0.000466369759679423*x_88 - 1.20029074507373e-5*x_89 + 0.000105141613907065*x_9 + 0.000582669282541217*x_90 + 0.000169075883110838*x_91 - 5.19814593046446e-7*x_92 + 0.000923765826130138*x_93 + 1.35172285518908e-5*x_94 + 0.000390827389548554*x_95 + 0.000947425463005655*x_96 - 0.00119908110615425*x_97 - 0.000160162381571727*x_98 + 0.00123357286837148*x_99 + 1.8386080856805e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) + 4.55129184075987e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00739860028253753*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 5.13874130033089e-5*std::sin(0.284959942102432*x_10 + 8.18303966522217) - 0.00332895624902752*std::sin(0.273439943790436*x_100 - 4.60543966293335) - 0.000169876345440947*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 8.00831132072092e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.000447686930126062*std::sin(0.25927996635437*x_107 + 8.18303966522217) + 0.00524859798957601*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 1.27104028266745e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) - 0.000413672032492233*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 4.09027103786225e-5*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000459974514332693*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 3.42444435015591e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) + 0.000642708207777856*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 7.98193550664595e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 8.00478020477388e-5*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 2.96859376377803e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) + 0.000900109499499076*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 1.08392345819084e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.0010724386567854*std::sin(0.282799929380417*x_116 + 8.1476001739502) - 0.000290383607938361*std::sin(0.274159938097*x_117 - 1.41383981704712) - 0.000526674065546647*std::sin(0.265279948711395*x_118 + 4.94767951965332) + 0.000399962325918696*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 2.62616532702825e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) - 0.000157576988208709*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000154062232469787*std::sin(0.326479852199554*x_12 - 1.30671977996826) - 0.000290399126660235*std::sin(0.332799851894379*x_12 + 1.83999991416931) + 0.000503842079912747*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.00401050638147435*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 1.25245786746873e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.00043877854873323*std::sin(0.309599906206131*x_120 + 1.76591992378235) + 0.00400118170778553*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 8.30915802444415e-5*std::sin(0.30583992600441*x_13 - 1.21431982517242) + 0.000333698631731779*std::sin(0.359359860420227*x_13 - 4.56663990020752) - 0.005285378457429*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 6.19647416813173e-5*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000153001421210923*std::sin(0.290399938821793*x_14 + 4.97815942764282) + 0.000276092119488715*std::sin(0.342319846153259*x_14 + 1.82951986789703) + 0.00424466260890785*std::sin(0.297839939594269*x_15 + 1.80775988101959) - 0.000935581834387506*std::sin(0.350399851799011*x_15 - 7.56120014190674) - 0.00128042371380733*std::sin(0.274879962205887*x_16 - 1.19007980823517) + 0.000747572707282136*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 5.82678296749177e-6*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.000580222092604545*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.000508208469946189*std::sin(0.368079841136932*x_17 - 1.18871986865997) + 0.000199717281039082*std::sin(0.39055985212326*x_17 - 4.4017596244812) + 0.000898746478254804*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.000382213472565238*std::sin(0.196479991078377*x_19 - 1.39183986186981) + 0.000268099859480674*std::sin(0.286639958620071*x_19 - 4.57791996002197) + 0.00812171542563639*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.000891832993912311*std::sin(0.368159830570221*x_19 + 8.2324800491333) + 0.000801077345174845*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 4.50776234316519e-5*std::sin(0.262639969587326*x_20 - 1.36751985549927) + 0.00111593659334236*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 6.20037352452498e-5*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.000181983879550012*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.000750085147123731*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 4.76332428672298e-6*std::sin(0.402559846639633*x_21 + 7.99271965026855) + 0.000148901907131492*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000208302550277044*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000162746413026738*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.000153499273978522*std::sin(0.284639924764633*x_23 + 1.84703981876373) + 0.000563950352917475*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 2.95549379490906e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) - 0.000233265500237537*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.000580035319344244*std::sin(0.297839939594269*x_26 - 4.39423990249634) - 0.000281269991895416*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.000593550586615597*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000828734487659626*std::sin(0.24975997209549*x_27 - 1.37239980697632) + 0.00027439757265139*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000255982047318919*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.0121539738946615*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.000590488495957101*std::sin(0.246799975633621*x_29 + 1.81951987743378) + 0.000332658564495157*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 3.44132113184541e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) - 0.000583369388106665*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 2.73564652508629e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 2.88493314972449e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 4.23980707698743e-5*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 2.0458653141428e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 6.75508540760393e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) + 0.000986102264387642*std::sin(0.253359973430634*x_34 + 8.17903995513916) + 0.000875293229191065*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.00155134727161747*std::sin(0.196479991078377*x_36 - 1.38119983673096) - 0.0109843108032719*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.000509563648910706*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.00142796610521267*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 4.59129586474305e-5*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 3.63846976118546e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) + 6.4241768216863e-5*std::sin(0.334319829940796*x_4 - 1.40255987644196) + 0.000172430058614093*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.000862625454905378*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.00022967140663072*std::sin(0.230719983577728*x_41 + 8.20055961608887) + 0.000695424350284689*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.00954445639418291*std::sin(0.247039973735809*x_42 - 7.60703992843628) - 0.000777599425584273*std::sin(0.278799951076508*x_42 - 1.23991978168488) - 0.0144747809197966*std::sin(0.175760015845299*x_44 + 8.01152038574219) + 0.000152096693636709*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.000691885444584779*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 8.0073025741699e-5*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 2.61425061735788e-5*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 3.78622291159908e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 3.92522112470238e-5*std::sin(0.251279979944229*x_52 + 7.98904037475586) - 0.00022809971121071*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 5.74773361967358e-5*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 1.36281005090654e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 1.957184082948e-5*std::sin(0.30311992764473*x_56 - 4.84959983825684) - 9.98670060285028e-5*std::sin(0.23479999601841*x_57 + 1.57991981506348) + 0.0308136483387207*std::sin(0.124480053782463*x_6 + 1.72319996356964) + 0.000341275227707171*std::sin(0.282399952411652*x_6 + 1.81655991077423) + 0.000540801108393191*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000671620149896054*std::sin(0.408159852027893*x_7 - 7.60512018203735) - 0.000311519895512426*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.000605588360352278*std::sin(0.358639866113663*x_8 - 1.3698399066925) - 0.000232163709052404*std::sin(0.363359838724136*x_8 - 7.57208013534546) + 0.000633960315607901*std::sin(0.303199917078018*x_9 + 8.1802396774292) - 0.000688927549323688*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.000473477408221979*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 6.46464610500712e-5*std::sin(0.337999850511551*x_9 + 8.23991966247559) - 3.84038862781626e-5*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 2.29521316193256e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) + 0.0124408892216593*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 1.86853525226945e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) - 0.000587405913475676*std::sin(0.261599957942963*x_93 - 4.42095994949341) - 0.00452954206258919*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 3.23191268757113e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.000484427532856761*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000102942920217574*std::sin(0.320959836244583*x_95 - 4.5601601600647) - 0.000131975948957716*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 2.42934082921943e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000157005690587472*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 4.05502905113419e-5*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 3.83859473456027e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.00523894924513379*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0573237731847536);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.33305228316625e-5*x_1 + 2.09206387874949e-5*x_10 + 7.83447999148721e-6*x_100 + 7.83359632228535e-6*x_101 - 9.17711327998471e-5*x_102 - 3.40571149199132e-5*x_103 + 2.36294924851654e-5*x_104 - 6.66746547512214e-5*x_105 - 2.90449078880804e-5*x_106 - 1.69509878861902e-5*x_107 + 3.19656884043929e-5*x_108 - 0.000126785499779337*x_109 - 9.92152175189427e-6*x_11 - 0.000230050243185908*x_110 + 1.46476920668394e-5*x_111 - 2.53306964544243e-5*x_112 + 2.72545615405217e-5*x_113 - 0.000125390743910142*x_114 + 7.64854792870749e-6*x_115 - 4.41731770756716e-5*x_116 + 3.95475564377643e-5*x_117 + 0.000102415208351809*x_118 + 6.61714589355739e-6*x_119 - 3.12654975808408e-5*x_12 + 4.20876577331348e-5*x_120 - 8.42813777473338e-5*x_13 + 0.000242258694929857*x_14 - 3.5220233787369e-5*x_15 + 1.10869336378175e-6*x_16 + 1.72168542510302e-5*x_17 + 1.93892197384219e-5*x_18 - 9.57358077105195e-6*x_19 - 4.81432506431021e-5*x_2 + 9.32352418149189e-6*x_20 + 1.31435742547683e-5*x_21 + 3.97458640570422e-5*x_22 - 3.74504810640682e-6*x_23 - 1.63844545561069e-5*x_24 - 0.000106616139232547*x_25 + 4.62968322043059e-5*x_26 + 1.9290527440131e-5*x_27 - 9.29158043474178e-5*x_28 + 0.000108275113215561*x_29 + 3.33151252598208e-6*x_3 - 2.20229831651964e-5*x_30 + 2.01535144818987e-6*x_31 + 1.4320332329924e-5*x_32 + 1.58177564809268e-5*x_33 + 9.58780804815279e-6*x_34 - 0.00017678686037986*x_35 - 4.35301120653915e-5*x_36 + 4.19771607593597e-5*x_37 - 0.000131450043578941*x_38 - 0.000379857868373606*x_39 + 2.91049340566918e-6*x_4 - 0.000115015924144211*x_40 + 3.08579618008687e-5*x_41 - 0.000252334298773651*x_42 - 0.000124025516891832*x_43 - 9.29322962106545e-5*x_44 - 0.000295656618611073*x_45 - 7.03855582555835e-5*x_46 - 4.49296984595908e-5*x_47 - 0.000121447930514095*x_48 - 0.000197543835771847*x_49 - 7.68668084724984e-5*x_5 - 6.07785905604056e-5*x_50 + 9.80724478405587e-5*x_51 + 0.000168120812475857*x_52 + 6.42385267895393e-5*x_53 + 2.10334301515926e-5*x_54 - 5.33909665316178e-5*x_55 + 2.01719377673182e-5*x_56 - 1.17745817293694e-5*x_57 - 0.000216669149622475*x_58 - 0.000273504921308424*x_59 - 5.92922587623509e-5*x_6 + 9.98805969162371e-5*x_60 + 1.46229443787268e-5*x_61 - 7.90362542879388e-6*x_62 - 6.06584886898871e-6*x_63 + 2.44047521527409e-6*x_64 - 1.43355472551899e-7*x_65 - 7.3147923145956e-7*x_66 + 1.91366268183126e-6*x_67 + 1.11515842506143e-5*x_68 - 8.33628884089e-6*x_69 + 0.000112557133139657*x_7 - 3.27427061787298e-6*x_70 + 7.69090496980528e-6*x_71 + 7.55183033312815e-7*x_72 + 3.11636975938065e-6*x_73 - 3.71761465399006e-6*x_74 + 1.24135601185193e-5*x_75 - 6.68827631922793e-6*x_76 + 9.8132749970691e-6*x_77 + 5.73326877589134e-6*x_78 - 1.10573486588905e-5*x_79 - 2.49286377049134e-6*x_8 + 4.14528455155334e-6*x_80 + 1.06432337129635e-5*x_81 + 1.22578258472562e-5*x_82 + 2.50378788158369e-5*x_83 + 8.23498304267726e-6*x_84 + 7.72146476848267e-6*x_85 - 4.05713956989012e-6*x_86 - 1.00578354919012e-5*x_87 + 1.5159510375292e-5*x_88 - 6.89455562648888e-6*x_89 + 7.33656588834024e-6*x_9 - 2.0744856965257e-5*x_90 - 9.76738255865659e-6*x_91 - 3.14866783675217e-5*x_92 - 2.18760901331685e-5*x_93 - 2.15011482994695e-5*x_94 - 5.67457734863565e-5*x_95 - 0.000125905619449258*x_96 - 3.7816151807657e-6*x_97 + 1.6840960089926e-5*x_98 - 0.000119759494170943*x_99 + 9.88386722363752e-9*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) + 1.19155891585944e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.000366999181700242*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.000156112312117498*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.000133553268849822*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.000913370490766245*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 2.74490908115531e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) - 0.000758036475649894*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.000210566726009467*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 6.83277392698406e-6*std::sin(0.25927996635437*x_108 - 7.43847990036011) - 0.000108302129549997*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000233994305668169*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000157659732611163*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 0.000104032854346281*std::sin(0.285999923944473*x_109 + 1.73759996891022) + 0.000168265345767387*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 2.7358685720295e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 4.30315657341972e-5*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 9.0184348484547e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) + 0.00046681169414007*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 5.826883730569e-6*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.000367586434904886*std::sin(0.282799929380417*x_116 + 8.1476001739502) - 0.000150597748437996*std::sin(0.274159938097*x_117 - 1.41383981704712) - 0.000273141893218871*std::sin(0.265279948711395*x_118 + 4.94767951965332) + 0.000207427086435833*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 7.97815490689884e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000847240801419806*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 8.28197516244991e-5*std::sin(0.326479852199554*x_12 - 1.30671977996826) - 0.000150605796704182*std::sin(0.332799851894379*x_12 + 1.83999991416931) + 0.000131909256428822*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.000198936623685241*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 6.73287981363324e-6*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000150394655602071*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.000160522054470669*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.000475346412161742*std::sin(0.30583992600441*x_13 - 1.21431982517242) + 8.73645535733681e-5*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.000212042309148484*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.000354484985748165*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 8.22494877540415e-5*std::sin(0.290399938821793*x_14 + 4.97815942764282) + 7.22827799415262e-5*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.000170290182320618*std::sin(0.297839939594269*x_15 + 1.80775988101959) - 0.000244941637514162*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 5.13688855303378e-5*std::sin(0.274879962205887*x_16 - 1.19007980823517) + 0.00019571957935936*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 1.77014663338555e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.00019887549663014*std::sin(0.363599836826324*x_17 - 7.59863996505737) + 0.000860513299651066*std::sin(0.368079841136932*x_17 - 1.18871986865997) + 5.22873318608356e-5*std::sin(0.39055985212326*x_17 - 4.4017596244812) + 0.000235297892715004*std::sin(0.371279835700989*x_18 + 8.21751976013184) + 0.000647174921116585*std::sin(0.196479991078377*x_19 - 1.39183986186981) + 7.01903523399471e-5*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.000325832351830586*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.000305682482339292*std::sin(0.368159830570221*x_19 + 8.2324800491333) + 0.000209727454606984*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000257877952302481*std::sin(0.262639969587326*x_20 - 1.36751985549927) + 0.000292159730435766*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.000354708058298454*std::sin(0.183680012822151*x_21 - 4.60888004302979) + 0.000308140375329566*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.00025709733919214*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 1.44707336739811e-5*std::sin(0.402559846639633*x_21 + 7.99271965026855) + 7.7222995166057e-5*std::sin(0.31143993139267*x_22 - 1.34287977218628) - 0.000352703910825434*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 8.74881357265537e-5*std::sin(0.359199851751328*x_22 - 4.37824010848999) + 0.000259909416226941*std::sin(0.284639924764633*x_23 + 1.84703981876373) + 0.000292473993222829*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 8.97863781822337e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) - 6.10704820291297e-5*std::sin(0.374559849500656*x_24 + 5.01847982406616) - 0.000982132601245164*std::sin(0.297839939594269*x_26 - 4.39423990249634) - 7.36383818776914e-5*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.000319076981892495*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000284054993611152*std::sin(0.24975997209549*x_27 - 1.37239980697632) + 7.18391361447753e-5*std::sin(0.237519979476929*x_28 - 4.59055995941162) + 0.000433436216073224*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.000602884100155364*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.000306237113730449*std::sin(0.246799975633621*x_29 + 1.81951987743378) + 8.70922569524852e-5*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 0.000104545562275455*std::sin(0.316479921340942*x_3 - 7.54071998596191) - 0.000302545026491866*std::sin(0.329519838094711*x_3 + 4.96783971786499) + 4.63207592394167e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) + 4.88485236030211e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 0.000128803153736893*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 6.21523337731088e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 2.31535645115786e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) + 0.000511408966231699*std::sin(0.253359973430634*x_34 + 8.17903995513916) + 0.000453941565348887*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.000531735973209514*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.000440675846751643*std::sin(0.246479973196983*x_37 + 8.1879997253418) - 0.000862807927921424*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.000489446148233332*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000262656698796464*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 0.00011053483602136*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.000345407332678491*std::sin(0.334319829940796*x_4 - 1.40255987644196) + 4.51433528968088e-5*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.000295671378144218*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.000123465229261402*std::sin(0.230719983577728*x_41 + 8.20055961608887) + 0.00018206678760225*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.000473441942080077*std::sin(0.247039973735809*x_42 - 7.60703992843628) - 0.000203580776830041*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.00058070883577656*std::sin(0.175760015845299*x_44 + 8.01152038574219) + 3.98199407369371e-5*std::sin(0.266639977693558*x_44 - 4.617919921875) + 0.00117152047261872*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 0.000243257725115987*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000149554822257195*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 0.000115023500576672*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000224552207706216*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.0012264188085244*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 0.000174613184895091*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 4.14014669332129e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.000111965668366457*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.000536952782159526*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.00123620232678853*std::sin(0.124480053782463*x_6 + 1.72319996356964) + 8.93481575263143e-5*std::sin(0.282399952411652*x_6 + 1.81655991077423) + 0.000141585379483156*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000230202869831815*std::sin(0.408159852027893*x_7 - 7.60512018203735) - 0.000161559377235128*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.000207569976141147*std::sin(0.358639866113663*x_8 - 1.3698399066925) - 6.07820256620159e-5*std::sin(0.363359838724136*x_8 - 7.57208013534546) + 0.0003287823193858*std::sin(0.303199917078018*x_9 + 8.1802396774292) - 0.000180365881270488*std::sin(0.304719924926758*x_9 + 4.98575973510742) + 0.000801705660085654*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.000369826440040064*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 0.000206485348894029*std::sin(0.40175986289978*x_9 + 1.58287978172302) - 3.88632139796149e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.000499111823243846*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 1.00447476979749e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) - 0.000304638435401556*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.00018171916468661*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 1.7373901556905e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) - 0.000820246728246255*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 5.53393712868083e-5*std::sin(0.320959836244583*x_95 - 4.5601601600647) - 3.4552194005938e-5*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 7.38021222719394e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 8.44020762884729e-5*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 0.000123189692548917*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 0.000116614529564987*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.000259872139662851*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0391648455239751);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.44757987151835e-5*x_1 + 0.000124499283111104*x_10 - 0.00015505799399305*x_100 - 0.00027420728565101*x_101 - 0.000533295627779172*x_102 + 3.1453954610019e-5*x_103 - 0.00017556136628413*x_104 - 0.000129054990517854*x_105 - 0.000128033415804925*x_106 - 7.32130313539763e-5*x_107 + 1.4929660554472e-5*x_108 - 0.000224391356782729*x_109 + 5.54123188290034e-6*x_11 - 0.000189950500614288*x_110 + 0.000115790456758036*x_111 - 0.000124149784953604*x_112 + 4.36781075041841e-5*x_113 - 6.99379304246164e-5*x_114 + 4.78542494097844e-5*x_115 - 0.000269758300356076*x_116 - 0.000150650610652165*x_117 - 6.21046449954787e-5*x_118 - 2.70492536542237e-5*x_119 + 0.000134839800772399*x_12 + 0.000142175034920546*x_120 + 0.000109502339972895*x_13 - 0.000679076693598542*x_14 + 0.000130932909454232*x_15 + 2.99761039084663e-5*x_16 - 0.000151819405018586*x_17 - 0.000166659147562311*x_18 - 0.000415001396528115*x_19 + 0.000167514487458818*x_2 + 0.000140877893695049*x_20 - 6.19437374574938e-6*x_21 + 8.83222132989544e-5*x_22 - 2.36154974285681e-5*x_23 + 0.00021499280249822*x_24 - 0.000145179722585544*x_25 - 0.000128110426689465*x_26 + 1.35184934159043e-5*x_27 - 0.00025195849172466*x_28 - 0.000610836051944407*x_29 - 9.33892766378766e-5*x_3 - 0.000161704944087314*x_30 + 9.45634646024651e-6*x_31 + 0.000108949612999187*x_32 - 0.000272281679477132*x_33 - 0.000444839339189094*x_34 - 0.000239863800646038*x_35 - 0.000151313291883592*x_36 + 0.000140091969424135*x_37 - 0.000469575709936524*x_38 - 0.000731956717970662*x_39 - 1.88593122082439e-5*x_4 + 6.72822516939784e-5*x_40 - 0.000265146232982902*x_41 - 0.000189202992154162*x_42 - 0.000286843105851253*x_43 - 0.000412739160012634*x_44 - 0.000150551244188162*x_45 + 0.000108514623905643*x_46 - 0.000183338810021989*x_47 - 0.000344556263215989*x_48 - 0.000897744409104531*x_49 + 0.000196647061184302*x_5 - 0.000116804754533898*x_50 - 0.000419623951636005*x_51 - 0.00016303416271085*x_52 + 0.00013629115473395*x_53 - 0.000615773794077558*x_54 - 0.000496899233512815*x_55 + 0.000107844062586814*x_56 - 0.000515234627639257*x_57 - 2.64805001538542e-5*x_58 - 0.000910331482586808*x_59 + 7.93225536266703e-5*x_6 - 0.000293341946418609*x_60 + 3.29488005867491e-5*x_61 + 7.58019464252101e-6*x_62 - 3.6711507997638e-6*x_63 + 2.22270776123323e-6*x_64 - 6.07662681230595e-6*x_65 + 3.28527403389404e-5*x_66 + 2.34493130095691e-5*x_67 - 4.27914254738343e-6*x_68 + 2.96579788981504e-5*x_69 + 1.28265376944214e-5*x_7 - 2.84332803892062e-6*x_70 + 1.51531819510414e-6*x_71 - 9.25132566198381e-6*x_72 - 5.29552882052316e-7*x_73 - 4.81784303096679e-6*x_74 + 1.90471591689713e-5*x_75 + 1.47951641649101e-5*x_76 + 2.42081403197196e-5*x_77 + 1.40966278312415e-5*x_78 - 2.06530122219128e-5*x_79 - 0.000134556928287962*x_8 - 1.48287471520696e-5*x_80 + 5.62940587025675e-5*x_81 + 2.65018739770917e-5*x_82 - 4.52999952777251e-5*x_83 - 5.98239815008571e-6*x_84 + 1.66197359441104e-5*x_85 + 8.37802443462443e-6*x_86 - 4.42291287369211e-5*x_87 + 2.22377216073924e-5*x_88 - 3.48779089224554e-5*x_89 - 5.20172394335688e-5*x_9 - 1.56675790507532e-5*x_90 - 4.73865117185764e-5*x_91 - 4.2956363102919e-5*x_92 + 6.78725830078063e-5*x_93 + 8.20038853025129e-6*x_94 - 0.000123900377080359*x_95 - 0.0002570119253397*x_96 + 1.40583232384454e-7*x_97 + 0.000133021118023118*x_98 - 0.000222326650638831*x_99 + 6.68919480029216e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 6.08812516213507e-9*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) + 0.00138785575451825*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.000837358049050611*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.000236865661899406*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.00136715194715047*std::sin(0.279119968414307*x_100 + 1.78559982776642) + 1.53284609739645e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.0013964655929075*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.000373454183186695*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 4.62427861380484e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 5.53356540956742e-5*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.00160541983227317*std::sin(0.244239971041679*x_109 - 7.61184024810791) + 8.80422989266635e-5*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 0.000558013309590871*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 8.59731291375465e-5*std::sin(0.251519978046417*x_11 + 7.98832035064697) + 1.52779758441396e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.00029122864486608*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 0.000483732442865127*std::sin(0.318399846553802*x_113 - 1.34959983825684) + 0.00212070640239552*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 3.94351314829627e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) - 0.000205272165868122*std::sin(0.282799929380417*x_116 + 8.1476001739502) - 0.000684159401548706*std::sin(0.274159938097*x_117 - 1.41383981704712) - 0.00124087243096761*std::sin(0.265279948711395*x_118 + 4.94767951965332) + 0.000942332755920052*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 0.000427933718823933*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.00126816765275029*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000560506772696408*std::sin(0.326479852199554*x_12 - 1.30671977996826) - 0.000684195964492275*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 6.73974280662067e-5*std::sin(0.349599838256836*x_12 + 8.05080032348633) - 0.00075230505061862*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 4.55667236531052e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) + 8.39852447177917e-5*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.000284696608395282*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.0032613210612337*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 4.46378546464975e-5*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.000376071228654178*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.00243209861341763*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000556647345985437*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 3.69320060883157e-5*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.000302021036981885*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.000125149946574731*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 9.11061569437168e-5*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.000100000535429737*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 9.49474459355653e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) + 0.000111058515915939*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.00158524985776149*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 2.67155754135124e-5*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.000120222592619546*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.00119223485803518*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 3.58629056886991e-5*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.000577885486063075*std::sin(0.324719846248627*x_19 + 1.82007992267609) - 0.000170702994613952*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000107157688687375*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.00176928399069463*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.000149275456089861*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.002433629099791*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.000567660588581075*std::sin(0.322159916162491*x_21 - 4.58671998977661) + 0.000143571477735727*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 7.76183835420732e-5*std::sin(0.402559846639633*x_21 + 7.99271965026855) + 0.000350820903410522*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000649756168434195*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000592101420777625*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.000478808828720839*std::sin(0.284639924764633*x_23 + 1.84703981876373) + 0.00132869736929882*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 0.00048159780254493*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 3.12032190231306e-5*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.00180929866750247*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 3.76246343878952e-5*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00215944633803234*std::sin(0.14824004471302*x_27 - 7.64807987213135) + 0.000158625504717834*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 3.67053316934473e-5*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000798482371111958*std::sin(0.239359974861145*x_28 - 4.58543968200684) + 0.00227988564942249*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.00139122266192505*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 4.44987280043234e-5*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 0.000560763381673478*std::sin(0.316479921340942*x_3 - 7.54071998596191) - 0.00137444966085555*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 8.53327624633637e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 8.99894459794504e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 0.000690876690388864*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 0.000333373814315311*std::sin(0.318879842758179*x_33 - 4.5557599067688) + 1.29297000203199e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) + 0.00232330998247146*std::sin(0.253359973430634*x_34 + 8.17903995513916) + 0.00206223793455348*std::sin(0.252959966659546*x_35 - 4.41495990753174) + 0.000296938582401589*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.000781568111532212*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.00158947705464581*std::sin(0.251679986715317*x_37 - 4.41239976882935) - 0.000273322575001069*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.00180207066203238*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 0.000592888756738876*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.000517012879445329*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 2.30654463674564e-5*std::sin(0.358399868011475*x_4 + 8.20823955535889) - 0.00016511246992175*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.000835586871925117*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 9.30248077570605e-5*std::sin(0.253119975328445*x_41 + 8.16639995574951) + 0.00179038307579337*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 0.000104017118536855*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.00102992599089222*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 2.03455137575313e-5*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.00215819170178609*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 0.00130479019467921*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.0010260859852046*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 0.000616965137031354*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.00154063820742508*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.0018357291800499*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 0.000936593365757207*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 0.000222069938679377*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.00076818922587005*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.000803722092052054*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.00219248757367081*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 4.56513529281945e-5*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 7.23413252965432e-5*std::sin(0.363519847393036*x_7 - 4.3854398727417) + 0.000128552735336007*std::sin(0.408159852027893*x_7 - 7.60512018203735) - 0.000733957632104141*std::sin(0.350399851799011*x_8 - 1.36039984226227) + 0.00011591379475881*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 3.10558357554273e-5*std::sin(0.363359838724136*x_8 - 7.57208013534546) + 0.00149364460759781*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 9.21557503819692e-5*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.00147691358649856*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.00253735534137859*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 0.000309071564772901*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 7.15943663605441e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.000885208227343441*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 6.79807534351036e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) - 0.00138395993177065*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.000322291102224552*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 0.000117582935227316*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.00151107020636284*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000374525300965062*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 1.76540227205465e-5*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 0.000395861161001272*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000571215615374216*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 0.000660767105532757*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 0.00062549912715403*std::sin(0.279519945383072*x_99 + 4.96663951873779) + 0.00098274073200698*std::sin(0.307279914617538*x_99 - 4.6276798248291) - 0.0089816696044439);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.13865028026999e-5*x_1 + 8.8216829423193e-5*x_10 + 1.13003242440705e-5*x_100 - 0.00021511249319104*x_101 - 0.00175731701192814*x_102 + 0.000866565519242258*x_103 + 0.000499752330522413*x_104 - 0.000452491435931724*x_105 - 0.00161766514521697*x_106 - 0.000134291680046954*x_107 + 0.000306892751555367*x_108 - 0.000229100246043572*x_109 - 0.000462556368449342*x_11 - 0.00021450577688411*x_110 - 2.38275585550302e-5*x_111 + 0.000251200999787401*x_112 - 4.52461255104896e-5*x_113 - 0.000229383987864548*x_114 - 4.97264072686563e-5*x_115 - 0.000426026619033016*x_116 - 0.000133411837310783*x_117 + 0.000185466054662969*x_118 + 8.08869769255585e-6*x_119 - 0.000843003744255651*x_12 - 4.03230518496947e-5*x_120 + 7.53883553966814e-5*x_13 - 0.000163004610247492*x_14 + 0.000126404397261408*x_15 + 7.68528524023992e-5*x_16 + 5.6102345403383e-5*x_17 - 8.02180208387042e-5*x_18 - 8.18027984176277e-5*x_19 + 0.000155990340339436*x_2 + 2.18796117092538e-5*x_20 + 0.000161551672353977*x_21 + 0.000135298726983492*x_22 + 9.46045430044177e-5*x_23 + 0.000305196091627498*x_24 + 0.000290967101981261*x_25 + 0.000561175079788616*x_26 + 0.000172672434007555*x_27 - 0.00128437446250097*x_28 - 0.000305314106781211*x_29 - 3.69481846167782e-5*x_3 + 0.0010052204592483*x_30 + 1.66991434231506e-5*x_31 + 4.20693918311307e-5*x_32 - 0.000207800890413107*x_33 - 0.000740437061276767*x_34 - 0.000275879358066879*x_35 - 0.000322698557024722*x_36 + 1.16863555357035e-5*x_37 - 0.000827050736933922*x_38 - 0.00014075827762246*x_39 + 1.19751319285984e-5*x_4 - 0.000167190620090064*x_40 + 3.87410670428399e-5*x_41 - 0.000238687801668443*x_42 + 0.00219128763590118*x_43 - 7.6922582785602e-5*x_44 - 0.000228138563369022*x_45 - 0.00195922981442766*x_46 - 0.000197685724288901*x_47 - 0.00132153495073842*x_48 - 0.00190181082653953*x_49 + 0.000342953035929921*x_5 - 0.00177763190987844*x_50 - 0.000886263321162137*x_51 - 0.000480079839152812*x_52 + 0.000325778031413367*x_53 - 0.000335419995010198*x_54 - 0.000387018402596041*x_55 - 8.14413840579917e-5*x_56 - 0.00158123943844284*x_57 - 0.000426389441263354*x_58 - 0.000111352292573582*x_59 + 0.000145368594444692*x_6 - 0.00213290161354753*x_60 + 0.00040954910273698*x_61 - 3.510441852696e-5*x_62 - 6.14429538557685e-6*x_63 - 8.07450488102867e-6*x_64 - 3.99630947487663e-6*x_65 - 6.60677524394863e-5*x_66 - 8.79600024028147e-6*x_67 + 9.49580375932672e-7*x_68 + 5.29857899652923e-6*x_69 + 0.000634684165950128*x_7 + 3.81510057863767e-5*x_70 + 7.69386151987399e-6*x_71 - 7.12354945533469e-5*x_72 + 7.94294689127169e-5*x_73 - 6.07596262020059e-5*x_74 + 0.000265129490554408*x_75 - 5.13758003284495e-5*x_76 + 1.0953868562332e-5*x_77 + 0.000316362208779333*x_78 - 0.000153555459563756*x_79 - 5.05648513858564e-5*x_8 - 4.26156422015262e-5*x_80 + 0.000384375521145652*x_81 - 6.32580432114828e-6*x_82 - 5.26230278973403e-5*x_83 - 1.7873053519312e-6*x_84 + 2.65053813020663e-5*x_85 - 5.77518180612691e-7*x_86 + 5.85448889938766e-5*x_87 + 0.000454882596939583*x_88 + 1.89426636464872e-5*x_89 + 3.80397879099689e-5*x_9 - 0.000506187597826684*x_90 - 0.000116187196422196*x_91 - 4.0419586930327e-5*x_92 - 0.000861990877443994*x_93 - 5.27668304461426e-5*x_94 - 0.000442231116349307*x_95 - 0.000855916047040178*x_96 + 0.000755520875607839*x_97 - 9.26242739793281e-5*x_98 - 0.00137886904258416*x_99 + 8.54538497571968e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 2.50222715776003e-9*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 6.86488736366385e-5*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 4.69922237014211e-5*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.00307370500936064*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.000497750107438863*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 4.54043065002172e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.00159857641120508*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.00484615619006491*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 5.9074734956476e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 2.27430239660271e-5*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000530485388310933*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000260789359886799*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 3.13155003434853e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 3.5335065038337e-5*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 4.52547649179171e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.000372041921432623*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 2.71468856035073e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) - 0.000333592049962187*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 5.03780186032736e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.000608034971734616*std::sin(0.282799929380417*x_116 + 8.1476001739502) + 0.000107619865251376*std::sin(0.274159938097*x_117 - 1.41383981704712) + 0.000195192119720325*std::sin(0.265279948711395*x_118 + 4.94767951965332) - 0.000148231134417662*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 2.40154818684258e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000461712091858269*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000716042258775273*std::sin(0.326479852199554*x_12 - 1.30671977996826) + 0.000107625616687446*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 2.77004283550731e-5*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 3.72120043368984e-5*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 5.82110713356724e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000248771993427081*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.00369438687041179*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.00107765154933056*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 1.83462148339671e-5*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.00488011647666206*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.000803648211771812*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000711111876567032*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 1.51791013101205e-5*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.00391919861603985*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 5.14367866579285e-5*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 0.00118224587192561*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 4.11003468028374e-5*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 5.32841551393865e-6*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.000328965504408519*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.00181468347043734*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 1.09801353544173e-5*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 4.94116379373925e-5*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.00136478731044375*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 1.47396996908945e-5*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.00749897430934179*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.00050563791766971*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 4.40419458627408e-5*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000584631686969377*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 6.13524016454472e-5*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.000804153936593294*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.0006498182490749*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.000425271877644743*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 4.35591494807659e-6*std::sin(0.402559846639633*x_21 + 7.99271965026855) - 5.51849441328161e-5*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000743795542954487*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.00075640413177897*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.000548106951547758*std::sin(0.284639924764633*x_23 + 1.84703981876373) - 0.000209007186804868*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 2.70270903790361e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 1.28245625656339e-5*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.0020711589210532*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 1.54637724190885e-5*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00275867288123953*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000469863285504874*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 1.50859378465413e-5*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000914046926544806*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.000112772225314956*std::sin(0.132480040192604*x_29 + 1.57615983486176) + 0.000218842560771819*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 1.82890336077036e-5*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 3.14698333706144e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) + 0.000216204128688777*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 9.76829947473934e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 0.000103013641246005*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 3.87717440844575e-5*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 1.87088150358894e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 3.82989566712277e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) - 0.000365462064373831*std::sin(0.253359973430634*x_34 + 8.17903995513916) - 0.000324394823970158*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.000879559300180335*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.0101420771601471*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.00181952247059539*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.000809606521480249*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000595465519793905*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 3.32726975256516e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.00018823307594124*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 9.47992769029511e-6*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.0004890782710716*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.00106745456133908*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 3.82333138882926e-5*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 8.85594782679551e-5*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 4.27511675505017e-5*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.013364911790467*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 8.36203194035872e-6*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.00247054733239124*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 7.32243426588001e-5*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000339053754886621*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 3.46238550739756e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000509079333195559*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.000668348824359261*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 5.25612729355509e-5*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 1.24624827427334e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.000253835882421445*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.000292617626375561*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.0284509792770845*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 1.87627639122577e-5*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 2.97323763826633e-5*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000380784985952033*std::sin(0.408159852027893*x_7 - 7.60512018203735) + 0.000115453242750832*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.000343347285404029*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 1.27639878558135e-5*std::sin(0.363359838724136*x_8 - 7.57208013534546) - 0.00023495377106453*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 3.7876130205682e-5*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.00169066766324637*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.000838428619414868*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 0.000112526193516862*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 8.1956237103452e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.0114869708884537*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 8.68447887056699e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) + 0.000217700116425072*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.00418223463644416*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 0.000150211120783722*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.00172976777933864*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000478452635249006*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 7.25582571294777e-6*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 2.22155817974966e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000729722707029268*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 3.70820053296688e-5*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 3.51027794401594e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 4.86102709950161e-5*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0232888790555195);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.62279824478223e-5*x_1 + 9.8241710753888e-5*x_10 + 0.000160345198252253*x_100 + 1.49373061591232e-5*x_101 - 0.000846689309071894*x_102 + 0.00051616662606942*x_103 + 7.69409257029768e-5*x_104 - 0.000215086692379587*x_105 - 0.000690747187147611*x_106 - 6.78167555247488e-5*x_107 + 0.000232421644644454*x_108 + 5.18340255687579e-5*x_109 - 0.000175292654317085*x_11 - 0.000280186742630104*x_110 - 4.26393685827724e-5*x_111 + 0.00012051126516926*x_112 - 1.17418008656014e-5*x_113 - 0.000208418220234304*x_114 + 2.3357745319783e-6*x_115 - 0.000301251618041565*x_116 - 0.000111420413984758*x_117 + 3.46940196381082e-5*x_118 + 1.72358061177016e-5*x_119 - 0.000274669685272844*x_12 + 5.8357165426665e-5*x_120 + 0.000161729706809987*x_13 + 0.000160937172045718*x_14 + 0.000123977500076064*x_15 + 0.000116187479510295*x_16 + 0.000170762788998039*x_17 + 0.000189491648732555*x_18 + 0.000144270229858881*x_19 + 0.000167568395209773*x_2 + 0.000154770776135615*x_20 + 8.15173583966548e-5*x_21 + 9.55354626378366e-5*x_22 + 7.03525314084951e-5*x_23 + 0.00034482371545194*x_24 + 0.000168645989940672*x_25 + 0.000498161529279441*x_26 + 0.000465605288059671*x_27 - 0.000587193415416757*x_28 - 0.000361004071304385*x_29 - 4.73823697758455e-5*x_3 + 0.000410684613915061*x_30 - 1.50638046906656e-5*x_31 + 5.57746985230807e-5*x_32 - 0.000202979705427892*x_33 + 0.000137851658775819*x_34 - 2.03870010678027e-5*x_35 - 0.0003676123993394*x_36 + 1.5346012593579e-5*x_37 - 0.000419548866345555*x_38 + 0.000153708577186154*x_39 - 1.53866338920578e-6*x_4 - 0.00020521136434984*x_40 - 0.0002400786624096*x_41 + 0.000134634516930909*x_42 + 0.00191022237777658*x_43 - 0.000118487346782456*x_44 - 0.000394547263339815*x_45 - 0.000675368662963915*x_46 - 0.000148600223570316*x_47 - 0.00059706391166927*x_48 - 0.000569899397108018*x_49 + 0.000251403647770801*x_5 - 0.000777629420067993*x_50 - 0.000613232398435833*x_51 - 0.000435733494803226*x_52 + 0.000258199877346892*x_53 + 0.000337020643504074*x_54 + 0.000269323445783369*x_55 - 4.17554678037131e-6*x_56 - 0.000835600274538159*x_57 - 0.000275882748876019*x_58 - 0.000143479381075427*x_59 + 0.000171010825544905*x_6 - 0.000437718416515532*x_60 + 0.000176049955483808*x_61 + 1.95787807220145e-6*x_62 + 3.78506936331157e-6*x_63 - 1.65836697928942e-5*x_64 - 6.44697764320741e-6*x_65 - 3.44463437805848e-5*x_66 + 4.48421380971081e-6*x_67 - 2.04971944638151e-5*x_68 + 2.1539914960059e-5*x_69 + 0.000234768106649546*x_7 + 3.04070511042564e-5*x_70 - 1.31462266957348e-5*x_71 - 2.79123630693142e-5*x_72 + 3.1241032472702e-5*x_73 - 2.51713667638349e-5*x_74 + 9.18030662637527e-5*x_75 - 1.70823349009488e-5*x_76 - 9.20299003728017e-6*x_77 + 0.000167098776920836*x_78 - 6.98793333787237e-5*x_79 - 2.24927602804858e-5*x_8 - 2.58647646450128e-5*x_80 + 0.000180708098511517*x_81 - 3.66474030438446e-5*x_82 - 5.24858881834561e-5*x_83 + 2.59410149117011e-5*x_84 - 2.70048968902626e-6*x_85 + 7.1457777519792e-6*x_86 - 3.35586474887662e-6*x_87 + 0.000185897601251328*x_88 + 1.55776470243928e-6*x_89 + 4.85315123154188e-5*x_9 - 0.000194187790017868*x_90 - 3.0814857281373e-5*x_91 + 3.37777479203126e-5*x_92 - 0.000320765451392337*x_93 + 4.95360086004798e-5*x_94 - 0.000183237230920098*x_95 - 0.000228028536485709*x_96 + 0.000125746799012076*x_97 - 0.000109477596429902*x_98 - 0.000443222408206287*x_99 + 2.35822991320504e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 4.34054394992312e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00193193895380813*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.000212251276784102*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.0012846579432316*std::sin(0.273439943790436*x_100 - 4.60543966293335) - 0.00072994557086714*std::sin(0.279119968414307*x_100 + 1.78559982776642) + 1.51840882175533e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.00149506531184209*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.00202545560642557*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 1.63025782319758e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 0.000394516919747072*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000609597852110035*std::sin(0.244239971041679*x_109 - 7.61184024810791) + 8.72130630758886e-5*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 0.000141443719992266*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 0.000612947558724414*std::sin(0.251519978046417*x_11 + 7.98832035064697) + 1.51340785873473e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.000102670668504879*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 0.000122615204734015*std::sin(0.318399846553802*x_113 - 1.34959983825684) + 0.000681807229128385*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 1.39025861065123e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) - 0.000203338787921621*std::sin(0.282799929380417*x_116 + 8.1476001739502) - 0.000219957286555624*std::sin(0.274159938097*x_117 - 1.41383981704712) - 0.000398940557214405*std::sin(0.265279948711395*x_118 + 4.94767951965332) + 0.000302960034687036*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 0.000108471493529357*std::sin(0.278959959745407*x_119 + 4.94783973693848) - 0.000677096180253746*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000197602832237589*std::sin(0.326479852199554*x_12 - 1.30671977996826) - 0.000219969041544063*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 0.000480511636739346*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.00104723234219771*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 1.60642370230879e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) + 8.31942206679301e-5*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.00154407251964373*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.00123836411759924*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 0.000318246692969522*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.00203964934063187*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.000923498053938898*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000196242217725774*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 0.000263307654353388*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.00163803280336429*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.00089225965132367*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 0.000494120790901114*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.00071295630015661*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 2.40670244348426e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) + 0.000110012499352831*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.00169717899601612*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 0.000190469358204143*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.00085712995896398*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.00127641453457238*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 0.000255685476510729*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.00313420347211182*std::sin(0.324719846248627*x_19 + 1.82007992267609) - 0.000169095210120655*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000763983402004523*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000671819108508805*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.00106426307039922*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.000924079198625871*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.000607741185459799*std::sin(0.322159916162491*x_21 - 4.58671998977661) + 0.00014221923434887*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 1.96745000867931e-5*std::sin(0.402559846639633*x_21 + 7.99271965026855) + 0.000112788940423086*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000695633256927463*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000208741309502305*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.0005126159029338*std::sin(0.284639924764633*x_23 + 1.84703981876373) + 0.00042717627988886*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 0.000122074121819782*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 0.000222464124737997*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.00193704713548514*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 0.000268245765011795*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.000761298048920107*std::sin(0.14824004471302*x_27 - 7.64807987213135) + 0.000157131473360601*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 0.000261691573627309*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000854860514451629*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.0031736726832079*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.000447278165028534*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 0.00031725478611991*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 0.00014214080090221*std::sin(0.316479921340942*x_3 - 7.54071998596191) - 0.000441885644229594*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 9.1357820608392e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 9.63432968195407e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 0.000175121574100433*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 8.45027020580226e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) + 1.28079202516482e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) + 0.000746944291659545*std::sin(0.253359973430634*x_34 + 8.17903995513916) + 0.000663009613387832*std::sin(0.252959966659546*x_35 - 4.41495990753174) + 0.000294141834463297*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.0042388908320649*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.00170170466099503*std::sin(0.251679986715317*x_37 - 4.41239976882935) - 0.000270748256965532*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000684268614876887*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 0.000150283854978695*std::sin(0.333039849996567*x_4 - 4.3776798248291) + 0.00027604192951557*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 0.000164445672544992*std::sin(0.358399868011475*x_4 + 8.20823955535889) - 0.000163557340385853*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.000294580441336403*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 0.000663222676521104*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.00249226967219276*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 0.00074159262914241*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.00558587764275548*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 0.000145053845472126*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.0023105743285288*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 0.000330734725808195*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000389617594156206*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 0.000156386671406163*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000584999464467296*std::sin(0.251279979944229*x_52 + 7.98904037475586) - 0.000980126888662149*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 0.000237405179223961*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 5.62896936065829e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.000291690991160481*std::sin(0.30311992764473*x_56 - 4.84959983825684) - 0.000429120832197373*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.0118911139519621*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 0.000325472454131986*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 0.000515759274789963*std::sin(0.363519847393036*x_7 - 4.3854398727417) + 0.000127341947587897*std::sin(0.408159852027893*x_7 - 7.60512018203735) - 0.00023596742051483*std::sin(0.350399851799011*x_8 - 1.36039984226227) + 0.000114822048230322*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 0.000221413352071679*std::sin(0.363359838724136*x_8 - 7.57208013534546) + 0.000480206826394485*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 0.00065702671038846*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.00158119346654647*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.000963465340996936*std::sin(0.337999850511551*x_9 + 8.23991966247559) - 0.000165018541104506*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 7.6649402758363e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.0048009904498258*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 2.39661500463218e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) - 0.000444943196870338*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.00174796895922159*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 4.14530602582238e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.00161776176997494*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000132036335367203*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 0.000125864793299684*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 0.000100341827426177*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000201378161539931*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 0.000167489477130214*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 0.000158549844378172*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.0013680060737416*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0571640122315894);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000230085527953673*x_1 + 6.43634607583716e-5*x_10 + 0.000586947784602242*x_100 + 0.000550344140526073*x_101 - 0.00182381003448542*x_102 + 0.000706132460166361*x_103 + 0.000465960996529661*x_104 - 0.000576113628804774*x_105 - 0.00156248782690868*x_106 - 0.000198623602907222*x_107 + 0.000718073209016108*x_108 - 0.000362618484488806*x_109 - 0.000403886928842655*x_11 - 0.00189837269062558*x_110 - 1.15734240246228e-5*x_111 + 0.000232091478434694*x_112 + 3.99966695010839e-5*x_113 - 0.00128184522038818*x_114 + 2.13924878572636e-6*x_115 - 0.000464680052996992*x_116 - 7.86659080205713e-5*x_117 + 6.42263457380009e-5*x_118 + 0.000104941791858372*x_119 - 0.000913037428948589*x_12 + 0.000199149636243165*x_120 + 0.000154936230875422*x_13 + 0.00186233555453078*x_14 + 0.000210128836393433*x_15 + 0.000411533904170283*x_16 + 0.000713371707383791*x_17 + 0.000964666865602361*x_18 + 0.000979870189921844*x_19 + 8.16013470911319e-5*x_2 + 0.000306927450094847*x_20 + 0.000259174314120681*x_21 + 0.000306512443568757*x_22 + 0.000140020760017222*x_23 + 0.000794603486666696*x_24 + 0.000296757940670217*x_25 + 0.00162412604032324*x_26 + 0.00120007777231309*x_27 - 0.00139341913690754*x_28 - 0.000348190822148366*x_29 + 3.71134742057768e-5*x_3 + 0.000937648403680793*x_30 - 6.91648330358746e-5*x_31 + 4.30835777376778e-5*x_32 - 0.000230736858458319*x_33 + 0.0010993289400174*x_34 - 0.000332904632756283*x_35 - 0.00102824738818772*x_36 + 4.35899763724362e-5*x_37 - 0.00103723609005227*x_38 - 0.000720265063308428*x_39 + 4.23361900227017e-6*x_4 - 0.0013224108324511*x_40 - 0.000417921008413947*x_41 - 0.000478754466327894*x_42 + 0.00585835381343435*x_43 - 0.000331813138095663*x_44 - 0.0027315798468092*x_45 - 0.00187963963033349*x_46 - 0.000419127876462993*x_47 - 0.00138500885316219*x_48 - 0.000866338978673533*x_49 + 0.000329633345169774*x_5 - 0.00157006173210588*x_50 - 0.000975334372543846*x_51 - 0.000607059661130306*x_52 + 0.000502900951842523*x_53 + 0.00199954783915495*x_54 + 0.00100388160045115*x_55 - 0.000429394459738026*x_56 - 0.00145476480083329*x_57 - 0.00129617904517399*x_58 - 0.000587350838354323*x_59 + 0.000353288046685654*x_6 - 0.000428257118726116*x_60 + 0.000400513062157719*x_61 - 2.69066538733552e-5*x_62 + 6.39944586755751e-6*x_63 - 2.34490574086106e-5*x_64 - 1.85810725664914e-6*x_65 - 0.000119952923400671*x_66 + 6.55094517638678e-7*x_67 - 1.46735895719406e-6*x_68 - 4.9683189285648e-5*x_69 + 0.000697934714700255*x_7 + 5.8539233963541e-5*x_70 + 3.59655669357582e-5*x_71 - 4.93354827059288e-5*x_72 + 8.85634059712493e-5*x_73 - 4.81611630660224e-5*x_74 + 0.000247907116733603*x_75 - 5.72314007735109e-5*x_76 + 3.5992581910034e-5*x_77 + 0.000378156877901426*x_78 - 0.000160772394182727*x_79 - 8.49318447986016e-6*x_8 - 6.23832446796354e-5*x_80 + 0.000358085870232783*x_81 - 2.14824710123438e-5*x_82 - 5.83512286184135e-5*x_83 + 6.1430804476881e-5*x_84 - 6.53206954935573e-8*x_85 + 1.11598861127817e-5*x_86 - 9.32768269349283e-6*x_87 + 0.000449936943983188*x_88 + 2.41733828943094e-5*x_89 + 0.000233658258712467*x_9 - 0.000433229196808688*x_90 - 3.59405051687797e-5*x_91 - 3.78722938101084e-5*x_92 - 0.000875115600198248*x_93 + 1.18310559189556e-5*x_94 - 0.000497560463043021*x_95 - 0.000770919444444565*x_96 + 2.43744571469705e-5*x_97 - 0.000345767118382114*x_98 - 0.0014141281302796*x_99 + 3.88038964471471e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 5.24875674682214e-9*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00932709871666012*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 5.66481785864747e-5*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.00289991258485575*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.00150667356840861*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 0.000109735933788048*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.00163090565369933*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.00457214640993447*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 2.68253554919649e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 4.77065401974472e-5*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000310524087662938*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000630291840907828*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 3.77502045286042e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 7.41200336045419e-5*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 0.000109374512450762*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.000168941203167425*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 3.27250234742046e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) + 0.00197499836775291*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 2.28762475025796e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.00146953649426995*std::sin(0.282799929380417*x_116 + 8.1476001739502) - 0.000637152648671778*std::sin(0.274159938097*x_117 - 1.41383981704712) - 0.00115561542275834*std::sin(0.265279948711395*x_118 + 4.94767951965332) + 0.00087758760605425*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 2.89501793821621e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.0013975876541683*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000325148951629965*std::sin(0.326479852199554*x_12 - 1.30671977996826) - 0.000637186699473807*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 5.81053601659042e-5*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.00505587374575359*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 2.64331728834334e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000601247527013859*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.00348550005488701*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.000630812406049312*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 3.84836438969176e-5*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.00460418652510117*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.000470422245854817*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000322910105267898*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 3.18401989064466e-5*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.00369760056823647*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.000107895552235688*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 0.00111539971205759*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 8.6213484618734e-5*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 6.42329751267784e-6*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.000795064160051698*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.00185138321250463*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 2.30323051781237e-5*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.00010364753143659*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.00139238845581481*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 3.09184951329405e-5*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.00707496975374799*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.00122205696620131*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 9.23838828034997e-5*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000342219079385091*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.000128694883304902*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.000470718276136253*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.000662960024222011*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.00102782335430933*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 5.25096768039677e-6*std::sin(0.402559846639633*x_21 + 7.99271965026855) + 0.000326716942442728*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000758837893326836*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000343476949080032*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.000559191740754684*std::sin(0.284639924764633*x_23 + 1.84703981876373) + 0.00123740614572509*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 3.25806127454686e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 2.69012383958265e-5*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.00211304556377701*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 3.2437334701727e-5*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00125269086318907*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.00113559462442953*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 3.16447760582443e-5*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000932532401829103*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.0153219946998323*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.00129563549361623*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 3.8363698612889e-5*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 3.79362498823662e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) - 0.0012800149203501*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 9.96585132165871e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 0.000105096965486694*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 4.67385560845257e-5*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 2.25530994665898e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 9.2563285233859e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) + 0.00216368160061291*std::sin(0.253359973430634*x_34 + 8.17903995513916) + 0.00192054711112323*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.00212577327057708*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.00956862714662605*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.00185632007549141*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.00195670707216073*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000348560754627912*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 4.0109566286174e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.000569775467614039*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 1.98854185838049e-5*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.00118203458897074*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.000484722413067739*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 8.0199498915274e-5*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.0120322876741315*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 8.96763023370317e-5*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.0126092373141313*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 1.75404824569926e-5*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.00252051111469314*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 8.82704693050627e-5*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000198467969570448*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 4.17383594793254e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000297993873105421*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.00202307039835798*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 6.3361555199089e-5*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 1.50232717763444e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.000148584970560652*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.00088574414494662*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.0268423133013176*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 3.93574114037085e-5*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 6.23676434226144e-5*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000920304685321317*std::sin(0.408159852027893*x_7 - 7.60512018203735) - 0.000683529376705829*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.00082982293710889*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 2.67741748253307e-5*std::sin(0.363359838724136*x_8 - 7.57208013534546) + 0.00139102030279929*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 7.94502582805288e-5*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.00172485933808854*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.000490781250249439*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 0.000340613169121842*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 8.36137012350767e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.0108374783331038*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 3.94355104829596e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) - 0.00128887176612234*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.0039457640919051*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 6.82096452373179e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.00176475020595585*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000217261440717052*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 1.52200666700032e-5*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 2.67804361220082e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000331361131641829*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 4.47016100707778e-5*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 4.23156931504744e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.006604519086707*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0146651784059758);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000252461119682772*x_1 + 5.49519144516336e-5*x_10 + 0.000128630823511407*x_100 - 0.000142452489897292*x_101 - 0.00188837898144905*x_102 + 0.00133541942433963*x_103 + 0.000646284949666701*x_104 - 0.000538760152684867*x_105 - 0.00195644635209037*x_106 - 4.42323267833689e-5*x_107 + 0.000296016697981453*x_108 - 1.80481416141525e-5*x_109 - 0.000589440480591258*x_11 - 6.10535730657644e-5*x_110 - 0.000220504372231399*x_111 + 0.000509818649997652*x_112 - 4.61762717749805e-5*x_113 + 5.8970697539623e-5*x_114 - 0.000111870391061338*x_115 - 0.000586285985554972*x_116 + 3.04726619454033e-5*x_117 + 0.000876984463006548*x_118 + 2.32387637536946e-5*x_119 - 0.00115431330176943*x_12 - 6.05438938286714e-5*x_120 - 0.000140461225323964*x_13 + 0.000525744414294218*x_14 - 8.64605166632351e-5*x_15 - 5.69384436776739e-5*x_16 - 1.80734653203481e-5*x_17 - 0.000160164256640666*x_18 + 8.90573698820763e-5*x_19 + 1.13145518441069e-5*x_2 + 4.00801296805451e-5*x_20 + 0.000194692271552331*x_21 + 1.89744570533466e-5*x_22 + 0.000175516945264032*x_23 + 1.1595271484105e-5*x_24 + 0.000451069041574088*x_25 + 0.000733000538882685*x_26 + 0.000328006083828647*x_27 - 0.00156858346932222*x_28 + 0.000645917269527765*x_29 + 3.79119049352211e-6*x_3 + 0.00131163988015213*x_30 + 2.86569467959576e-5*x_31 - 3.12802968255722e-5*x_32 + 0.000118794819336028*x_33 - 0.000593342687393954*x_34 - 0.00033363088229996*x_35 - 0.000316611416616577*x_36 + 8.54395684662206e-6*x_37 - 0.000859333732798281*x_38 + 6.39283169100074e-6*x_39 + 4.28028395523601e-5*x_4 - 0.000187386228937239*x_40 + 0.000344325772680926*x_41 - 0.000311507197037776*x_42 + 0.00165704054299683*x_43 + 0.000155157473353907*x_44 + 3.32834196481344e-5*x_45 - 0.00222957442548086*x_46 - 0.000114891783989659*x_47 - 0.00156036042258193*x_48 - 0.00176066015033151*x_49 + 4.98145723448025e-5*x_5 - 0.00234516929672639*x_50 - 0.000462978781909804*x_51 - 6.04472423334604e-5*x_52 + 0.000610876482588594*x_53 - 0.000187628800253687*x_54 - 0.000155691548493395*x_55 + 0.000223118084786005*x_56 - 0.00169498937941627*x_57 - 0.00069670816164621*x_58 + 0.000168331656660212*x_59 - 0.000109040025455684*x_6 - 0.00198808205595869*x_60 + 0.000505564090466195*x_61 - 4.73104869754386e-5*x_62 - 2.21357293072046e-5*x_63 - 1.82706868549969e-5*x_64 - 4.28138189209198e-6*x_65 - 9.55602444604475e-5*x_66 - 3.8683712679127e-5*x_67 + 1.01644141991106e-5*x_68 + 1.76038607635137e-5*x_69 + 0.00105618207954731*x_7 + 6.06016284343155e-5*x_70 - 2.82282044156541e-5*x_71 - 8.04733247724681e-5*x_72 + 8.71318763952795e-5*x_73 - 9.78387888111265e-5*x_74 + 0.000296417687726937*x_75 - 9.70609107926254e-5*x_76 - 3.21044593975753e-5*x_77 + 0.000404185132964481*x_78 - 0.000200269505308831*x_79 + 0.000111280848514138*x_8 - 2.24220000383031e-5*x_80 + 0.000479260235673452*x_81 - 8.8268252610157e-5*x_82 + 3.60462145862369e-5*x_83 + 5.08354904507396e-5*x_84 + 2.13473256858967e-5*x_85 - 2.49205693451061e-5*x_86 + 6.62735972468039e-5*x_87 + 0.00055353892547547*x_88 + 1.80596777198692e-5*x_89 + 5.22540632953948e-5*x_9 - 0.000668491385224771*x_90 - 0.000129405995549769*x_91 - 2.31342850510779e-5*x_92 - 0.001186016165485*x_93 - 4.27793846645779e-5*x_94 - 0.000506416333229838*x_95 - 0.000993218912466196*x_96 + 0.00100134804645238*x_97 - 0.000130078161727888*x_98 - 0.00148103791642526*x_99 + 3.99087090226342e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 5.13354046757463e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) + 3.92970762623244e-5*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.00390690718406639*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.000417283598813943*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 2.05894468206218e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) - 0.00124238714287284*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.0061598241784467*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 2.75891187426426e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 0.000466593264814277*std::sin(0.272719949483871*x_108 - 1.22631990909576) - 0.000721481171831423*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000118259898028562*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 2.61874733362229e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 0.000724930131687432*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 2.05216343443708e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.000173751245015452*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 2.27014844120552e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) - 0.00112554059762637*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 2.35275729681866e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.000275725028760175*std::sin(0.282799929380417*x_116 + 8.1476001739502) + 0.000363109754759542*std::sin(0.274159938097*x_117 - 1.41383981704712) + 0.000658578809377726*std::sin(0.265279948711395*x_118 + 4.94767951965332) - 0.000500132301229006*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 2.00828594206632e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000387071505213481*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000334406492329686*std::sin(0.326479852199554*x_12 - 1.30671977996826) + 0.000363129160122448*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 0.000568298803283779*std::sin(0.349599838256836*x_12 + 8.05080032348633) - 2.71857700318002e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000112810394518469*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.00469583989380122*std::sin(0.365439832210541*x_120 + 4.6199197769165) + 0.00146564885625321*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 0.000376388834182816*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.00620299022309811*std::sin(0.383359849452972*x_13 + 8.02447986602783) + 0.00109299344778467*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000332103902224288*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 0.000311412697265561*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.00498159230705557*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.00105527120114409*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 0.00150272224442246*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.000843209989506285*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 4.4558681057323e-6*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.000149175668145176*std::sin(0.363599836826324*x_17 - 7.59863996505737) + 0.00141034197442939*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 0.000225267194493274*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.00101372348283447*std::sin(0.371279835700989*x_18 + 8.21751976013184) + 0.00106069012113916*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 0.000302397984165597*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.00953175288880143*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.000229291135991707*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000903559497609745*std::sin(0.341359823942184*x_2 + 1.9651198387146) + 0.000795122285926597*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.001258698818183*std::sin(0.303999930620193*x_20 + 8.18367958068848) + 0.00109368125360339*std::sin(0.183680012822151*x_21 - 4.60888004302979) + 0.000505027993779916*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.000192847625787007*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 3.64261804238875e-6*std::sin(0.402559846639633*x_21 + 7.99271965026855) - 0.000186194170413438*std::sin(0.31143993139267*x_22 - 1.34287977218628) - 0.000578065591995171*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000353256318872198*std::sin(0.359199851751328*x_22 - 4.37824010848999) + 0.00042597965586695*std::sin(0.284639924764633*x_23 + 1.84703981876373) - 0.000705190888005941*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 2.26013060910245e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 0.000263107251096099*std::sin(0.374559849500656*x_24 + 5.01847982406616) - 0.00160967045198865*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 0.000317252977007169*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00128835709121166*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000213068448249925*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 0.000309501366358212*std::sin(0.237519979476929*x_28 - 4.59055995941162) + 0.000710382150994983*std::sin(0.239359974861145*x_28 - 4.58543968200684) + 0.000738375469874411*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 0.000375215710719191*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 2.63165337691878e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) + 0.000729473391950552*std::sin(0.329519838094711*x_3 + 4.96783971786499) + 7.59176076293971e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) + 8.00604979076806e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 3.24227300625524e-5*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 1.56451785707012e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 1.73673907267755e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) - 0.00123307012379856*std::sin(0.253359973430634*x_34 + 8.17903995513916) - 0.00109450912897852*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.000398852902566847*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.0128913327719034*std::sin(0.246479973196983*x_37 + 8.1879997253418) - 0.00141410276530469*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.000367131483872934*std::sin(0.210720002651215*x_38 + 1.80111992359161) + 0.000809856728333303*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 2.78241723657619e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.000157803231321706*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 0.000194489106542095*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.000221781849113855*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.000498523280161256*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 0.000784390271867781*std::sin(0.253119975328445*x_41 + 8.16639995574951) + 0.000877078038162718*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.0169877947719682*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 0.000171554485866147*std::sin(0.266639977693558*x_44 - 4.617919921875) + 0.00192006851853134*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 6.12335903915614e-5*std::sin(0.241359978914261*x_48 - 4.40191984176636) - 0.000461126556507649*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 2.89540729543416e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) - 0.000692368087721601*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.000560303249609958*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 4.39541734419078e-5*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 1.0421705894805e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) - 0.000345226869462699*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.00024531292788397*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.0361633061705185*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 0.000384934707180415*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 0.00060998601539517*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000172674198169134*std::sin(0.408159852027893*x_7 - 7.60512018203735) + 0.000389539594419001*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.000155697360421028*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 0.000261864507313984*std::sin(0.363359838724136*x_8 - 7.57208013534546) - 0.00079273474271499*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 0.000777062332502436*std::sin(0.304719924926758*x_9 + 4.98575973510742) + 0.00131395894057059*std::sin(0.330319851636887*x_9 + 5.06711959838867) - 0.0011402961818769*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 9.43351579232313e-5*std::sin(0.40175986289978*x_9 + 1.58287978172302) - 6.36950317431554e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.0146007925128105*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 4.05583061785329e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) + 0.000734520859151709*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.00531593061039184*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 7.01516892258732e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) - 0.00134434690399691*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000223447241470324*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 0.000148859686090331*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 1.85776995286505e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000340795543615487*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 3.10096921707463e-5*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 2.93545717147619e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.0515356361865997*std::sin(0.00352330931585409*x_1 + 0.0109306229284532*x_100 + 0.0156400478817007*x_101 - 0.000684914901445426*x_102 + 0.000214819068485975*x_103 - 0.0012941732145686*x_104 - 0.00137454293893978*x_105 - 0.000394936864599295*x_106 - 0.0030928752845192*x_107 + 0.00696974567986063*x_108 - 0.00177718464140935*x_109 + 0.000707548381697717*x_11 - 0.0288638915306423*x_110 - 0.000772783747425692*x_111 + 1.17793398694357e-5*x_112 - 0.000235708879373233*x_113 - 0.0239098755222856*x_114 - 0.000383997092584811*x_115 - 0.000101251957579382*x_116 - 0.000933247786306062*x_117 - 0.00123774178435034*x_118 + 0.00174223628619074*x_119 + 0.00117533786569347*x_120 + 0.00225050374600398*x_13 + 0.0439790173723096*x_14 + 0.00124055423012967*x_15 + 0.0058224372273949*x_16 + 0.018208430339846*x_17 + 0.0222037854313203*x_18 + 0.0223169148425209*x_19 + 0.000252830977793197*x_2 + 0.00378794452653641*x_20 + 0.00225086996282011*x_21 + 0.00364596582531321*x_22 + 0.000701124219545127*x_23 + 0.0109034091078709*x_24 - 0.000906474572429098*x_25 + 0.0244466541469939*x_26 + 0.0197217872071611*x_27 + 0.000339367271667519*x_28 + 0.000504391251443673*x_3 + 0.0053902517785724*x_30 - 0.00181946303688608*x_31 + 0.000245238921071488*x_32 - 0.00106095747846447*x_33 + 0.0365363675700914*x_34 - 0.00133672567313732*x_35 - 0.0118929390123496*x_36 - 0.0034487156693774*x_37 - 0.0017303344646013*x_38 - 0.000628680783544722*x_39 - 5.91005959927564e-5*x_4 - 0.0260710328218221*x_40 - 0.00265697379700189*x_41 + 0.0790594404967248*x_43 - 0.000954774654617906*x_44 - 0.0426598931739377*x_45 - 0.00181278302541545*x_46 - 0.00540912678012725*x_47 + 0.00252341826090709*x_48 + 0.0185686422647879*x_49 + 1.55922349355426e-5*x_5 - 0.000342096987296078*x_50 - 0.00489364327690651*x_51 - 0.00779075335096849*x_52 + 0.000670964168309632*x_53 + 0.0523618962734074*x_54 + 0.0252191037211571*x_55 - 0.00846275557371763*x_56 - 0.000309650790440566*x_57 - 0.0177026223293262*x_58 - 0.000127811866956352*x_59 + 0.00441539786748501*x_6 + 0.0313203339550799*x_60 + 0.000454031018575992*x_61 + 4.25041763261411e-6*x_62 + 0.000192120473254786*x_63 - 0.000345517442568905*x_64 - 4.49443665995212e-5*x_65 - 0.0011641115801631*x_66 + 0.000183733005760001*x_67 - 6.11618767134738e-5*x_68 - 0.00115782682991218*x_69 + 0.000413852672210121*x_7 + 0.000475713658192258*x_70 + 0.000623637000357718*x_71 + 0.000391412855126839*x_72 + 0.000390267176947664*x_73 + 0.000365495084707788*x_74 - 1.19111237081552e-5*x_75 - 0.000192736255209981*x_76 + 0.000500309596760423*x_77 + 0.00176645679617819*x_78 - 0.000133772687769832*x_79 - 0.000627865587384528*x_8 - 0.000526212268883796*x_80 - 0.00020516508623983*x_81 - 0.000150244589415882*x_82 - 0.000131483666804918*x_83 + 0.00129173298549434*x_84 - 0.000546185536599553*x_85 + 0.000372104683045799*x_86 + 0.000106159912523029*x_87 + 0.000284174055833435*x_88 + 0.000215644716424795*x_89 + 0.00397537117761718*x_9 + 0.000489903962634689*x_90 + 0.00169673710561297*x_91 - 1.21892745252734e-5*x_92 - 0.000974525762900142*x_93 + 0.00326340601126758*x_94 - 0.0014148665155953*x_95 + 0.00257336272475175*x_96 - 0.0110199381244972*x_97 - 0.00718754394287108*x_98 - 0.197416196539585*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.107011986834468*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 0.324303409766387*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.254673885251613*std::sin(0.247039973735809*x_42 - 7.60703992843628) - 0.139790419044441*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 1.91682237333557) + 0.13658367519192);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000104171423731326*x_1 + 0.000108332103884672*x_10 + 0.000166503462915429*x_100 - 9.74658745122668e-5*x_101 - 0.000858927203526249*x_102 + 0.000650247912727689*x_103 + 0.000334072821770821*x_104 - 0.000396345145492969*x_105 - 0.000916276914215336*x_106 + 5.27131407735903e-5*x_107 + 0.000115800204026508*x_108 + 0.000110736612265013*x_109 - 0.000273720760605297*x_11 - 0.000112955906905365*x_110 - 0.000120004036253037*x_111 + 0.000195789927306545*x_112 - 4.89545466007898e-5*x_113 - 1.89954422125607e-5*x_114 + 4.06748127342143e-5*x_115 - 0.000299091214473143*x_116 + 0.000102319397528864*x_117 + 0.000315708940798327*x_118 + 3.36419079135755e-5*x_119 - 0.000570426326731996*x_12 - 0.000109723735104943*x_120 - 5.04521062020263e-5*x_13 + 0.00029613416920503*x_14 - 4.73508471885192e-5*x_15 + 3.56703088932234e-5*x_16 + 0.000200315796908053*x_17 + 9.19411685835671e-6*x_18 + 1.34247408204475e-5*x_19 - 5.29899914677546e-6*x_2 - 0.000168596162508357*x_20 + 9.87447442242479e-5*x_21 + 0.000101871250827816*x_22 + 0.000108077510056417*x_23 + 0.000130411061125746*x_24 + 0.000155169666495225*x_25 + 0.000384203787449458*x_26 + 0.000226791672527067*x_27 - 0.000655653822701456*x_28 + 3.63497711619712e-5*x_29 + 1.2613161357828e-5*x_3 + 0.000674494140251718*x_30 + 1.52055713145932e-5*x_31 + 3.11551835913223e-5*x_32 - 9.02358241647477e-5*x_33 - 9.13999308392974e-5*x_34 - 0.000242096465271411*x_35 - 0.000130101108298939*x_36 + 1.72917831123145e-5*x_37 - 0.000343171460293243*x_38 + 0.000158575094556156*x_39 + 2.81247011249909e-5*x_4 - 0.000262361604848327*x_40 + 0.000357045154322604*x_41 - 0.000386497174316122*x_42 + 0.00118202217571526*x_43 + 5.3968990594113e-5*x_44 - 4.20310370152742e-5*x_45 - 0.00126119868664933*x_46 - 0.000141226611241759*x_47 - 0.000732765560834787*x_48 - 0.000972935723756555*x_49 + 6.68225128703899e-5*x_5 - 0.00100932643386218*x_50 - 0.000310866328400797*x_51 - 0.00010478204517553*x_52 + 0.000243232324540639*x_53 - 0.000187846330034103*x_54 - 0.000119707329154451*x_55 + 5.51099775170759e-5*x_56 - 0.000670997245555997*x_57 - 0.000583999094240614*x_58 - 0.000147665931200285*x_59 + 8.65462931080775e-6*x_6 - 0.00111053347343043*x_60 + 0.000250963794524251*x_61 - 1.65633551536071e-5*x_62 - 6.56133327062756e-6*x_63 - 3.56178097476392e-6*x_64 - 4.1715789482483e-6*x_65 - 4.29160412925278e-5*x_66 - 9.75142215946291e-6*x_67 + 5.31922236314065e-6*x_68 + 1.55399428658863e-5*x_69 + 0.000446601403191218*x_7 + 2.82191892654036e-5*x_70 - 1.6823181119256e-5*x_71 - 3.7034962697776e-5*x_72 + 4.26569464623036e-5*x_73 - 4.0279251803591e-5*x_74 + 0.000134567768226065*x_75 - 4.20494130003764e-5*x_76 - 1.47361977349476e-5*x_77 + 0.000210044594282576*x_78 - 9.3865770805758e-5*x_79 + 0.000129935013736688*x_8 - 2.6450444200913e-5*x_80 + 0.000237780137812777*x_81 - 3.7965723415166e-5*x_82 + 8.85676198749208e-6*x_83 + 4.09089474291629e-5*x_84 + 1.45560760882425e-5*x_85 - 9.71891689753579e-6*x_86 + 6.78173543616961e-5*x_87 + 0.000267715526259984*x_88 + 5.12490762402446e-6*x_89 + 4.89665023117323e-5*x_9 - 0.000329959714956981*x_90 - 5.68335528816839e-5*x_91 - 3.39077198916364e-5*x_92 - 0.000505875375895616*x_93 - 8.69396880653563e-5*x_94 - 0.000302512317023412*x_95 - 0.000543075855305857*x_96 + 0.000496118608865384*x_97 - 9.24729711794042e-5*x_98 - 0.000799736219066945*x_99 - 3.27597043642376e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 3.40684826873991e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00065070781290228*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.000133592056220523*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.00188193189680899*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.000902679551517826*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 8.00915620314334e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) - 0.000240103437320844*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.0029671474273644*std::sin(0.297439932823181*x_107 + 4.77040004730225) + 2.26469709447685e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 0.000309652269516294*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000327877803958096*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000460023041964345*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 8.90254121414176e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 0.000481096229726141*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 7.98277760640162e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) - 0.000142626498301315*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 7.71746468266448e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) - 0.00156612787003648*std::sin(0.219279989600182*x_115 + 8.16695976257324) - 1.93129859051238e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.00107255179981068*std::sin(0.282799929380417*x_116 + 8.1476001739502) + 0.000505247263413066*std::sin(0.274159938097*x_117 - 1.41383981704712) + 0.000916376210824413*std::sin(0.265279948711395*x_118 + 4.94767951965332) - 0.000695906604623636*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 6.82725215200376e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000837323905671223*std::sin(0.284319937229156*x_119 + 1.74959993362427) + 0.000274502936689559*std::sin(0.326479852199554*x_12 - 1.30671977996826) + 0.000505274264908827*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 0.000377148637733254*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.000352724533893154*std::sin(0.376479834318161*x_12 - 7.77008008956909) + 2.23158756814414e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000438824840175747*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.00226195567544931*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.000666065515115454*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 0.000249788553573941*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.00298794023161117*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.000496711910707989*std::sin(0.269039958715439*x_14 - 7.42424011230469) + 0.000272612818643343*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 0.000206667467655913*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.00239960076292072*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.000700325416226315*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 0.000723851576345759*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.000559592061478557*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 1.51479102037658e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.00058028330643946*std::sin(0.363599836826324*x_17 - 7.59863996505737) + 0.000272562347252994*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 0.000149497438738589*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.000672752482285836*std::sin(0.371279835700989*x_18 + 8.21751976013184) + 0.000204988715054532*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 0.000200684898722877*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.00459138365689719*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.000891927082914363*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000599642708493076*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000361344078218951*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.00083532912941421*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.000497024484715734*std::sin(0.183680012822151*x_21 - 4.60888004302979) + 9.76015873517602e-5*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.000750164281629215*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 1.23832325606176e-5*std::sin(0.402559846639633*x_21 + 7.99271965026855) - 0.000259078952938494*std::sin(0.31143993139267*x_22 - 1.34287977218628) - 0.000111716815834076*std::sin(0.336239844560623*x_22 + 1.80423986911774) - 0.000289976119360029*std::sin(0.359199851751328*x_22 - 4.37824010848999) + 8.23247247761264e-5*std::sin(0.284639924764633*x_23 + 1.84703981876373) - 0.000981234355945014*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 7.68340864295845e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 0.000174609801666404*std::sin(0.374559849500656*x_24 + 5.01847982406616) - 0.000311084520387563*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 0.000210543339883342*std::sin(0.371679842472076*x_26 - 7.57416009902954) + 0.0010575685973637*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000828821919725318*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 0.000205399022528458*std::sin(0.237519979476929*x_28 - 4.59055995941162) + 0.000137288281872318*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.00106894351215769*std::sin(0.132480040192604*x_29 + 1.57615983486176) + 0.00102740887744101*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 0.000249010016097455*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 8.94641584873643e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) + 0.00101502212536188*std::sin(0.329519838094711*x_3 + 4.96783971786499) + 1.46718184018257e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) + 1.54724723702488e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 0.00011022242846835*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 5.31864396538088e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 6.7557980738196e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) - 0.00171574929475028*std::sin(0.253359973430634*x_34 + 8.17903995513916) - 0.0015229492872292*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.0015515109398352*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.00620967153629002*std::sin(0.246479973196983*x_37 + 8.1879997253418) - 0.000273289156783649*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.00142811675663141*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000368040159568648*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 9.45894390250124e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.000341364363426741*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 0.000129071715728532*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.000862716462491721*std::sin(0.364639848470688*x_4 + 8.21175956726074) - 0.000409220836171632*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 0.000520556652199085*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.000839436124189405*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 0.000582068421343562*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.0081829107607663*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 0.000113851270260616*std::sin(0.266639977693558*x_44 - 4.617919921875) + 0.000371071975298201*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 0.000208166154539511*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000209559401682923*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 9.84305833876494e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000314647335226466*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.00121206366008507*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 0.00014942405308681*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 3.542902557225e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.000156888678798684*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.000530667786496352*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.0174196304570341*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 0.00025545997913504*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 0.000404814146032517*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000671691006289676*std::sin(0.408159852027893*x_7 - 7.60512018203735) + 0.000542022932436969*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.00060565225034611*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 0.000173785061016295*std::sin(0.363359838724136*x_8 - 7.57208013534546) - 0.00110304681744076*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 0.000515693502157132*std::sin(0.304719924926758*x_9 + 4.98575973510742) + 0.000253935385551349*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.0005182086831546*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 0.000204068451979763*std::sin(0.40175986289978*x_9 + 1.58287978172302) - 1.23096863562417e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.0070331072262507*std::sin(0.313279926776886*x_92 - 7.58616018295288) - 3.32929366161508e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) + 0.00102204539851036*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.00256064935909409*std::sin(0.333759844303131*x_94 + 8.03415966033936) + 5.75851400852902e-5*std::sin(0.370559841394424*x_94 + 1.59087979793549) - 0.000259808155978581*std::sin(0.28383994102478*x_95 + 8.19295978546143) + 0.000183420254647191*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 9.87899807248649e-5*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 6.31556674423359e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) - 0.000279747491986301*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 0.000105418746987729*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 9.97920956935817e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.000460766236182968*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0580572856745834);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000264224855539797*x_1 - 8.32788535610216e-5*x_10 + 9.84962271041612e-5*x_100 + 0.000494144757727134*x_101 + 0.00331955582209468*x_102 - 0.00169390014974055*x_103 - 0.00144107178108314*x_104 + 0.000759693043700133*x_105 + 0.00315121903487494*x_106 - 0.000184535266528998*x_107 - 0.000580557938889466*x_108 + 0.000139006813649043*x_109 + 0.000961929930461927*x_11 + 0.000116655718559208*x_110 + 6.03248319481427e-5*x_111 - 0.000540548159206847*x_112 - 3.26185665265294e-6*x_113 - 0.000303535379843148*x_114 + 0.000115598255503303*x_115 + 0.000791380075322904*x_116 - 0.000140166644007328*x_117 - 0.00102361386052046*x_118 - 4.17413652764543e-5*x_119 + 0.00184191808947038*x_12 - 4.49754251452541e-5*x_120 + 9.91566081906256e-5*x_13 - 3.98828026651653e-5*x_14 + 8.12039733973856e-5*x_15 + 5.27386228694938e-5*x_16 + 0.000378880607422071*x_17 + 0.000489976760686701*x_18 + 0.000164393951610138*x_19 - 8.52190867652104e-5*x_2 - 0.000211542895201238*x_20 - 0.000315193569751535*x_21 - 8.034885752112e-5*x_22 - 0.0002772971332503*x_23 - 1.35678731635702e-5*x_24 - 0.000548687709267492*x_25 - 0.000867053775891923*x_26 - 8.72484160638802e-6*x_27 + 0.00271622033732983*x_28 - 0.000661547181938045*x_29 - 5.41300683776677e-6*x_3 - 0.00175726452952671*x_30 - 9.4309944640971e-5*x_31 + 2.80916980243419e-5*x_32 + 3.44578337486743e-5*x_33 + 0.00157470697955882*x_34 + 0.000590935731313243*x_35 + 0.000472139242577041*x_36 - 0.000141902228166551*x_37 + 0.00163319668362682*x_38 + 0.000199103427850958*x_39 - 7.11658871076414e-5*x_4 - 0.000201288469577649*x_40 - 5.03123778498559e-5*x_41 + 0.000437068784935389*x_42 - 0.00263600806275917*x_43 - 2.58234461270969e-5*x_44 - 0.00034919317327047*x_45 + 0.00376729741847232*x_46 + 0.000145059480035363*x_47 + 0.00239835914584273*x_48 + 0.00344089799080102*x_49 - 0.000232285941503883*x_5 + 0.00381903286993785*x_50 + 0.000450199707195806*x_51 - 0.00039514382874575*x_52 - 0.000904450166034986*x_53 + 0.00096660141297339*x_54 + 0.000653215463595902*x_55 + 0.000223726956075767*x_56 + 0.00229800973282506*x_57 + 0.000949784978839835*x_58 + 0.000162042165550407*x_59 + 0.000110225471658432*x_6 + 0.00383642525031489*x_60 - 0.000803376137993147*x_61 + 9.88096829103724e-5*x_62 + 4.402658423579e-5*x_63 + 1.83165464306583e-5*x_64 - 3.52909539906059e-6*x_65 + 0.000144564694510184*x_66 + 5.12649917789277e-5*x_67 - 2.84839788487566e-5*x_68 + 1.04080086664245e-5*x_69 - 0.00169046629304504*x_7 - 7.07202938939283e-5*x_70 - 1.31791806939679e-5*x_71 + 0.000136821854029128*x_72 - 0.000147811156331334*x_73 + 0.000159023615896746*x_74 - 0.000544564510516896*x_75 + 0.000138639517141657*x_76 - 2.65029292226203e-6*x_77 - 0.000576775747600863*x_78 + 0.000318717579378394*x_79 - 0.000438385643957552*x_8 + 2.55740253533506e-5*x_80 - 0.000742329339403847*x_81 + 3.06586067713602e-5*x_82 - 2.61303455656991e-5*x_83 - 2.21038726280877e-6*x_84 - 5.63190816559888e-5*x_85 + 2.91943277058184e-5*x_86 - 4.86843481459299e-5*x_87 - 0.000899182361528572*x_88 - 4.28468137902445e-5*x_89 - 6.41409652046167e-5*x_9 + 0.00103393343897775*x_90 + 0.000220467008100197*x_91 - 1.63046154981698e-5*x_92 + 0.001892445272994*x_93 + 0.000132317018382675*x_94 + 0.000780947572175553*x_95 + 0.00161535827941857*x_96 - 0.00144615189154278*x_97 + 8.78598109747699e-5*x_98 + 0.00265856878881308*x_99 + 9.8310930656461e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 2.34234505453262e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00234446090091226*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.000156238969600731*std::sin(0.284959942102432*x_10 + 8.18303966522217) - 0.00623320692373277*std::sin(0.273439943790436*x_100 - 4.60543966293335) - 0.000299940115217769*std::sin(0.279119968414307*x_100 + 1.78559982776642) + 6.40857844689412e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.000727836325641093*std::sin(0.25927996635437*x_107 + 8.18303966522217) + 0.00982758404772435*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 6.79629084980553e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 0.00021289837554009*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000705416368456038*std::sin(0.244239971041679*x_109 - 7.61184024810791) + 0.000368090430131745*std::sin(0.284079939126968*x_109 - 4.62680006027222) + 0.000104117258576328*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 0.000330772985927582*std::sin(0.251519978046417*x_11 + 7.98832035064697) + 6.38747144108095e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.000428018019588155*std::sin(0.317599922418594*x_113 - 4.6147198677063) - 9.02575171055938e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) - 0.000682110542410991*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 5.79577152765926e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) - 0.000858209301092991*std::sin(0.282799929380417*x_116 + 8.1476001739502) + 0.000220055138211881*std::sin(0.274159938097*x_117 - 1.41383981704712) + 0.000399118032554653*std::sin(0.265279948711395*x_118 + 4.94767951965332) - 0.000303094811495924*std::sin(0.274959951639175*x_119 - 4.43680000305176) + 7.98462776613489e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) - 0.000278223903841982*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000823775418539562*std::sin(0.326479852199554*x_12 - 1.30671977996826) + 0.000220066898429722*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 0.000259304840348804*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.00127084516599955*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 6.69693011348225e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) + 0.000351128551046156*std::sin(0.309599906206131*x_120 + 1.76591992378235) + 0.00749189585515502*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.00143301410206649*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 0.000171739665811177*std::sin(0.359359860420227*x_13 - 4.56663990020752) - 0.00989645256077444*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.00106865639573843*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.00081810322864102*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 0.000142092186857402*std::sin(0.342319846153259*x_14 + 1.82951986789703) + 0.00794779455887505*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.000481501859156159*std::sin(0.350399851799011*x_15 - 7.56120014190674) - 0.00239749199483981*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.000384742023819224*std::sin(0.361039847135544*x_16 - 4.37679958343506) + 1.77158279376583e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) + 0.000464317463215523*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.000826230476107844*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 0.000102785495176792*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.000462544359332333*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.000621391492050195*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 0.000137978930366857*std::sin(0.286639958620071*x_19 - 4.57791996002197) + 0.0152072688965056*std::sin(0.324719846248627*x_19 + 1.82007992267609) - 0.000713681258647795*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000412278452672273*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000777417758516169*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.000574322335732936*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.00106932888658335*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.000295864072199505*std::sin(0.322159916162491*x_21 - 4.58671998977661) + 0.000600248830830895*std::sin(0.370239853858948*x_21 - 7.59639978408813) + 1.44824741106118e-5*std::sin(0.402559846639633*x_21 + 7.99271965026855) - 0.000112839116458627*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000338652197803991*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000870209994738361*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.000249554633032604*std::sin(0.284639924764633*x_23 + 1.84703981876373) - 0.000427366316359828*std::sin(0.351999849081039*x_23 - 4.38535976409912) + 8.98592239208876e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 0.000120051253576226*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.000943004468445606*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 0.000144757004726522*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00317373294593505*std::sin(0.14824004471302*x_27 - 7.64807987213135) + 0.000663187251733267*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 0.000141220079872626*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000416168130479538*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.00385133883418408*std::sin(0.132480040192604*x_29 + 1.57615983486176) + 0.00044747714415735*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 0.00017120439001843*std::sin(0.268239974975586*x_3 - 4.35111999511719) - 0.00010463038247715*std::sin(0.316479921340942*x_3 - 7.54071998596191) + 0.000442082224405869*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 4.44753416078276e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 4.69023999164862e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) + 0.000128907654676399*std::sin(0.320959836244583*x_32 + 8.1947193145752) + 6.22027593805832e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) + 5.405695784839e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) - 0.000747276582247482*std::sin(0.253359973430634*x_34 + 8.17903995513916) - 0.000663304564238518*std::sin(0.252959966659546*x_35 - 4.41495990753174) + 0.00124145157329383*std::sin(0.196479991078377*x_36 - 1.38119983673096) - 0.0205672520242308*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.000828433686458083*std::sin(0.251679986715317*x_37 - 4.41239976882935) - 0.0011427169147487*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000791824117627909*std::sin(0.289599925279617*x_38 - 1.41983985900879) + 0.000110624515457595*std::sin(0.333039849996567*x_4 - 4.3776798248291) + 0.000113427701253777*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 8.87419900060855e-5*std::sin(0.358399868011475*x_4 + 8.20823955535889) - 0.000690308190659999*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.0012280599605156*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 0.00035790361169609*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.00302443759388354*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 0.000400195424211828*std::sin(0.278799951076508*x_42 - 1.23991978168488) - 0.0271028808729909*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 7.82773222670838e-5*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.0011248471328152*std::sin(0.23055998980999*x_48 + 4.97743940353394) + 0.000243455085662521*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000450858918555768*std::sin(0.244559973478317*x_48 - 4.62120008468628) + 0.000115116821768948*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000676951528527957*std::sin(0.251279979944229*x_52 + 7.98904037475586) - 0.000402741496964116*std::sin(0.284239947795868*x_52 - 4.43495988845825) + 0.000174754852558828*std::sin(0.291199922561646*x_53 - 4.42575979232788) - 4.14350568886289e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 0.00033753990271381*std::sin(0.30311992764473*x_56 - 4.84959983825684) - 0.000176328971622806*std::sin(0.23479999601841*x_57 + 1.57991981506348) + 0.0576961160803747*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 0.000175638998733363*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 0.000278325988763459*std::sin(0.363519847393036*x_7 - 4.3854398727417) + 0.000537457928987729*std::sin(0.408159852027893*x_7 - 7.60512018203735) + 0.000236072394545386*std::sin(0.350399851799011*x_8 - 1.36039984226227) + 0.00048461658874348*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 0.000119484211245407*std::sin(0.363359838724136*x_8 - 7.57208013534546) - 0.00048042045438583*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 0.000354560000665701*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.000769765731104355*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.0011149058672481*std::sin(0.337999850511551*x_9 + 8.23991966247559) - 6.78073574350964e-5*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 3.73149047231213e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) + 0.0232945797519847*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 9.99111453091566e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) + 0.000445141137249745*std::sin(0.261599957942963*x_93 - 4.42095994949341) - 0.00848120877350599*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 0.000172811349297392*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.000787568123676432*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000550438909189164*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 6.79220806255185e-5*std::sin(0.30311992764473*x_97 - 1.4171998500824) - 7.38619996188151e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000839514178156234*std::sin(0.268079966306686*x_98 - 4.40687990188599) + 0.000123289639159193*std::sin(0.268799960613251*x_98 + 8.18647956848145) + 0.000116709141595408*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.00166011288595623*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.132299683906975);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000101449759047765*x_1 + 2.82502806007391e-5*x_10 + 0.00057566587350929*x_100 + 0.000571766257564826*x_101 - 1.63704516602596e-5*x_102 + 0.000134352712784691*x_103 - 0.000139164036145506*x_104 - 0.000162885862755313*x_105 - 0.000108889175597801*x_106 - 0.000207134440252772*x_107 + 0.000313783419199146*x_108 - 7.83112296699662e-6*x_109 - 7.50812139652621e-6*x_11 - 0.00101399969622288*x_110 - 0.000122120956217521*x_111 + 0.000114997546216538*x_112 - 1.52360412151881e-5*x_113 - 0.000859759350095331*x_114 + 2.66919293894418e-5*x_115 - 2.08161339131817e-5*x_116 - 7.26049015280793e-5*x_117 - 0.000254911851817132*x_118 + 6.25597626212255e-5*x_119 - 0.000112779385712414*x_12 + 2.50910582018198e-5*x_120 + 0.000117201510956506*x_13 + 0.00134252888444515*x_14 + 0.00015784480121769*x_15 + 0.000295845219505416*x_16 + 0.000713020021382593*x_17 + 0.000846385628517061*x_18 + 0.000795336039270584*x_19 + 6.49197611160479e-6*x_2 + 2.84914452497959e-5*x_20 + 7.40044239369799e-5*x_21 + 0.00017038263610442*x_22 + 3.13209746577266e-5*x_23 + 0.000508620935840575*x_24 + 0.000170165068847575*x_25 + 0.000873478185764376*x_26 + 0.000950142794133079*x_27 - 3.42773024293019e-5*x_28 - 0.000407856245324113*x_29 + 4.20430527330273e-5*x_3 + 0.00024930238620427*x_30 - 8.49311023787043e-5*x_31 + 2.55549251521689e-5*x_32 - 0.000107641758433795*x_33 + 0.00142787315248439*x_34 + 0.000124144590180388*x_35 - 0.000499814189551565*x_36 - 7.45942402064815e-5*x_37 + 7.2956908688421e-5*x_38 + 6.90326663861833e-5*x_39 - 1.55007685793566e-5*x_4 - 0.000959205129279283*x_40 - 0.000150011895284352*x_41 - 0.000116030577174942*x_42 + 0.00334033608603163*x_43 - 6.78346290708888e-5*x_44 - 0.00175746979198648*x_45 - 0.000207798299086666*x_46 - 0.000135356261241574*x_47 - 0.000221919195595129*x_48 + 0.000773230953165918*x_49 + 0.000153388521590687*x_5 + 0.000166888310880322*x_50 - 0.000631176786939483*x_51 - 0.000744899116003339*x_52 + 5.58202539721134e-5*x_53 + 0.00170829913836736*x_54 + 0.00111582177243084*x_55 - 5.69646222488116e-5*x_56 - 0.000306052066358285*x_57 - 0.000550196837943916*x_58 + 5.37634077893943e-5*x_59 + 0.000291155115295065*x_6 + 0.000832715193467932*x_60 + 3.05986096190314e-5*x_61 + 2.4015041981273e-5*x_62 + 2.98059121737555e-5*x_63 - 1.48914852421982e-5*x_64 - 4.82474090496123e-6*x_65 - 5.31419899403172e-5*x_66 + 1.12288796928422e-5*x_67 - 2.25634531166458e-5*x_68 - 1.04633369671683e-5*x_69 - 8.66099483903971e-5*x_7 + 2.58006465513657e-5*x_70 - 7.75683575500349e-6*x_71 + 5.90707147155844e-6*x_72 + 1.41305758281339e-5*x_73 + 1.76256099492595e-5*x_74 - 2.07169600798519e-5*x_75 - 4.32311906896003e-7*x_76 - 1.28771955729465e-5*x_77 + 0.000110136016041346*x_78 - 9.77793293130349e-6*x_79 - 0.000154833844541932*x_8 - 3.69520817703864e-5*x_80 + 2.96466479206761e-5*x_81 - 5.09361656015709e-5*x_82 - 5.010045316209e-5*x_83 + 5.74639536492049e-5*x_84 - 2.84023049932907e-5*x_85 + 1.12836193466032e-5*x_86 + 9.81948504929432e-6*x_87 + 4.39549077741671e-5*x_88 + 1.93376352155647e-5*x_89 + 0.000154038681846243*x_9 + 1.44106052206033e-6*x_90 + 5.13131667194076e-5*x_91 - 1.38268183290723e-5*x_92 - 1.96960307320222e-5*x_93 + 3.97665068152941e-5*x_94 - 7.73995883833681e-5*x_95 + 4.95317842660848e-5*x_96 - 0.000327076811215769*x_97 - 0.000265635601350744*x_98 - 3.18730593669231e-5*x_99 + 6.77878357773718e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 5.41935109492463e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 0.00732984475731775*std::sin(0.228879988193512*x_10 + 7.79663991928101) - 0.000337164410165886*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 9.97865694913563e-5*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.000273872347019672*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 6.96895673488188e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.00136628527845509*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.000157328468396669*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 4.68621184791514e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 0.000492570914075287*std::sin(0.272719949483871*x_108 - 1.22631990909576) + 0.000180103414931803*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000400276957420316*std::sin(0.284079939126968*x_109 - 4.62680006027222) - 0.000224685519660597*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 0.000765290724348815*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 6.94600409233662e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.00029512908715091*std::sin(0.317599922418594*x_113 - 4.6147198677063) + 0.000194776134249431*std::sin(0.318399846553802*x_113 - 1.34959983825684) - 0.00022426812519438*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 3.99632885068526e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.000933252754624365*std::sin(0.282799929380417*x_116 + 8.1476001739502) + 7.23509610505815e-5*std::sin(0.274159938097*x_117 - 1.41383981704712) + 0.000131224262530705*std::sin(0.265279948711395*x_118 + 4.94767951965332) - 9.96532100062139e-5*std::sin(0.274959951639175*x_119 - 4.43680000305176) - 0.000172308631965685*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000254043489604104*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000568013672706755*std::sin(0.326479852199554*x_12 - 1.30671977996826) + 7.23548276408821e-5*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 0.000599938923492188*std::sin(0.349599838256836*x_12 + 8.05080032348633) + 0.00397323656527596*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 4.61770014497809e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000381831899367378*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.000119936750940515*std::sin(0.365439832210541*x_120 + 4.6199197769165) - 0.00036587006620288*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 0.000397344338382076*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.000158430975139558*std::sin(0.383359849452972*x_13 + 8.02447986602783) - 0.000272844060426984*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000564102556467971*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 0.000328750645399488*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.000127235171839485*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.00111402358187011*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 3.83811261963987e-5*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.000890155830804472*std::sin(0.361039847135544*x_16 - 4.37679958343506) - 3.82308376230672e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.000504918265292875*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.00155098955128787*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 0.000237808978976355*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.00107016268817792*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.00116646836360855*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 0.0003192340368099*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.000243451118033179*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.000776086905267261*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000953865306727465*std::sin(0.341359823942184*x_2 + 1.9651198387146) - 0.000198486453389004*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.00132877706167634*std::sin(0.303999930620193*x_20 + 8.18367958068848) - 0.000273015757460251*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.00055539234856669*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.000652735730222864*std::sin(0.370239853858948*x_21 - 7.59639978408813) - 3.12532452929354e-5*std::sin(0.402559846639633*x_21 + 7.99271965026855) - 3.70998768136894e-5*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000635713684623396*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000600031469758798*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 0.000468460846581658*std::sin(0.284639924764633*x_23 + 1.84703981876373) - 0.000140511891521972*std::sin(0.351999849081039*x_23 - 4.38535976409912) - 0.000193916615737259*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 0.00027775578634601*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.00177019623418732*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 0.000334916083582408*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00218836792921907*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000721177606352662*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 0.000326732900860231*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000781225627252846*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.0120410264685642*std::sin(0.132480040192604*x_29 + 1.57615983486176) + 0.00014712404214248*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 0.000396105901095522*std::sin(0.268239974975586*x_3 - 4.35111999511719) + 0.000225792843382745*std::sin(0.316479921340942*x_3 - 7.54071998596191) + 0.000145350270205218*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 8.3488556908055e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 8.8044600513259e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) - 0.000278183307697854*std::sin(0.320959836244583*x_32 + 8.1947193145752) - 0.000134233838912534*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 5.87838010545597e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) - 0.000245693780820248*std::sin(0.253359973430634*x_34 + 8.17903995513916) - 0.000218084990343129*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.00135000646000186*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.000329258365472825*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.00155512539029565*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.00124263825512831*std::sin(0.210720002651215*x_38 + 1.80111992359161) - 0.000202164613676718*std::sin(0.289599925279617*x_38 - 1.41983985900879) - 0.000238728209738348*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 0.00010356971002983*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 0.000205317316411024*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.000750670051760951*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.00084677793580348*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 0.000828061316657594*std::sin(0.253119975328445*x_41 + 8.16639995574951) - 0.00945575933159552*std::sin(0.247039973735809*x_42 - 7.60703992843628) + 0.000925909488095874*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.000433886366799622*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 0.000181105807325443*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.0021115490171834*std::sin(0.23055998980999*x_48 + 4.97743940353394) - 0.000525377187068345*std::sin(0.241359978914261*x_48 - 4.40191984176636) + 0.000115111067045525*std::sin(0.244559973478317*x_48 - 4.62120008468628) - 0.000248422627281055*std::sin(0.405439853668213*x_5 - 4.41264009475708) + 0.000172835912920536*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.000367739270006269*std::sin(0.284239947795868*x_52 - 4.43495988845825) - 0.000377121770178057*std::sin(0.291199922561646*x_53 - 4.42575979232788) + 8.94170420590069e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) + 8.61790169223927e-5*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 0.00016100423669852*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.000923649345686715*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 0.000406366004127023*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 0.000643947077324267*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.000584454272499379*std::sin(0.408159852027893*x_7 - 7.60512018203735) + 7.76172043136987e-5*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.000526992384964271*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 0.000276443852619403*std::sin(0.363359838724136*x_8 - 7.57208013534546) - 0.000157955328221894*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 0.000820325393180617*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.00144499463576612*std::sin(0.330319851636887*x_9 + 5.06711959838867) + 0.000284652246528357*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 6.19142261530061e-5*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 7.00470740385873e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.000372919787460118*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 6.88912236444293e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) + 0.000146355996705507*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.000135774528104602*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 0.00011915773036035*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.00147841306520639*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000379541340239957*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 0.000157147471204199*std::sin(0.30311992764473*x_97 - 1.4171998500824) + 0.000159394532611114*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000578865939541281*std::sin(0.268079966306686*x_98 - 4.40687990188599) - 0.000266059604546186*std::sin(0.268799960613251*x_98 + 8.18647956848145) - 0.000251858860740966*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.00519026345414721*std::sin(0.307279914617538*x_99 - 4.6276798248291) + 0.0916983726593465);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.57560631131032e-5*x_1 + 1.2182844593115e-5*x_10 + 0.000120263893490649*x_100 - 1.69925250096321e-6*x_101 - 0.000309321253368962*x_102 + 0.000324483889790281*x_103 - 2.20842604789719e-5*x_104 - 0.0001392277803803*x_105 - 0.000357087442458372*x_106 - 0.000102507014872878*x_107 + 8.1432357770035e-5*x_108 + 2.42450828383691e-6*x_109 - 0.000106201591545092*x_11 + 1.26471389490275e-5*x_110 - 0.000108367846942317*x_111 + 0.000180343409027387*x_112 + 5.09281520312324e-6*x_113 + 3.00882460894437e-5*x_114 - 1.50015929253272e-5*x_115 - 0.000148626150993563*x_116 - 4.24578087593083e-5*x_117 + 0.000103449277560009*x_118 - 3.98477608363277e-6*x_119 - 0.000236359514093425*x_12 + 2.36870035138273e-5*x_120 - 2.88491635534166e-5*x_13 - 1.30007419255229e-5*x_14 + 4.46752169121726e-5*x_15 + 1.66171452349151e-5*x_16 - 3.87989739781759e-5*x_17 - 2.36005708110551e-5*x_18 + 1.72190464283902e-5*x_19 - 8.00970700905514e-6*x_2 + 8.55857669031771e-6*x_20 + 2.19047127091864e-5*x_21 - 5.57003525099893e-6*x_22 + 2.62147712763665e-5*x_23 + 2.59283060059198e-5*x_24 + 0.000205840985135948*x_25 + 0.000107026607711477*x_26 + 0.000236169296943469*x_27 - 0.000309539091399668*x_28 - 1.15767561360839e-5*x_29 + 9.25010154953618e-6*x_3 + 0.000206270690425206*x_30 - 9.95359881083728e-6*x_31 - 4.77644031653787e-6*x_32 + 4.22893028128054e-5*x_33 - 4.80944232088115e-5*x_34 + 5.32217977776216e-5*x_35 - 0.000123842545209211*x_36 + 5.07777591157103e-5*x_37 - 0.000104389516745251*x_38 - 5.77683642249828e-5*x_39 - 3.99211677274297e-6*x_4 - 3.76361659376587e-6*x_40 - 3.50185636955631e-5*x_41 - 7.535761078144e-5*x_42 + 0.000292365149818342*x_43 - 9.83324309106029e-6*x_44 - 0.000161396413213775*x_45 - 0.000317739985552615*x_46 + 2.78496395196696e-5*x_47 - 0.000484027367578174*x_48 - 0.000153191725272248*x_49 + 5.82407724422219e-5*x_5 - 0.000296748397939347*x_50 - 0.000314699235816274*x_51 - 0.00025008877161293*x_52 + 0.000178885918430705*x_53 - 0.000101838502359112*x_54 + 0.000156616386925857*x_55 + 0.000290364195735361*x_56 - 0.000530629234556365*x_57 - 1.45621708508713e-5*x_58 + 6.68527170468389e-5*x_59 + 1.97150538541702e-5*x_6 - 0.000314917023902463*x_60 + 8.34432217377328e-5*x_61 + 7.91197609310814e-6*x_62 + 7.60027374312682e-6*x_63 - 7.68794893720029e-6*x_64 - 3.33698833921808e-6*x_65 - 1.95150930972594e-5*x_66 - 6.21572574786323e-6*x_67 - 1.18460219336641e-5*x_68 + 2.63875487126836e-5*x_69 + 0.000148261270729752*x_7 + 1.76630789915442e-5*x_70 - 2.91264160330981e-5*x_71 - 1.64739373731885e-5*x_72 + 1.0614967176407e-5*x_73 - 1.65843902770731e-5*x_74 + 2.70658059783829e-5*x_75 - 1.45998798554155e-5*x_76 - 2.90622134811221e-5*x_77 + 8.98242324429041e-5*x_78 - 3.73858619424465e-5*x_79 - 0.000101624398832912*x_8 - 7.81725792139028e-6*x_80 + 9.84475398202419e-5*x_81 - 5.53683175455863e-5*x_82 - 1.16224157574839e-5*x_83 + 2.0975751800832e-5*x_84 - 4.24376152878919e-6*x_85 - 7.96117820076444e-6*x_86 - 4.30370671159686e-6*x_87 + 9.97942958821446e-5*x_88 + 3.90983245804031e-6*x_89 + 4.29865833514395e-6*x_9 - 0.00011126042520869*x_90 - 2.92564437167945e-5*x_91 - 6.5851461016656e-6*x_92 - 0.000186617671625429*x_93 - 3.40853526450056e-5*x_94 - 8.26652815602799e-5*x_95 - 0.000162149212203317*x_96 + 0.00018725011982345*x_97 - 9.60558126170383e-6*x_98 - 0.000187028236684865*x_99 + 7.41064168503806e-8*std::pow(-9.60000038146973*x_5 - 1.22399985790253, 2) - 5.08475774764125e-8*std::pow(-8.62271976470947*x_5 - 3.82071995735168, 2) - 9.2165215499135e-5*std::sin(0.284959942102432*x_10 + 8.18303966522217) + 0.000666718252485669*std::sin(0.273439943790436*x_100 - 4.60543966293335) + 0.00011093459044942*std::sin(0.279119968414307*x_100 + 1.78559982776642) - 2.29677284654686e-5*std::sin(0.257519960403442*x_104 + 4.78615999221802) + 0.000255794885887228*std::sin(0.25927996635437*x_107 + 8.18303966522217) - 0.00105118115644571*std::sin(0.297439932823181*x_107 + 4.77040004730225) - 5.12301897041411e-5*std::sin(0.25927996635437*x_108 - 7.43847990036011) + 0.000462159348552389*std::sin(0.272719949483871*x_108 - 1.22631990909576) - 0.000176930493934404*std::sin(0.244239971041679*x_109 - 7.61184024810791) - 0.000131920068078448*std::sin(0.284079939126968*x_109 - 4.62680006027222) - 6.14186690963781e-5*std::sin(0.285999923944473*x_109 + 1.73759996891022) - 0.000718041306361373*std::sin(0.251519978046417*x_11 + 7.98832035064697) - 2.28920829877307e-5*std::sin(0.21399998664856*x_111 + 4.97735977172852) + 0.000322638404165993*std::sin(0.317599922418594*x_113 - 4.6147198677063) + 5.32428211457878e-5*std::sin(0.318399846553802*x_113 - 1.34959983825684) + 0.000168261131887069*std::sin(0.219279989600182*x_115 + 8.16695976257324) + 4.36883119639207e-5*std::sin(0.243999972939491*x_116 + 1.98391973972321) + 0.000307573955088219*std::sin(0.282799929380417*x_116 + 8.1476001739502) - 5.42825895964334e-5*std::sin(0.274159938097*x_117 - 1.41383981704712) - 9.84533264605702e-5*std::sin(0.265279948711395*x_118 + 4.94767951965332) + 7.4766585297363e-5*std::sin(0.274959951639175*x_119 - 4.43680000305176) - 4.71012411709322e-5*std::sin(0.278959959745407*x_119 + 4.94783973693848) + 0.000102902723777178*std::sin(0.284319937229156*x_119 + 1.74959993362427) - 0.000620958871508532*std::sin(0.326479852199554*x_12 - 1.30671977996826) - 5.42854905742694e-5*std::sin(0.332799851894379*x_12 + 1.83999991416931) - 0.000562898405345128*std::sin(0.349599838256836*x_12 + 8.05080032348633) - 5.04812121392492e-5*std::sin(0.252879977226257*x_120 - 1.22575986385345) - 0.000125841093835873*std::sin(0.309599906206131*x_120 + 1.76591992378235) - 0.000801350536484729*std::sin(0.365439832210541*x_120 + 4.6199197769165) + 0.00035942445374287*std::sin(0.30583992600441*x_13 - 1.21431982517242) - 0.000372812107516305*std::sin(0.359359860420227*x_13 - 4.56663990020752) + 0.00105854749214319*std::sin(0.383359849452972*x_13 + 8.02447986602783) + 0.000268037307325316*std::sin(0.269039958715439*x_14 - 7.42424011230469) - 0.000616683195688264*std::sin(0.290399938821793*x_14 + 4.97815942764282) - 0.000308453422182339*std::sin(0.342319846153259*x_14 + 1.82951986789703) - 0.000850114517975123*std::sin(0.297839939594269*x_15 + 1.80775988101959) + 0.00104524322926302*std::sin(0.350399851799011*x_15 - 7.56120014190674) + 0.000256441297827274*std::sin(0.274879962205887*x_16 - 1.19007980823517) - 0.000835197180992758*std::sin(0.361039847135544*x_16 - 4.37679958343506) - 1.04505495894683e-5*std::sin(0.39743983745575*x_16 - 4.60031986236572) - 0.000166406910756905*std::sin(0.363599836826324*x_17 - 7.59863996505737) - 0.000290375078718967*std::sin(0.368079841136932*x_17 - 1.18871986865997) - 0.000223126538053813*std::sin(0.39055985212326*x_17 - 4.4017596244812) - 0.00100409032827665*std::sin(0.371279835700989*x_18 + 8.21751976013184) - 0.000218385315764872*std::sin(0.196479991078377*x_19 - 1.39183986186981) - 0.000299524373591541*std::sin(0.286639958620071*x_19 - 4.57791996002197) - 0.00162660471051491*std::sin(0.324719846248627*x_19 + 1.82007992267609) + 0.000255776495448231*std::sin(0.368159830570221*x_19 + 8.2324800491333) - 0.000894973203181279*std::sin(0.341359823942184*x_2 + 1.9651198387146) + 0.000194989674408463*std::sin(0.262639969587326*x_20 - 1.36751985549927) - 0.00124673772577207*std::sin(0.303999930620193*x_20 + 8.18367958068848) + 0.000268205979534639*std::sin(0.183680012822151*x_21 - 4.60888004302979) - 0.000103980131136959*std::sin(0.322159916162491*x_21 - 4.58671998977661) - 0.000215123404862438*std::sin(0.370239853858948*x_21 - 7.59639978408813) - 8.54319732635341e-6*std::sin(0.402559846639633*x_21 + 7.99271965026855) + 2.78348394812311e-5*std::sin(0.31143993139267*x_22 - 1.34287977218628) + 0.000119017830301929*std::sin(0.336239844560623*x_22 + 1.80423986911774) + 0.000655961083745578*std::sin(0.359199851751328*x_22 - 4.37824010848999) - 8.77048817575533e-5*std::sin(0.284639924764633*x_23 + 1.84703981876373) + 0.000105421534560867*std::sin(0.351999849081039*x_23 - 4.38535976409912) - 5.30078683853203e-5*std::sin(0.364799857139587*x_23 + 1.79015982151031) + 0.000260607010292752*std::sin(0.374559849500656*x_24 + 5.01847982406616) + 0.000331414786400943*std::sin(0.297839939594269*x_26 - 4.39423990249634) + 0.000314238203241747*std::sin(0.371679842472076*x_26 - 7.57416009902954) - 0.00239234818644037*std::sin(0.14824004471302*x_27 - 7.64807987213135) - 0.000237679929266562*std::sin(0.24975997209549*x_27 - 1.37239980697632) - 0.000306560254162951*std::sin(0.237519979476929*x_28 - 4.59055995941162) - 0.000146260465018901*std::sin(0.239359974861145*x_28 - 4.58543968200684) - 0.000110382417640662*std::sin(0.246799975633621*x_29 + 1.81951987743378) - 0.000371650131944419*std::sin(0.268239974975586*x_3 - 4.35111999511719) + 6.17213603840762e-5*std::sin(0.316479921340942*x_3 - 7.54071998596191) - 0.000109051613837784*std::sin(0.329519838094711*x_3 + 4.96783971786499) - 1.56306638327636e-5*std::sin(0.420159846544266*x_3 - 7.4061598777771) - 1.64836428353685e-5*std::sin(0.217999994754791*x_32 + 5.02079963684082) - 7.60424995319657e-5*std::sin(0.320959836244583*x_32 + 8.1947193145752) - 3.66933469774077e-5*std::sin(0.318879842758179*x_33 - 4.5557599067688) - 1.93734935106056e-5*std::sin(0.345999836921692*x_33 + 4.83023977279663) + 0.000184336109389585*std::sin(0.253359973430634*x_34 + 8.17903995513916) + 0.000163622125484442*std::sin(0.252959966659546*x_35 - 4.41495990753174) - 0.000444924297560252*std::sin(0.196479991078377*x_36 - 1.38119983673096) + 0.00219992092285871*std::sin(0.246479973196983*x_37 + 8.1879997253418) + 0.000291149387337912*std::sin(0.251679986715317*x_37 - 4.41239976882935) + 0.000409538746046964*std::sin(0.210720002651215*x_38 + 1.80111992359161) + 0.000198603035747122*std::sin(0.289599925279617*x_38 - 1.41983985900879) - 6.52572935720953e-5*std::sin(0.333039849996567*x_4 - 4.3776798248291) - 4.19518928805872e-5*std::sin(0.334319829940796*x_4 - 1.40255987644196) - 0.000192640926387586*std::sin(0.358399868011475*x_4 + 8.20823955535889) + 0.000247399812797044*std::sin(0.364639848470688*x_4 + 8.21175956726074) + 0.000925707067805587*std::sin(0.230719983577728*x_41 + 8.20055961608887) - 0.000776936412062313*std::sin(0.253119975328445*x_41 + 8.16639995574951) + 0.000868743390259255*std::sin(0.278799951076508*x_42 - 1.23991978168488) + 0.00289898692503962*std::sin(0.175760015845299*x_44 + 8.01152038574219) - 0.000169924247536443*std::sin(0.266639977693558*x_44 - 4.617919921875) - 0.000395322593614164*std::sin(0.23055998980999*x_48 + 4.97743940353394) - 0.000143613917141076*std::sin(0.241359978914261*x_48 - 4.40191984176636) - 0.000113083130363702*std::sin(0.244559973478317*x_48 - 4.62120008468628) - 6.79073006755217e-5*std::sin(0.405439853668213*x_5 - 4.41264009475708) - 0.000169791025085301*std::sin(0.251279979944229*x_52 + 7.98904037475586) + 0.000148956277456459*std::sin(0.284239947795868*x_52 - 4.43495988845825) - 0.000103087716763389*std::sin(0.291199922561646*x_53 - 4.42575979232788) + 2.44424995704882e-5*std::sin(0.229599997401237*x_56 - 7.59856033325195) - 8.46607824545354e-5*std::sin(0.30311992764473*x_56 - 4.84959983825684) + 6.5216292382702e-5*std::sin(0.23479999601841*x_57 + 1.57991981506348) - 0.00617131023548336*std::sin(0.124480053782463*x_6 + 1.72319996356964) - 0.000381276771272121*std::sin(0.282399952411652*x_6 + 1.81655991077423) - 0.000604189474559414*std::sin(0.363519847393036*x_7 - 4.3854398727417) - 0.00019261974986958*std::sin(0.408159852027893*x_7 - 7.60512018203735) - 5.82336818503002e-5*std::sin(0.350399851799011*x_8 - 1.36039984226227) - 0.000173681922010587*std::sin(0.358639866113663*x_8 - 1.3698399066925) + 0.000259376075986428*std::sin(0.363359838724136*x_8 - 7.57208013534546) + 0.000118508781803806*std::sin(0.303199917078018*x_9 + 8.1802396774292) + 0.000769678108227458*std::sin(0.304719924926758*x_9 + 4.98575973510742) - 0.000270530791623106*std::sin(0.330319851636887*x_9 + 5.06711959838867) - 0.000279637466046217*std::sin(0.337999850511551*x_9 + 8.23991966247559) + 2.50789442454485e-5*std::sin(0.40175986289978*x_9 + 1.58287978172302) + 1.31141596802498e-5*std::sin(0.254799962043762*x_92 - 4.38168001174927) - 0.00249164221477996*std::sin(0.313279926776886*x_92 - 7.58616018295288) + 7.53126527522371e-5*std::sin(0.238639980554581*x_93 + 1.95847976207733) - 0.000109806177952326*std::sin(0.261599957942963*x_93 - 4.42095994949341) + 0.000907169738085926*std::sin(0.333759844303131*x_94 + 8.03415966033936) - 0.000130264557582719*std::sin(0.370559841394424*x_94 + 1.59087979793549) + 0.00027678736444871*std::sin(0.28383994102478*x_95 + 8.19295978546143) - 0.000414918819124821*std::sin(0.320959836244583*x_95 - 4.5601601600647) + 0.000147445110628857*std::sin(0.30311992764473*x_97 - 1.4171998500824) + 4.35711214011568e-5*std::sin(0.310159921646118*x_97 - 7.62712001800537) + 0.000632822690445784*std::sin(0.268079966306686*x_98 - 4.40687990188599) - 7.2728437667989e-5*std::sin(0.268799960613251*x_98 + 8.18647956848145) - 6.88466085852213e-5*std::sin(0.279519945383072*x_99 + 4.96663951873779) - 0.083677738904953*std::sin(0.00365202904922216*x_1 + 0.0113299596720557*x_100 + 0.0162114376214938*x_101 - 0.000709937417378718*x_102 + 0.000222667216559*x_103 - 0.00134145422687194*x_104 - 0.00142476015938283*x_105 - 0.000409365392824079*x_106 - 0.00320586964472839*x_107 + 0.00722437668870166*x_108 - 0.00184211187676694*x_109 + 0.000733397783743494*x_11 - 0.0299183979871351*x_110 - 0.000801016442600143*x_111 + 1.22096834332049e-5*x_112 - 0.000244320210762414*x_113 - 0.024783393151931*x_114 - 0.000398025949815488*x_115 - 0.000104951072194147*x_116 - 0.000967342836002413*x_117 - 0.00128296114438301*x_118 + 0.00180588672676192*x_119 + 0.00121827737600234*x_120 + 0.00233272310745089*x_13 + 0.0455857361933*x_14 + 0.00128587633937861*x_15 + 0.00603515274575435*x_16 + 0.0188736527453412*x_17 + 0.023014973176779*x_18 + 0.0231322356306223*x_19 + 0.000262067843799337*x_2 + 0.00392633237890997*x_20 + 0.00233310270354392*x_21 + 0.00377916666203556*x_22 + 0.000726738922799153*x_23 + 0.0113017516283112*x_24 - 0.000939591495982467*x_25 + 0.0253397823175417*x_26 + 0.0204422982277021*x_27 + 0.000351765633777349*x_28 + 0.000522818559857064*x_3 + 0.00558717793790861*x_30 - 0.0018859348609542*x_31 + 0.000254198420707171*x_32 - 0.00109971824327393*x_33 + 0.0378711784170124*x_34 - 0.00138556128670615*x_35 - 0.0123274327798266*x_36 - 0.00357471021644343*x_37 - 0.00179355008689107*x_38 - 0.000651648855768006*x_39 - 6.12597629225091e-5*x_4 - 0.0270235056513732*x_40 - 0.00275404303732577*x_41 + 0.0819477790411652*x_43 - 0.000989656161732821*x_44 - 0.0442184194293961*x_45 - 0.0018790108035545*x_46 - 0.00560674251422106*x_47 + 0.00261560821546444*x_48 + 0.0192470245659317*x_49 + 1.61618778886844e-5*x_5 - 0.000354595076178773*x_50 - 0.00507242646093393*x_51 - 0.00807537885618899*x_52 + 0.000695477011520904*x_53 + 0.0542748731717544*x_54 + 0.0261404523782738*x_55 - 0.00877193184618012*x_56 - 0.000320963497787426*x_57 - 0.0183493656668734*x_58 - 0.000132481314898906*x_59 + 0.00457670894898989*x_6 + 0.0324645834870627*x_60 + 0.000470618478379467*x_61 + 4.40570136598125e-6*x_62 + 0.000199139356320382*x_63 - 0.00035814049354015*x_64 - 4.65863532565129e-5*x_65 - 0.00120664095206213*x_66 + 0.000190445463109664*x_67 - 6.33963499762736e-5*x_68 - 0.00120012659626027*x_69 + 0.000428972265991128*x_7 + 0.000493093266325589*x_70 + 0.000646420804221686*x_71 + 0.000405712638038902*x_72 + 0.000404525103929257*x_73 + 0.000378847994041984*x_74 - 1.2346281830926e-5*x_75 - 0.000199777635105113*x_76 + 0.000518587786985364*x_77 + 0.0018309921030237*x_78 - 0.000138659906903327*x_79 - 0.000650803877427772*x_8 - 0.000545436781089109*x_80 - 0.000212660538052248*x_81 - 0.000155733589034106*x_82 - 0.000136287259398173*x_83 + 0.00133892484705682*x_84 - 0.000566139747353697*x_85 + 0.000385699065852651*x_86 + 0.000110038333180805*x_87 + 0.000294556002298484*x_88 + 0.000223523028520622*x_89 + 0.00412060643008832*x_9 + 0.000507801995930415*x_90 + 0.001758725290087*x_91 - 1.26345945429577e-5*x_92 - 0.00101012885224469*x_93 + 0.003382630499947*x_94 - 0.00146655690786921*x_95 + 0.00266737733831374*x_96 - 0.0114225378879455*x_97 - 0.00745013194095986*x_98 - 0.204628552283308*std::sin(0.228879988193512*x_10 + 7.79663991928101) + 0.110921536969774*std::sin(0.376479834318161*x_12 - 7.77008008956909) - 0.336151432376166*std::sin(0.132480040192604*x_29 + 1.57615983486176) - 0.263978079594667*std::sin(0.247039973735809*x_42 - 7.60703992843628) - 0.144897488521948*std::sin(0.307279914617538*x_99 - 4.6276798248291) - 7.31427917117585) - 0.0130049917496416);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
