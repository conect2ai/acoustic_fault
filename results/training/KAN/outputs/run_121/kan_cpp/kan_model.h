
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00481479973458672*x_1 + 0.0484918831571297*x_10 + 0.0334488954936557*x_100 - 0.0183644139583584*x_101 - 0.00490677400400801*x_102 - 0.0246457552702954*x_103 - 0.0328564477732145*x_104 + 0.0847732826179381*x_105 + 0.0890594259117171*x_106 - 0.0820083348999589*x_107 + 0.0037877004492257*x_108 - 0.00614541830040859*x_109 + 0.000479079092456006*x_11 - 0.110370793375071*x_110 - 0.115392410721088*x_111 + 0.107010019155506*x_112 - 0.0344312172051922*x_113 + 0.00670234176227538*x_114 - 0.108069670898696*x_115 + 0.014399159584502*x_116 + 0.0221247797902204*x_117 - 0.0211039261145983*x_118 + 0.0113811240190386*x_119 - 0.0491307398543557*x_12 + 0.0841372238882424*x_120 + 0.000129959178440324*x_13 - 0.0766429686771071*x_14 + 0.000171760145645621*x_15 - 3.29436211861647e-7*x_16 + 8.38943224684458e-5*x_17 - 0.000160860351385806*x_18 - 0.00481989090125399*x_19 + 0.00384769929132803*x_2 + 0.0131582661588362*x_20 - 0.00119004542095495*x_21 - 0.00343832800861981*x_22 + 0.0213932815481804*x_23 + 0.0275489307465762*x_24 - 0.0399507867196302*x_25 + 0.00114862645868037*x_26 - 0.00330116753423264*x_27 + 0.000279272048049026*x_28 - 0.0106164923789703*x_29 - 0.00264472360453052*x_3 + 0.0100097315668737*x_30 + 2.13873843405698e-5*x_31 - 0.0249827726837647*x_33 + 0.0641226101500053*x_34 + 0.141689972836604*x_35 + 0.0194341243060543*x_36 + 0.154444819074036*x_37 + 0.0873278114811602*x_38 - 0.0089031159211099*x_39 + 0.00397204235841797*x_4 + 0.0199396245306727*x_40 - 0.0712623551277924*x_41 + 0.0102707531808357*x_42 + 0.164981806097659*x_43 + 0.0123908967211267*x_44 - 0.0023026471871396*x_45 + 0.0245042454245068*x_46 + 0.165834502934179*x_47 + 0.0770716238661333*x_48 - 0.0304342553004837*x_49 + 0.0369354681667844*x_5 + 0.0591932978727728*x_50 + 0.0115912347629032*x_51 + 0.0272163207084682*x_52 + 0.00418001572249045*x_53 + 0.0252637907409908*x_54 + 0.00976779718537681*x_55 + 0.0282289269107582*x_56 + 0.0174359752908893*x_57 + 0.116477645246176*x_58 + 0.0557605702384861*x_59 - 0.00237804200269189*x_6 + 0.037909895619339*x_60 - 0.00510434876703084*x_61 + 0.00637526412991792*x_62 - 0.0114444856341783*x_63 + 0.0144593727466809*x_64 - 0.042887910316867*x_65 - 0.0138365244118575*x_66 - 0.0499664122085064*x_67 - 0.0783271628791638*x_68 + 0.0420095928551805*x_69 - 0.154594952304682*x_7 - 0.000847855822101925*x_70 + 0.00769657542405258*x_71 + 0.00796181263953571*x_72 - 0.0362907626455276*x_73 + 0.0401981964242747*x_74 - 0.017333553280328*x_75 + 0.0806068062844464*x_76 + 0.00711146352298322*x_77 - 0.0290011057491536*x_78 + 0.0557866142494135*x_79 + 4.55354402429261e-5*x_8 - 0.0518229153011236*x_80 - 0.00919569818554421*x_81 + 0.0217084870526362*x_82 - 0.00865277429357217*x_83 + 0.0457174878067678*x_84 + 0.0553074425762695*x_85 + 0.00630371834334738*x_86 + 0.0462511802237113*x_87 + 0.01314655272722*x_88 + 0.0709733645315962*x_89 - 0.0158298941560375*x_9 - 0.0187242490978647*x_90 - 0.00282269902197368*x_91 - 0.000503298901025912*x_92 + 0.151536296432056*x_93 + 0.00161257229592216*x_94 - 0.00120834636506265*x_95 - 0.0372027284173725*x_96 - 0.000975486608344376*x_97 - 0.0622576946240272*x_98 + 0.106335251532872*x_99 + 0.00043186330781064*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 0.00101513658448182*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) - 0.00012995078213226*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) + 0.0186342815360675*std::exp(0.0169760637246818*x_10 + 0.0101502444051446*x_100 - 0.0178535346774105*x_101 + 0.0211745335545048*x_102 + 0.00712564878833091*x_103 - 0.0516703125050543*x_104 + 0.0429556611012071*x_105 + 0.0341438861578815*x_106 - 0.00313415224383909*x_107 - 0.0160792475593343*x_11 + 0.0366016934182379*x_110 - 0.00852811299567698*x_111 - 0.0214882423864741*x_113 + 0.0427887184981328*x_114 + 0.055799483413556*x_115 - 0.090718130458987*x_116 + 0.0446063502632528*x_117 - 0.00814289698635973*x_118 + 0.038356009482507*x_119 - 0.0244220620551702*x_120 + 0.00581508764547638*x_14 - 0.0462154208843942*x_18 - 0.0200522400496644*x_19 + 0.00994652452547065*x_2 - 0.0063594194229763*x_22 + 0.0166479942330318*x_23 - 0.0138014857291669*x_25 - 0.0181480289451114*x_26 + 0.00218821208549969*x_27 - 0.0393581577540034*x_28 + 0.00583356831912286*x_31 + 0.0128592843743654*x_32 + 0.00467575843589096*x_33 - 0.0522482970789038*x_34 - 0.0664605410220206*x_35 - 0.0608664729067357*x_37 + 0.0664651448327488*x_38 - 0.0829758579204834*x_39 - 0.000186918231564023*x_4 + 0.0677262797912472*x_40 + 0.0462191277924544*x_41 - 0.0120675835145839*x_42 + 0.0801538670333558*x_43 + 0.0547097128959563*x_44 + 0.0609281633701482*x_46 + 0.0541718834569567*x_48 - 0.0440277501669282*x_49 - 0.0371253908035061*x_51 - 0.0770898312717765*x_52 + 0.0102247116336809*x_54 + 0.00161341030361257*x_55 - 0.0201182607406159*x_56 + 8.85017126467398e-5*x_57 - 0.0691993717413958*x_58 + 0.0496414252393215*x_59 - 0.00615824585624837*x_6 + 0.0718223594577359*x_60 - 0.0161925366650467*x_61 + 0.00697994412322583*x_62 - 0.00652550373832763*x_63 - 0.00278107320079975*x_64 - 0.018264993314622*x_65 - 0.0265156600770352*x_66 + 0.000113722580979379*x_67 + 0.0113235785182563*x_68 + 0.00897730947621871*x_69 - 0.0202495191027227*x_70 + 0.0304816487701986*x_71 + 0.0238351380009096*x_72 - 0.0125509783852344*x_73 + 0.0227169851419805*x_74 + 0.0222223868853724*x_75 + 0.00297319530631892*x_76 - 0.00310537524574062*x_77 - 0.0304469026424518*x_78 - 0.00693482055121851*x_79 - 0.00953674288083351*x_8 + 0.000831011020589404*x_80 - 0.0302593751349853*x_81 - 0.0471294772769684*x_82 + 0.0154406401701289*x_83 + 0.0232148530262912*x_84 + 0.0253025393257779*x_85 + 0.0142309214267315*x_86 - 0.0403599866935359*x_87 - 5.9763392163418e-5*x_88 + 0.0285829803707784*x_89 - 0.0367851136387016*x_90 + 0.00927754546367832*x_91 + 0.0557022389600709*x_93 - 5.35143900116648e-5*x_94 - 0.000532773450680499*x_95 - 0.0279507126878246*x_98 - 0.0532590317505854*x_99 - 0.456110267411361*std::sin(0.217919990420341*x_1 + 5.01607990264893) - 0.404442771949572*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.54801413671397*std::sin(0.240719974040985*x_109 + 1.97031986713409) + 0.116304355353615*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.338452330299646*std::sin(0.307599931955338*x_12 + 1.92247986793518) - 0.148491505527298*std::sin(0.307839930057526*x_13 - 7.44687986373901) - 0.127403515610755*std::sin(0.345919847488403*x_15 - 4.35887956619263) - 0.39012005562315*std::sin(0.323279827833176*x_16 - 1.13703989982605) + 0.140654091221592*std::sin(0.376959830522537*x_17 - 1.17751979827881) - 0.147517926231554*std::sin(0.285919934511185*x_20 + 5.19008016586304) - 0.314552589786377*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.340570867218688*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.358937278005733*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.319690294662941*std::sin(0.31263992190361*x_3 + 2.06999969482422) + 0.115429903922655*std::sin(0.304399937391281*x_30 + 1.99511981010437) - 0.440382636280173*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.461275588531166*std::sin(0.23735998570919*x_45 + 8.19351959228516) - 0.512786285465637*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.221644585998565*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.610632309974072*std::sin(0.171040013432503*x_50 - 1.1548798084259) - 0.372376077524127*std::sin(0.195439994335175*x_53 + 5.20183992385864) + 0.196341457619068*std::sin(0.312079936265945*x_7 - 1.16279983520508) + 0.33845794549298*std::sin(0.310399949550629*x_9 - 7.43655967712402) - 0.214998101659244*std::sin(0.291199922561646*x_92 + 1.9851998090744) + 0.34098474965603*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.241913906996876*std::sin(0.262799948453903*x_97 + 1.9579998254776)) + 0.00934289228775646*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.642593152650806*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.0745214330127445*std::sin(0.251999974250793*x_10 + 1.99783980846405) - 0.00586946039506685*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.00861652760386816*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.00357781793161405*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.0052047990070469*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.0119413846874393*std::sin(0.264959961175919*x_107 - 1.22583997249603) - 0.0650254727961678*std::sin(0.246479973196983*x_108 + 5.1735200881958) + 0.00490310052869313*std::sin(0.263439953327179*x_108 + 1.9554398059845) - 0.0136984123598424*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.105498937503596*std::sin(0.22919999063015*x_11 + 5.00559949874878) - 0.339592119777026*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.00263396415360331*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.0159493102484304*std::sin(0.20728000998497*x_111 - 7.41167974472046) - 0.00787019414404316*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.00376854585136802*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.00353320376094236*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.00390863969600231*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.453035360234681*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.00213947251344416*std::sin(0.3018399477005*x_12 + 1.93759989738464) + 0.00354401711032864*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.627028260569933*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0333425827264258*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.00934593187016495*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.00239171951740462*std::sin(0.302559942007065*x_14 - 1.21279990673065) - 0.0203149658166221*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0030158337065289*std::sin(0.326959848403931*x_15 + 5.06239986419678) + 0.469483195960276*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.00602518966326244*std::sin(0.354799836874008*x_16 - 4.36759996414185) - 0.0179883042497143*std::sin(0.357919842004776*x_16 - 1.1639997959137) + 0.140263262499436*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.00305723664841656*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.0386511684863889*std::sin(0.382559835910797*x_17 - 1.17599976062775) + 0.512836493340223*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.376834523061775*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.0547885105831836*std::sin(0.34215983748436*x_18 + 1.9981597661972) + 0.742516775173661*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.537495968789516*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.0050760968494854*std::sin(0.406159847974777*x_2 - 7.39583969116211) + 0.00686026035185702*std::sin(0.32399994134903*x_20 - 1.21511995792389) + 0.0384753119427627*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.00153985527541605*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.509187822759336*std::sin(0.264239966869354*x_21 - 4.20663976669312) + 0.0340149322845203*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.003246868509085*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.00834619736736226*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.244156174006807*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.00285479354929946*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.00426701368979661*std::sin(0.294239938259125*x_24 + 8.23031997680664) + 0.0133565999825488*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.00696635972572371*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0823558645952995*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.00441483359346063*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.00159475689092467*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.0735230239078897*std::sin(0.345359832048416*x_26 - 1.14991986751556) - 0.506566524621936*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.0724425898154983*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.491708521877221*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.451282495213978*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.0105139932198434*std::sin(0.267519950866699*x_28 + 5.01783990859985) + 0.0821749976849466*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.739559806919412*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.00245667421150089*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.0076306690676509*std::sin(0.280479967594147*x_3 + 2.05519986152649) - 0.00271299178715941*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.419029345884883*std::sin(0.379759848117828*x_3 - 7.40215969085693) - 0.0352945892035482*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.000988602753329582*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.334982541059343*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.0045231132628486*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.0039607481043996*std::sin(0.31127992272377*x_32 - 1.16535985469818) + 0.0481401357892816*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.208194722253212*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.00492431370907097*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.00474885840918526*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.0892301417436659*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.00528867001396016*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.436489265572222*std::sin(0.235199987888336*x_36 - 1.18823993206024) - 0.126297660206178*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.0170477235976039*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.00891413903711183*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.00303068571307804*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.707236032922443*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.00318740808019362*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 1.08842408645678*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.00366752166247561*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.377158388576571*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.00439189702818206*std::sin(0.220799997448921*x_45 - 1.18895995616913) + 0.00593884428112391*std::sin(0.198320001363754*x_47 - 1.18783986568451) + 0.0106224945565353*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.00746933924291813*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.130515015864152*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.00563765643533332*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.00242851188582687*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.00750706060754859*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.0759270819480369*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 1.00240425570863*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0173709899040557*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.0113200293890437*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.0168776434280716*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.00427909422244551*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.00796828102754161*std::sin(0.42375984787941*x_6 - 7.41519975662231) - 0.00580428675223019*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.00296175344976359*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.00792113653761302*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.659589276626513*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.00311054194978116*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.00790715876181018*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.00214645455224902*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.00693508382917699*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.313868674235471*std::sin(0.385519832372665*x_91 - 4.3854398727417) + 0.0509863095150958*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.573646023583372*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.00446036330012367*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.684554758479186*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.0022112990139323*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.0135063099119624*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.00278099911633719*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.43408214147552*std::sin(0.292799949645996*x_95 - 1.21631991863251) - 0.0506854830854456*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 0.0140019591655032*std::sin(0.271919965744019*x_96 + 1.98279976844788) - 0.64491436359789*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.00234960858190175*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.00983358962492875*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 6.95379012301018);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00509372100297648*x_1 - 0.0013455129318748*x_10 - 0.0150258356196132*x_100 - 0.00634925060193735*x_101 - 0.00154052073017202*x_102 - 0.000809725783696286*x_103 - 0.00814089235469605*x_104 + 0.00866599058775034*x_105 - 0.00114388918321188*x_106 - 0.00405525536057098*x_107 - 0.000643105887552793*x_108 + 0.00423123382398872*x_109 - 0.000998412156602169*x_11 + 0.0199349606881461*x_110 + 0.0145211469190385*x_111 - 0.0178945966613663*x_112 - 0.00689247713070425*x_113 + 0.00192835324819995*x_114 + 0.0217965617562724*x_115 - 0.00347298108916322*x_116 - 0.00735241350496264*x_117 + 0.00670964183771567*x_118 - 0.0115801919174728*x_119 + 0.00618201842958512*x_12 + 0.00882006408870242*x_120 - 0.000244733626414296*x_13 - 0.00968975838832176*x_14 - 0.000140117266329553*x_15 + 6.01425429836021e-7*x_16 - 6.84387119064386e-5*x_17 - 0.00134970797087164*x_18 + 0.00407137844250364*x_19 - 0.00388521977253599*x_2 - 0.000725450101973653*x_20 + 0.00097080676408043*x_21 + 0.0031361933257279*x_22 + 0.0016856899464518*x_23 + 0.0121951565513747*x_24 + 0.00168107099038308*x_25 - 0.00162278453259577*x_26 + 0.00369153640059341*x_27 - 0.00199708587517418*x_28 + 0.011827126757381*x_29 + 0.00289690929101601*x_3 + 0.00205601226167582*x_30 + 0.000202987940458273*x_31 + 0.000485918500855545*x_32 + 0.0137275647568556*x_33 - 0.0101335833189786*x_34 - 0.0103231127573159*x_35 - 0.021807030481398*x_36 - 0.00919104210986035*x_37 + 0.0086517324575219*x_38 + 0.0029541628853602*x_39 - 0.00435785670250192*x_4 - 0.00552067592087329*x_40 + 0.00103430496846409*x_41 - 0.0115151902539708*x_42 - 0.000402348991094871*x_43 + 0.00535335130322051*x_44 + 0.00187243389309774*x_45 - 0.00380952041454305*x_46 - 0.0221160209299727*x_47 - 0.000588239633071471*x_48 + 0.0173059829223179*x_49 - 0.00203635029300915*x_5 + 0.00965430873341314*x_50 - 0.0137586846091729*x_51 - 0.00625839966786393*x_52 + 0.0191919827633409*x_53 + 0.013739954290881*x_54 + 0.00563636094513591*x_55 + 0.00782038377139508*x_56 - 0.00392951494350708*x_57 - 0.00486234394981334*x_58 + 0.00498524142880964*x_59 + 0.00237209456232279*x_6 + 0.0179424570284069*x_60 + 0.00491667684000942*x_61 + 0.00334723326985799*x_62 + 0.00168721748020732*x_63 - 0.00545389862229417*x_64 + 0.00387078517759441*x_65 - 0.0051512757663585*x_66 - 0.00329552346323203*x_67 + 0.014198744914273*x_68 + 0.000451200306631184*x_69 + 0.0105172474742287*x_7 + 0.00630863565194075*x_70 + 0.00465892964545711*x_71 + 0.00936943796217831*x_72 + 0.000932078535738842*x_73 + 0.0119601918494642*x_74 - 0.00352144402317862*x_75 + 0.00311794673292359*x_76 - 0.00269409216956156*x_77 + 0.00298056527301936*x_78 + 0.00498770214958838*x_79 - 0.000410245844200843*x_8 + 0.00179300867587556*x_80 + 0.000718332342261265*x_81 - 0.00680578132139952*x_82 - 0.00250394015345348*x_83 - 0.00497097540153859*x_84 - 0.00453841578502342*x_85 + 0.014703213273798*x_86 - 0.00254048775344483*x_87 - 0.00141204795459366*x_88 + 0.0021297278838329*x_89 - 0.00462181942577477*x_9 + 0.00304817649012369*x_90 + 0.00344242944166803*x_91 + 0.000621991745827755*x_92 - 0.0229270278277323*x_93 - 0.00176836011660208*x_94 + 0.000965604071684628*x_95 + 0.0107739656428204*x_96 + 0.00164958929511939*x_97 - 0.00608145747500629*x_98 - 0.0102389197919378*x_99 - 2.38097692285637e-5*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) + 5.59671714981225e-5*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) + 0.000142342143991477*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) - 0.0172352061680172*std::sin(0.217919990420341*x_1 + 5.01607990264893) - 0.00762167802112172*std::sin(0.251359969377518*x_1 - 4.32871961593628) - 0.0354278643166867*std::sin(0.351279854774475*x_1 - 4.22824001312256) + 0.0816273697957064*std::sin(0.251999974250793*x_10 + 1.99783980846405) + 0.00478814653012208*std::sin(0.375039845705032*x_10 - 4.37103986740112) - 0.00702912942096656*std::sin(0.257679969072342*x_100 - 1.20759987831116) + 0.00653173697947842*std::sin(0.213199988007545*x_104 - 7.40104007720947) - 0.00950198662840961*std::sin(0.258399993181229*x_107 + 1.97087979316711) - 0.00974145761407158*std::sin(0.264959961175919*x_107 - 1.22583997249603) + 0.071225929232543*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.0152828275436047*std::sin(0.255919963121414*x_108 - 7.42927980422974) - 0.00895119976742848*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.0207080114264009*std::sin(0.240719974040985*x_109 + 1.97031986713409) + 0.0111747931145574*std::sin(0.245199963450432*x_109 - 7.44343996047974) + 0.115558711588214*std::sin(0.22919999063015*x_11 + 5.00559949874878) + 0.0187226139787617*std::sin(0.282719939947128*x_11 + 5.160560131073) + 0.00480861837956912*std::sin(0.324079930782318*x_11 + 1.93391978740692) + 0.0130110145368811*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.00439483538516802*std::sin(0.277119934558868*x_112 - 7.6016001701355) + 0.00642029083522901*std::sin(0.290239930152893*x_113 + 1.96135985851288) - 0.00307427745095607*std::sin(0.233919993042946*x_116 - 4.23400020599365) + 0.00645028844465776*std::sin(0.258559972047806*x_116 - 7.44599962234497) - 0.00713569190210811*std::sin(0.232799991965294*x_118 + 5.16344022750854) - 0.0249770406155844*std::sin(0.257359951734543*x_119 + 1.94495987892151) - 0.00390586441226108*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.012789222491892*std::sin(0.307599931955338*x_12 + 1.92247986793518) - 0.00647002951460833*std::sin(0.272319942712784*x_120 + 1.9690397977829) + 0.0345697305465551*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.00561110304858378*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.0365219403347818*std::sin(0.316559940576553*x_13 - 7.46415996551514) - 0.00762415762997545*std::sin(0.215839996933937*x_14 + 8.38799953460693) - 0.00436637165863958*std::sin(0.302559942007065*x_14 - 1.21279990673065) + 0.0222520845354243*std::sin(0.310479938983917*x_15 - 7.4489598274231) - 0.00550576718027843*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.00481424342965113*std::sin(0.345919847488403*x_15 - 4.35887956619263) - 0.0258838534099407*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.0147416098021736*std::sin(0.323279827833176*x_16 - 1.13703989982605) + 0.0049151862416049*std::sin(0.354799836874008*x_16 - 4.36759996414185) + 0.0197035658551815*std::sin(0.357919842004776*x_16 - 1.1639997959137) - 0.00773308556424376*std::sin(0.372639834880829*x_16 - 7.57360029220581) + 0.00558135323070242*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.00531494779614963*std::sin(0.376959830522537*x_17 - 1.17751979827881) - 0.0423367224102503*std::sin(0.382559835910797*x_17 - 1.17599976062775) - 0.028274035644099*std::sin(0.388559848070145*x_17 - 1.18951988220215) + 0.0207758864186509*std::sin(0.331519842147827*x_18 + 8.21232032775879) - 0.0600128289691459*std::sin(0.34215983748436*x_18 + 1.9981597661972) - 0.0409369185700166*std::sin(0.218959987163544*x_19 + 1.99543976783752) + 0.02963357790927*std::sin(0.389999836683273*x_2 - 7.38967990875244) - 0.00414094207652462*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.00557431405021658*std::sin(0.285919934511185*x_20 + 5.19008016586304) - 0.0055964142508034*std::sin(0.32399994134903*x_20 - 1.21511995792389) - 0.0421440971944266*std::sin(0.343999862670898*x_20 - 4.3459997177124) + 0.00281119102137837*std::sin(0.345839828252792*x_20 - 4.35503959655762) - 0.0280728747606649*std::sin(0.264239966869354*x_21 - 4.20663976669312) - 0.0118861142206265*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.03725840129362*std::sin(0.354239851236343*x_21 - 4.35671949386597) + 0.0059275490015578*std::sin(0.363679856061935*x_21 - 1.16999983787537) - 0.0068086013490844*std::sin(0.309839934110641*x_22 + 2.02199983596802) - 0.0134609772437071*std::sin(0.394959837198257*x_22 - 1.19871985912323) + 0.00521176900310399*std::sin(0.330879837274551*x_23 + 2.02455973625183) - 0.00778994673354209*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.0128692764244234*std::sin(0.301199942827225*x_24 - 1.1619998216629) - 0.0108959518517956*std::sin(0.333999842405319*x_24 + 2.01279973983765) - 0.00568296724113533*std::sin(0.305119931697845*x_25 + 1.99959981441498) - 0.0902088478762341*std::sin(0.316639930009842*x_25 + 1.99391984939575) - 0.00805980974768089*std::sin(0.352719843387604*x_25 + 8.23471927642822) - 0.00291142052413817*std::sin(0.33111983537674*x_26 - 1.14807987213135) + 0.0805337581203184*std::sin(0.345359832048416*x_26 - 1.14991986751556) + 0.0279283556440788*std::sin(0.352879852056503*x_26 - 4.36879968643188) + 0.079350300024653*std::sin(0.341279834508896*x_27 - 1.17215991020203) + 0.0271091945573394*std::sin(0.359519839286804*x_27 + 8.22399997711182) + 0.0248804005193388*std::sin(0.263759940862656*x_28 - 4.36847972869873) - 0.00857703038521771*std::sin(0.267519950866699*x_28 + 5.01783990859985) - 0.0900107345338262*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.0135632947333683*std::sin(0.167520016431808*x_29 - 4.41631984710693) - 0.0407738930698721*std::sin(0.25383996963501*x_29 + 2.02095985412598) + 0.00448495426556052*std::sin(0.382479846477509*x_29 + 8.20479965209961) - 0.00622489277710961*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.0120802545614712*std::sin(0.31263992190361*x_3 + 2.06999969482422) + 0.00495289283018831*std::sin(0.360559850931168*x_3 + 1.971599817276) + 0.0231021988788399*std::sin(0.379759848117828*x_3 - 7.40215969085693) + 0.00436179216782924*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 0.0386600789629592*std::sin(0.310399919748306*x_31 - 7.49072027206421) - 0.00180481323682783*std::sin(0.402799874544144*x_31 + 5.18520021438599) - 0.018468475681935*std::sin(0.432959854602814*x_31 + 5.20775985717773) + 0.00368983307103668*std::sin(0.257839977741241*x_32 + 2.03919982910156) - 0.00723082206931503*std::sin(0.31127992272377*x_32 - 1.16535985469818) - 0.0527305032555559*std::sin(0.317919850349426*x_32 - 1.18943989276886) + 0.0114783270581242*std::sin(0.328159838914871*x_32 + 1.98015987873077) + 0.00898992697976143*std::sin(0.241519972681999*x_34 - 1.18687987327576) - 0.0038739898361172*std::sin(0.240319982171059*x_35 - 1.21359980106354) - 0.097738616698204*std::sin(0.253919988870621*x_35 - 1.2183198928833) - 0.00965510323966049*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.016640900394944*std::sin(0.215199992060661*x_36 + 1.98215985298157) + 0.0240648105455089*std::sin(0.235199987888336*x_36 - 1.18823993206024) + 0.138340681293919*std::sin(0.241599977016449*x_37 + 1.95127987861633) - 0.0139070703431193*std::sin(0.242719978094101*x_38 + 1.96239984035492) - 0.00727191275290761*std::sin(0.301439940929413*x_4 + 2.01935982704163) + 0.00553288130465556*std::sin(0.317439913749695*x_4 + 2.014319896698) - 0.0389917977041747*std::sin(0.323519825935364*x_4 + 2.02319979667664) + 0.00260020102564954*std::sin(0.254159957170486*x_41 + 1.95487987995148) - 0.0600077058009969*std::sin(0.259839981794357*x_42 - 7.42735958099365) - 0.00669550192986575*std::sin(0.233439981937408*x_44 - 1.19471991062164) - 0.0207937419831985*std::sin(0.193519994616508*x_45 + 1.98415982723236) - 0.00801793628892032*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0174303900539865*std::sin(0.23735998570919*x_45 + 8.19351959228516) - 0.0108420745683058*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.0193768436748676*std::sin(0.200479999184608*x_47 - 1.20559990406036) - 0.00866554283164832*std::sin(0.211520001292229*x_47 - 1.1898398399353) + 0.00609328428356757*std::sin(0.212239995598793*x_48 + 1.98431980609894) + 0.142960179818518*std::sin(0.228079989552498*x_48 + 8.19400024414063) + 0.0102922199284884*std::sin(0.224479988217354*x_49 + 1.95463979244232) - 0.00443354055263575*std::sin(0.28519994020462*x_5 - 1.17671978473663) - 0.00612405634931293*std::sin(0.356399834156036*x_5 - 1.15343987941742) + 0.0831670533579433*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 0.00837536536371102*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.023074187334099*std::sin(0.171040013432503*x_50 - 1.1548798084259) - 0.0552652044535759*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0140711115857815*std::sin(0.195439994335175*x_53 + 5.20183992385864) + 0.0141707822245119*std::sin(0.234479993581772*x_53 - 7.41767978668213) + 0.00923457282130823*std::sin(0.195119991898537*x_54 - 7.38695955276489) + 0.013768323555719*std::sin(0.210720002651215*x_57 - 7.4017596244812) - 0.00781200119895728*std::sin(0.387679845094681*x_6 + 2.00447988510132) + 0.00650030745332705*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.00741922675979069*std::sin(0.312079936265945*x_7 - 1.16279983520508) + 0.00473497964069795*std::sin(0.399279862642288*x_7 - 1.18111991882324) - 0.0054070371666988*std::sin(0.315919935703278*x_8 + 5.16639995574951) + 0.00646184825764771*std::sin(0.318479925394058*x_8 + 1.95895981788635) - 0.036364905696037*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.0127894346752645*std::sin(0.310399949550629*x_9 - 7.43655967712402) - 0.00567866846998524*std::sin(0.339839845895767*x_9 - 4.35839986801147) + 0.00645044556741652*std::sin(0.354879856109619*x_9 - 4.35031986236572) - 0.00391861096390947*std::sin(0.339999854564667*x_91 + 5.20272016525269) + 0.00565745321336329*std::sin(0.367439836263657*x_91 + 1.99071979522705) - 0.0173044122213285*std::sin(0.385519832372665*x_91 - 4.3854398727417) - 0.00812421221925139*std::sin(0.291199922561646*x_92 + 1.9851998090744) - 0.0558480717969462*std::sin(0.297839939594269*x_92 - 1.19751989841461) - 0.0316266262805362*std::sin(0.319359838962555*x_92 - 1.18919992446899) - 0.00814292970357581*std::sin(0.23735998570919*x_93 + 1.97199988365173) - 0.0377413189055905*std::sin(0.277359932661057*x_94 - 7.40759992599487) - 0.00403699232830159*std::sin(0.284879922866821*x_94 + 5.16616010665894) + 0.011018081150027*std::sin(0.285759925842285*x_94 - 7.43239974975586) + 0.00507704838962608*std::sin(0.268399953842163*x_95 + 1.97319984436035) + 0.0239320994116607*std::sin(0.292799949645996*x_95 - 1.21631991863251) + 0.0555185602829476*std::sin(0.301199942827225*x_95 + 8.17088031768799) - 0.0114224183622678*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.0128849159520697*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.0091412896395979*std::sin(0.262799948453903*x_97 + 1.9579998254776) + 0.0355558388308011*std::sin(0.26623997092247*x_97 + 1.96175980567932) - 0.00428949308071248*std::sin(0.277999937534332*x_97 - 1.21655988693237) + 0.00802197559435287*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 0.0616266053440419);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00020611077307191*x_1 + 0.0071139317270748*x_10 - 0.00239156242092417*x_100 - 0.00434600434631958*x_101 + 0.000861239392138279*x_102 - 1.74512437953449e-5*x_103 - 0.00895931688117728*x_104 + 0.0185349554514092*x_105 + 0.0126720797982815*x_106 - 0.00897873242931706*x_107 - 0.000221554738900068*x_108 + 0.00185539437065267*x_109 - 0.00217179725377752*x_11 - 0.0022456808211454*x_110 - 0.00326317285388241*x_111 + 0.00492401199109321*x_112 - 0.00787873019418908*x_113 + 0.00959619347219205*x_114 + 0.00103169895781381*x_115 - 0.00879435732492876*x_116 + 0.00167319378694128*x_117 - 0.000953841447756011*x_118 - 0.000202235821056849*x_119 - 0.00155189209623843*x_12 + 0.00840585735465307*x_120 - 0.000571635640739328*x_13 - 0.00933161942117567*x_14 - 0.000137857970286296*x_15 + 1.3851930080696e-6*x_16 - 6.7335184018219e-5*x_17 - 0.00411373423424032*x_18 - 0.000858131457263978*x_19 - 9.17531498448897e-5*x_2 + 0.000968198965021265*x_20 + 0.000955153162363034*x_21 - 0.00197472801312501*x_22 + 0.00406407195987069*x_23 + 0.00623637506185343*x_24 - 0.00447371657355679*x_25 - 0.00293914291451261*x_26 + 0.00597824550978201*x_27 - 0.00554909853344687*x_28 + 0.00221343389740263*x_29 + 0.000649804681442345*x_3 - 3.03404647550506e-5*x_30 + 0.000631260906360186*x_31 + 0.00142936613331588*x_32 + 0.00275291350840294*x_33 - 0.0036625132769118*x_34 + 0.00303831411871891*x_35 - 0.00576389198549524*x_36 + 0.00568761321341005*x_37 + 0.014115223463303*x_38 - 0.0103599574230069*x_39 - 0.000996701723100649*x_4 + 0.00952961192445543*x_40 + 0.00107214164390457*x_41 - 0.00685319720900456*x_42 + 0.0244619754724238*x_43 + 0.00896900578686204*x_44 + 0.00186010682958584*x_45 + 0.00576339553397936*x_46 + 0.00822038043061063*x_47 + 0.0155924103785331*x_48 - 0.00117000023352676*x_49 + 0.00271775031907544*x_5 + 0.00535632054207373*x_50 - 0.00896305948979559*x_51 - 0.00525604009853051*x_52 + 0.00568565348954089*x_53 + 0.00680774787225944*x_54 + 0.00693668634957879*x_55 - 0.000519267526507355*x_56 + 0.00309188603615777*x_57 + 0.00527038889565587*x_58 + 0.0135485639928233*x_59 - 0.000100234762387159*x_6 + 0.0192207903059909*x_60 - 0.00037448724170917*x_61 + 0.0022789225752314*x_62 - 0.00198510472154283*x_63 - 0.00152046534357496*x_64 - 0.00143226536563946*x_65 - 0.00641987924302568*x_66 - 0.00366322351076289*x_67 - 0.00229612463296413*x_68 + 0.0053506250659895*x_69 - 0.0117358168952155*x_7 - 0.00198686976933514*x_70 + 0.00633926354512158*x_71 + 0.00601763653920412*x_72 - 0.00255649363454928*x_73 + 0.0118788567060069*x_74 - 0.00135510595788378*x_75 + 0.0073462748187133*x_76 - 0.000837489222568357*x_77 - 0.00347951098668473*x_78 + 0.0064657500981305*x_79 - 0.00107123899315275*x_8 - 0.00489782677510709*x_80 - 0.00478915609753247*x_81 - 0.00342041418261527*x_82 - 0.000564878806920166*x_83 + 0.00399220585982514*x_84 + 0.00558641867101179*x_85 + 0.00684205194466654*x_86 - 7.74521293655504e-5*x_87 - 0.000178886119633225*x_88 + 0.0114672428650535*x_89 - 0.00285124945974911*x_9 - 0.00601873037816566*x_90 + 0.00172477304599724*x_91 + 0.00111619969580847*x_92 + 0.0134514701495892*x_93 - 0.000402154990464901*x_94 + 0.000910621732156645*x_95 + 0.00106805315204604*x_96 - 0.00091783581317972*x_97 - 0.0124398884496228*x_98 - 0.000415125720021525*x_99 + 3.17769531795141e-5*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 7.46948099837994e-5*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) + 3.19287151375603e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) - 0.0506986664510733*std::sin(0.217919990420341*x_1 + 5.01607990264893) - 0.00749878362382744*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.0472826752260566*std::sin(0.351279854774475*x_1 - 4.22824001312256) + 0.0183098059685785*std::sin(0.251999974250793*x_10 + 1.99783980846405) + 0.00471094090947721*std::sin(0.375039845705032*x_10 - 4.37103986740112) - 0.00691578946862284*std::sin(0.257679969072342*x_100 - 1.20759987831116) + 0.0150437875515008*std::sin(0.213199988007545*x_104 - 7.40104007720947) - 0.0218848169490148*std::sin(0.258399993181229*x_107 + 1.97087979316711) - 0.00958438320618773*std::sin(0.264959961175919*x_107 - 1.22583997249603) + 0.0159766625758431*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.0449555966148113*std::sin(0.255919963121414*x_108 - 7.42927980422974) - 0.0206162538472256*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.0609141865747054*std::sin(0.240719974040985*x_109 + 1.97031986713409) + 0.0109946071422695*std::sin(0.245199963450432*x_109 - 7.44343996047974) + 0.0259209330455532*std::sin(0.22919999063015*x_11 + 5.00559949874878) - 0.0249875428060634*std::sin(0.282719939947128*x_11 + 5.160560131073) + 0.0110751295628956*std::sin(0.324079930782318*x_11 + 1.93391978740692) + 0.0128012207375018*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.0129277416891869*std::sin(0.277119934558868*x_112 - 7.6016001701355) + 0.00631676799282306*std::sin(0.290239930152893*x_113 + 1.96135985851288) - 0.00302470680871644*std::sin(0.233919993042946*x_116 - 4.23400020599365) + 0.0148561966460384*std::sin(0.258559972047806*x_116 - 7.44599962234497) - 0.0164348064451382*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.0333348149066511*std::sin(0.257359951734543*x_119 + 1.94495987892151) - 0.00899592169856715*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.0376204681837925*std::sin(0.307599931955338*x_12 + 1.92247986793518) - 0.0149016639487342*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.046137394212475*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0165054852903727*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.00819222330450527*std::sin(0.316559940576553*x_13 - 7.46415996551514) - 0.0075012232506674*std::sin(0.215839996933937*x_14 + 8.38799953460693) - 0.0100565542993915*std::sin(0.302559942007065*x_14 - 1.21279990673065) + 0.00499135708108356*std::sin(0.310479938983917*x_15 - 7.4489598274231) - 0.0126807910404789*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.014161462269426*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 0.0345450638356612*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.0433635635701973*std::sin(0.323279827833176*x_16 - 1.13703989982605) + 0.0048359321916336*std::sin(0.354799836874008*x_16 - 4.36759996414185) + 0.00441969977227489*std::sin(0.357919842004776*x_16 - 1.1639997959137) + 0.0103207173303197*std::sin(0.372639834880829*x_16 - 7.57360029220581) + 0.0128548795697641*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.0156343221482251*std::sin(0.376959830522537*x_17 - 1.17751979827881) - 0.00949653498106497*std::sin(0.382559835910797*x_17 - 1.17599976062775) + 0.03773504473032*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.0277278777316482*std::sin(0.331519842147827*x_18 + 8.21232032775879) - 0.0134614560875922*std::sin(0.34215983748436*x_18 + 1.9981597661972) + 0.0546351597205914*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.0395495146855383*std::sin(0.389999836683273*x_2 - 7.38967990875244) - 0.00407417218945845*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.0163972676607659*std::sin(0.285919934511185*x_20 + 5.19008016586304) - 0.00550617586045739*std::sin(0.32399994134903*x_20 - 1.21511995792389) - 0.00945332728816473*std::sin(0.343999862670898*x_20 - 4.3459997177124) + 0.00647468822231722*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.0374665717387059*std::sin(0.264239966869354*x_21 - 4.20663976669312) - 0.034963906691708*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.00835741859737712*std::sin(0.354239851236343*x_21 - 4.35671949386597) + 0.0136522318888087*std::sin(0.363679856061935*x_21 - 1.16999983787537) - 0.00669881726257565*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.0179652662534264*std::sin(0.394959837198257*x_22 - 1.19871985912323) + 0.0120036593476632*std::sin(0.330879837274551*x_23 + 2.02455973625183) - 0.017941675248882*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.0378559528994346*std::sin(0.301199942827225*x_24 - 1.1619998216629) - 0.0107202620060604*std::sin(0.333999842405319*x_24 + 2.01279973983765) - 0.00559133324242704*std::sin(0.305119931697845*x_25 + 1.99959981441498) - 0.0202347142312276*std::sin(0.316639930009842*x_25 + 1.99391984939575) - 0.0185632192371759*std::sin(0.352719843387604*x_25 + 8.23471927642822) - 0.00670553513955353*std::sin(0.33111983537674*x_26 - 1.14807987213135) + 0.0180644983268961*std::sin(0.345359832048416*x_26 - 1.14991986751556) - 0.0372736938843589*std::sin(0.352879852056503*x_26 - 4.36879968643188) + 0.0177990372669867*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.0361804265263297*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.0332058372679273*std::sin(0.263759940862656*x_28 - 4.36847972869873) - 0.00843873157794129*std::sin(0.267519950866699*x_28 + 5.01783990859985) - 0.0201902754986266*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.0398974604052414*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.0544175829085095*std::sin(0.25383996963501*x_29 + 2.02095985412598) + 0.0103296717796922*std::sin(0.382479846477509*x_29 + 8.20479965209961) - 0.00612452059608276*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.035534985232297*std::sin(0.31263992190361*x_3 + 2.06999969482422) + 0.0114074200686284*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.0308326168586307*std::sin(0.379759848117828*x_3 - 7.40215969085693) + 0.0128305425586399*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 0.00867182841139321*std::sin(0.310399919748306*x_31 - 7.49072027206421) - 0.00415681571231036*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.0246483651902764*std::sin(0.432959854602814*x_31 + 5.20775985717773) + 0.00363033701122874*std::sin(0.257839977741241*x_32 + 2.03919982910156) - 0.0166539086578721*std::sin(0.31127992272377*x_32 - 1.16535985469818) - 0.0118279602252419*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.0153191850791897*std::sin(0.328159838914871*x_32 + 1.98015987873077) + 0.0207054497160472*std::sin(0.241519972681999*x_34 - 1.18687987327576) - 0.0038115243731687*std::sin(0.240319982171059*x_35 - 1.21359980106354) - 0.0219237139682469*std::sin(0.253919988870621*x_35 - 1.2183198928833) - 0.022237472571478*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.0489504709339869*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.0321173359824557*std::sin(0.235199987888336*x_36 - 1.18823993206024) + 0.0310311484786546*std::sin(0.241599977016449*x_37 + 1.95127987861633) - 0.0136828282506024*std::sin(0.242719978094101*x_38 + 1.96239984035492) - 0.00715465808372996*std::sin(0.301439940929413*x_4 + 2.01935982704163) + 0.012743239839023*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.0520391658623981*std::sin(0.323519825935364*x_4 + 2.02319979667664) + 0.002558274544761*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 0.0800873809125687*std::sin(0.259839981794357*x_42 - 7.42735958099365) - 0.0154209682508691*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.0277517080944365*std::sin(0.193519994616508*x_45 + 1.98415982723236) - 0.0184667769861147*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0512728146588124*std::sin(0.23735998570919*x_45 + 8.19351959228516) - 0.024971285116895*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.0569984556477003*std::sin(0.200479999184608*x_47 - 1.20559990406036) - 0.00852581682110682*std::sin(0.211520001292229*x_47 - 1.1898398399353) + 0.00599503420038424*std::sin(0.212239995598793*x_48 + 1.98431980609894) + 0.0320673465317003*std::sin(0.228079989552498*x_48 + 8.19400024414063) + 0.0237048690913249*std::sin(0.224479988217354*x_49 + 1.95463979244232) - 0.0102112565745325*std::sin(0.28519994020462*x_5 - 1.17671978473663) - 0.00602531008740586*std::sin(0.356399834156036*x_5 - 1.15343987941742) + 0.0186551718348085*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 0.0246367725944938*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.0678744725114968*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 0.073757951936416*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0413912422009302*std::sin(0.195439994335175*x_53 + 5.20183992385864) + 0.0139422879564723*std::sin(0.234479993581772*x_53 - 7.41767978668213) + 0.00908567158748548*std::sin(0.195119991898537*x_54 - 7.38695955276489) + 0.0135463186612006*std::sin(0.210720002651215*x_57 - 7.4017596244812) - 0.0179924707253855*std::sin(0.387679845094681*x_6 + 2.00447988510132) + 0.00639549439713518*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.0218242183558851*std::sin(0.312079936265945*x_7 - 1.16279983520508) + 0.00465863130014465*std::sin(0.399279862642288*x_7 - 1.18111991882324) - 0.0124533977216855*std::sin(0.315919935703278*x_8 + 5.16639995574951) + 0.00635765532994466*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.0485332677770823*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.0376210923372797*std::sin(0.310399949550629*x_9 - 7.43655967712402) - 0.0130790144040194*std::sin(0.339839845895767*x_9 - 4.35839986801147) + 0.00634643650037245*std::sin(0.354879856109619*x_9 - 4.35031986236572) - 0.00902527934349607*std::sin(0.339999854564667*x_91 + 5.20272016525269) + 0.00556623061107675*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.0230947848203626*std::sin(0.385519832372665*x_91 - 4.3854398727417) - 0.0238979865669309*std::sin(0.291199922561646*x_92 + 1.9851998090744) - 0.0125272609037945*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.0422094734684338*std::sin(0.319359838962555*x_92 - 1.18919992446899) - 0.0187546597317491*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.0503702540030208*std::sin(0.277359932661057*x_94 - 7.40759992599487) - 0.00929793332536445*std::sin(0.284879922866821*x_94 + 5.16616010665894) + 0.0108404220520541*std::sin(0.285759925842285*x_94 - 7.43239974975586) + 0.0116933730801149*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.0319402172776832*std::sin(0.292799949645996*x_95 - 1.21631991863251) + 0.0124533482945701*std::sin(0.301199942827225*x_95 + 8.17088031768799) - 0.0112382396005326*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.0379019577564616*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.0268897969570353*std::sin(0.262799948453903*x_97 + 1.9579998254776) - 0.047453472351562*std::sin(0.26623997092247*x_97 + 1.96175980567932) - 0.00987948884234226*std::sin(0.277999937534332*x_97 - 1.21655988693237) + 0.00789262666974003*std::sin(0.251839965581894*x_98 + 1.98623991012573) - 0.19933324159782);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00575345473488376*x_1 + 0.0340049590391487*x_10 + 0.0166169843531438*x_100 - 0.0108708046341967*x_101 + 0.00192625732323156*x_102 - 0.00898286668607141*x_103 - 0.0248965883487484*x_104 + 0.0624437979285977*x_105 + 0.0552560540469007*x_106 - 0.0465586803034727*x_107 + 0.0021645732727529*x_108 - 0.000747929182731783*x_109 - 0.00190403962431674*x_11 - 0.0675989784350307*x_110 - 0.0578901916286104*x_111 + 0.0613405332557058*x_112 - 0.0233067312993296*x_113 + 0.0181985626122826*x_114 - 0.0570330785747561*x_115 - 0.00411886819966773*x_116 + 0.0104949504663454*x_117 - 0.0137151907964009*x_118 + 0.00746141886820167*x_119 - 0.0282869113904012*x_12 + 0.0435760001630988*x_120 - 0.00133748017308032*x_13 - 0.0417782792513976*x_14 + 9.79717223477931e-5*x_15 + 3.19751694800795e-6*x_16 + 4.78531922323411e-5*x_17 - 0.00364879847055786*x_18 - 0.00715654544553396*x_19 + 0.00323997584594161*x_2 + 0.00752212273736069*x_20 - 0.000678800073933409*x_21 - 0.00867605589072606*x_22 + 0.0142816295429903*x_23 + 0.0145375379638513*x_24 - 0.0247073459121413*x_25 - 0.00180226641583664*x_26 + 0.00773318155403022*x_27 - 0.00804014628687314*x_28 - 0.00711051012945734*x_29 - 0.00175487468741259*x_3 - 2.06733635291821e-5*x_30 + 0.000802128146071227*x_31 + 0.00174128744397883*x_32 - 0.0145527583062392*x_33 + 0.0298671941654141*x_34 + 0.0719997428182423*x_35 + 0.00909998546635536*x_36 + 0.0764643424625998*x_37 + 0.0494041333894032*x_38 - 0.0213627350338058*x_39 + 0.0026102903885431*x_4 + 0.0296978946526514*x_40 - 0.0267985223943015*x_41 + 4.71403536659275e-6*x_42 + 0.112316582428549*x_43 + 0.0142218766160937*x_44 - 0.00131142650338638*x_45 + 0.0196030006750646*x_46 + 0.0959476050003786*x_47 + 0.060763390181126*x_48 - 0.024817416006943*x_49 + 0.0211147214654765*x_5 + 0.0269903772428015*x_50 - 1.71450659715308e-5*x_51 + 0.0103834560450957*x_52 - 0.000955450035452202*x_53 + 0.0125301562387148*x_54 + 0.0167216368390354*x_55 + 0.00584045786454624*x_56 + 0.0178160776622891*x_57 + 0.0668664403652675*x_58 + 0.0462459622320101*x_59 - 0.00241181499989645*x_6 + 0.0353775656934445*x_60 - 0.00546716956058078*x_61 + 0.00421689559638498*x_62 - 0.00869348701924804*x_63 + 0.0078397519842665*x_64 - 0.0213718473433054*x_65 - 0.012771586065819*x_66 - 0.022763893701431*x_67 - 0.0444292536991404*x_68 + 0.028681689536668*x_69 - 0.0912697630034948*x_7 - 0.0087683762844128*x_70 + 0.0115370935599357*x_71 + 0.00712638663015725*x_72 - 0.0177990828886887*x_73 + 0.0304237276829741*x_74 - 0.00937008791078175*x_75 + 0.0425087140558373*x_76 + 0.00419696142146752*x_77 - 0.0167607892265253*x_78 + 0.0315668622227027*x_79 - 0.00126116456896474*x_8 - 0.0305218115485691*x_80 - 0.0109400202048097*x_81 + 0.00923857279167712*x_82 - 0.00175178937400457*x_83 + 0.0259535935451792*x_84 + 0.0357643970112796*x_85 + 0.00375302774645318*x_86 + 0.0206102147447544*x_87 + 0.00600935337490233*x_88 + 0.0470649329222708*x_89 - 0.00856411716793461*x_9 - 0.0204800891113947*x_90 - 0.000616687238892295*x_91 + 0.00186431534949007*x_92 + 0.0957744928573242*x_93 + 0.00106275661018359*x_94 - 0.000761382243886403*x_95 - 0.0188863237213087*x_96 - 0.000840855038529852*x_97 - 0.0446518255233796*x_98 + 0.0523360002926356*x_99 + 0.000246881220359928*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 0.000580318249492895*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) - 8.62272858240143e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) - 0.0617623079629906*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 0.0053291713610325*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.367348137366941*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.0494478047686168*std::sin(0.251999974250793*x_10 + 1.99783980846405) - 0.00334793116293284*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.00491485406486548*std::sin(0.257679969072342*x_100 - 1.20759987831116) + 0.0347263994099932*std::sin(0.213199988007545*x_104 - 7.40104007720947) - 0.0505179225500466*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.00681134742083763*std::sin(0.264959961175919*x_107 - 1.22583997249603) - 0.043146874044438*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.0547659652046957*std::sin(0.255919963121414*x_108 - 7.42927980422974) - 0.0475896288076164*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.0742070948586535*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.00781355329712526*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.0700025570372777*std::sin(0.22919999063015*x_11 + 5.00559949874878) - 0.194132994025804*std::sin(0.282719939947128*x_11 + 5.160560131073) + 0.0255653286382768*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.0090974619835383*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.0157488790014644*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.00448914660968141*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.00214957274528003*std::sin(0.233919993042946*x_116 - 4.23400020599365) + 0.0342933730403724*std::sin(0.258559972047806*x_116 - 7.44599962234497) - 0.0379373645689952*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.258984545753489*std::sin(0.257359951734543*x_119 + 1.94495987892151) - 0.020765779156081*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.0458301392191766*std::sin(0.307599931955338*x_12 + 1.92247986793518) - 0.034398327707414*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.358450230362113*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0201073704091685*std::sin(0.307839930057526*x_13 - 7.44687986373901) - 0.0221240716191783*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.00533090513415349*std::sin(0.215839996933937*x_14 + 8.38799953460693) - 0.0232140955257051*std::sin(0.302559942007065*x_14 - 1.21279990673065) - 0.0134797523741883*std::sin(0.310479938983917*x_15 - 7.4489598274231) - 0.029271765039144*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.0172518264308714*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 0.268387200905649*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.0528265131032564*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.00343675889749102*std::sin(0.354799836874008*x_16 - 4.36759996414185) - 0.011935923944273*std::sin(0.357919842004776*x_16 - 1.1639997959137) + 0.0801836247517218*std::sin(0.372639834880829*x_16 - 7.57360029220581) + 0.0296736231337204*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.019046098978622*std::sin(0.376959830522537*x_17 - 1.17751979827881) + 0.0256465201503442*std::sin(0.382559835910797*x_17 - 1.17599976062775) + 0.293170771934288*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.215423179614127*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.0363542603161864*std::sin(0.34215983748436*x_18 + 1.9981597661972) + 0.424470994125228*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.307267735677794*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.00289539781931927*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.0199755371473754*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 0.00391308193119738*std::sin(0.32399994134903*x_20 - 1.21511995792389) + 0.0255298326460255*std::sin(0.343999862670898*x_20 - 4.3459997177124) + 0.014945877724851*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.291084953969647*std::sin(0.264239966869354*x_21 - 4.20663976669312) - 0.0425938535240668*std::sin(0.273359954357147*x_21 - 1.16527986526489) + 0.0225702011196569*std::sin(0.354239851236343*x_21 - 4.35671949386597) + 0.0315141951975598*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.00476065811461394*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.139575585855609*std::sin(0.394959837198257*x_22 - 1.19871985912323) + 0.0277087048365599*std::sin(0.330879837274551*x_23 + 2.02455973625183) - 0.041415752425652*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.0461170122386494*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.00761858404394157*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.00397360085052334*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0546462480580932*std::sin(0.316639930009842*x_25 + 1.99391984939575) - 0.0428504964829237*std::sin(0.352719843387604*x_25 + 8.23471927642822) - 0.015478754317469*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.0487853223591921*std::sin(0.345359832048416*x_26 - 1.14991986751556) - 0.289586449069175*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.0480684132512205*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.281092646091741*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.257982493836573*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.00599716552771415*std::sin(0.267519950866699*x_28 + 5.01783990859985) + 0.0545262359849128*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.048604024700882*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.422780598303283*std::sin(0.25383996963501*x_29 + 2.02095985412598) + 0.0238445475760483*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.00435252187527967*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.0432895548346517*std::sin(0.31263992190361*x_3 + 2.06999969482422) + 0.0263323730267144*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.239544491063923*std::sin(0.379759848117828*x_3 - 7.40215969085693) + 0.0156304687343941*std::sin(0.304399937391281*x_30 + 1.99511981010437) - 0.0234193021493174*std::sin(0.310399919748306*x_31 - 7.49072027206421) - 0.00959540555895603*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.191497858327576*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.00257997683379772*std::sin(0.257839977741241*x_32 + 2.03919982910156) - 0.0384431302164402*std::sin(0.31127992272377*x_32 - 1.16535985469818) + 0.0319428108103612*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.119017675669049*std::sin(0.328159838914871*x_32 + 1.98015987873077) + 0.0477955245207682*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.00270874151733431*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.0592075923669132*std::sin(0.253919988870621*x_35 - 1.2183198928833) - 0.0513319768537194*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.0596326150644603*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.249525719387416*std::sin(0.235199987888336*x_36 - 1.18823993206024) - 0.0838033005020206*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.00972399526495719*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.0050846111676886*std::sin(0.301439940929413*x_4 + 2.01935982704163) + 0.0294159190238698*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.404302221866382*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.00181809265629139*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 0.622214163309778*std::sin(0.259839981794357*x_42 - 7.42735958099365) - 0.0355970662929947*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.215608322255512*std::sin(0.193519994616508*x_45 + 1.98415982723236) - 0.0426278735484476*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0624617488142999*std::sin(0.23735998570919*x_45 + 8.19351959228516) - 0.0576425862025418*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.0694368593407766*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.00605905452293354*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.00426049959190465*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.0866016763622867*std::sin(0.228079989552498*x_48 + 8.19400024414063) + 0.0547192486738373*std::sin(0.224479988217354*x_49 + 1.95463979244232) - 0.0235712032672089*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.00428201580015112*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.0503805062924009*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 0.0300130958604944*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.0826862789009682*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 0.573039620332465*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0504237848198958*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 0.00990838586791716*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.00645692731630798*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.00962698179839511*std::sin(0.210720002651215*x_57 - 7.4017596244812) - 0.0415330064083503*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.00454509521685072*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.026586776132436*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 0.00331075621750888*std::sin(0.399279862642288*x_7 - 1.18111991882324) - 0.0287468605771162*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.00451820407245776*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.377064229826343*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.0458308995776354*std::sin(0.310399949550629*x_9 - 7.43655967712402) - 0.0301910058572795*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.00451023117068332*std::sin(0.354879856109619*x_9 - 4.35031986236572) - 0.02083354701707*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.00395576112733764*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.179427795616252*std::sin(0.385519832372665*x_91 - 4.3854398727417) - 0.0291130893446005*std::sin(0.291199922561646*x_92 + 1.9851998090744) + 0.0338313553141627*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.327933463657395*std::sin(0.319359838962555*x_92 - 1.18919992446899) - 0.0432924090700987*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.391336126778894*std::sin(0.277359932661057*x_94 - 7.40759992599487) - 0.021462929148576*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.00770397835693591*std::sin(0.285759925842285*x_94 - 7.43239974975586) + 0.0269924540372562*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.248149650330833*std::sin(0.292799949645996*x_95 - 1.21631991863251) - 0.0336317455380055*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 0.0079866959272271*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.046173056437568*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.0327577831327267*std::sin(0.262799948453903*x_97 + 1.9579998254776) - 0.368675092866435*std::sin(0.26623997092247*x_97 + 1.96175980567932) - 0.0228053656255948*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.00560906436585932*std::sin(0.251839965581894*x_98 + 1.98623991012573) - 1.74756179185525);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00715262251961282*x_1 + 0.0399201486843084*x_10 + 0.002005878508278*x_100 - 0.0320288735846668*x_101 - 0.00543778219141656*x_102 - 0.0263268345355703*x_103 - 0.051869666597543*x_104 + 0.0902031483103983*x_105 + 0.0753493056820826*x_106 - 0.0826788530377486*x_107 + 0.00301235549213131*x_108 + 0.00176402121973589*x_109 - 0.00129280838651791*x_11 - 0.0570909411195093*x_110 - 0.0793206909708097*x_111 + 0.0581075013568984*x_112 - 0.0452725305719048*x_113 + 0.00489389617909421*x_114 - 0.0489846267769536*x_115 + 0.00347823268360251*x_116 + 0.0083366230162423*x_117 - 0.00490208159504967*x_118 - 0.0110928199865609*x_119 - 0.0343020154973567*x_12 + 0.0923470182123475*x_120 + 0.000215510332549822*x_13 - 0.0891000925780587*x_14 + 0.000138614006324049*x_15 - 5.31184491504447e-7*x_16 + 6.77044613666432e-5*x_17 - 0.00516858190877682*x_18 + 0.00200907254127239*x_19 - 0.00390840656931127*x_2 + 0.0104373848532811*x_20 - 0.000960391381167649*x_21 + 0.00549687165425395*x_22 + 0.0233967465141148*x_23 + 0.0499039549107983*x_24 - 0.0331312463390841*x_25 - 0.000968548531466694*x_26 - 0.00316597329653704*x_27 - 0.00366055662704356*x_28 + 0.0156869860982719*x_29 + 0.00352945388966798*x_3 + 0.0146088675749001*x_30 + 0.000626560950027554*x_31 + 0.00134311847230032*x_32 + 0.00481722778166322*x_33 + 0.0387656349235104*x_34 + 0.105449529494957*x_35 - 0.0267231811258594*x_36 + 0.116396511306508*x_37 + 0.102259060711646*x_38 - 0.000912771254981118*x_39 - 0.00532031913635349*x_4 + 0.00591088571949876*x_40 - 0.0642869558370893*x_41 - 0.00939019086171365*x_42 + 0.150220703074255*x_43 + 0.0218111637211885*x_44 - 0.00190426766531702*x_45 + 0.017994285380447*x_46 + 0.10500687564424*x_47 + 0.0660460371261263*x_48 + 0.00502855209111894*x_49 + 0.0292979098719599*x_5 + 0.0781005269954061*x_50 - 0.0146704579297261*x_51 + 0.0074659334565423*x_52 + 0.0437372998413656*x_53 + 0.0521199287671733*x_54 + 0.0153954028243358*x_55 + 0.0465615628038035*x_56 + 0.00453803615768556*x_57 + 0.0906247852812725*x_58 + 0.0608270771343501*x_59 + 0.00253034760707172*x_6 + 0.0677615123811797*x_60 + 0.00456803061268813*x_61 + 0.0128304503867974*x_62 - 0.00559485855804297*x_63 + 0.0038465354825991*x_64 - 0.0363972246120747*x_65 - 0.0222286620348689*x_66 - 0.0541910476389328*x_67 - 0.040050643939672*x_68 + 0.0396495300775196*x_69 - 0.117392542059959*x_7 + 0.0138524557915109*x_70 + 0.0159604194265686*x_71 + 0.0269675947379429*x_72 - 0.0333854786410615*x_73 + 0.0583342039132375*x_74 - 0.0213874395309094*x_75 + 0.0809359222189514*x_76 + 0.00187515816696669*x_77 - 0.0222061140279734*x_78 + 0.0597493717910228*x_79 - 0.00105685599577584*x_8 - 0.0416816321615632*x_80 - 0.00546456213831008*x_81 + 0.00232819344468186*x_82 - 0.0108021942864342*x_83 + 0.0325136522914174*x_84 + 0.0431056914299137*x_85 + 0.0350895011379967*x_86 + 0.0341718572497145*x_87 + 0.0106096661351894*x_88 + 0.0670116981714486*x_89 - 0.0237955527390193*x_9 - 0.00984305420615148*x_90 + 0.00473598206307602*x_91 - 0.000574781867044805*x_92 + 0.0889061592321104*x_93 - 0.00215760999358045*x_94 - 0.00103080741067316*x_95 - 0.0130087840605642*x_96 + 0.00575283453862684*x_97 - 0.0670398339720073*x_98 + 0.0772450005664367*x_99 + 0.000342562119751903*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 0.00080522548206452*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) + 0.000173422770030262*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) - 0.0476395192556171*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 0.00753990820042717*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.509717006582644*std::sin(0.351279854774475*x_1 - 4.22824001312256) + 0.099450831519747*std::sin(0.251999974250793*x_10 + 1.99783980846405) - 0.00473677649295411*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.00695371680831114*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.00576889039598976*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.00839224230486889*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.00963694555777654*std::sin(0.264959961175919*x_107 - 1.22583997249603) + 0.086778220413953*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.042242985082179*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.00790578226483141*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.0572386369780837*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.0110549033964739*std::sin(0.245199963450432*x_109 - 7.44343996047974) + 0.140791133973338*std::sin(0.22919999063015*x_11 + 5.00559949874878) - 0.269370873371044*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.00424701614211222*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.0128714247611406*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.0121476843918175*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.00635141019910811*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.0030412948039283*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.00569695429816914*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.00630230895887981*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.35935619099321*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.00344969550469107*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.0353504568049477*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.00571438979338307*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.497370640664307*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0155095476736621*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.044496562171475*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.00754236120658648*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.0038564197557231*std::sin(0.302559942007065*x_14 - 1.21279990673065) + 0.0271108614136928*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.00486274439841271*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.0133069625238187*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 0.372402924460924*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.0407470149868381*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.00486245324809054*std::sin(0.354799836874008*x_16 - 4.36759996414185) + 0.0240058697604264*std::sin(0.357919842004776*x_16 - 1.1639997959137) + 0.111259464872604*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.00492950269589648*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.0146909503378688*std::sin(0.376959830522537*x_17 - 1.17751979827881) - 0.0515810108552777*std::sin(0.382559835910797*x_17 - 1.17599976062775) + 0.406791577490973*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.298912249966699*std::sin(0.331519842147827*x_18 + 8.21232032775879) - 0.0731167224641833*std::sin(0.34215983748436*x_18 + 1.9981597661972) + 0.58897830830853*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.426351938441072*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.00409651562736663*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.0154078598737586*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 0.00553637264466989*std::sin(0.32399994134903*x_20 - 1.21511995792389) - 0.0513463256273537*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.00248286986072384*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.403897383180274*std::sin(0.264239966869354*x_21 - 4.20663976669312) - 0.0328541916915837*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.0453938305132285*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.00523526599651539*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.00673555469059891*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.193669281473108*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0046030824943788*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.0068801528655539*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.0355717324208667*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.0107790537059085*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.00562199704388575*std::sin(0.305119931697845*x_25 + 1.99959981441498) - 0.109906088536026*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.00711849837079843*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.00257139348279902*std::sin(0.33111983537674*x_26 - 1.14807987213135) + 0.0981184280532474*std::sin(0.345359832048416*x_26 - 1.14991986751556) - 0.401818120065744*std::sin(0.352879852056503*x_26 - 4.36879968643188) + 0.0966765600624342*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.390032472099233*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.357965785403591*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.00848501098545465*std::sin(0.267519950866699*x_28 + 5.01783990859985) - 0.109664716840638*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.0374900557800664*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.586632785327312*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.00396115300881443*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.00615810848566926*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.0333908114694848*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.00437444066872416*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.332381979131968*std::sin(0.379759848117828*x_3 - 7.40215969085693) + 0.0120563502369874*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 0.0471015666572121*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.00159402771134282*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.265714468605616*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.00365024638320031*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.00638632880072174*std::sin(0.31127992272377*x_32 - 1.16535985469818) - 0.0642442897320403*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.165143979787907*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.00793998649626218*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.00383242740676845*std::sin(0.240319982171059*x_35 - 1.21359980106354) - 0.119079993959789*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.00852747630937442*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.045996809499549*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.346231516683826*std::sin(0.235199987888336*x_36 - 1.18823993206024) + 0.168547581799116*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.013757867156473*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.00719389541863243*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.00488669184335826*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.560992958237305*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.00257230454785975*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 0.863358510672896*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.00591352911191746*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.299169146200429*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.00708151534547918*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0481790234775785*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.00957582034399347*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.053559180456739*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.00857257381857782*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.00602791196504041*std::sin(0.212239995598793*x_48 + 1.98431980609894) + 0.174175754930573*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.00909018365029332*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.00391574394294944*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.00605835389006198*std::sin(0.356399834156036*x_5 - 1.15343987941742) + 0.101326707355572*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 0.0231501947599413*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.0637789406807534*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 0.795125958777776*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0388937030868074*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 0.0140187497825236*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.00913549892161102*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.0136206089257785*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.00689963157299758*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.00643056835211535*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.0205073494705692*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 0.00468418000902377*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.00477554513902353*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.00639252176918691*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.523198652629864*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.0353510432971406*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.00501545241356667*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.0063812414136874*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.00346095337677279*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.00559675674553003*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.248966551279617*std::sin(0.385519832372665*x_91 - 4.3854398727417) - 0.0224559869306322*std::sin(0.291199922561646*x_92 + 1.9851998090744) - 0.0680425841587386*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.455026843614448*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.00719191068314104*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.543001743629734*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.00356550889060494*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.0108998727295796*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.00448409600492333*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.344322140457232*std::sin(0.292799949645996*x_95 - 1.21631991863251) + 0.0676411232989252*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 0.0112998719756594*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.0356149613542017*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.0252672720918718*std::sin(0.262799948453903*x_97 + 1.9579998254776) - 0.511558234878828*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.00378851988601702*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.007935911147108*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 4.77363546214404);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000313216158415465*x_1 - 0.00659776565997109*x_10 + 0.00749270067608268*x_100 + 0.00282016879641482*x_101 + 0.00086154426890667*x_102 + 0.00161554056612533*x_103 + 0.00441468112377857*x_104 - 0.015649767967757*x_105 - 0.00426484411199005*x_106 + 0.0113944079983697*x_107 - 0.000680822811436776*x_108 - 0.00349023049226894*x_109 - 0.00172985510711885*x_11 + 0.0163219473798445*x_110 - 0.00091380460432655*x_111 - 0.00283665999883631*x_112 + 0.00603154333780599*x_113 - 0.00218235974547056*x_114 + 0.00929613109278564*x_115 - 0.009739576333794*x_116 + 0.0130276699328263*x_117 - 0.0016463714247323*x_118 + 0.012434765378542*x_119 + 0.0046097112592565*x_12 - 0.0159296927287294*x_120 + 0.00119370572817329*x_13 + 0.0141588428616905*x_14 - 0.000110947096274935*x_15 - 2.85136466342444e-6*x_16 - 5.41908685326292e-5*x_17 - 0.00642335037151357*x_18 - 0.00114223107764703*x_19 + 0.00279200205555645*x_2 - 0.00127636372934899*x_20 + 0.000768700348931033*x_21 + 0.00262677472017433*x_22 - 0.00165146026516516*x_23 - 0.00869799621605223*x_24 + 0.0026560760875533*x_25 - 0.00234509451134124*x_26 - 0.00610976845940403*x_27 - 0.0010596150718911*x_28 - 0.00453609235779594*x_29 - 0.000952250534550077*x_3 + 0.00271043724378737*x_30 + 0.000501506835798899*x_31 + 0.00113595483954577*x_32 - 0.00222896957080846*x_33 - 0.0103891354736165*x_34 - 0.0196150023384834*x_35 + 0.0109869421424885*x_36 - 0.0156844665474049*x_37 - 0.000877912858745254*x_38 - 0.00632299077746052*x_39 + 0.00141364872822888*x_4 + 5.09329700777554e-5*x_40 + 0.00747749474455371*x_41 + 0.00467533477413033*x_42 - 0.0188669244610374*x_43 + 0.00292822182955297*x_44 + 0.00150897750333542*x_45 + 0.00707015434458552*x_46 - 0.0103859020890785*x_47 - 0.0106688761693407*x_48 - 0.00763372581436473*x_49 - 0.00358277384919363*x_5 - 0.00844942209348138*x_50 + 0.00103926467895113*x_51 - 0.0124609003446612*x_52 - 0.00769393260806131*x_53 - 0.00650251004795036*x_54 - 0.0121581076732011*x_55 - 0.00550220832843292*x_56 - 0.00616642748922127*x_57 - 0.027622960118985*x_58 - 0.0113694005574487*x_59 - 0.00140023302155543*x_6 - 0.00739787243643509*x_60 - 0.00309220435213045*x_61 - 0.00145122479957679*x_62 + 0.00022905442385385*x_63 - 0.000387477663002653*x_64 - 0.00134972921139848*x_65 + 0.00195226109988395*x_66 + 0.00347421178304793*x_67 + 0.00385485503849938*x_68 - 0.00835363645301462*x_69 + 0.0161962843969276*x_7 - 0.00113757918453736*x_70 - 0.00238249202824268*x_71 - 0.00268266840898463*x_72 - 0.00076743406563303*x_73 - 0.0114914334331869*x_74 + 0.00843078269229723*x_75 - 0.00831780653642663*x_76 - 0.000995293774243896*x_77 - 0.00451875197979562*x_78 - 0.0105727463244917*x_79 - 0.000826055055464266*x_8 + 0.00575343710589392*x_80 - 0.0022244275062085*x_81 - 0.00622590075378843*x_82 + 0.00190616882696657*x_83 + 0.00239577664245332*x_84 - 0.00353938641706796*x_85 - 0.00456639423106604*x_86 - 0.00761777822005156*x_87 - 0.000350535895300878*x_88 - 0.00819854131085253*x_89 + 0.00394974209367086*x_9 + 0.000521908406200898*x_90 - 0.000196778191902623*x_91 - 0.00162213416456238*x_92 - 0.000762733491971581*x_93 + 0.000575890190526984*x_94 + 0.000733457914020499*x_95 - 0.00263264483981023*x_96 - 0.00244211231674692*x_97 + 0.0118896264570744*x_98 - 0.0145001041252389*x_99 - 4.18911318157234e-5*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) + 9.84691676796434e-5*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) - 4.67896537614227e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) - 0.0402915629321729*std::sin(0.217919990420341*x_1 + 5.01607990264893) - 0.00603496676274791*std::sin(0.251359969377518*x_1 - 4.32871961593628) - 0.0623321175351609*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.0268319435347652*std::sin(0.251999974250793*x_10 + 1.99783980846405) + 0.00379133113264219*std::sin(0.375039845705032*x_10 - 4.37103986740112) - 0.00556577728802344*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.0309670377907788*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.0450490244683631*std::sin(0.258399993181229*x_107 + 1.97087979316711) - 0.00771344220507852*std::sin(0.264959961175919*x_107 - 1.22583997249603) - 0.0234128591446946*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.0357273943666166*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.0424377378240517*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.0484101053073144*std::sin(0.240719974040985*x_109 + 1.97031986713409) + 0.00884838021759058*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.0379856025257874*std::sin(0.22919999063015*x_11 + 5.00559949874878) + 0.0329407430450146*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.0227977133110833*std::sin(0.324079930782318*x_11 + 1.93391978740692) + 0.0103023297575815*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.010274016148796*std::sin(0.277119934558868*x_112 - 7.6016001701355) + 0.0050836891417357*std::sin(0.290239930152893*x_113 + 1.96135985851288) - 0.00243426213814982*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.0305808893797636*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.0338303948077195*std::sin(0.232799991965294*x_118 + 5.16344022750854) - 0.043944840067534*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.0185177466943572*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.0298979749857503*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.0306744820123375*std::sin(0.272319942712784*x_120 + 1.9690397977829) + 0.0608223089126992*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0131173430359336*std::sin(0.307839930057526*x_13 - 7.44687986373901) - 0.0120052213282814*std::sin(0.316559940576553*x_13 - 7.46415996551514) - 0.00603693015676369*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.0207010166800186*std::sin(0.302559942007065*x_14 - 1.21279990673065) - 0.0073145401754294*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0261029035422866*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.0112544863244246*std::sin(0.345919847488403*x_15 - 4.35887956619263) - 0.0455402950228468*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.0344621638566767*std::sin(0.323279827833176*x_16 - 1.13703989982605) + 0.00389192321147617*std::sin(0.354799836874008*x_16 - 4.36759996414185) - 0.00647681001829322*std::sin(0.357919842004776*x_16 - 1.1639997959137) - 0.0136056634402561*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.0264612578494624*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.0124250067868154*std::sin(0.376959830522537*x_17 - 1.17751979827881) + 0.013916613361449*std::sin(0.382559835910797*x_17 - 1.17599976062775) - 0.0497456041156626*std::sin(0.388559848070145*x_17 - 1.18951988220215) + 0.0365532898785137*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.0197269719983841*std::sin(0.34215983748436*x_18 + 1.9981597661972) - 0.0720247993789375*std::sin(0.218959987163544*x_19 + 1.99543976783752) + 0.0521375955580241*std::sin(0.389999836683273*x_2 - 7.38967990875244) - 0.00327886427752985*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.0130313396409946*std::sin(0.285919934511185*x_20 + 5.19008016586304) - 0.00443133046299909*std::sin(0.32399994134903*x_20 - 1.21511995792389) + 0.0138532950292855*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.0133278879522601*std::sin(0.345839828252792*x_20 - 4.35503959655762) - 0.0493916797662407*std::sin(0.264239966869354*x_21 - 4.20663976669312) - 0.0277867357356054*std::sin(0.273359954357147*x_21 - 1.16527986526489) + 0.0122473053120305*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.0281025758561073*std::sin(0.363679856061935*x_21 - 1.16999983787537) - 0.00539115962766394*std::sin(0.309839934110641*x_22 + 2.02199983596802) - 0.0236833699088567*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0247090549088244*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.0369322242527002*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.0300851208794004*std::sin(0.301199942827225*x_24 - 1.1619998216629) - 0.0086275892384667*std::sin(0.333999842405319*x_24 + 2.01279973983765) - 0.00449986450739483*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0296527833569697*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.038211647809317*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.0138030771415164*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.0264724596166087*std::sin(0.345359832048416*x_26 - 1.14991986751556) + 0.0491374114738988*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.0260834420496072*std::sin(0.341279834508896*x_27 - 1.17215991020203) + 0.0476961717569786*std::sin(0.359519839286804*x_27 + 8.22399997711182) + 0.0437748105736886*std::sin(0.263759940862656*x_28 - 4.36847972869873) - 0.00679143007017892*std::sin(0.267519950866699*x_28 + 5.01783990859985) + 0.0295876610085432*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.031707560558876*std::sin(0.167520016431808*x_29 - 4.41631984710693) - 0.0717379707813852*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.0212632181405776*std::sin(0.382479846477509*x_29 + 8.20479965209961) - 0.00492896982887728*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.0282405868636141*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.0234817200888524*std::sin(0.360559850931168*x_3 + 1.971599817276) + 0.0406462258905699*std::sin(0.379759848117828*x_3 - 7.40215969085693) + 0.0101967694447004*std::sin(0.304399937391281*x_30 + 1.99511981010437) - 0.0127080543986638*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.00855663966349856*std::sin(0.402799874544144*x_31 + 5.18520021438599) - 0.0324936097364306*std::sin(0.432959854602814*x_31 + 5.20775985717773) + 0.00292166893984287*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.0342814079903071*std::sin(0.31127992272377*x_32 - 1.16535985469818) + 0.0173331799058806*std::sin(0.317919850349426*x_32 - 1.18943989276886) + 0.0201950765335021*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.0426213439691879*std::sin(0.241519972681999*x_34 - 1.18687987327576) - 0.00306748721677824*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.0321279131126703*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.0457749520281989*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.0389022260003543*std::sin(0.215199992060661*x_36 + 1.98215985298157) + 0.0423398539063933*std::sin(0.235199987888336*x_36 - 1.18823993206024) - 0.0454743226240106*std::sin(0.241599977016449*x_37 + 1.95127987861633) - 0.0110118411005205*std::sin(0.242719978094101*x_38 + 1.96239984035492) - 0.00575801701984535*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.0262314519080411*std::sin(0.317439913749695*x_4 + 2.014319896698) - 0.0686025354415475*std::sin(0.323519825935364*x_4 + 2.02319979667664) + 0.00205888082949331*std::sin(0.254159957170486*x_41 + 1.95487987995148) - 0.105578121717073*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.0317434492450952*std::sin(0.233439981937408*x_44 - 1.19471991062164) - 0.0365847051266384*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.0380131252748146*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0407478536053574*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.0514023963215335*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.0452981710077576*std::sin(0.200479999184608*x_47 - 1.20559990406036) - 0.00686151564330571*std::sin(0.211520001292229*x_47 - 1.1898398399353) + 0.00482476011521311*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.0469928099142566*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.0487955293481454*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.0210194651547933*std::sin(0.28519994020462*x_5 - 1.17671978473663) - 0.00484912592986439*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.0273380568948641*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 0.0195794908016888*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.0539416275046248*std::sin(0.171040013432503*x_50 - 1.1548798084259) - 0.097234120262295*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0328947082185884*std::sin(0.195439994335175*x_53 + 5.20183992385864) + 0.011220652393091*std::sin(0.234479993581772*x_53 - 7.41767978668213) + 0.00731208270545235*std::sin(0.195119991898537*x_54 - 7.38695955276489) + 0.010901979171418*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.0370367847189458*std::sin(0.387679845094681*x_6 + 2.00447988510132) + 0.00514704758187852*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.0173442800153378*std::sin(0.312079936265945*x_7 - 1.16279983520508) + 0.00374923273781836*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.0256348234479396*std::sin(0.315919935703278*x_8 + 5.16639995574951) + 0.00511659497459131*std::sin(0.318479925394058*x_8 + 1.95895981788635) - 0.0639807569470901*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.0298984710169335*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.0269226304831061*std::sin(0.339839845895767*x_9 - 4.35839986801147) + 0.00510756614178567*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.0185781782377334*std::sin(0.339999854564667*x_91 + 5.20272016525269) + 0.00447966209144898*std::sin(0.367439836263657*x_91 + 1.99071979522705) - 0.0304455455405108*std::sin(0.385519832372665*x_91 - 4.3854398727417) - 0.0189923581252961*std::sin(0.291199922561646*x_92 + 1.9851998090744) + 0.0183579639124914*std::sin(0.297839939594269*x_92 - 1.19751989841461) - 0.055644183599023*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.0386057204462669*std::sin(0.23735998570919*x_93 + 1.97199988365173) - 0.0664024312876014*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.0191394256052212*std::sin(0.284879922866821*x_94 + 5.16616010665894) + 0.0087242931734193*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.0240703429793828*std::sin(0.268399953842163*x_95 + 1.97319984436035) + 0.0421063606898871*std::sin(0.292799949645996*x_95 - 1.21631991863251) - 0.0182496493317351*std::sin(0.301199942827225*x_95 + 8.17088031768799) - 0.00904445385589013*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.0301216821485983*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.0213700284873036*std::sin(0.262799948453903*x_97 + 1.9579998254776) + 0.0625572770983787*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.0203365344855504*std::sin(0.277999937534332*x_97 - 1.21655988693237) + 0.00635192879433254*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 0.0721159115181335);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.92967310115384e-5*x_1 - 0.0662291386846565*x_10 - 0.0196587543146376*x_100 + 0.0318352826153927*x_101 + 0.0134929321375672*x_102 + 0.0348775391812305*x_103 + 0.0488418224051659*x_104 - 0.133441184725426*x_105 - 0.122453504017411*x_106 + 0.122605030388058*x_107 - 0.00371386982771006*x_108 + 0.000491023797264986*x_109 - 0.00100114465790681*x_11 + 0.133252016296669*x_110 + 0.134848300862636*x_111 - 0.12521302537145*x_112 + 0.0573411072360218*x_113 - 0.0121858822507258*x_114 + 0.129914830597498*x_115 - 0.0288003700404487*x_116 - 0.00981323249839772*x_117 + 0.0186328156422025*x_118 + 0.00994270028131465*x_119 + 0.0582856640352051*x_12 - 0.138322069034035*x_120 + 0.000899421532261614*x_13 + 0.125291399157126*x_14 + 0.000174344463429111*x_15 - 2.17508629174489e-6*x_16 + 8.51566035911948e-5*x_17 - 0.00590707764140448*x_18 - 0.00344683774316729*x_19 + 0.00254386406721886*x_2 - 0.0175622971466156*x_20 - 0.00120795094573763*x_21 + 0.0016716597582354*x_22 - 0.0304830108732405*x_23 - 0.0585588665669016*x_24 + 0.0520454668246691*x_25 - 0.000512898577226566*x_26 - 0.00821571993212387*x_27 - 0.00179699844207829*x_28 - 0.00288221729949112*x_29 - 0.000841158958743953*x_3 - 0.0155234920756031*x_30 + 0.000561351116646512*x_31 + 0.00118956507140111*x_32 + 0.0138607367270086*x_33 - 0.0810220477600413*x_34 - 0.1952611885845*x_35 + 0.00791592784839419*x_36 - 0.215922470477085*x_37 - 0.123613960225576*x_38 - 0.00142895097993591*x_39 + 0.00124602388754551*x_4 - 0.0127746982199427*x_40 + 0.103192290182283*x_41 + 0.00653075675044953*x_42 - 0.223637103097942*x_43 - 0.0191289321558912*x_44 - 0.00235225895250269*x_45 - 0.0175472016357114*x_46 - 0.200726541489476*x_47 - 0.105091224012416*x_48 + 0.00790931907352184*x_49 - 0.0492976551290404*x_5 - 0.0950763588310346*x_50 + 0.00306255158575127*x_51 - 0.0431213461661719*x_52 - 0.035637955962735*x_53 - 0.0552240029693385*x_54 - 0.0283372734204518*x_55 - 0.0504276503964828*x_56 - 0.0222618090477907*x_57 - 0.172563626178664*x_58 - 0.0820620200115605*x_59 - 0.00132601706973741*x_6 - 0.0762547986491509*x_60 - 0.00334715859643449*x_61 - 0.0132949671820895*x_62 + 0.0138928749384922*x_63 - 0.0108187780569998*x_64 + 0.0474188474585362*x_65 + 0.0252593777096391*x_66 + 0.073778230816547*x_67 + 0.091760311010925*x_68 - 0.0594721089511737*x_69 + 0.204503577988253*x_7 - 0.00936614899113895*x_70 - 0.0153056914276047*x_71 - 0.0226411321980698*x_72 + 0.04588045180546*x_73 - 0.0760137306898764*x_74 + 0.0348412334026411*x_75 - 0.117491748666851*x_76 - 0.00563573420533628*x_77 + 0.0302333645972539*x_78 - 0.0891573958960264*x_79 - 0.000867726359545465*x_8 + 0.0723255620721098*x_80 + 0.00918852942613282*x_81 - 0.0293212149920966*x_82 + 0.019745191337503*x_83 - 0.0524602976516271*x_84 - 0.0665404443600778*x_85 - 0.0308428950767038*x_86 - 0.0688950830951773*x_87 - 0.0150329842050776*x_88 - 0.102276340854043*x_89 + 0.029858108501015*x_9 + 0.0183640075503051*x_90 - 3.95327642547192e-5*x_91 - 0.00168060909841972*x_92 - 0.17278599920834*x_93 + 0.000507931014166584*x_94 - 0.00127581215856379*x_95 + 0.0342473489081763*x_96 + 0.00113838750594348*x_97 + 0.0969055762676951*x_98 - 0.140458501881743*x_99 - 0.000576406621277952*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) + 0.0013548996597168*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) - 4.13310730841902e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) - 0.0421930822139354*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 0.0094834662410314*std::sin(0.251359969377518*x_1 - 4.32871961593628) - 0.857667093445702*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.0237016718456804*std::sin(0.251999974250793*x_10 + 1.99783980846405) - 0.00595777279618556*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.0087461726122309*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.0236223659003249*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.0343644279647969*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.0121210557787234*std::sin(0.264959961175919*x_107 - 1.22583997249603) - 0.0206814651237505*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.0374135123608383*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.0323724786863637*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.0506947709289726*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.0139045198391651*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.0335541212197374*std::sin(0.22919999063015*x_11 + 5.00559949874878) + 0.453252551983696*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.0173906180230606*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.016189284929137*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.0107588878784175*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.00798860975558984*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.00382524771328704*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.0233278030455094*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.025806600234084*std::sin(0.232799991965294*x_118 + 5.16344022750854) - 0.604664894167883*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.0141257614312045*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.031308979468668*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.0233991976499004*std::sin(0.272319942712784*x_120 + 1.9690397977829) + 0.836892680124102*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0137364026824981*std::sin(0.307839930057526*x_13 - 7.44687986373901) - 0.010604666635088*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.00948655155725575*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.0157912097962997*std::sin(0.302559942007065*x_14 - 1.21279990673065) - 0.00646121033742665*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0199118928553248*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.0117856303455253*std::sin(0.345919847488403*x_15 - 4.35887956619263) - 0.626617769641347*std::sin(0.361199855804443*x_15 + 5.0304799079895) - 0.0360885705854264*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.00611584518021687*std::sin(0.354799836874008*x_16 - 4.36759996414185) - 0.00572121156492081*std::sin(0.357919842004776*x_16 - 1.1639997959137) - 0.187208942655004*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.0201852537309519*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.0130113923291418*std::sin(0.376959830522537*x_17 - 1.17751979827881) + 0.0122930716020963*std::sin(0.382559835910797*x_17 - 1.17599976062775) - 0.68448128157228*std::sin(0.388559848070145*x_17 - 1.18951988220215) + 0.502959872465403*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.017425581423456*std::sin(0.34215983748436*x_18 + 1.9981597661972) - 0.991034843385474*std::sin(0.218959987163544*x_19 + 1.99543976783752) + 0.717394207188193*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.0051524722351113*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.0136463404449163*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 0.00696348041353104*std::sin(0.32399994134903*x_20 - 1.21511995792389) + 0.0122371401214412*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.0101668182799379*std::sin(0.345839828252792*x_20 - 4.35503959655762) - 0.679611412232495*std::sin(0.264239966869354*x_21 - 4.20663976669312) - 0.0290981024320882*std::sin(0.273359954357147*x_21 - 1.16527986526489) + 0.0108185085856154*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.0214372887100064*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.00847177496395733*std::sin(0.309839934110641*x_22 + 2.02199983596802) - 0.325874490326283*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0188486331838066*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.0281727467994993*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.0315049575221894*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.013557564523724*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.00707117616761544*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0261934264853878*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.0291487204008522*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.0105293034803737*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.0233841260871741*std::sin(0.345359832048416*x_26 - 1.14991986751556) + 0.676112773715598*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.0230404921382084*std::sin(0.341279834508896*x_27 - 1.17215991020203) + 0.656281843404716*std::sin(0.359519839286804*x_27 + 8.22399997711182) + 0.602325350645971*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.0106721876575077*std::sin(0.267519950866699*x_28 + 5.01783990859985) + 0.0261359014488497*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.03320396659013*std::sin(0.167520016431808*x_29 - 4.41631984710693) - 0.987088187001772*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.0162200699507887*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.00774548076449324*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.029573372601905*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.0179123940641509*std::sin(0.360559850931168*x_3 + 1.971599817276) + 0.559277171988226*std::sin(0.379759848117828*x_3 - 7.40215969085693) + 0.0106779955947861*std::sin(0.304399937391281*x_30 + 1.99511981010437) - 0.011225505702333*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.00652720077309378*std::sin(0.402799874544144*x_31 + 5.18520021438599) - 0.447100161525604*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.00459116841032174*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.026150643422746*std::sin(0.31127992272377*x_32 - 1.16535985469818) + 0.015311054215623*std::sin(0.317919850349426*x_32 - 1.18943989276886) + 0.277876851891512*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.0325125376604012*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.00482031013736123*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.0283798023313672*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.034918182138878*std::sin(0.254799962043762*x_35 - 1.21839988231659) - 0.0407381769404477*std::sin(0.215199992060661*x_36 + 1.98215985298157) + 0.58258087279528*std::sin(0.235199987888336*x_36 - 1.18823993206024) - 0.0401691912791337*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.0173042250991351*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.00904826193245243*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.020009952493843*std::sin(0.317439913749695*x_4 + 2.014319896698) - 0.943945745818242*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.00323536609370091*std::sin(0.254159957170486*x_41 + 1.95487987995148) - 1.45271626194088*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.0242146303457323*std::sin(0.233439981937408*x_44 - 1.19471991062164) - 0.503392134766356*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.0289972828632627*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0426709070607783*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.0392109255739776*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.0474359720591794*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.0107823215145546*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.00758172355747398*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.0415105286074795*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.037222347721782*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.0160341295887045*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.00762001248097012*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.024148740943088*std::sin(0.366639852523804*x_5 - 1.15463984012604) + 0.0205035249313447*std::sin(0.378639847040176*x_5 + 2.02248001098633) + 0.056487347683372*std::sin(0.171040013432503*x_50 - 1.1548798084259) - 1.33790585988147*std::sin(0.197199985384941*x_51 - 1.18839991092682) - 0.0344471404747134*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 0.0176323552979726*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.0114903515155753*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.017131585888883*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.0282525079186948*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.00808817246269335*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.0181628256481536*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 0.00589161854516669*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.0195548306353595*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.00804031863275309*std::sin(0.318479925394058*x_8 + 1.95895981788635) - 0.880351767550858*std::sin(0.355119854211807*x_8 - 1.16895985603333) + 0.0313094989095377*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.0205371993462206*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.00802613054614477*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.0141718599970151*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.00703942969126491*std::sin(0.367439836263657*x_91 + 1.99071979522705) - 0.418919548776264*std::sin(0.385519832372665*x_91 - 4.3854398727417) - 0.0198886831261948*std::sin(0.291199922561646*x_92 + 1.9851998090744) + 0.0162162847370692*std::sin(0.297839939594269*x_92 - 1.19751989841461) - 0.765643573517494*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.0294493280367594*std::sin(0.23735998570919*x_93 + 1.97199988365173) - 0.913673118966951*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.0145999923474505*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.0137095270014892*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.018361409090753*std::sin(0.268399953842163*x_95 + 1.97319984436035) + 0.57936809170811*std::sin(0.292799949645996*x_95 - 1.21631991863251) - 0.0161206063660312*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 0.0142126338359228*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.0315432442632549*std::sin(0.278559952974319*x_96 + 1.97535979747772) + 0.022378565219642*std::sin(0.262799948453903*x_97 + 1.9579998254776) + 0.860765206517788*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.0155131744278523*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.00998154665214089*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 2.35295918142868);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00446960186496459*x_1 + 0.0220921485245618*x_10 + 0.0108108966126938*x_100 - 0.0156583083986108*x_101 - 0.00994443631864973*x_102 - 0.0197871596403*x_103 - 0.0192939849897567*x_104 + 0.0463683282873209*x_105 + 0.0524732328748494*x_106 - 0.0528869773178554*x_107 + 0.00105608293008707*x_108 - 0.00312276263575598*x_109 + 0.000418160353222802*x_11 - 0.041267456725745*x_110 - 0.0660563721175467*x_111 + 0.0511919545762655*x_112 - 0.0234689934760682*x_113 - 0.00548616682144449*x_114 - 0.0507522862155002*x_115 + 0.0144296933769859*x_116 + 0.0129151845663473*x_117 - 0.00631242984478699*x_118 - 0.00105791657823678*x_119 - 0.0222525607045171*x_12 + 0.0621370130732139*x_120 + 0.00137630292031284*x_13 - 0.0556799153238463*x_14 - 0.000217482988761804*x_15 - 3.27826833963285e-6*x_16 - 0.000106227133902348*x_17 + 0.000200769185094728*x_18 + 0.00565551603876015*x_19 - 0.00150638804892685*x_2 + 0.00727709217719937*x_20 + 0.00150683753753663*x_21 + 0.0072960832797156*x_22 + 0.0127326452302784*x_23 + 0.0277732670450385*x_24 - 0.0212149150921071*x_25 - 0.000297772991301432*x_26 - 0.00613270923031942*x_27 + 0.00528747228634628*x_28 + 0.0036088737518059*x_29 + 0.00105244200945202*x_3 + 0.0145257063477586*x_30 - 0.000398868806027216*x_31 - 0.000819554717616553*x_32 - 0.00263633853786415*x_33 + 0.0325476397198349*x_34 + 0.082596401865274*x_35 - 0.0030976116608556*x_36 + 0.0979371799481156*x_37 + 0.0631032814939638*x_38 + 0.00916871688469736*x_39 - 0.00156872281315343*x_4 - 0.0093731725930949*x_40 - 0.0542770043170557*x_41 - 1.79476313971754e-5*x_42 + 0.0811786556185826*x_43 + 0.0083195838155094*x_44 + 0.00293425919331035*x_45 + 0.00808099592818934*x_46 + 0.0798534825988561*x_47 + 0.0306044801130945*x_48 + 0.0029296366787041*x_49 + 0.0204269166783199*x_5 + 0.048790151162435*x_50 - 0.00134940154644171*x_51 + 0.0129908568562536*x_52 + 0.0217885867118814*x_53 + 0.0289074809593605*x_54 - 0.0010940571369816*x_55 + 0.0311196732292479*x_56 - 0.00107647874589077*x_57 + 0.0611439746938095*x_58 + 0.022928742039194*x_59 + 0.00133879924661324*x_6 + 0.0286481225734847*x_60 + 0.00318764539389975*x_61 + 0.0063032368406911*x_62 - 0.00428929409054929*x_63 + 0.00310314978288615*x_64 - 0.0247519298909377*x_65 - 0.00930362630627746*x_66 - 0.0387582541560988*x_67 - 0.0361252117461663*x_68 + 0.0194718365013631*x_69 - 0.0808059394357685*x_7 + 0.0123082128854096*x_70 + 0.00231814770451909*x_71 + 0.0108867743991462*x_72 - 0.024573840912263*x_73 + 0.0277318249569624*x_74 - 0.0124991048263627*x_75 + 0.0546724964714947*x_76 + 0.000838147125626824*x_77 - 0.0166241199415729*x_78 + 0.037660530140946*x_79 + 0.000589680359558974*x_8 - 0.029408222650481*x_80 - 0.0016091005804886*x_81 + 0.00918844918463468*x_82 - 0.0114726410786835*x_83 + 0.0252884930842689*x_84 + 0.0248019901779234*x_85 + 0.0173755035774356*x_86 + 0.0309890641868723*x_87 + 0.00757499616421083*x_88 + 0.0396053466680193*x_89 - 0.0137778172695412*x_9 - 0.000130485501546963*x_90 + 0.000531984156359414*x_91 - 0.00171110303950361*x_92 + 0.0671577194707515*x_93 - 0.000638296837766678*x_94 + 0.00156396522364801*x_95 - 0.0159277324264647*x_96 - 0.00141642124386553*x_97 - 0.0340222011579921*x_98 + 0.0594911137497906*x_99 + 0.000238839149546905*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 0.000561414582175845*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) + 5.17126485515732e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) + 0.0290690609623271*std::sin(0.217919990420341*x_1 + 5.01607990264893) - 0.0118299861168794*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.355381898179408*std::sin(0.351279854774475*x_1 - 4.22824001312256) + 0.0296550787283872*std::sin(0.251999974250793*x_10 + 1.99783980846405) + 0.00743192074238161*std::sin(0.375039845705032*x_10 - 4.37103986740112) - 0.010910261917827*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.0356033940042599*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.0517937226831646*std::sin(0.258399993181229*x_107 + 1.97087979316711) - 0.0151202016161364*std::sin(0.264959961175919*x_107 - 1.22583997249603) + 0.0258762538126605*std::sin(0.246479973196983*x_108 + 5.1735200881958) + 0.0257761607961597*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.0487914766212837*std::sin(0.263439953327179*x_108 + 1.9554398059845) - 0.0349263270015102*std::sin(0.240719974040985*x_109 + 1.97031986713409) + 0.0173449530454919*std::sin(0.245199963450432*x_109 - 7.44343996047974) + 0.0419822750442184*std::sin(0.22919999063015*x_11 + 5.00559949874878) - 0.187809178537435*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.0262109658306536*std::sin(0.324079930782318*x_11 + 1.93391978740692) + 0.0201950437831755*std::sin(0.20728000998497*x_111 - 7.41167974472046) - 0.00741237073031999*std::sin(0.277119934558868*x_112 - 7.6016001701355) + 0.0099652532206955*std::sin(0.290239930152893*x_113 + 1.96135985851288) - 0.00477173917127677*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.0351594318108341*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.038895450181469*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.250548213279955*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.0212902065765748*std::sin(0.3018399477005*x_12 + 1.93759989738464) + 0.0215704230430069*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.0352670370456627*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.346773837433911*std::sin(0.290079921483994*x_13 + 5.14888000488281) + 0.00946373922047175*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.0132683561733283*std::sin(0.316559940576553*x_13 - 7.46415996551514) - 0.0118338348412986*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.0238003537221415*std::sin(0.302559942007065*x_14 - 1.21279990673065) + 0.00808414286066394*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0300110060816976*std::sin(0.326959848403931*x_15 + 5.06239986419678) + 0.00811974828613907*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 0.259644580175544*std::sin(0.361199855804443*x_15 + 5.0304799079895) + 0.0248633378588427*std::sin(0.323279827833176*x_16 - 1.13703989982605) + 0.00762910540683073*std::sin(0.354799836874008*x_16 - 4.36759996414185) + 0.00715827054243885*std::sin(0.357919842004776*x_16 - 1.1639997959137) + 0.0775716707628438*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.0304230128638026*std::sin(0.300399929285049*x_17 - 1.15783989429474) - 0.00896424098393212*std::sin(0.376959830522537*x_17 - 1.17751979827881) - 0.0153808561922313*std::sin(0.382559835910797*x_17 - 1.17599976062775) + 0.283620834904785*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.208405843655168*std::sin(0.331519842147827*x_18 + 8.21232032775879) - 0.0218025543668426*std::sin(0.34215983748436*x_18 + 1.9981597661972) + 0.410643997532079*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.297258594904448*std::sin(0.389999836683273*x_2 - 7.38967990875244) - 0.00642736247061751*std::sin(0.406159847974777*x_2 - 7.39583969116211) + 0.0094016905495215*std::sin(0.285919934511185*x_20 + 5.19008016586304) - 0.00868647333406594*std::sin(0.32399994134903*x_20 - 1.21511995792389) - 0.0153108757928307*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.0153233269909414*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.281602961742711*std::sin(0.264239966869354*x_21 - 4.20663976669312) + 0.0200472321315043*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.0135359111339915*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.0323100674820608*std::sin(0.363679856061935*x_21 - 1.16999983787537) - 0.0105679693122461*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.135028959167749*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0284084717219458*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.042461682657749*std::sin(0.294239938259125*x_24 + 8.23031997680664) + 0.0217054427591823*std::sin(0.301199942827225*x_24 - 1.1619998216629) - 0.0169121496315791*std::sin(0.333999842405319*x_24 + 2.01279973983765) - 0.00882081654184297*std::sin(0.305119931697845*x_25 + 1.99959981441498) - 0.0327727145008112*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.0439326603241412*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.0158696610654487*std::sin(0.33111983537674*x_26 - 1.14807987213135) + 0.0292577715455993*std::sin(0.345359832048416*x_26 - 1.14991986751556) - 0.280153270123806*std::sin(0.352879852056503*x_26 - 4.36879968643188) + 0.0288278233176148*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.271936149856045*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.249578802859474*std::sin(0.263759940862656*x_28 - 4.36847972869873) - 0.0133128361103668*std::sin(0.267519950866699*x_28 + 5.01783990859985) - 0.0327007402747525*std::sin(0.305919945240021*x_28 - 1.17223989963531) - 0.0228759805720184*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.409008665772448*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.0244467274646121*std::sin(0.382479846477509*x_29 + 8.20479965209961) - 0.00966196616128262*std::sin(0.280479967594147*x_3 + 2.05519986152649) - 0.020374671057865*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.0269973814695995*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.231741411683495*std::sin(0.379759848117828*x_3 - 7.40215969085693) - 0.00735663972891225*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 0.014045138146207*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.00983773182796104*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.18525988147795*std::sin(0.432959854602814*x_31 + 5.20775985717773) + 0.00572717371200918*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.0394139886399832*std::sin(0.31127992272377*x_32 - 1.16535985469818) - 0.0191568983460403*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.115140715832507*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.0490025721083967*std::sin(0.241519972681999*x_34 - 1.18687987327576) - 0.00601301260053144*std::sin(0.240319982171059*x_35 - 1.21359980106354) - 0.0355082661641923*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.0526283354448373*std::sin(0.254799962043762*x_35 - 1.21839988231659) + 0.0280666992511114*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.24139750492842*std::sin(0.235199987888336*x_36 - 1.18823993206024) + 0.0502589242478039*std::sin(0.241599977016449*x_37 + 1.95127987861633) - 0.0215858566354596*std::sin(0.242719978094101*x_38 + 1.96239984035492) - 0.0112870980211513*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.0301588005896994*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.39113221609044*std::sin(0.323519825935364*x_4 + 2.02319979667664) + 0.00403590153628695*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 0.601945751014554*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.036496049062332*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.208584955338709*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.0437044151796631*std::sin(0.220799997448921*x_45 - 1.18895995616913) + 0.0293982599417181*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.0590983154851071*std::sin(0.198320001363754*x_47 - 1.18783986568451) + 0.0326811669411557*std::sin(0.200479999184608*x_47 - 1.20559990406036) - 0.0134502206875614*std::sin(0.211520001292229*x_47 - 1.1898398399353) + 0.00945769006261366*std::sin(0.212239995598793*x_48 + 1.98431980609894) + 0.0519371798718125*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.0561011508031863*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.0241664800075828*std::sin(0.28519994020462*x_5 - 1.17671978473663) - 0.0095054529187126*std::sin(0.356399834156036*x_5 - 1.15343987941742) + 0.0302144430368197*std::sin(0.366639852523804*x_5 - 1.15463984012604) - 0.0141259700618648*std::sin(0.378639847040176*x_5 + 2.02248001098633) - 0.0389171415608452*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 0.554373051856083*std::sin(0.197199985384941*x_51 - 1.18839991092682) + 0.0237324692555067*std::sin(0.195439994335175*x_53 + 5.20183992385864) + 0.021995176982906*std::sin(0.234479993581772*x_53 - 7.41767978668213) + 0.0143334404797266*std::sin(0.195119991898537*x_54 - 7.38695955276489) + 0.0213705008353118*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.0425818978201472*std::sin(0.387679845094681*x_6 + 2.00447988510132) + 0.0100894509995306*std::sin(0.42375984787941*x_6 - 7.41519975662231) - 0.0125133376921185*std::sin(0.312079936265945*x_7 - 1.16279983520508) + 0.00734939776489266*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.0294728454692043*std::sin(0.315919935703278*x_8 + 5.16639995574951) + 0.0100297565661404*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.364781492269795*std::sin(0.355119854211807*x_8 - 1.16895985603333) - 0.0215707809134804*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.0309534617807891*std::sin(0.339839845895767*x_9 - 4.35839986801147) + 0.0100120578826279*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.0213596858746481*std::sin(0.339999854564667*x_91 + 5.20272016525269) + 0.0087812149484022*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.173582996906707*std::sin(0.385519832372665*x_91 - 4.3854398727417) + 0.0137023728042512*std::sin(0.291199922561646*x_92 + 1.9851998090744) - 0.0202895054699432*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.317251143905217*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.0443857331512684*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.378588487089404*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.0220049626781165*std::sin(0.284879922866821*x_94 + 5.16616010665894) + 0.0171017125990172*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.0276741324340627*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.240066260847915*std::sin(0.292799949645996*x_95 - 1.21631991863251) + 0.0201697945211034*std::sin(0.301199942827225*x_95 + 8.17088031768799) - 0.0177293045274732*std::sin(0.271919965744019*x_96 + 1.98279976844788) - 0.0217318205337293*std::sin(0.278559952974319*x_96 + 1.97535979747772) - 0.0154177851554143*std::sin(0.262799948453903*x_97 + 1.9579998254776) - 0.356665628560049*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.0233813015911348*std::sin(0.277999937534332*x_97 - 1.21655988693237) + 0.0124513079204011*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 3.01954843398975);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00181080410623128*x_1 + 0.000283057627712546*x_10 + 0.00472985052128848*x_100 - 0.00213331119134116*x_101 - 0.00291649436382165*x_102 - 0.00549042596986624*x_103 - 0.000701837388083958*x_104 - 0.000984260718898946*x_105 + 0.00561719048492073*x_106 - 0.00738891337631159*x_107 + 0.000342202036756204*x_108 - 0.00240606426692028*x_109 + 0.000984805733818376*x_11 - 0.00452590032467485*x_110 - 0.0155901040938115*x_111 + 0.00855659713947961*x_112 - 0.00129430038725612*x_113 - 0.00805626044636112*x_114 - 0.00996512888298108*x_115 + 0.00648449659109454*x_116 + 0.00490152572950151*x_117 - 0.000784266997196955*x_118 + 0.00149454036096811*x_119 - 0.00400603470078685*x_12 + 0.00954676836040809*x_120 + 0.0010071405159442*x_13 - 0.00791108560213803*x_14 + 2.16868136498406e-5*x_15 - 2.4176428529917e-6*x_16 + 1.05926816189749e-5*x_17 + 0.000740679293837426*x_18 + 0.00195592603750866*x_19 - 0.000104691702847104*x_2 + 0.00110490992720245*x_20 - 0.000150257751482956*x_21 + 0.00428170055400961*x_22 + 0.00102747020501556*x_23 + 0.00342035355964567*x_24 - 0.00256131995837375*x_25 + 0.00118826823267961*x_26 - 0.00708370265952134*x_27 + 0.00431200687147201*x_28 + 8.95575144449417e-5*x_29 + 0.00492318931421987*x_30 - 0.000332642477334156*x_31 - 0.00073921644872319*x_32 - 0.00152961120922922*x_33 + 0.00820080190833241*x_34 + 0.0157183048378595*x_35 + 0.0026327477349645*x_36 + 0.0188758798547446*x_37 + 0.0104589419873924*x_38 + 0.0077462681710137*x_39 + 1.07450016125174e-5*x_4 - 0.00878413528231044*x_40 - 0.0141707469799174*x_41 + 0.00447416594237954*x_42 + 0.0043752233077936*x_43 - 0.00190636355833739*x_44 - 0.00029344841274415*x_45 + 0.000374045381270481*x_46 + 0.012878011518766*x_47 - 0.00325547445630594*x_48 + 0.00126540061854819*x_49 + 0.00310150022432437*x_5 + 0.0101420255895171*x_50 + 0.00414335083900718*x_51 + 0.00294708140285661*x_52 + 0.00307424492514155*x_53 + 0.0041380582169287*x_54 - 0.00690888896920404*x_55 + 0.00917598681518469*x_56 - 0.00415083827684589*x_57 + 0.00703450386763164*x_58 - 0.00340092554959557*x_59 + 0.000354006996010994*x_6 - 0.00355732172226844*x_60 + 0.000836422101788464*x_61 + 0.00046018217563934*x_62 + 0.000372460041160462*x_63 + 0.00139071869201259*x_64 - 0.00658452362303473*x_65 + 0.00120475442149783*x_66 - 0.00841143523149682*x_67 - 0.00616574974915099*x_68 + 0.000679983260305996*x_69 - 0.0108940911161989*x_7 + 0.00515524753621195*x_70 - 0.00316651437662769*x_71 - 7.76374658119595e-5*x_72 - 0.00563524105731977*x_73 - 0.000814833034617371*x_74 - 0.00108983302138001*x_75 + 0.00955144665031682*x_76 + 0.000386945597434532*x_77 - 0.00341283052823987*x_78 + 0.0047897340801225*x_79 + 0.000548220025276779*x_8 - 0.00366415123991887*x_80 + 0.00217319455713466*x_81 + 0.00215382690434966*x_82 - 0.00238703889151044*x_83 + 0.00476907813866375*x_84 + 0.00269912954396731*x_85 + 0.00118800004621196*x_86 + 0.00643524448947428*x_87 + 0.00219016441944148*x_88 + 0.00250773359171475*x_89 - 0.00177279141880928*x_9 + 0.00400258059834779*x_90 - 0.000533320051946254*x_91 - 0.00157349599181846*x_92 + 0.00797811793851032*x_93 + 3.07627673425355e-6*x_94 - 0.00012194196695849*x_95 - 0.00465425233709477*x_96 + 0.000262425109064258*x_97 - 3.32521209037602e-5*x_98 + 0.0129231591555936*x_99 + 3.62639005955986e-5*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 8.52418150021343e-5*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) + 0.0262195159766539*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 0.00117965412309996*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.0539590509072811*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.000741090975059846*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.00108794172100517*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.0262566337282465*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.0381966057997592*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.00150774548696454*std::sin(0.264959961175919*x_107 - 1.22583997249603) + 0.0232494080454675*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.0359825226368044*std::sin(0.263439953327179*x_108 + 1.9554398059845) - 0.0315026133802097*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.00172959166417747*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.0285158165834325*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.0193299472908878*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.0020137949807917*std::sin(0.20728000998497*x_111 - 7.41167974472046) - 0.00668576026726075*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.00099370801735392*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.000475824885349831*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.025929222451092*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.0286844447747846*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.0380417344393733*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.0157010074941997*std::sin(0.3018399477005*x_12 + 1.93759989738464) + 0.0194559450108232*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.0260085786843151*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.0526520547142879*std::sin(0.290079921483994*x_13 + 5.14888000488281) + 0.00853603981262495*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.00118003790745819*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.0175521797222537*std::sin(0.302559942007065*x_14 - 1.21279990673065) + 0.0221323841881206*std::sin(0.326959848403931*x_15 + 5.06239986419678) + 0.00732379591452027*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 0.0394228721025601*std::sin(0.361199855804443*x_15 + 5.0304799079895) + 0.0224260661556191*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.000760753694874673*std::sin(0.354799836874008*x_16 - 4.36759996414185) + 0.0117780161372825*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.022436229129701*std::sin(0.300399929285049*x_17 - 1.15783989429474) - 0.00808550575477443*std::sin(0.376959830522537*x_17 - 1.17751979827881) + 0.0430632824783524*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.0316430903902907*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.0623497158440435*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.0451339579681647*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.00064091914937276*std::sin(0.406159847974777*x_2 - 7.39583969116211) + 0.0084800735699789*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 0.000866191556142908*std::sin(0.32399994134903*x_20 - 1.21511995792389) - 0.0113005794967514*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.0427569007486283*std::sin(0.264239966869354*x_21 - 4.20663976669312) + 0.0180820675232981*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.023827885833297*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.0010538092309506*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.0205019853825293*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0209505542278675*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.0313144541471567*std::sin(0.294239938259125*x_24 + 8.23031997680664) + 0.0195777291857579*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.00168643368185444*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.000879587896375169*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0323992642583576*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.0117034875365265*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.0425367882885817*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.0412891501474415*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.0378945449891037*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.00132751990176392*std::sin(0.267519950866699*x_28 + 5.01783990859985) - 0.020633523004647*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.0621014169010746*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.0180288645744218*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.000963465054548682*std::sin(0.280479967594147*x_3 + 2.05519986152649) - 0.0183774086824852*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.0199099096222177*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.0351862227491458*std::sin(0.379759848117828*x_3 - 7.40215969085693) - 0.00663549239367175*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 0.007255087009193*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.028128746643981*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.000571098225841664*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.0290668542264674*std::sin(0.31127992272377*x_32 - 1.16535985469818) - 0.01748227408018*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.0361382004041023*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.000599601304379219*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.0388121123322414*std::sin(0.254799962043762*x_35 - 1.21839988231659) + 0.0253154125061061*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.0366523458962098*std::sin(0.235199987888336*x_36 - 1.18823993206024) + 0.00215248306541391*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.00112551879494486*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.0222413790289829*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.0593871642523762*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.000402449152574514*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 0.0913958240101998*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.026914945037069*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.0316702856315221*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.0322309390375067*std::sin(0.220799997448921*x_45 - 1.18895995616913) + 0.0265164446566284*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.0435835646304718*std::sin(0.198320001363754*x_47 - 1.18783986568451) + 0.0294775390185404*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.00134121951910385*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.000943095196151148*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.0413732288611624*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.0178221889178367*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.0009478579785899*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.0127412474108744*std::sin(0.378639847040176*x_5 + 2.02248001098633) - 0.035102221438893*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 0.0841726713711962*std::sin(0.197199985384941*x_51 - 1.18839991092682) + 0.0214060529033475*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 0.00219329938005396*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.00142929180077327*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.00213100836924201*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.0314031098940581*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.00100609268293469*std::sin(0.42375984787941*x_6 - 7.41519975662231) - 0.0112866961187694*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 0.000732862007613602*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.0217355038770044*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.00100014011597653*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.0553862287647614*std::sin(0.355119854211807*x_8 - 1.16895985603333) - 0.0194562678004245*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.0228274222536821*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.000998375251269784*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.0157522467800101*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.000875638932908756*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.0263557986906778*std::sin(0.385519832372665*x_91 - 4.3854398727417) + 0.012359174007194*std::sin(0.291199922561646*x_92 + 1.9851998090744) + 0.0481695064156948*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.032733394405407*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.0574825998522155*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.0162281226664488*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.00170533638671952*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.0204089969338662*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.0364502177983017*std::sin(0.292799949645996*x_95 - 1.21631991863251) + 0.00176791815128905*std::sin(0.271919965744019*x_96 + 1.98279976844788) - 0.0196015212333256*std::sin(0.278559952974319*x_96 + 1.97535979747772) - 0.0139064300952445*std::sin(0.262799948453903*x_97 + 1.9579998254776) - 0.0541539648106485*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.017243139007889*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.00124161064782069*std::sin(0.251839965581894*x_98 + 1.98623991012573) - 1.23611497879028*std::sin(0.0067188649826021*x_1 - 0.0162113425099147*x_100 - 0.00965487551964748*x_101 - 0.00227181035607311*x_102 - 0.00449724704188939*x_103 - 0.0127112581768854*x_104 + 0.0119805879122729*x_105 + 0.000721369854650113*x_106 - 0.010793512330661*x_107 + 0.00429394378360207*x_109 + 0.0162151470885798*x_110 + 0.0086624040637397*x_111 - 0.0167387806512651*x_112 - 0.00987460352831404*x_113 - 0.00262001086705361*x_114 + 0.0191983477120394*x_115 + 0.00095565311137381*x_116 - 0.00908387713050386*x_117 + 0.00791200718039771*x_118 - 0.0153096528189652*x_119 + 0.00292645846997247*x_12 + 0.0175741714054021*x_120 - 0.0180377946335938*x_14 + 0.00488905441701471*x_19 - 0.00502307779909484*x_2 + 0.00527250289594755*x_22 + 0.00292428746719096*x_23 + 0.0175005243190342*x_24 + 0.0150342316735104*x_29 + 0.00351069429573148*x_3 + 0.00389399903652051*x_30 + 0.0150744249328694*x_33 - 0.00415821351857436*x_34 - 0.026472508122666*x_36 + 0.0158310136202587*x_38 + 0.00901581886410261*x_39 - 0.00527262146646025*x_4 - 0.0101791723596145*x_40 - 0.00749697193443447*x_41 - 0.0104174470523238*x_42 + 0.00721702161206306*x_43 + 0.00392067493492425*x_44 - 2.85027956983897e-5*x_45 - 0.00502316315778044*x_46 - 0.0165550864357268*x_47 + 0.021075677520441*x_49 + 0.0191444235437284*x_50 - 0.0126089628854993*x_51 - 0.00353707530371261*x_52 + 0.0251379638585438*x_53 + 0.019249891582652*x_54 + 0.00522763066059103*x_55 + 0.0160534768984398*x_56 - 0.00543208773184658*x_57 + 0.00389315323239684*x_58 + 0.00751312898771668*x_59 + 0.00315669224548032*x_6 + 0.0191137139319497*x_60 + 0.00643746851162802*x_61 + 0.00439143927664648*x_62 + 0.00253833296944814*x_63 - 0.00460268887717645*x_64 - 0.00537913801689854*x_66 - 0.00883193005456303*x_67 + 0.013015110769941*x_68 + 0.00353482400479081*x_69 + 0.00313292296175644*x_7 + 0.0101395503176903*x_70 + 0.00432643756732335*x_71 + 0.0113376555136398*x_72 - 0.00182588693641058*x_73 + 0.0152942480546026*x_74 - 0.00635608715842191*x_75 + 0.0102476597471633*x_76 - 0.00213344355024337*x_77 + 0.00268391433191269*x_78 + 0.0101877458187414*x_79 - 6.04452616676516e-5*x_8 - 0.000470642504104825*x_80 + 0.00303594614908083*x_81 - 0.00607542845646717*x_82 - 0.00343176956615134*x_83 - 0.0040265765577803*x_84 - 0.00210758845947779*x_85 + 0.0178245740588459*x_86 + 0.0010546183762163*x_87 + 3.76774660268654e-5*x_88 + 0.00497548961570995*x_89 - 0.00701164696239709*x_9 + 0.00530212936330259*x_90 + 0.00374694479908381*x_91 - 0.0231373235898947*x_93 - 0.00214058223364081*x_94 + 0.0104488960731908*x_96 + 0.00405384936211398*x_97 - 0.00948865404816485*x_98 - 0.00104047919286305*x_99 + 0.000172501001154166*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) + 0.0989222349509067*std::sin(0.251999974250793*x_10 + 1.99783980846405) + 0.0863169807354112*std::sin(0.246479973196983*x_108 + 5.1735200881958) + 0.14004280729568*std::sin(0.22919999063015*x_11 + 5.00559949874878) + 0.0442600560535311*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.0269667629873389*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0238782748454973*std::sin(0.357919842004776*x_16 - 1.1639997959137) - 0.0513068497955986*std::sin(0.382559835910797*x_17 - 1.17599976062775) - 0.0727280957626384*std::sin(0.34215983748436*x_18 + 1.9981597661972) - 0.0510734119560006*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.045152555275112*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.109321920657216*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.0975969134151455*std::sin(0.345359832048416*x_26 - 1.14991986751556) + 0.0961627091759674*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.109081831889764*std::sin(0.305919945240021*x_28 - 1.17223989963531) + 0.0468512145370585*std::sin(0.310399919748306*x_31 - 7.49072027206421) - 0.0639028213843051*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.118447065353132*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.16765172530336*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.173249983823137*std::sin(0.228079989552498*x_48 + 8.19400024414063) + 0.100788140216197*std::sin(0.366639852523804*x_5 - 1.15463984012604) - 0.0676809272879844*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.0672816002548045*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 2.07319276459112) + 1.32317108171292);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00199983713587636*x_1 - 0.00492945529285521*x_10 + 0.00733615359071409*x_100 + 0.00510987053695281*x_101 + 0.00133022392944849*x_102 + 0.00165108858842163*x_103 + 0.00756563565896298*x_104 - 0.0162823053101331*x_105 - 0.00863375686879928*x_106 + 0.0103564550801797*x_107 + 0.000201940334296141*x_108 - 0.00282796984756899*x_109 + 0.000764256080316914*x_11 - 7.38639260763922e-5*x_110 - 0.000468369209484535*x_111 + 0.000526523918807803*x_112 + 0.00798015656249095*x_113 - 0.00470044996373956*x_114 - 0.00244807990570689*x_115 + 0.00106376825843122*x_116 + 0.00427878989168937*x_117 - 0.0019458090111836*x_118 + 0.00711541981431581*x_119 + 0.000440976918628734*x_12 - 0.0136362543631061*x_120 + 0.00051072453871926*x_13 + 0.0132793953130451*x_14 + 0.000120567244567444*x_15 - 1.23732370365126e-6*x_16 + 5.88897223907949e-5*x_17 + 0.00031446830577581*x_18 - 0.00199295151397835*x_19 + 0.00216225211192031*x_2 - 0.000813327685092872*x_20 - 0.000835353840527556*x_21 - 0.000123088831865792*x_22 - 0.00311964533656757*x_23 - 0.0101405699236219*x_24 + 0.00283674536106389*x_25 + 0.00128930844572379*x_26 - 0.00514515911558338*x_27 + 0.00209647136941579*x_28 - 0.00605068243073393*x_29 - 0.00152917989402474*x_3 - 0.000964225358331605*x_30 - 0.000140253597434298*x_31 - 0.000342263250067942*x_32 - 0.00623793071421954*x_33 + 0.000803096042757302*x_34 - 0.00698910494011511*x_35 + 0.0123158425453936*x_36 - 0.00884476774369606*x_37 - 0.0116710715342229*x_38 + 0.000759993625811623*x_39 + 0.00230161097524736*x_4 - 0.000799681239139124*x_40 + 0.00412879907233057*x_41 + 0.00803078618097042*x_42 - 0.0173384198000216*x_43 - 0.00501283985505598*x_44 - 0.0016190032070174*x_45 + 0.000709475048574964*x_46 - 0.00226851964749072*x_47 - 0.00968579468346472*x_48 - 0.00788777651483908*x_49 - 0.00228302410509754*x_5 - 0.00970024156681533*x_50 + 0.00868800530013882*x_51 + 0.00014809189179247*x_52 - 0.0117821828475018*x_53 - 0.010385182217054*x_54 - 0.00743187895126482*x_55 - 0.00521421244395306*x_56 - 0.00123232553985949*x_57 - 0.0103320436468598*x_58 - 0.0103090908273175*x_59 - 0.00121107639171045*x_6 - 0.0168725210822611*x_60 - 0.00257823723464866*x_61 - 0.00267713054627884*x_62 + 0.000562880975724584*x_63 + 0.0024208787398505*x_64 - 0.000183226073413921*x_65 + 0.00518032238241914*x_66 + 0.00544689059640287*x_67 - 0.000929040685175915*x_68 - 0.00493032272147718*x_69 + 0.00903933146500772*x_7 - 0.00241432830686939*x_70 - 0.00457312240507166*x_71 - 0.00664234693566835*x_72 + 0.00172059746068714*x_73 - 0.0128786010218683*x_74 + 0.00445949070587022*x_75 - 0.00877124316955262*x_76 + 0.00110618413800222*x_77 + 5.90435317246994e-5*x_78 - 0.00878086386627931*x_79 + 0.000280158950588441*x_8 + 0.00434428151686745*x_80 + 0.00121129707962853*x_81 + 0.00135148370335045*x_82 + 0.00248496874291232*x_83 - 0.000613908953692802*x_84 - 0.00239335937745582*x_85 - 0.00980151449273804*x_86 - 0.00294595583307008*x_87 + 0.00018491840169679*x_88 - 0.00920309457252319*x_89 + 0.00435907391161926*x_9 + 0.0012110798449813*x_90 - 0.00187901686549677*x_91 - 0.000992639662753327*x_92 - 0.00115361614023906*x_93 + 0.000933814073142857*x_94 - 0.000834019890236258*x_95 - 0.00389143580363217*x_96 - 0.000306820906662832*x_97 + 0.0113709329955143*x_98 - 0.00283860865843028*x_99 - 2.66939716964386e-5*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) + 6.27467690912489e-5*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) - 7.51375769131521e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) + 0.0121398499301229*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 0.00655825468237159*std::sin(0.251359969377518*x_1 - 4.32871961593628) - 0.0397194276961059*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.0430883124579777*std::sin(0.251999974250793*x_10 + 1.99783980846405) - 0.00412007491185423*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.00604838210303527*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.013437863764636*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.0195486135169144*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.0083822696043524*std::sin(0.264959961175919*x_107 - 1.22583997249603) - 0.0375977457262509*std::sin(0.246479973196983*x_108 + 5.1735200881958) + 0.01076466571265*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.0184154694811901*std::sin(0.263439953327179*x_108 + 1.9554398059845) - 0.0145859671545024*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.00961561733059069*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.0609995138225829*std::sin(0.22919999063015*x_11 + 5.00559949874878) + 0.0209905825980389*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.0098928598753734*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.0111956378598563*std::sin(0.20728000998497*x_111 - 7.41167974472046) - 0.00309556158037368*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.00552449241697711*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.00264533537519795*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.0132702981816697*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.0146803914407776*std::sin(0.232799991965294*x_118 + 5.16344022750854) - 0.0280026408006235*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.00803560737672199*std::sin(0.3018399477005*x_12 + 1.93759989738464) + 0.0090082613611336*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.0133109118514174*std::sin(0.272319942712784*x_120 + 1.9690397977829) + 0.0387573436728735*std::sin(0.290079921483994*x_13 + 5.14888000488281) + 0.00395225611392257*std::sin(0.307839930057526*x_13 - 7.44687986373901) - 0.0192786902316614*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.00656038832096539*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.00898301748507513*std::sin(0.302559942007065*x_14 - 1.21279990673065) - 0.0117461186573003*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0113271170472473*std::sin(0.326959848403931*x_15 + 5.06239986419678) + 0.00339097729341339*std::sin(0.345919847488403*x_15 - 4.35887956619263) - 0.0290193005940951*std::sin(0.361199855804443*x_15 + 5.0304799079895) + 0.0103834516966155*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.00422938926236477*std::sin(0.354799836874008*x_16 - 4.36759996414185) - 0.0104008423183207*std::sin(0.357919842004776*x_16 - 1.1639997959137) - 0.00866983485629162*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.0114826216322139*std::sin(0.300399929285049*x_17 - 1.15783989429474) - 0.00374365516737632*std::sin(0.376959830522537*x_17 - 1.17751979827881) + 0.0223481159349506*std::sin(0.382559835910797*x_17 - 1.17599976062775) - 0.0316990181627731*std::sin(0.388559848070145*x_17 - 1.18951988220215) + 0.0232925787185946*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.0316787314424254*std::sin(0.34215983748436*x_18 + 1.9981597661972) - 0.0458958226414257*std::sin(0.218959987163544*x_19 + 1.99543976783752) + 0.0332232489269692*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.00356317239950793*std::sin(0.406159847974777*x_2 - 7.39583969116211) + 0.00392634328671856*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 0.00481556815482226*std::sin(0.32399994134903*x_20 - 1.21511995792389) + 0.0222464356344892*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.00578351548452386*std::sin(0.345839828252792*x_20 - 4.35503959655762) - 0.0314734896044207*std::sin(0.264239966869354*x_21 - 4.20663976669312) + 0.00837214486928913*std::sin(0.273359954357147*x_21 - 1.16527986526489) + 0.0196674429256039*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.0121948566195173*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.00585862346248295*std::sin(0.309839934110641*x_22 + 2.02199983596802) - 0.0150915761551712*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0107222691385924*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.0160264020532359*std::sin(0.294239938259125*x_24 + 8.23031997680664) + 0.00906464842826664*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.00937568171377789*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.00489004474023358*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0476181828900458*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.0165815962428527*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.00598971950154337*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.042511032047072*std::sin(0.345359832048416*x_26 - 1.14991986751556) + 0.0313114641277892*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.04188632476648*std::sin(0.341279834508896*x_27 - 1.17215991020203) + 0.0303930737538912*std::sin(0.359519839286804*x_27 + 8.22399997711182) + 0.0278942941816724*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.0073803104157395*std::sin(0.267519950866699*x_28 + 5.01783990859985) + 0.0475136055942058*std::sin(0.305919945240021*x_28 - 1.17223989963531) - 0.00955348958497894*std::sin(0.167520016431808*x_29 - 4.41631984710693) - 0.0457130490057438*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.00922697968405306*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.00535635749628949*std::sin(0.280479967594147*x_3 + 2.05519986152649) - 0.00850889023689668*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.01018967838142*std::sin(0.360559850931168*x_3 + 1.971599817276) + 0.0259006896319444*std::sin(0.379759848117828*x_3 - 7.40215969085693) - 0.00307228714455952*std::sin(0.304399937391281*x_30 + 1.99511981010437) - 0.0204073408977303*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.0037130757826444*std::sin(0.402799874544144*x_31 + 5.18520021438599) - 0.0207056591938114*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.00317500489370376*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.0148761045000832*std::sin(0.31127992272377*x_32 - 1.16535985469818) + 0.0278346393621189*std::sin(0.317919850349426*x_32 - 1.18943989276886) + 0.0128687571337085*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.0184951436941827*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.00333346697561443*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.0515928917719978*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.0198636231642037*std::sin(0.254799962043762*x_35 - 1.21839988231659) + 0.0117212426429584*std::sin(0.215199992060661*x_36 + 1.98215985298157) + 0.026979907508357*std::sin(0.235199987888336*x_36 - 1.18823993206024) - 0.0730253408404619*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.0119666704553875*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.00625729081304527*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.0113828994387646*std::sin(0.317439913749695*x_4 + 2.014319896698) - 0.0437150790634223*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.00223740500508099*std::sin(0.254159957170486*x_41 + 1.95487987995148) - 0.0672767545473878*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.0137747804377417*std::sin(0.233439981937408*x_44 - 1.19471991062164) - 0.0233125972215075*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.0164954491986673*std::sin(0.220799997448921*x_45 - 1.18895995616913) + 0.0122773303328141*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.0223056013174848*std::sin(0.198320001363754*x_47 - 1.18783986568451) + 0.0136483411941341*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.00745647306189734*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.00524311182825943*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.0754638170075279*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.0211743751576694*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.00912120529783882*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.00526959038635405*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.043901059047536*std::sin(0.366639852523804*x_5 - 1.15463984012604) - 0.00589930155950655*std::sin(0.378639847040176*x_5 + 2.02248001098633) - 0.0162526150696884*std::sin(0.171040013432503*x_50 - 1.1548798084259) - 0.0619597690897335*std::sin(0.197199985384941*x_51 - 1.18839991092682) + 0.00991117723432792*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 0.012193587635062*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.00794610849175348*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.01184728247211*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.0160717751144266*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.00559334462496264*std::sin(0.42375984787941*x_6 - 7.41519975662231) - 0.00522583243759204*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 0.00407432619345566*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.0111239979571597*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.00556025149252576*std::sin(0.318479925394058*x_8 + 1.95895981788635) - 0.0407699778219241*std::sin(0.355119854211807*x_8 - 1.16895985603333) - 0.00900841081535395*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.0116828300808722*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.00555043977568426*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.00806183109409734*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.00486809058635324*std::sin(0.367439836263657*x_91 + 1.99071979522705) - 0.0194005866090251*std::sin(0.385519832372665*x_91 - 4.3854398727417) + 0.00572239845469331*std::sin(0.291199922561646*x_92 + 1.9851998090744) + 0.0294802977700375*std::sin(0.297839939594269*x_92 - 1.19751989841461) - 0.0354577257209898*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.0167526004714289*std::sin(0.23735998570919*x_93 + 1.97199988365173) - 0.0423131231966532*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.00830537927308418*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.00948077078205933*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.0104451059190856*std::sin(0.268399953842163*x_95 + 1.97319984436035) + 0.0268311203774638*std::sin(0.292799949645996*x_95 - 1.21631991863251) - 0.0293063598481222*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 0.00982869238253714*std::sin(0.271919965744019*x_96 + 1.98279976844788) - 0.00907566434050771*std::sin(0.278559952974319*x_96 + 1.97535979747772) - 0.00643879065389052*std::sin(0.262799948453903*x_97 + 1.9579998254776) + 0.0398629044356258*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.00882485375927769*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.00690270027909057*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 0.13515126928996);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000519349040992275*x_1 + 0.00277644117690761*x_10 + 0.000748232461784111*x_100 - 0.00175977679370568*x_101 - 0.00176332850043994*x_102 - 0.00309759183846619*x_103 - 0.00153691437219656*x_104 + 0.00533466854989042*x_105 + 0.00546559532948335*x_106 - 0.00759966946694395*x_107 + 0.000320967363037637*x_108 - 0.000231732824375015*x_109 + 0.000850584664617585*x_11 - 0.00837892138406157*x_110 - 0.00855191746050731*x_111 + 0.00677063227673646*x_112 - 0.00267847289974075*x_113 - 0.00249134334486697*x_114 - 0.00919700170829026*x_115 + 0.00575982394016812*x_116 - 0.000864552673537672*x_117 - 0.000410995118796033*x_118 - 0.00232236007826398*x_119 - 0.00366739793649908*x_12 + 0.00985361724290166*x_120 + 0.000105935298379293*x_13 - 0.00840424634419983*x_14 + 1.89506940696126e-5*x_15 - 2.56021365761573e-7*x_16 + 9.25625460610149e-6*x_17 + 0.00209983577200804*x_18 + 0.00119531512209569*x_19 - 0.000688915039947032*x_2 + 0.00105525222348502*x_20 - 0.000131300463309985*x_21 + 0.000987281664518722*x_22 + 0.00121117978501834*x_23 + 0.00411990242099382*x_24 - 0.00251920745738087*x_25 + 0.00102709415877412*x_26 - 0.00107753508473614*x_27 + 0.00216968086909268*x_28 + 0.000811279018828755*x_29 + 0.000171170105831563*x_3 + 0.00157929650180082*x_30 - 0.000287056407641359*x_31 - 0.000637977320018772*x_32 - 0.00061255818577326*x_33 + 0.00733472669031287*x_34 + 0.0146603506173755*x_35 - 0.00109747552440498*x_36 + 0.0155602103168908*x_37 + 0.00600539123860618*x_38 + 0.00471406359399597*x_39 - 0.000247802555696377*x_4 - 0.00342548565564244*x_40 - 0.00931219780784265*x_41 + 0.000679339860069791*x_42 + 0.0095753854743872*x_43 - 0.00132805954119549*x_44 - 0.000257815160912979*x_45 - 0.00139020913304378*x_46 + 0.0114920656123912*x_47 + 0.00285800319726936*x_48 + 0.00201369996349869*x_49 + 0.00296211023838317*x_5 + 0.00725647229845758*x_50 + 0.00161929898226085*x_51 + 0.00527831021674258*x_52 + 0.00318843273495388*x_53 + 0.00375357013528576*x_54 + 0.000506092412485533*x_55 + 0.00550531125023429*x_56 + 0.000294970381628786*x_57 + 0.0125497378313383*x_58 + 0.00231926330000239*x_59 + 0.000459434202543175*x_6 + 0.00114766689572163*x_60 + 0.00108335210548371*x_61 + 0.000648856876307192*x_62 - 0.000223230275243458*x_63 + 0.000854882130180345*x_64 - 0.00296289160678971*x_65 - 0.000253595384997351*x_66 - 0.00532683703977551*x_67 - 0.00537561750869559*x_68 + 0.00309764000298401*x_69 - 0.0118745188412485*x_7 + 0.00237513987155668*x_70 - 0.000645949789805184*x_71 + 0.000684780707197334*x_72 - 0.00279586842876714*x_73 + 0.00338273331844963*x_74 - 0.00299569358318223*x_75 + 0.00765777951063148*x_76 + 0.000487063536276048*x_77 - 0.000790955351083162*x_78 + 0.00583615580173595*x_79 + 0.000470191628984993*x_8 - 0.00415638904422201*x_80 + 0.00121960183589883*x_81 + 0.00320882039849638*x_82 - 0.00185288870146915*x_83 + 0.00230172705124991*x_84 + 0.0029463722375165*x_85 + 0.00175709660673809*x_86 + 0.00581650197899945*x_87 + 0.00118085136840265*x_88 + 0.00459400043820655*x_89 - 0.00203498251759337*x_9 + 0.00120193711359856*x_90 - 0.000277590475120424*x_91 - 0.000195130141608192*x_92 + 0.00680568681485864*x_93 - 0.000101712904121452*x_94 - 0.000106887588631412*x_95 - 0.00205333250704404*x_96 + 0.000426968803235202*x_97 - 0.00423973109374205*x_98 + 0.0111977144145307*x_99 + 3.46341007475928e-5*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) - 8.14108124113353e-5*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) + 8.41059122108978e-6*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) + 0.0226286313891791*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 0.00103082291182914*std::sin(0.251359969377518*x_1 - 4.32871961593628) + 0.051533982133022*std::sin(0.351279854774475*x_1 - 4.22824001312256) + 0.00482312841828156*std::sin(0.251999974250793*x_10 + 1.99783980846405) - 0.000647591138692396*std::sin(0.375039845705032*x_10 - 4.37103986740112) + 0.000950681416515441*std::sin(0.257679969072342*x_100 - 1.20759987831116) - 0.0027805013544861*std::sin(0.213199988007545*x_104 - 7.40104007720947) + 0.00404490976498436*std::sin(0.258399993181229*x_107 + 1.97087979316711) + 0.00131752058737841*std::sin(0.264959961175919*x_107 - 1.22583997249603) + 0.00420853696817338*std::sin(0.246479973196983*x_108 + 5.1735200881958) + 0.0200652935449282*std::sin(0.255919963121414*x_108 - 7.42927980422974) + 0.00381044477997306*std::sin(0.263439953327179*x_108 + 1.9554398059845) - 0.0271881840462395*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.00151137751365426*std::sin(0.245199963450432*x_109 - 7.44343996047974) + 0.00682803460697117*std::sin(0.22919999063015*x_11 + 5.00559949874878) - 0.0272342370299336*std::sin(0.282719939947128*x_11 + 5.160560131073) - 0.00204698535161566*std::sin(0.324079930782318*x_11 + 1.93391978740692) - 0.00175972428297162*std::sin(0.20728000998497*x_111 - 7.41167974472046) - 0.00577011432167445*std::sin(0.277119934558868*x_112 - 7.6016001701355) - 0.000868336719974253*std::sin(0.290239930152893*x_113 + 1.96135985851288) + 0.000415792378657684*std::sin(0.233919993042946*x_116 - 4.23400020599365) - 0.00274582944989146*std::sin(0.258559972047806*x_116 - 7.44599962234497) + 0.0030375995024514*std::sin(0.232799991965294*x_118 + 5.16344022750854) + 0.0363320338283284*std::sin(0.257359951734543*x_119 + 1.94495987892151) + 0.001662691152882*std::sin(0.3018399477005*x_12 + 1.93759989738464) + 0.0167913629057862*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.00275423304481712*std::sin(0.272319942712784*x_120 + 1.9690397977829) - 0.0502857259586616*std::sin(0.290079921483994*x_13 + 5.14888000488281) + 0.00736698948276686*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.00215797726620777*std::sin(0.316559940576553*x_13 - 7.46415996551514) + 0.00103115827598539*std::sin(0.215839996933937*x_14 + 8.38799953460693) + 0.00185872492251005*std::sin(0.302559942007065*x_14 - 1.21279990673065) + 0.00131481219543661*std::sin(0.310479938983917*x_15 - 7.4489598274231) + 0.0023437552905677*std::sin(0.326959848403931*x_15 + 5.06239986419678) + 0.00632076802130214*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 0.0376510993504447*std::sin(0.361199855804443*x_15 + 5.0304799079895) + 0.0193547121539812*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.000664773108981057*std::sin(0.354799836874008*x_16 - 4.36759996414185) + 0.00116422749692232*std::sin(0.357919842004776*x_16 - 1.1639997959137) + 0.0112486795630287*std::sin(0.372639834880829*x_16 - 7.57360029220581) - 0.00237593158857916*std::sin(0.300399929285049*x_17 - 1.15783989429474) - 0.00697815815832714*std::sin(0.376959830522537*x_17 - 1.17751979827881) - 0.00250155615089434*std::sin(0.382559835910797*x_17 - 1.17599976062775) + 0.0411278996297029*std::sin(0.388559848070145*x_17 - 1.18951988220215) - 0.0302209625148689*std::sin(0.331519842147827*x_18 + 8.21232032775879) - 0.00354598686184525*std::sin(0.34215983748436*x_18 + 1.9981597661972) + 0.0595475474138179*std::sin(0.218959987163544*x_19 + 1.99543976783752) - 0.0431055132441203*std::sin(0.389999836683273*x_2 - 7.38967990875244) + 0.000560057504031202*std::sin(0.406159847974777*x_2 - 7.39583969116211) + 0.00731868807719543*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 0.000756908389179919*std::sin(0.32399994134903*x_20 - 1.21511995792389) - 0.002490174476404*std::sin(0.343999862670898*x_20 - 4.3459997177124) - 0.00119669859138845*std::sin(0.345839828252792*x_20 - 4.35503959655762) + 0.0408352875410913*std::sin(0.264239966869354*x_21 - 4.20663976669312) + 0.0156056443262831*std::sin(0.273359954357147*x_21 - 1.16527986526489) - 0.0022014926433223*std::sin(0.354239851236343*x_21 - 4.35671949386597) - 0.00252330399699136*std::sin(0.363679856061935*x_21 - 1.16999983787537) + 0.000920855256374899*std::sin(0.309839934110641*x_22 + 2.02199983596802) + 0.0195805695361513*std::sin(0.394959837198257*x_22 - 1.19871985912323) - 0.0022186029256733*std::sin(0.330879837274551*x_23 + 2.02455973625183) + 0.00331610986664652*std::sin(0.294239938259125*x_24 + 8.23031997680664) + 0.0168964681718822*std::sin(0.301199942827225*x_24 - 1.1619998216629) + 0.001473664563616*std::sin(0.333999842405319*x_24 + 2.01279973983765) + 0.000768614578456641*std::sin(0.305119931697845*x_25 + 1.99959981441498) - 0.00533018347719919*std::sin(0.316639930009842*x_25 + 1.99391984939575) + 0.00343098811093225*std::sin(0.352719843387604*x_25 + 8.23471927642822) + 0.00123936538416634*std::sin(0.33111983537674*x_26 - 1.14807987213135) + 0.00475851002418985*std::sin(0.345359832048416*x_26 - 1.14991986751556) - 0.0406250675429154*std::sin(0.352879852056503*x_26 - 4.36879968643188) + 0.00468858286143384*std::sin(0.341279834508896*x_27 - 1.17215991020203) - 0.0394335017056201*std::sin(0.359519839286804*x_27 + 8.22399997711182) - 0.0361914594784682*std::sin(0.263759940862656*x_28 - 4.36847972869873) + 0.00116003318587261*std::sin(0.267519950866699*x_28 + 5.01783990859985) - 0.00531847752496528*std::sin(0.305919945240021*x_28 - 1.17223989963531) - 0.0178076661196965*std::sin(0.167520016431808*x_29 - 4.41631984710693) + 0.059310407711109*std::sin(0.25383996963501*x_29 + 2.02095985412598) - 0.0019092044657308*std::sin(0.382479846477509*x_29 + 8.20479965209961) + 0.000841909364386912*std::sin(0.280479967594147*x_3 + 2.05519986152649) - 0.0158605371409044*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.00210840168032344*std::sin(0.360559850931168*x_3 + 1.971599817276) - 0.0336048567199378*std::sin(0.379759848117828*x_3 - 7.40215969085693) - 0.00572673086703035*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 0.00228431377815956*std::sin(0.310399919748306*x_31 - 7.49072027206421) + 0.000768292670902212*std::sin(0.402799874544144*x_31 + 5.18520021438599) + 0.0268645630825877*std::sin(0.432959854602814*x_31 + 5.20775985717773) - 0.000499045546126296*std::sin(0.257839977741241*x_32 + 2.03919982910156) + 0.00307809555420645*std::sin(0.31127992272377*x_32 - 1.16535985469818) - 0.00311569501012561*std::sin(0.317919850349426*x_32 - 1.18943989276886) - 0.0166965723997013*std::sin(0.328159838914871*x_32 + 1.98015987873077) - 0.00382693060398672*std::sin(0.241519972681999*x_34 - 1.18687987327576) + 0.000523952530164097*std::sin(0.240319982171059*x_35 - 1.21359980106354) - 0.00577509603629826*std::sin(0.253919988870621*x_35 - 1.2183198928833) + 0.00411009012149825*std::sin(0.254799962043762*x_35 - 1.21839988231659) + 0.0218483490914082*std::sin(0.215199992060661*x_36 + 1.98215985298157) - 0.0350050882435692*std::sin(0.235199987888336*x_36 - 1.18823993206024) + 0.00817415620548671*std::sin(0.241599977016449*x_37 + 1.95127987861633) + 0.00188091476790002*std::sin(0.242719978094101*x_38 + 1.96239984035492) + 0.000983517574180655*std::sin(0.301439940929413*x_4 + 2.01935982704163) - 0.00235529752807561*std::sin(0.317439913749695*x_4 + 2.014319896698) + 0.0567181410727857*std::sin(0.323519825935364*x_4 + 2.02319979667664) - 0.000351674104465343*std::sin(0.254159957170486*x_41 + 1.95487987995148) + 0.087288243258165*std::sin(0.259839981794357*x_42 - 7.42735958099365) + 0.00285021461265922*std::sin(0.233439981937408*x_44 - 1.19471991062164) + 0.0302469355268503*std::sin(0.193519994616508*x_45 + 1.98415982723236) + 0.00341316295827123*std::sin(0.220799997448921*x_45 - 1.18895995616913) + 0.0228848943062368*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 0.00461537308028908*std::sin(0.198320001363754*x_47 - 1.18783986568451) + 0.0254404530314224*std::sin(0.200479999184608*x_47 - 1.20559990406036) + 0.00117200438926245*std::sin(0.211520001292229*x_47 - 1.1898398399353) - 0.000824109471744047*std::sin(0.212239995598793*x_48 + 1.98431980609894) + 0.00844710919500443*std::sin(0.228079989552498*x_48 + 8.19400024414063) - 0.00438130493339551*std::sin(0.224479988217354*x_49 + 1.95463979244232) + 0.00188731811316094*std::sin(0.28519994020462*x_5 - 1.17671978473663) + 0.000828271357135522*std::sin(0.356399834156036*x_5 - 1.15343987941742) + 0.00491410392763303*std::sin(0.366639852523804*x_5 - 1.15463984012604) - 0.0109962743536428*std::sin(0.378639847040176*x_5 + 2.02248001098633) - 0.0302948090494619*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 0.0803897190479795*std::sin(0.197199985384941*x_51 - 1.18839991092682) + 0.0184743944578695*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 0.00191658148705396*std::sin(0.234479993581772*x_53 - 7.41767978668213) - 0.00124896502040349*std::sin(0.195119991898537*x_54 - 7.38695955276489) - 0.00186214942947999*std::sin(0.210720002651215*x_57 - 7.4017596244812) + 0.00332549825309748*std::sin(0.387679845094681*x_6 + 2.00447988510132) - 0.000879158872659522*std::sin(0.42375984787941*x_6 - 7.41519975662231) - 0.00974093062208788*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 0.000640400379962206*std::sin(0.399279862642288*x_7 - 1.18111991882324) + 0.00230172681677137*std::sin(0.315919935703278*x_8 + 5.16639995574951) - 0.000873957312062641*std::sin(0.318479925394058*x_8 + 1.95895981788635) + 0.0528970186759444*std::sin(0.355119854211807*x_8 - 1.16895985603333) - 0.0167916414878512*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 0.00241735780575357*std::sin(0.339839845895767*x_9 - 4.35839986801147) - 0.000872415111734285*std::sin(0.354879856109619*x_9 - 4.35031986236572) + 0.00166811724462984*std::sin(0.339999854564667*x_91 + 5.20272016525269) - 0.000765163836464185*std::sin(0.367439836263657*x_91 + 1.99071979522705) + 0.0251712963069119*std::sin(0.385519832372665*x_91 - 4.3854398727417) + 0.0106665276785635*std::sin(0.291199922561646*x_92 + 1.9851998090744) - 0.00329990324157484*std::sin(0.297839939594269*x_92 - 1.19751989841461) + 0.0460046357607068*std::sin(0.319359838962555*x_92 - 1.18919992446899) + 0.00346637152436067*std::sin(0.23735998570919*x_93 + 1.97199988365173) + 0.0548991730568782*std::sin(0.277359932661057*x_94 - 7.40759992599487) + 0.00171851112072625*std::sin(0.284879922866821*x_94 + 5.16616010665894) - 0.00149018240633694*std::sin(0.285759925842285*x_94 - 7.43239974975586) - 0.00216125357902486*std::sin(0.268399953842163*x_95 + 1.97319984436035) - 0.0348120443406274*std::sin(0.292799949645996*x_95 - 1.21631991863251) + 0.00328043334622853*std::sin(0.301199942827225*x_95 + 8.17088031768799) + 0.00154486853468399*std::sin(0.271919965744019*x_96 + 1.98279976844788) - 0.0169170017879444*std::sin(0.278559952974319*x_96 + 1.97535979747772) - 0.0120018798533455*std::sin(0.262799948453903*x_97 + 1.9579998254776) - 0.0517201360672502*std::sin(0.26623997092247*x_97 + 1.96175980567932) + 0.00182599840723106*std::sin(0.277999937534332*x_97 - 1.21655988693237) - 0.00108496268379179*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 0.117426291974279);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0053243961520745*x_1 - 0.0328140421397866*x_10 - 0.0100829930078644*x_100 + 0.0245020677151723*x_101 + 0.00734022416443611*x_102 + 0.0251238513691806*x_103 + 0.0371985346751506*x_104 - 0.0691457304394115*x_105 - 0.0662297723019382*x_106 + 0.0713667602246786*x_107 - 0.00266665415396934*x_108 + 0.00179063995143413*x_109 - 0.000270976312570808*x_11 + 0.0574414621166986*x_110 + 0.0809606906906286*x_111 - 0.0608580671599929*x_112 + 0.034830816803881*x_113 + 0.00295892249190477*x_114 + 0.0573713228344367*x_115 - 0.0115196312406774*x_116 - 0.0120925812105298*x_117 + 0.00693566959130728*x_118 + 0.00472808055463229*x_119 + 0.0323942280647502*x_12 - 0.0803457715552738*x_120 - 0.000987568185324199*x_13 + 0.0752537492164829*x_14 - 9.71508288434634e-5*x_15 + 2.37850522632878e-6*x_16 - 4.74522359796223e-5*x_17 + 0.00183998607097529*x_18 - 0.00280852612013296*x_19 + 0.0021891818381099*x_2 - 0.00958706317803232*x_20 + 0.00067311248818849*x_21 - 0.00663296225617885*x_22 - 0.0187222425574065*x_23 - 0.0389058167710576*x_24 + 0.0291079927757797*x_25 - 0.000649685129649136*x_26 + 0.00790210102093163*x_27 - 0.00201632365215247*x_28 - 0.00832885127385036*x_29 - 0.00185121442033947*x_3 - 0.0150481973076269*x_30 - 1.20971143082694e-5*x_31 + 0.00199490372733336*x_33 - 0.0419519185790091*x_34 - 0.103234780698368*x_35 + 0.0117585228673765*x_36 - 0.115274536284939*x_37 - 0.0859834268202641*x_38 - 0.00585123674573852*x_39 + 0.00278029132401827*x_4 + 0.0018450683295767*x_40 + 0.0645132266064781*x_41 + 0.000917085858971117*x_42 - 0.122859750876552*x_43 - 0.0134394728926963*x_44 + 0.00132959612851604*x_45 - 0.0142785133523862*x_46 - 0.103010089183767*x_47 - 0.0502368404118076*x_48 - 0.000673303843158281*x_49 - 0.0269110430318643*x_5 - 0.0669754378749865*x_50 + 0.00385529656625934*x_51 - 0.0128667272460801*x_52 - 0.0311124311872638*x_53 - 0.0403642842844581*x_54 - 0.00563356147763646*x_55 - 0.0416387148849306*x_56 - 0.00214579746828615*x_57 - 0.0826634008401655*x_58 - 0.0433145881998694*x_59 - 0.00166454658627272*x_6 - 0.0451487408401973*x_60 - 0.00319299051280259*x_61 - 0.00941566341918966*x_62 + 0.00502444756043306*x_63 - 0.00562439123214121*x_64 + 0.0345322809597013*x_65 + 0.0149212611150453*x_66 + 0.0491830110861158*x_67 + 0.0430325300859426*x_68 - 0.0318674784806963*x_69 + 0.107575316821756*x_7 - 0.0133328486582639*x_70 - 0.00816748115326855*x_71 - 0.0179190288659827*x_72 + 0.0312488414845253*x_73 - 0.0424062559321873*x_74 + 0.0175958212996522*x_75 - 0.071816216564662*x_76 - 0.00250451629406899*x_77 + 0.0209088545510981*x_78 - 0.0508009346840019*x_79 + 3.18732223926192e-5*x_8 + 0.037724511700459*x_80 + 0.00273347579978523*x_81 - 0.00761374179968648*x_82 + 0.0107654163667715*x_83 - 0.0313489427485984*x_84 - 0.0374732306351555*x_85 - 0.0242565077352945*x_86 - 0.0351810383429812*x_87 - 0.0104651376166107*x_88 - 0.0553113012631553*x_89 + 0.0190794176607196*x_9 + 0.00513668720036582*x_90 - 0.0019757910145334*x_91 + 0.00167777188431074*x_92 - 0.0858202977617396*x_93 + 0.00112874444911265*x_94 + 0.000683463852773086*x_95 + 0.0178215363949103*x_96 - 0.00331321472309499*x_97 + 0.0518249056477375*x_98 - 0.0768997495669282*x_99 - 0.000314653979960292*std::pow(-5.27479982376099*x_6 - 9.93552017211914, 2) + 0.000739624693122942*std::pow(-4.01704025268555*x_61 - 7.02767992019653, 2) - 9.09610219402628e-5*std::pow(-2.74767994880676*x_65 - 6.67144012451172, 2) + 0.00150503776967525*std::pow(-0.0897440146771995*x_10 - 0.0536592992136364*x_100 + 0.0943827676494804*x_101 - 0.111939238737392*x_102 - 0.0376697649004922*x_103 + 0.273155270799739*x_104 - 0.227085238536815*x_105 - 0.180501762374657*x_106 + 0.0165687057690958*x_107 + 0.0850029931771046*x_11 - 0.193494968245253*x_110 + 0.0450838963769969*x_111 + 0.113597661471732*x_113 - 0.226202695936626*x_114 - 0.29498414589276*x_115 + 0.479581684154642*x_116 - 0.235811612022957*x_117 + 0.0430474507230026*x_118 - 0.20276916567839*x_119 + 0.129107308447486*x_120 - 0.0307414792656603*x_14 + 0.244317968960721*x_18 + 0.106006230567536*x_19 - 0.0525823334241575*x_2 + 0.0336190909323858*x_22 - 0.0880096742699486*x_23 + 0.0729615980437617*x_25 + 0.0959396125289255*x_26 - 0.0115679901243767*x_27 + 0.208067025691435*x_28 - 0.0308391774054571*x_31 - 0.0679806475957938*x_32 - 0.0247184117886847*x_33 + 0.276210788081011*x_34 + 0.3513438607245*x_35 + 0.321770801905601*x_37 - 0.351368198784504*x_38 + 0.438652135844799*x_39 + 0.000988143823501833*x_4 - 0.358035192739107*x_40 - 0.244337565541928*x_41 + 0.0637953184916809*x_42 - 0.423733672077189*x_43 - 0.289223070598017*x_44 - 0.322096928735927*x_46 - 0.286379833564379*x_48 + 0.23275284078017*x_49 + 0.196263496132056*x_51 + 0.407535637313757*x_52 - 0.0540529704532781*x_54 - 0.00852929868289977*x_55 + 0.106355249159469*x_56 - 0.000467864584366432*x_57 + 0.365822698001754*x_58 - 0.262429551839955*x_59 + 0.0325555862343651*x_6 - 0.379689130876361*x_60 + 0.0856018963934633*x_61 - 0.0368994967266803*x_62 + 0.0344970961918071*x_63 + 0.0147021522891707*x_64 + 0.0965579450390002*x_65 + 0.140175121024628*x_66 - 0.000601194784731153*x_67 - 0.0598621337208641*x_68 - 0.0474585749948718*x_69 + 0.107049146906701*x_70 - 0.161141332819143*x_71 - 0.126004532574691*x_72 + 0.0663507870072395*x_73 - 0.120093413942568*x_74 - 0.117478718691641*x_75 - 0.0157178064088274*x_76 + 0.0164165760774547*x_77 + 0.160957647304701*x_78 + 0.0366609508202682*x_79 + 0.0504160214611967*x_8 - 0.00439314239379647*x_80 + 0.159966282542209*x_81 + 0.249150130976683*x_82 - 0.0816269931903413*x_83 - 0.122725394090705*x_84 - 0.133761954328762*x_85 - 0.0752318112198065*x_86 + 0.213363197555042*x_87 + 0.000315939362060421*x_88 - 0.151104016308782*x_89 + 0.194464619821988*x_90 - 0.0490457734940164*x_91 - 0.294470062781246*x_93 + 0.000282903992382265*x_94 + 0.00281650853536656*x_95 + 0.147761531199208*x_98 + 0.281554040125846*x_99 + 2.41122837407079*std::sin(0.217919990420341*x_1 + 5.01607990264893) + 2.1380879955792*std::sin(0.255919963121414*x_108 - 7.42927980422974) - 2.89707847037981*std::sin(0.240719974040985*x_109 + 1.97031986713409) - 0.614843343142123*std::sin(0.277119934558868*x_112 - 7.6016001701355) + 1.78922931667501*std::sin(0.307599931955338*x_12 + 1.92247986793518) + 0.785000814535472*std::sin(0.307839930057526*x_13 - 7.44687986373901) + 0.67351908901442*std::sin(0.345919847488403*x_15 - 4.35887956619263) + 2.06237091033128*std::sin(0.323279827833176*x_16 - 1.13703989982605) - 0.743568298971809*std::sin(0.376959830522537*x_17 - 1.17751979827881) + 0.779853984503276*std::sin(0.285919934511185*x_20 + 5.19008016586304) + 1.662883262714*std::sin(0.273359954357147*x_21 - 1.16527986526489) + 1.8004289688111*std::sin(0.301199942827225*x_24 - 1.1619998216629) - 1.89752305763946*std::sin(0.167520016431808*x_29 - 4.41631984710693) - 1.6900437558252*std::sin(0.31263992190361*x_3 + 2.06999969482422) - 0.610220552881238*std::sin(0.304399937391281*x_30 + 1.99511981010437) + 2.32808420225534*std::sin(0.215199992060661*x_36 + 1.98215985298157) + 2.43853486053939*std::sin(0.23735998570919*x_45 + 8.19351959228516) + 2.71084632311943*std::sin(0.200479999184608*x_47 - 1.20559990406036) - 1.17172480626688*std::sin(0.378639847040176*x_5 + 2.02248001098633) - 3.22810964175457*std::sin(0.171040013432503*x_50 - 1.1548798084259) + 1.96856731388063*std::sin(0.195439994335175*x_53 + 5.20183992385864) - 1.03795973790377*std::sin(0.312079936265945*x_7 - 1.16279983520508) - 1.78925900141236*std::sin(0.310399949550629*x_9 - 7.43655967712402) + 1.13658814574454*std::sin(0.291199922561646*x_92 + 1.9851998090744) - 1.8026169596277*std::sin(0.278559952974319*x_96 + 1.97535979747772) - 1.27887863595736*std::sin(0.262799948453903*x_97 + 1.9579998254776) + 1.75565100549726, 2) - 0.00528451886285346*std::sin(0.251359969377518*x_1 - 4.32871961593628) - 0.468190951442127*std::sin(0.351279854774475*x_1 - 4.22824001312256) - 0.0521624078906511*std::sin(0.251999974250793*x_10 + 1.99783980846405) + 0.00331987924265692*std::sin(0.375039845705032*x_10 - 4.37103986740112) - 0.00487367308243614*std::sin(0.257679969072342*x_100 - 1.20759987831116) + 0.0258315823907383*std::sin(0.213199988007545*x_104 - 7.40104007720947) - 0.0375782661240986*std::sin(0.258399993181229*x_107 + 1.97087979316711) - 0.00675427594429821*std::sin(0.264959961175919*x_107 - 1.22583997249603) - 0.0455155664370553*std::sin(0.246479973196983*x_108 + 5.1735200881958) - 0.0354000252941523*std::sin(0.263439953327179*x_108 + 1.9554398059845) + 0.00774808445577351*std::sin(0.245199963450432*x_109 - 7.44343996047974) - 0.07384558223876*std::sin(0.22919999063015*x_11 + 5.00559949874878) + 0.247425539791044*std::sin(0.282719939947128*x_11 + 5.160560131073) + 0.0190170275146898*std::sin(0.324079930782318*x_11 + 1.93391978740692) + 0.00902123542275923*std::sin(0.20728000998497*x_111 - 7.41167974472046) + 0.00445153257980052*std::sin(0.290239930152893*x_113 + 1.96135985851288) - 0.00213156172882142*std::sin(0.233919993042946*x_116 - 4.23400020599365) + 0.0255094713589507*std::sin(0.258559972047806*x_116 - 7.44599962234497) - 0.02822009120443*std::sin(0.232799991965294*x_118 + 5.16344022750854) - 0.330079857636554*std::sin(0.257359951734543*x_119 + 1.94495987892151) - 0.0154468342325124*std::sin(0.3018399477005*x_12 + 1.93759989738464) - 0.0255875429464184*std::sin(0.272319942712784*x_120 + 1.9690397977829) + 0.456850429679054*std::sin(0.290079921483994*x_13 + 5.14888000488281) - 0.0233386467488643*std::sin(0.316559940576553*x_13 - 7.46415996551514) - 0.005286238108894*std::sin(0.215839996933937*x_14 + 8.38799953460693) - 0.0172680390534861*std::sin(0.302559942007065*x_14 - 1.21279990673065) - 0.0142197686003979*std::sin(0.310479938983917*x_15 - 7.4489598274231) - 0.0217740976080978*std::sin(0.326959848403931*x_15 + 5.06239986419678) - 0.342063688814591*std::sin(0.361199855804443*x_15 + 5.0304799079895) + 0.00340796270010579*std::sin(0.354799836874008*x_16 - 4.36759996414185) - 0.0125911865298438*std::sin(0.357919842004776*x_16 - 1.1639997959137) - 0.102195284918751*std::sin(0.372639834880829*x_16 - 7.57360029220581) + 0.022073023804185*std::sin(0.300399929285049*x_17 - 1.15783989429474) + 0.0270544719086723*std::sin(0.382559835910797*x_17 - 1.17599976062775) - 0.373650738045881*std::sin(0.388559848070145*x_17 - 1.18951988220215) + 0.274560214594144*std::sin(0.331519842147827*x_18 + 8.21232032775879) + 0.038350049391462*std::sin(0.34215983748436*x_18 + 1.9981597661972) - 0.540994926566247*std::sin(0.218959987163544*x_19 + 1.99543976783752) + 0.391617539007021*std::sin(0.389999836683273*x_2 - 7.38967990875244) - 0.00287113762254645*std::sin(0.406159847974777*x_2 - 7.39583969116211) - 0.00388029467930212*std::sin(0.32399994134903*x_20 - 1.21511995792389) + 0.0269313784523602*std::sin(0.343999862670898*x_20 - 4.3459997177124) + 0.0111176418635641*std::sin(0.345839828252792*x_20 - 4.35503959655762) - 0.370992330399118*std::sin(0.264239966869354*x_21 - 4.20663976669312) + 0.0238092680248726*std::sin(0.354239851236343*x_21 - 4.35671949386597) + 0.0234421518946566*std::sin(0.363679856061935*x_21 - 1.16999983787537) - 0.00472076912186205*std::sin(0.309839934110641*x_22 + 2.02199983596802) - 0.177891269051282*std::sin(0.394959837198257*x_22 - 1.19871985912323) + 0.0206113995141193*std::sin(0.330879837274551*x_23 + 2.02455973625183) - 0.0308075250885291*std::sin(0.294239938259125*x_24 + 8.23031997680664) - 0.00755474882696273*std::sin(0.333999842405319*x_24 + 2.01279973983765) - 0.00394030651774215*std::sin(0.305119931697845*x_25 + 1.99959981441498) + 0.0576462371633751*std::sin(0.316639930009842*x_25 + 1.99391984939575) - 0.0318747739238452*std::sin(0.352719843387604*x_25 + 8.23471927642822) - 0.0115140274906426*std::sin(0.33111983537674*x_26 - 1.14807987213135) - 0.0514635562869752*std::sin(0.345359832048416*x_26 - 1.14991986751556) + 0.369082462446277*std::sin(0.352879852056503*x_26 - 4.36879968643188) - 0.0507072900485543*std::sin(0.341279834508896*x_27 - 1.17215991020203) + 0.358256977591853*std::sin(0.359519839286804*x_27 + 8.22399997711182) + 0.328802726782595*std::sin(0.263759940862656*x_28 - 4.36847972869873) - 0.00594691598521234*std::sin(0.267519950866699*x_28 + 5.01783990859985) + 0.057519636624841*std::sin(0.305919945240021*x_28 - 1.17223989963531) - 0.538840490630181*std::sin(0.25383996963501*x_29 + 2.02095985412598) + 0.0177370071687686*std::sin(0.382479846477509*x_29 + 8.20479965209961) - 0.00431605260793142*std::sin(0.280479967594147*x_3 + 2.05519986152649) + 0.0195876012180948*std::sin(0.360559850931168*x_3 + 1.971599817276) + 0.305303203625367*std::sin(0.379759848117828*x_3 - 7.40215969085693) - 0.0247049833039791*std::sin(0.310399919748306*x_31 - 7.49072027206421) - 0.00713763918747628*std::sin(0.402799874544144*x_31 + 5.18520021438599) - 0.244067018093954*std::sin(0.432959854602814*x_31 + 5.20775985717773) + 0.00255835951225398*std::sin(0.257839977741241*x_32 + 2.03919982910156) - 0.0285963100815481*std::sin(0.31127992272377*x_32 - 1.16535985469818) + 0.0336964185662183*std::sin(0.317919850349426*x_32 - 1.18943989276886) + 0.151689890710569*std::sin(0.328159838914871*x_32 + 1.98015987873077) + 0.0355531828966836*std::sin(0.241519972681999*x_34 - 1.18687987327576) - 0.00268604529169693*std::sin(0.240319982171059*x_35 - 1.21359980106354) + 0.062457991769666*std::sin(0.253919988870621*x_35 - 1.2183198928833) - 0.0381838086270108*std::sin(0.254799962043762*x_35 - 1.21839988231659) + 0.318024435367095*std::sin(0.235199987888336*x_36 - 1.18823993206024) - 0.088403963812436*std::sin(0.241599977016449*x_37 + 1.95127987861633) - 0.00964251905572203*std::sin(0.242719978094101*x_38 + 1.96239984035492) - 0.00504200781052008*std::sin(0.301439940929413*x_4 + 2.01935982704163) + 0.0218813280033205*std::sin(0.317439913749695*x_4 + 2.014319896698) - 0.515289510605865*std::sin(0.323519825935364*x_4 + 2.02319979667664) + 0.0018028590723954*std::sin(0.254159957170486*x_41 + 1.95487987995148) - 0.793021691109814*std::sin(0.259839981794357*x_42 - 7.42735958099365) - 0.0264792367316794*std::sin(0.233439981937408*x_44 - 1.19471991062164) - 0.274796181788761*std::sin(0.193519994616508*x_45 + 1.98415982723236) - 0.0317091736090503*std::sin(0.220799997448921*x_45 - 1.18895995616913) - 0.0428780190288805*std::sin(0.198320001363754*x_47 - 1.18783986568451) - 0.00600828641984151*std::sin(0.211520001292229*x_47 - 1.1898398399353) + 0.0042248013684134*std::sin(0.212239995598793*x_48 + 1.98431980609894) - 0.0913559659030767*std::sin(0.228079989552498*x_48 + 8.19400024414063) + 0.0407034649284937*std::sin(0.224479988217354*x_49 + 1.95463979244232) - 0.0175336772481666*std::sin(0.28519994020462*x_5 - 1.17671978473663) - 0.00424613729488913*std::sin(0.356399834156036*x_5 - 1.15343987941742) - 0.053146313193455*std::sin(0.366639852523804*x_5 - 1.15463984012604) - 0.730347966320291*std::sin(0.197199985384941*x_51 - 1.18839991092682) + 0.00982536467157142*std::sin(0.234479993581772*x_53 - 7.41767978668213) + 0.00640282548401528*std::sin(0.195119991898537*x_54 - 7.38695955276489) + 0.0095463184535521*std::sin(0.210720002651215*x_57 - 7.4017596244812) - 0.0308947456459775*std::sin(0.387679845094681*x_6 + 2.00447988510132) + 0.00450701240019034*std::sin(0.42375984787941*x_6 - 7.41519975662231) + 0.00328301578171533*std::sin(0.399279862642288*x_7 - 1.18111991882324) - 0.0213836421307518*std::sin(0.315919935703278*x_8 + 5.16639995574951) + 0.00448034657352403*std::sin(0.318479925394058*x_8 + 1.95895981788635) - 0.480574263374707*std::sin(0.355119854211807*x_8 - 1.16895985603333) - 0.02245788416052*std::sin(0.339839845895767*x_9 - 4.35839986801147) + 0.00447244047575304*std::sin(0.354879856109619*x_9 - 4.35031986236572) - 0.015497244039297*std::sin(0.339999854564667*x_91 + 5.20272016525269) + 0.00392261627149256*std::sin(0.367439836263657*x_91 + 1.99071979522705) - 0.228683534226888*std::sin(0.385519832372665*x_91 - 4.3854398727417) + 0.0356886410559306*std::sin(0.297839939594269*x_92 - 1.19751989841461) - 0.417956332812714*std::sin(0.319359838962555*x_92 - 1.18919992446899) - 0.0322034950581713*std::sin(0.23735998570919*x_93 + 1.97199988365173) - 0.498764019449132*std::sin(0.277359932661057*x_94 - 7.40759992599487) - 0.0159654162846631*std::sin(0.284879922866821*x_94 + 5.16616010665894) + 0.00763942763108202*std::sin(0.285759925842285*x_94 - 7.43239974975586) + 0.0200786091342067*std::sin(0.268399953842163*x_95 + 1.97319984436035) + 0.316270613813869*std::sin(0.292799949645996*x_95 - 1.21631991863251) - 0.0354780730314937*std::sin(0.301199942827225*x_95 + 8.17088031768799) - 0.00791977634420248*std::sin(0.271919965744019*x_96 + 1.98279976844788) + 0.469882176998033*std::sin(0.26623997092247*x_97 + 1.96175980567932) - 0.0169640011955555*std::sin(0.277999937534332*x_97 - 1.21655988693237) + 0.00556206667721038*std::sin(0.251839965581894*x_98 + 1.98623991012573) + 0.988669759775645);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
