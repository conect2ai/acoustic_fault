
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.65560468201596e-6*x_1 + 0.000619684222838299*x_10 + 0.000782076571342321*x_100 - 0.00155220923664878*x_101 - 0.00136143303775253*x_102 - 0.000586086199682618*x_103 + 0.00121463731626438*x_104 - 0.00113733620512757*x_105 - 0.000722714501677342*x_106 + 0.000658019612937398*x_107 + 0.000353634078528186*x_108 + 0.00300405689886716*x_109 + 3.08624813710392e-5*x_11 + 0.000613258091278059*x_110 - 0.0022807286705117*x_111 - 0.00120070317773062*x_112 - 0.000786883186580713*x_113 + 0.000673908557104051*x_114 - 0.00073526659289161*x_115 - 5.46301166376988e-5*x_116 + 0.00110440516395934*x_117 - 0.000543850680776404*x_118 + 0.00179456508608627*x_119 - 0.00276990530835473*x_12 + 0.00010752006255249*x_120 - 0.00280974444492541*x_13 + 0.000245809914649794*x_14 + 0.000565902754008367*x_15 + 0.000239435806331761*x_16 + 0.000676806866466195*x_17 - 3.72603023913917e-5*x_18 - 0.00384651993221976*x_19 + 0.000210158748372135*x_2 - 0.000226286101910016*x_20 + 2.27689468676691e-5*x_21 - 0.000160124563739084*x_22 + 0.000181274034350086*x_23 + 0.000221662660748364*x_24 + 0.00333287756307107*x_25 - 0.000509464583907111*x_26 - 0.00422020909912556*x_27 + 0.000194285081799259*x_28 + 0.000305896686626439*x_29 + 0.000236780603732645*x_3 + 0.000437784254735157*x_30 + 1.87342271362385e-5*x_31 + 9.87797552019475e-7*x_32 + 0.00126332010031572*x_33 - 0.00311542936682853*x_34 + 0.000198753609662571*x_35 + 0.000475266932310284*x_36 + 0.000585526539993278*x_37 - 0.000633197494017445*x_38 + 0.000209850770390793*x_39 + 0.000267632332089791*x_4 - 0.000393068319342789*x_40 + 0.000785048241448508*x_41 - 0.00127462798527379*x_42 - 0.00238119983815027*x_43 + 2.286928427719e-5*x_44 + 4.72254742044574e-5*x_45 + 0.00116724873145334*x_46 + 0.00241516395764656*x_47 + 0.00104288674883774*x_48 + 0.000706273040639772*x_49 + 3.95378802729339e-5*x_5 + 0.00092073121771535*x_50 - 7.83091269745013e-5*x_51 - 0.00339572709237128*x_52 + 0.000453961296788231*x_53 - 0.000950168530956919*x_54 - 0.00331070438171842*x_55 + 0.00339336070146976*x_56 + 0.0025416844760935*x_57 + 0.0020939039140408*x_58 + 0.00137424165629088*x_59 - 0.00126134960154075*x_6 - 0.00269268693237149*x_60 - 3.84860513274038e-5*x_61 - 4.53773675927902e-5*x_62 + 3.33644810871689e-5*x_63 - 1.82667575850573e-5*x_64 + 7.54272074785995e-5*x_65 - 3.63541145267832e-5*x_66 - 4.86480261246382e-5*x_67 + 1.13128164275885e-5*x_68 - 1.78438325996112e-5*x_69 + 0.000134200539805526*x_7 + 0.000361008513210119*x_70 - 3.44110253766294e-5*x_71 + 7.39258420364822e-6*x_72 + 1.36464321014423e-5*x_73 + 5.41219817492528e-5*x_74 - 5.34957025971327e-5*x_75 + 2.52336520684756e-5*x_76 + 6.57226104632999e-5*x_77 + 0.000129066338120834*x_78 - 0.000194676605737775*x_79 + 0.000861430830000371*x_8 - 1.74104274729152e-6*x_80 - 6.27238508688883e-5*x_81 - 2.88407124172657e-5*x_82 + 1.03088741665192e-5*x_83 + 3.58660466416733e-6*x_84 + 0.000109268694426301*x_85 - 1.74104823777236e-5*x_86 + 2.07461769413277e-5*x_87 + 4.3704825744105e-5*x_88 + 3.53409709476189e-5*x_89 - 4.49273000039693e-5*x_9 + 9.27710721555609e-5*x_90 - 7.64799482835925e-5*x_91 - 0.00127891588847352*x_92 - 7.96633891152046e-5*x_93 + 7.69653950558002e-5*x_94 - 0.000708460795297887*x_95 - 0.0030969833130481*x_96 + 0.000474080472031968*x_97 - 0.000799120840806626*x_98 - 0.000204950293168563*x_99 + 1.93916981682323e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) + 2.78690220958149e-8*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) + 5.89157657291869e-9*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 2.36293754763894e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) + 0.000826891552737035*std::exp(0.226479843258858*x_10) + 3.61806836000439e-6*std::exp(0.253039866685867*x_15) - 0.000413202752635118*std::exp(0.364639848470688*x_22) + 0.0209170321841245*std::sin(0.130640044808388*x_1 - 7.68408012390137) - 0.0178038768637648*std::sin(0.249999970197678*x_100 + 1.79223990440369) + 0.00217791276436628*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.000898717316173644*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.0058029070544874*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.00219333220706906*std::sin(0.293919920921326*x_112 + 1.76895987987518) - 0.0361789403874749*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.0240635683393251*std::sin(0.254879981279373*x_118 + 8.16423988342285) - 0.000763104065499782*std::sin(0.0867200791835785*x_13 + 1.7151198387146) + 0.00207727385997259*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00550926892666622*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.0019943052011997*std::sin(0.335759848356247*x_15 + 5.07039976119995) - 0.00332039647651935*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 0.000241344125966286*std::sin(0.403359860181808*x_16 - 7.78911972045898) + 9.37381997329298e-5*std::sin(0.324799835681915*x_18 + 4.99583959579468) + 0.00905041540351986*std::sin(0.404319852590561*x_18 - 1.20223987102509) + 0.015664058382828*std::sin(0.180800005793571*x_19 + 7.99456024169922) + 0.000164717615772732*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00625549411713295*std::sin(0.348719835281372*x_20 + 8.23320007324219) - 0.00444571633232903*std::sin(0.35455983877182*x_21 - 1.396479845047) - 0.00720799773587677*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.00102442963119691*std::sin(0.445919841527939*x_21 - 7.63576030731201) - 0.00924557641222314*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00356264547233863*std::sin(0.308639913797379*x_25 - 1.38775980472565) + 3.25062793404271e-5*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00603160707254986*std::sin(0.274079948663712*x_27 - 7.57639980316162) - 0.00199967587827291*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00508237705940423*std::sin(0.380559861660004*x_29 - 7.58888006210327) - 0.00538071272933375*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.00048618046674818*std::sin(0.335599839687347*x_3 + 1.7707998752594) + 0.000551383941982864*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.00325993323823642*std::sin(0.273759961128235*x_32 + 1.80263984203339) - 0.0143711354899836*std::sin(0.30295991897583*x_32 - 1.35095977783203) + 0.00518232348974628*std::sin(0.228079989552498*x_37 + 1.79159986972809) + 0.00430386200199617*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00406703847574456*std::sin(0.253279983997345*x_40 + 1.75911998748779) - 0.0331981226296326*std::sin(0.26335996389389*x_40 - 7.62576007843018) - 0.00736932405082555*std::sin(0.266879975795746*x_41 - 1.23359990119934) - 0.0124998153599619*std::sin(0.13984003663063*x_43 - 1.42143988609314) + 0.00673029181596052*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.00144883381186131*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.00170912319186669*std::sin(0.347999840974808*x_5 - 4.38783979415894) + 0.00106171605125247*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.000249245528372707*std::sin(0.296719938516617*x_51 - 4.88095998764038) + 0.00462673525344196*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.00406757656512982*std::sin(0.184640005230904*x_55 + 1.80663990974426) - 0.00358093723702662*std::sin(0.267279952764511*x_58 + 8.13583946228027) + 0.00413433327541059*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.000973115127356302*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00643133702597142*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.00433829761247469*std::sin(0.341199845075607*x_7 - 7.59463977813721) - 0.0017315843695579*std::sin(0.176720008254051*x_8 + 1.78079986572266) - 0.0115670340808581*std::sin(0.366319835186005*x_9 + 5.02328014373779) + 0.00186641911272908*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00372076725323192*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.00189641275263247*std::sin(0.289119929075241*x_98 + 4.9695200920105) - 0.0483956858600877);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000777386762620627*x_1 - 0.000200883262359634*x_10 + 0.00130288859942198*x_100 + 0.00139141982434368*x_101 + 0.00130379230965516*x_102 + 1.74326014536227e-5*x_103 - 0.000918398224461604*x_104 + 0.000989791831546901*x_105 - 0.00111950555850887*x_106 + 0.00171279103362253*x_107 - 8.92341999247899e-5*x_108 - 0.00232231271755488*x_109 - 0.00115654872388312*x_11 - 0.00298248883642346*x_110 + 0.00110983802931202*x_111 + 0.000902915627015379*x_112 - 0.00197472443632043*x_113 + 0.0011554539742036*x_114 - 0.00187252660757511*x_115 - 0.000152023198630117*x_116 - 0.00441292504144709*x_117 + 7.22177675811153e-6*x_118 - 0.00116684620487891*x_119 + 0.00443346122525386*x_12 - 0.000316917997980002*x_120 + 0.00194059374147264*x_13 - 0.000147778214666655*x_14 - 0.000430470810540071*x_15 - 0.000119896569918354*x_16 + 0.000642692801121676*x_17 - 1.37554600259992e-5*x_18 + 0.0029890514923257*x_19 - 0.000104268486324601*x_2 - 0.000701729998478802*x_20 - 9.64343634062639e-6*x_21 - 0.000843666744584845*x_22 - 0.000115279969773482*x_23 - 0.000150665508989906*x_24 - 0.0021009716989828*x_25 - 0.00279594833336612*x_26 + 0.00262307195475975*x_27 - 0.000101090394674148*x_28 - 0.00027060390887628*x_29 + 3.46583609761669e-5*x_3 - 0.00108057810410538*x_30 + 9.92721992487127e-7*x_31 + 3.13767904815464e-6*x_32 + 0.000306211425137322*x_33 + 0.00429195256618657*x_34 + 0.000588295595994266*x_35 + 0.00148535342805944*x_36 - 0.000470320934025577*x_37 - 0.00313100175544614*x_38 - 0.000749570737691673*x_39 - 0.000161800250720252*x_4 + 0.000116174067602035*x_40 - 7.84802475381819e-5*x_41 + 0.00373008954638173*x_42 + 0.0015908446757697*x_43 - 4.24008970387918e-5*x_44 - 0.000421090990421009*x_45 + 0.000891176357859214*x_46 - 0.00201397407415508*x_47 - 0.000298293032574757*x_48 - 0.00147432003325299*x_49 + 3.61670164512812e-5*x_5 - 0.001669539947012*x_50 + 0.000606995228766488*x_51 + 0.00250319985283767*x_52 - 0.000354233232091373*x_53 - 0.00286172881982243*x_54 + 0.00532640266804794*x_55 - 0.00229032098238461*x_56 + 0.00216544205290225*x_57 - 0.00106281573422416*x_58 - 0.000486825507805003*x_59 + 0.000980163781709666*x_6 - 0.0019787909402897*x_60 - 2.45053639533216e-5*x_61 + 5.30857861459886e-5*x_62 - 2.31383058501742e-6*x_63 + 6.1231387405259e-5*x_64 - 4.31847924795307e-5*x_65 - 3.07445415026508e-5*x_66 + 4.71068197546587e-5*x_67 + 7.02959220450218e-6*x_68 - 1.21734852365513e-5*x_69 - 0.000294510972020662*x_7 - 0.000283303792037067*x_70 + 2.41597554877075e-5*x_71 + 3.63126103951291e-5*x_72 + 3.42560386130735e-5*x_73 - 1.07530965015117e-5*x_74 + 3.15907328278561e-5*x_75 + 1.80894757105251e-6*x_76 - 1.83642009783437e-5*x_77 - 5.47276455671799e-5*x_78 + 0.000164418528733354*x_79 - 0.000721411774879934*x_8 + 3.89581006986111e-5*x_80 + 6.6423012100367e-5*x_81 + 1.04977976021853e-5*x_82 + 0.000113318716994051*x_83 - 5.63543672162093e-5*x_84 - 4.51549214808894e-5*x_85 + 7.69342816688827e-5*x_86 - 5.45756797307379e-5*x_87 + 3.86788512549089e-5*x_88 + 9.09751378472862e-5*x_89 - 0.000191036498898023*x_9 - 0.000126887268061941*x_90 + 6.20240458462595e-5*x_91 + 0.00101870205203555*x_92 - 0.000101217183595232*x_93 + 2.02745977001461e-5*x_94 + 0.000502645005597485*x_95 + 0.00138734990566229*x_96 - 0.000245712803976891*x_97 - 0.000872282098629474*x_98 + 9.82629964991527e-5*x_99 + 2.40711880155104e-8*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 2.42816101264445e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 5.13318927667679e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 2.93314765342755e-8*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) + 0.00204236236274551*std::exp(0.226479843258858*x_10) - 3.15233613244161e-5*std::exp(0.253039866685867*x_15) + 0.000102317617188039*std::exp(0.364639848470688*x_22) + 0.00025964606609615*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.0135430500205467*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.000539296611826189*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 1.11559046055339e-5*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 7.2032302448853e-5*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 2.72261415574861e-5*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.0275205902123017*std::sin(0.231439992785454*x_115 + 4.96000003814697) - 0.0183046710660866*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.00664874258618246*std::sin(0.0867200791835785*x_13 + 1.7151198387146) + 0.00513071627673562*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 6.83873310172714e-5*std::sin(0.33231982588768*x_15 - 4.33975982666016) + 0.000493831550809288*std::sin(0.335759848356247*x_15 + 5.07039976119995) - 0.00820113927949693*std::sin(0.414319843053818*x_15 - 1.39479982852936) + 5.97618378234919e-5*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000816718438144117*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.0068844684477714*std::sin(0.404319852590561*x_18 - 1.20223987102509) + 0.0386890919166397*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.00143514505582583*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 7.76503293920403e-5*std::sin(0.348719835281372*x_20 + 8.23320007324219) - 0.0109805979787041*std::sin(0.35455983877182*x_21 - 1.396479845047) + 0.00548297849013118*std::sin(0.439759850502014*x_21 + 1.78055989742279) + 0.000253670136930209*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.0070329234906339*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 4.42236199497774e-5*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000283219410746414*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 7.48711879792345e-5*std::sin(0.274079948663712*x_27 - 7.57639980316162) - 0.00493905487116936*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 6.30882621528489e-5*std::sin(0.380559861660004*x_29 - 7.58888006210327) - 0.013289971492346*std::sin(0.407679855823517*x_29 - 7.6049599647522) - 0.000120388420851035*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.000419426643081213*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 4.04660103590884e-5*std::sin(0.273759961128235*x_32 + 1.80263984203339) + 0.0109318328969697*std::sin(0.30295991897583*x_32 - 1.35095977783203) + 0.0127999644112892*std::sin(0.228079989552498*x_37 + 1.79159986972809) + 0.0106302280368353*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 5.04847213310799e-5*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.0252531422679299*std::sin(0.26335996389389*x_40 - 7.62576007843018) - 0.0182016977080763*std::sin(0.266879975795746*x_41 - 1.23359990119934) - 0.0308736403799895*std::sin(0.13984003663063*x_43 - 1.42143988609314) + 0.0166233342809141*std::sin(0.272719949483871*x_44 - 4.44063997268677) - 0.000358761461257784*std::sin(0.228959992527962*x_48 + 1.77615988254547) - 0.000423214539006325*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 0.000807625985045652*std::sin(0.413919866085052*x_5 - 1.21863985061646) + 6.17183898104116e-5*std::sin(0.296719938516617*x_51 - 4.88095998764038) + 0.0114277016287561*std::sin(0.269599944353104*x_53 - 1.22887980937958) - 0.00100721677002357*std::sin(0.184640005230904*x_55 + 1.80663990974426) - 0.00884465612455335*std::sin(0.267279952764511*x_58 + 8.13583946228027) + 0.010211504336688*std::sin(0.410799860954285*x_6 - 4.4031195640564) - 0.000240963595827387*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 7.98330921821393e-5*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 5.38518991947766e-5*std::sin(0.341199845075607*x_7 - 7.59463977813721) - 0.0042768882238517*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.00879880951464319*std::sin(0.366319835186005*x_9 + 5.02328014373779) - 0.000462164288768158*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 4.61864078831544e-5*std::sin(0.278399974107742*x_97 - 7.60279989242554) + 0.00046959133940163*std::sin(0.289119929075241*x_98 + 4.9695200920105) - 0.0218973355180858);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.54028304626165e-5*x_1 + 0.000159551435517041*x_10 + 0.000166717346350589*x_100 - 8.69827284577755e-6*x_101 + 0.00015823579433948*x_102 - 0.000200997770055298*x_103 - 2.7733561620989e-6*x_104 + 6.11816998470838e-6*x_105 - 5.07606021669934e-5*x_106 + 8.25876985886967e-5*x_107 + 0.000170467967473652*x_108 - 2.48075726516932e-7*x_109 + 1.07550163095608e-5*x_11 - 8.95551419409315e-5*x_110 - 2.21942242160744e-5*x_111 - 1.84682327552975e-6*x_112 - 9.42750269323061e-5*x_113 + 8.26329206869661e-5*x_114 - 4.87420464975811e-5*x_115 - 1.67683087098198e-5*x_116 - 0.00024293891823275*x_117 - 0.00023279478256189*x_118 - 0.000109877580148558*x_119 + 0.000113991075062871*x_12 + 4.25076065214275e-5*x_120 - 8.7967770065106e-6*x_13 + 2.53622475367157e-5*x_14 + 4.02097239140213e-5*x_16 + 0.000148352463688207*x_17 - 8.25854716377577e-6*x_18 + 5.24128629543724e-5*x_19 + 1.87458653603958e-5*x_2 - 3.54646062495173e-5*x_20 + 1.24367072892655e-5*x_21 + 4.46812347966814e-5*x_22 + 1.44195612386269e-5*x_23 + 3.53562193012389e-5*x_24 + 1.70153378015937e-5*x_25 - 0.000103850723100111*x_26 - 2.4610323342881e-5*x_27 + 3.55977576772912e-5*x_28 + 4.40565635584021e-6*x_29 + 9.51750696493177e-5*x_3 - 3.85689243627376e-5*x_30 - 6.18287868221286e-7*x_31 + 4.5486005429685e-7*x_32 + 0.000511290492205667*x_33 + 4.37829838299063e-5*x_34 - 2.28910055231863e-5*x_35 - 0.000151977289253506*x_36 - 1.97095065761642e-6*x_37 + 9.74356038410837e-5*x_38 + 3.93228892733557e-5*x_39 + 2.01372448071814e-5*x_4 - 8.35031291675029e-6*x_40 + 0.00024222621208111*x_41 + 0.000578994320998055*x_42 - 5.34643949090161e-5*x_43 - 4.08512802245447e-6*x_44 + 7.65849934997094e-5*x_45 + 0.000251115032818822*x_46 - 9.65713780589073e-6*x_47 + 0.000269504946533723*x_48 + 1.60993867104537e-5*x_49 + 1.31262412981867e-5*x_5 + 0.000561183683281643*x_50 - 0.000174945950214798*x_51 + 5.95708300020735e-6*x_52 + 2.42324214250246e-6*x_53 - 0.000106355305366995*x_54 + 0.0005756134829202*x_55 + 4.86816828349368e-5*x_56 + 0.000651631291148986*x_57 + 0.000409604542703261*x_58 + 0.000350137116960606*x_59 + 1.94932416076421e-5*x_6 - 0.000138600339979645*x_60 - 1.9779273030781e-5*x_61 + 1.66304710551854e-6*x_62 - 6.13285766192263e-7*x_63 - 8.36145991859571e-6*x_64 - 3.76444140591718e-6*x_65 - 1.603873733682e-5*x_66 - 1.80780625545144e-6*x_67 + 3.44418020397869e-6*x_68 - 7.57095685397952e-6*x_69 - 1.26193636253296e-5*x_7 - 3.54798455460093e-6*x_70 + 2.82481843490137e-6*x_71 + 7.07719690908933e-6*x_72 + 8.77079475270777e-6*x_73 + 4.46029098228424e-6*x_74 + 3.85435190257005e-7*x_75 - 1.0574384162032e-5*x_76 + 2.95694566009682e-6*x_77 + 6.47987448898798e-6*x_78 - 5.65341260959004e-7*x_79 - 1.03192666655263e-5*x_8 + 1.77645444373999e-6*x_80 + 3.64852893616229e-6*x_81 - 4.98965488510474e-6*x_82 + 4.51579604041507e-6*x_83 - 4.93722982726237e-6*x_84 - 6.67075033149113e-6*x_85 + 1.71077991009006e-6*x_86 - 1.99578880939198e-7*x_87 + 4.29795235545426e-6*x_88 - 1.5455936387797e-6*x_89 + 7.78843354337119e-6*x_9 - 9.9791820237714e-6*x_90 - 9.17770903215177e-6*x_91 + 3.49531099508076e-6*x_92 - 0.00011065302654729*x_93 - 4.21920102539409e-6*x_94 - 4.5881141093382e-5*x_95 - 4.38137734838378e-5*x_96 - 1.66756495929631e-5*x_97 - 5.24655634353371e-5*x_98 - 9.18181891439513e-5*x_99 + 8.11606143111412e-7*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) + 8.28816199495384e-8*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) + 1.75213686630784e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 9.88966831483637e-7*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) + 9.46008612069543e-5*std::exp(0.226479843258858*x_10) + 1.07600247233061e-5*std::exp(0.253039866685867*x_15) + 1.71630023530652e-6*std::exp(0.364639848470688*x_22) + 0.0087544637241237*std::sin(0.130640044808388*x_1 - 7.68408012390137) - 9.04629063122371e-6*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.000376142660843416*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00242870684788296*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.000917981436023781*std::sin(0.293919920921326*x_112 + 1.76895987987518) - 0.00226944816797854*std::sin(0.0867200791835785*x_13 + 1.7151198387146) + 0.000237651352787002*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00230580966460181*std::sin(0.33231982588768*x_15 - 4.33975982666016) + 8.28364880016812e-6*std::sin(0.335759848356247*x_15 + 5.07039976119995) - 0.000379871296529207*std::sin(0.414319843053818*x_15 - 1.39479982852936) + 1.00245939201562e-6*std::sin(0.403359860181808*x_16 - 7.78911972045898) + 0.00027877454107675*std::sin(0.324799835681915*x_18 + 4.99583959579468) + 0.00179205290960662*std::sin(0.180800005793571*x_19 + 7.99456024169922) + 0.00048986515502888*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00261812937145422*std::sin(0.348719835281372*x_20 + 8.23320007324219) - 0.000508613967972045*std::sin(0.35455983877182*x_21 - 1.396479845047) + 4.25512367927239e-6*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00149108392983082*std::sin(0.308639913797379*x_25 - 1.38775980472565) + 9.66726812661071e-5*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00252442530326468*std::sin(0.274079948663712*x_27 - 7.57639980316162) - 0.000228773724430039*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00212714142270347*std::sin(0.380559861660004*x_29 - 7.58888006210327) - 0.000615582607437847*std::sin(0.407679855823517*x_29 - 7.6049599647522) - 2.01942422735549e-6*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.00136438893558074*std::sin(0.273759961128235*x_32 + 1.80263984203339) + 0.000592885806561063*std::sin(0.228079989552498*x_37 + 1.79159986972809) + 0.000492385066163814*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00170218893804371*std::sin(0.253279983997345*x_40 + 1.75911998748779) - 0.000843090486791951*std::sin(0.266879975795746*x_41 - 1.23359990119934) - 0.00143004641184957*std::sin(0.13984003663063*x_43 - 1.42143988609314) + 0.000769981746525908*std::sin(0.272719949483871*x_44 - 4.44063997268677) - 6.01795074296963e-6*std::sin(0.228959992527962*x_48 + 1.77615988254547) - 7.09910211793522e-6*std::sin(0.347999840974808*x_5 - 4.38783979415894) + 1.03527906401178e-6*std::sin(0.296719938516617*x_51 - 4.88095998764038) + 0.000529323510566058*std::sin(0.269599944353104*x_53 - 1.22887980937958) - 1.68952955209966e-5*std::sin(0.184640005230904*x_55 + 1.80663990974426) - 0.000409678567194773*std::sin(0.267279952764511*x_58 + 8.13583946228027) + 0.000472990063903567*std::sin(0.410799860954285*x_6 - 4.4031195640564) - 4.0419811131723e-6*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00269172539373022*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.00181571977986856*std::sin(0.341199845075607*x_7 - 7.59463977813721) - 0.000198102607373924*std::sin(0.176720008254051*x_8 + 1.78079986572266) - 7.75245455633795e-6*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00155726307908292*std::sin(0.278399974107742*x_97 - 7.60279989242554) + 7.87703768385973e-6*std::sin(0.289119929075241*x_98 + 4.9695200920105) - 0.148351296782494*std::sin(0.00202192655751549*x_1 + 0.00217219511135824*x_10 - 0.0128136243523693*x_101 - 0.0143544778764468*x_102 + 0.000343339859425779*x_103 + 0.0098525860502143*x_104 - 0.0107789359835303*x_105 + 0.000417389200496174*x_106 + 0.000722969455175506*x_107 + 0.00082362937293757*x_108 + 0.0249620476593816*x_109 + 0.00235133518444751*x_11 + 0.0124790224752444*x_110 - 0.017854062122115*x_111 - 0.00947280388627244*x_112 - 0.000432138042666395*x_113 - 1.05150095364109e-5*x_114 + 0.000148534675211735*x_116 + 0.0202889828535797*x_117 + 0.0150920442403362*x_119 - 0.0292926601005337*x_12 - 4.90890301719156e-5*x_120 - 0.0233378945263287*x_13 + 0.0015971703685837*x_14 + 0.00468694675763554*x_15 + 0.00127229618621062*x_16 + 0.00151500746561736*x_17 - 0.0325724709362525*x_19 + 0.00152238815647549*x_2 - 0.00104411560452232*x_20 + 0.0012004616563543*x_23 + 0.00134779062829734*x_24 + 0.0265462488295939*x_25 + 0.00270047527549756*x_26 - 0.0346389506837699*x_27 + 0.00106078821450259*x_28 + 0.0029530610574944*x_29 + 0.0060737454554561*x_30 + 0.000101837986344408*x_31 + 0.000677530759170896*x_33 - 0.0300195956828772*x_34 + 0.00263899162898068*x_35 + 0.0019895989896949*x_36 + 0.00518884752562241*x_37 + 0.00143906186127381*x_38 + 0.00278515155101529*x_39 + 0.00156115375944869*x_4 + 0.000621380069664361*x_41 - 0.022111208187744*x_42 - 0.0186750474847172*x_43 + 0.00049832412839798*x_44 + 0.00233549062270581*x_45 + 0.000947793016379098*x_46 + 0.0197379464287347*x_47 + 0.00332278598675234*x_48 + 0.011081719313462*x_49 + 0.000914723294534668*x_50 + 0.00162042205566254*x_51 - 0.0279469176563619*x_52 + 0.00390678276141286*x_53 + 0.00158322013927392*x_54 - 0.0419624201591005*x_55 + 0.0273976107302793*x_56 + 0.000408202606356471*x_57 + 0.0112672490728157*x_58 + 0.00546092774491704*x_59 - 0.0107464691280164*x_6 - 0.012012704846342*x_60 + 9.36786016234703e-5*x_61 - 0.000430644683526494*x_62 + 0.000235001862457655*x_63 - 0.000121117401948686*x_64 + 0.000680844137270208*x_65 + 7.52108462904198e-5*x_66 - 0.000384724659277529*x_67 - 1.03989551490829e-5*x_68 + 4.27681675018902e-5*x_69 + 0.00173815524140852*x_7 + 0.00307409380637964*x_70 - 0.000370848107593557*x_71 - 0.000129689605020804*x_72 - 0.000120765983231048*x_73 + 0.000311368920232937*x_74 - 0.000420761403398237*x_75 + 0.000348710430116836*x_76 + 0.000306119675872117*x_77 + 0.000859022360812251*x_78 - 0.00167877602974737*x_79 + 0.0079707250764813*x_8 - 6.75085651877687e-5*x_80 - 0.000923228625699584*x_81 - 0.000107521940150643*x_82 - 0.000184696304562978*x_83 + 0.000228136222879918*x_84 + 0.000936555186927549*x_85 - 0.000333896703155884*x_86 + 0.000199121211476902*x_87 + 0.000133487443864801*x_88 + 5.48494518539852e-5*x_89 + 0.00102257706340555*x_90 - 0.000472539874073341*x_91 - 0.0106755540065295*x_92 + 0.00149194117890459*x_93 + 0.000550615238584429*x_94 - 0.00505910300081343*x_95 - 0.0227977725903495*x_96 + 0.00366483187182515*x_97 - 0.00281534968466052*x_98 + 0.00194926427847154*x_99 - 0.147456117414002*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.299642944203198*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.199300432461711*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0749577817572433*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0596984223489261*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0765741535640241*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00456669836077644*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.119025303219011*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.274955073316789*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.0087933952763089*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0958010408974541*std::sin(0.366319835186005*x_9 + 5.02328014373779) + 0.866212995562594) + 0.199119692809334);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.38231208284551e-5*x_1 + 0.000488565769529702*x_10 + 0.000314655547248216*x_100 - 0.00010347459806101*x_101 + 0.000520361870826212*x_102 - 0.000789120226747416*x_103 + 2.00076999133064e-5*x_104 + 0.000124703347096201*x_105 - 0.000202985232038113*x_106 - 0.000169415776327321*x_107 + 0.000388512894391716*x_108 - 2.06881974940073e-6*x_109 + 0.000272483324301768*x_11 - 5.74697310584776e-5*x_110 + 7.68732080801167e-5*x_111 - 3.96038663420889e-5*x_112 + 0.000121768357447009*x_113 - 5.67332486568246e-5*x_114 - 4.6121362350439e-5*x_115 + 4.67142975270049e-5*x_116 - 0.000430438628991645*x_117 - 0.000770326214973466*x_118 - 0.000292981111581068*x_119 + 1.9748051730162e-5*x_12 + 0.000241433322806981*x_120 + 7.13058966961946e-5*x_13 + 7.1915929943913e-5*x_14 + 7.76854341787562e-5*x_16 + 0.000256926226366769*x_17 - 3.42726967611209e-5*x_18 + 0.000121211627748802*x_19 + 1.63827850672633e-5*x_2 + 0.00018557521315226*x_20 + 1.81815766723128e-5*x_21 + 0.000192791272819112*x_22 + 9.1551198828333e-5*x_23 + 0.000102336463159191*x_24 - 2.31530972847284e-5*x_25 + 0.000243405847754304*x_26 + 0.000153066585769417*x_27 + 8.83400983475309e-5*x_28 - 5.5944774629621e-5*x_29 + 0.000307411887274284*x_3 + 1.31821889298135e-5*x_30 + 1.95390696105073e-6*x_31 - 1.58248223828542e-6*x_32 + 0.00153598236802965*x_33 - 0.000374499029031483*x_34 - 0.000692412322800324*x_35 - 0.00106839228418671*x_36 - 3.94266917090366e-5*x_37 + 0.000360831768131888*x_38 - 0.000177167726052995*x_39 + 7.44976879533492e-5*x_4 - 0.000275441090344256*x_40 + 0.000908123863864995*x_41 + 0.00124639589956624*x_42 - 0.00035438766112443*x_43 - 4.03627425329982e-5*x_44 - 0.000402297147005*x_45 + 0.000747841006283197*x_46 + 8.7545750516458e-5*x_47 + 0.000875604205157519*x_48 - 0.000258960711231153*x_49 + 2.20332333876773e-5*x_5 + 0.00187058665684387*x_50 - 0.00121014065749603*x_51 + 2.99371025942241e-7*x_52 - 1.2781709259863e-5*x_53 + 5.61354923411676e-5*x_54 + 0.00132894461580746*x_55 - 0.000328951967023343*x_56 + 0.00206294241758171*x_57 + 0.00100433867283858*x_58 + 0.00105727462648964*x_59 + 4.12004658582366e-5*x_6 + 8.60809176254849e-5*x_60 - 5.76764434782062e-5*x_61 + 5.60717992505933e-7*x_62 + 2.93644971380567e-6*x_63 - 3.77554780753003e-5*x_64 - 3.24161894355965e-6*x_65 - 5.26663599519261e-5*x_66 - 8.22571899501236e-6*x_67 + 9.20339932861124e-6*x_68 - 2.28200760396048e-5*x_69 + 1.47999233485367e-5*x_7 - 1.48179122029448e-5*x_70 + 1.68365126937697e-5*x_71 + 1.61439778368314e-5*x_72 + 2.09095839815101e-5*x_73 + 1.05783524974309e-5*x_74 + 2.03175897807307e-7*x_75 - 4.05021661850107e-5*x_76 + 1.76656178505027e-5*x_77 + 1.23093158870141e-5*x_78 + 2.11833521147633e-6*x_79 - 0.000106643665929731*x_8 - 1.12654206399262e-5*x_80 + 4.12875200959895e-5*x_81 - 3.17863538236143e-5*x_82 - 1.33582766480989e-5*x_83 - 1.50685279555205e-5*x_84 - 2.57381455311664e-5*x_85 + 1.39534494944663e-6*x_86 + 6.25514366425411e-6*x_87 + 3.34544201714784e-6*x_88 - 1.04094313786575e-5*x_89 + 3.05151665495477e-5*x_9 - 2.63266427224444e-5*x_90 - 4.08287142889551e-5*x_91 + 4.67264871012073e-7*x_92 - 0.00037625429941775*x_93 - 2.9121871249275e-5*x_94 - 0.00016129520205533*x_95 - 3.79749466047097e-5*x_96 + 7.8962463624567e-5*x_97 + 2.90116893940714e-5*x_98 - 0.000578253654972457*x_99 + 2.67164025926111e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 2.84668404012045e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 6.01795676346811e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 3.25547511498183e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 6.56074142083839e-5*std::exp(0.226479843258858*x_10) - 3.69567953302385e-5*std::exp(0.253039866685867*x_15) - 0.000329797415211682*std::exp(0.364639848470688*x_22) + 0.0288178914515673*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.00173829916587899*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.00123818416662344*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00799480271042817*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.00302180581375762*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.00779473408410507*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 0.000164815526418627*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00759025049579733*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.00159175295010601*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 0.000263447638629271*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 0.000192628602816909*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000957489775607971*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.00124282121773388*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.00168250972830992*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00861834264328738*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 0.000352733017894118*std::sin(0.35455983877182*x_21 - 1.396479845047) - 0.000817647613140036*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00490834118332497*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000332035714363967*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00830988815072775*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 0.000158658730028273*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00700211144318116*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 0.000426917710794401*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.000388044513831081*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.00449128735720714*std::sin(0.273759961128235*x_32 + 1.80263984203339) - 0.000411177067450037*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 0.000341477979943137*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00560325538975403*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.000584698554288016*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 0.000991763141290838*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 0.000533996316024092*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.00115638543832522*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.0013641351790648*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 0.000198935100229055*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 0.000367095461551573*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.00324653267385183*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 0.000284119521823855*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 0.000328027193865441*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.000776690986831096*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00886060559028809*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.00597697553746542*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 0.000137387753683435*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.00148968078057139*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00512618931196005*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.00151362017799759*std::sin(0.289119929075241*x_98 + 4.9695200920105) - 0.0626489222049713*std::sin(0.00196871799572463*x_1 + 0.00211503211630537*x_10 - 0.0124764239132219*x_101 - 0.0139767286846053*x_102 + 0.000334304605371857*x_103 + 0.00959330762503905*x_104 - 0.010495279943113*x_105 + 0.000406405280737619*x_106 + 0.000703943954577758*x_107 + 0.000801954928720086*x_108 + 0.024305152061283*x_109 + 0.00228945797976484*x_11 + 0.0121506273433859*x_110 - 0.0173842186631074*x_111 - 0.00922351972259104*x_112 - 0.000420765995714476*x_113 - 1.02382989246579e-5*x_114 + 0.000144625870307465*x_116 + 0.0197550625715468*x_117 + 0.0146948854189499*x_119 - 0.0285218010853115*x_12 - 4.77972143611744e-5*x_120 - 0.022723739774586*x_13 + 0.00155513959455215*x_14 + 0.00456360612726636*x_15 + 0.00123881472765386*x_16 + 0.00147513887194946*x_17 - 0.0317153011611929*x_19 + 0.00148232533421698*x_2 - 0.00101663889452337*x_20 + 0.0011688705790314*x_23 + 0.00131232247508458*x_24 + 0.0258476637519535*x_25 + 0.00262941017917795*x_26 - 0.0337273998952523*x_27 + 0.00103287275187187*x_28 + 0.00287534897088777*x_29 + 0.00591391014434285*x_30 + 9.91580409384174e-5*x_31 + 0.000659701013015895*x_33 - 0.0292296067953521*x_34 + 0.00256954452239104*x_35 + 0.00193724115286412*x_36 + 0.00505229898820684*x_37 + 0.00140119183494577*x_38 + 0.00271185813298866*x_39 + 0.00152007079035375*x_4 + 0.000605027972349326*x_41 - 0.021529334636128*x_42 - 0.0181835991606698*x_43 + 0.000485210343389724*x_44 + 0.00227403037992482*x_45 + 0.000922851109815031*x_46 + 0.0192185270965763*x_47 + 0.00323534430256418*x_48 + 0.0107900952954443*x_49 + 0.000890651643288048*x_50 + 0.00157777939549492*x_51 - 0.0272114728948025*x_52 + 0.00380397275024235*x_53 + 0.0015415564763204*x_54 - 0.0408581466049347*x_55 + 0.0266766214054962*x_56 + 0.000397460438930668*x_57 + 0.0109707426956302*x_58 + 0.00531721920601348*x_59 - 0.0104636674780226*x_6 - 0.011696581223693*x_60 + 9.12133767395907e-5*x_61 - 0.000419311935475802*x_62 + 0.000228817606618555*x_63 - 0.000117930103803963*x_64 + 0.000662927197006856*x_65 + 7.32316146772279e-5*x_66 - 0.000374600332194753*x_67 - 1.01252985983275e-5*x_68 + 4.16426900829663e-5*x_69 + 0.00169241434136404*x_7 + 0.00299319664933915*x_70 - 0.000361088952705081*x_71 - 0.000126276722719647*x_72 - 0.000117587932941783*x_73 + 0.000303175006180823*x_74 - 0.000409688741511133*x_75 + 0.000339533845339796*x_76 + 0.000298063899746868*x_77 + 0.000836416522734148*x_78 - 0.00163459773960136*x_79 + 0.00776096927888641*x_8 - 6.57320250612965e-5*x_80 - 0.00089893315008251*x_81 - 0.000104692417102383*x_82 - 0.000179835878402911*x_83 + 0.000222132641658473*x_84 + 0.000911909012540571*x_85 - 0.00032510995306568*x_86 + 0.000193881182730378*x_87 + 0.000129974618495955*x_88 + 5.34060460896562e-5*x_89 + 0.000995667156781152*x_90 - 0.000460104621667747*x_91 - 0.0103946185428269*x_92 + 0.00145267959241867*x_93 + 0.000536125372552296*x_94 - 0.00492596879095573*x_95 - 0.0221978315652619*x_96 + 0.00356838898551936*x_97 - 0.00274126157938175*x_98 + 0.00189796788077487*x_99 - 0.143575695592695*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.291757608283072*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.194055687376303*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0729852097330461*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0581274121742177*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0745590454650924*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00444652216001068*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.115893060271084*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.267719417820842*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.00856199027587906*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0932799623818799*std::sin(0.366319835186005*x_9 + 5.02328014373779) - 2.15521757956166) + 0.100944226105806);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000111331818026646*x_1 + 0.000442636319130698*x_10 + 6.00361696927562e-5*x_100 - 0.000107930580356317*x_101 + 0.000466262122981006*x_102 - 0.000640530781069806*x_103 + 4.72092903961153e-6*x_104 + 4.55543460616782e-5*x_105 + 0.000148215651251559*x_106 - 0.000387394950858903*x_107 + 0.000404152685822932*x_108 + 2.59673964036793e-6*x_109 + 0.0004110669686404*x_11 + 0.000320169999315297*x_110 + 0.000120568425564662*x_111 - 1.15016014697443e-5*x_112 + 0.000413318741592406*x_113 - 0.000333936104144049*x_114 + 0.000281890633651695*x_115 + 7.05723893077348e-5*x_116 + 4.32533894727092e-5*x_117 - 0.000692575419098754*x_118 - 0.000373741366951611*x_119 - 0.000272281411136512*x_12 + 0.000218525556241823*x_120 + 5.90498454306987e-5*x_13 + 6.65257387818812e-5*x_14 + 6.74366678531276e-5*x_16 + 0.000132854127350005*x_17 - 2.22989349975227e-5*x_18 + 0.000121774610776104*x_19 + 1.88059757749023e-5*x_2 + 0.000204520864244735*x_20 + 1.68031887592479e-5*x_21 + 0.000310033350325401*x_22 + 8.61560490526592e-5*x_23 + 0.000102485473895751*x_24 - 7.34605520721485e-5*x_25 + 0.000577247331276641*x_26 + 0.000149920221975338*x_27 + 8.48048939965275e-5*x_28 - 2.65934776404483e-5*x_29 + 0.00026822805284612*x_3 + 0.000132121908259396*x_30 - 1.82191134324917e-6*x_31 - 1.72394574810826e-6*x_32 + 0.00137285985974394*x_33 - 0.000598861188003906*x_34 - 0.000653472025784652*x_35 - 0.00132381759214913*x_36 - 2.01362841318221e-5*x_37 + 0.000845531624147088*x_38 - 8.59719527686541e-5*x_39 + 5.0789699551559e-5*x_4 - 7.8982643225414e-5*x_40 + 0.000753022237436916*x_41 + 0.00103469392453854*x_42 - 0.000340520609546017*x_43 - 2.4829307201076e-5*x_44 - 0.000224268834001604*x_45 + 0.00042595073076794*x_46 + 6.22669521584276e-5*x_47 + 0.000779043782568354*x_48 + 7.85919400901025e-5*x_49 + 1.29077460373537e-5*x_5 + 0.00193221689791637*x_50 - 0.00122778777151335*x_51 + 1.59559038960947e-5*x_52 - 1.58679231606557e-6*x_53 + 0.000544082858644865*x_54 + 0.000923136875738012*x_55 - 0.000337588905370679*x_56 + 0.00135328426034867*x_57 + 0.000978515236786711*x_58 + 0.000993068169001559*x_59 + 3.91130948355761e-5*x_6 + 0.000597330040937084*x_60 - 4.91872533064829e-5*x_61 - 1.3996558935302e-6*x_62 + 3.91327581788915e-8*x_63 - 4.30560662489118e-5*x_64 - 2.67454721123271e-6*x_65 - 4.33377073725601e-5*x_66 - 8.61921253362225e-6*x_67 + 5.68267128112315e-6*x_68 - 1.75215817105829e-5*x_69 + 4.31694174648142e-5*x_7 - 1.27166348531154e-5*x_70 + 1.39518944604903e-5*x_71 + 1.04410382276654e-5*x_72 + 1.39679957286925e-5*x_73 + 5.96044215701116e-6*x_74 + 1.88107446971843e-6*x_75 - 4.08809181512186e-5*x_76 + 5.38522198553556e-6*x_77 + 4.81596108269361e-6*x_78 - 2.44643078630499e-6*x_79 - 6.39157823381418e-5*x_8 - 1.30600955316768e-5*x_80 + 1.92071895040233e-5*x_81 - 2.81959509722893e-5*x_82 - 2.61081570802054e-5*x_83 - 7.18776960274687e-6*x_84 - 2.93935977536684e-5*x_85 - 8.78407950736153e-6*x_86 + 7.58759727561648e-6*x_87 - 7.06141278414346e-6*x_88 - 2.61133905891567e-5*x_89 + 5.94389095333314e-5*x_9 - 1.92964780867308e-5*x_90 - 3.8849734761992e-5*x_91 - 1.52976330524941e-6*x_92 - 0.000338486012060281*x_93 - 3.80470312451382e-5*x_94 - 0.000150842606573578*x_95 + 9.95173721480397e-5*x_96 + 5.08096048719275e-5*x_97 + 0.000216989761241187*x_98 - 0.000430919837510052*x_99 + 2.37801401025501e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 2.38197163861611e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 5.03554385768521e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 2.89768257781996e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 0.00040420683127301*std::exp(0.226479843258858*x_10) - 3.09237123228624e-5*std::exp(0.253039866685867*x_15) - 0.000115499622592141*std::exp(0.364639848470688*x_22) + 0.0256506651224024*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.000608776443812907*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.00110210170897814*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00711613503678857*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.00268969466846298*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.00652226775336366*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 0.00101542733366487*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00675604507672116*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.000557453929343771*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 0.00162309910398948*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 6.74612046656704e-5*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000801182518895419*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.00765701304220707*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.00140784519744606*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00767114490054275*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 0.00217318571641142*std::sin(0.35455983877182*x_21 - 1.396479845047) - 0.00028635151876622*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00436889063211173*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000277831906694199*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00739659105584369*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 0.000977495353114114*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00623254536441851*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 0.00263023710317912*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.000135898563267008*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.00399767304841917*std::sin(0.273759961128235*x_32 + 1.80263984203339) - 0.00253325910693901*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 0.00210384350439292*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00498743038988233*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.00360232380334337*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 0.00611024594630814*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 0.00328994765936038*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.000404982196758221*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.000477739033356334*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 6.96698274061298e-5*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 0.00226167263378448*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.00113698070775437*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 0.00175045843529903*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 0.00202097330314817*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.000272007940972278*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00788678197223918*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.00532007687703253*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 0.000846445012993692*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.000521706841845094*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00456279619264005*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.000530090750390993*std::sin(0.289119929075241*x_98 + 4.9695200920105) + 0.0868868753314018*std::sin(0.00196980019601685*x_1 + 0.00211619474517314*x_10 - 0.0124832821781608*x_101 - 0.0139844116640363*x_102 + 0.00033448837193589*x_103 + 0.00959858104679763*x_104 - 0.0105010491772268*x_105 + 0.000406628680896773*x_106 + 0.000704330911142896*x_107 + 0.000802395761719069*x_108 + 0.0243185125541114*x_109 + 0.00229071649017624*x_11 + 0.0121573065186107*x_110 - 0.0173937747328736*x_111 - 0.0092285898726891*x_112 - 0.000420997289929547*x_113 - 1.02439268968267e-5*x_114 + 0.000144705370855258*x_116 + 0.0197659218894045*x_117 + 0.0147029631676824*x_119 - 0.0285374794615625*x_12 - 4.78234883930374e-5*x_120 - 0.0227362309682855*x_13 + 0.00155599445163545*x_14 + 0.00456611473230539*x_15 + 0.00123949570159893*x_16 + 0.00147594975279769*x_17 - 0.0317327349979633*x_19 + 0.00148314016544894*x_2 - 0.00101719773886325*x_20 + 0.00116951310481973*x_23 + 0.00131304385608943*x_24 + 0.0258618721603321*x_25 + 0.00263085556062438*x_26 - 0.0337459397786188*x_27 + 0.00103344051993023*x_28 + 0.00287692954438955*x_29 + 0.00591716100876339*x_30 + 9.92125479125562e-5*x_31 + 0.000660063649325724*x_33 - 0.0292456742509674*x_34 + 0.00257095699580726*x_35 + 0.00193830605039961*x_36 + 0.00505507622672108*x_37 + 0.00140196206725762*x_38 + 0.0027133488359082*x_39 + 0.00152090637018645*x_4 + 0.000605360554999507*x_41 - 0.0215411692677436*x_42 - 0.0181935946482755*x_43 + 0.000485477062532102*x_44 + 0.00227528040981585*x_45 + 0.00092335839919974*x_46 + 0.0192290914819708*x_47 + 0.00323712276477018*x_48 + 0.0107960265889597*x_49 + 0.000891141232691266*x_50 + 0.00157864669763092*x_51 - 0.0272264309863028*x_52 + 0.00380606378635359*x_53 + 0.00154240386679114*x_54 - 0.0408806062453156*x_55 + 0.0266912854902169*x_56 + 0.000397678922128409*x_57 + 0.0109767732906554*x_58 + 0.00532014207063453*x_59 - 0.0104694193348284*x_6 - 0.011703010810686*x_60 + 9.12635165479209e-5*x_61 - 0.000419542430396907*x_62 + 0.000228943387193166*x_63 - 0.000117994929743013*x_64 + 0.000663291606743486*x_65 + 7.32718699473963e-5*x_66 - 0.000374806249238153*x_67 - 1.01308644544459e-5*x_68 + 4.1665580985307e-5*x_69 + 0.00169334465809745*x_7 + 0.00299484200347094*x_70 - 0.000361287442570558*x_71 - 0.000126346136778199*x_72 - 0.000117652570790204*x_73 + 0.000303341660867271*x_74 - 0.000409913946582019*x_75 + 0.00033972048640644*x_76 + 0.000298227744868468*x_77 + 0.000836876299201516*x_78 - 0.00163549627466595*x_79 + 0.00776523546796974*x_8 - 6.57681578222526e-5*x_80 - 0.000899427291813229*x_81 - 0.000104749966311882*x_82 - 0.000179934733820793*x_83 + 0.000222254747521393*x_84 + 0.000912410287076585*x_85 - 0.000325288665347975*x_86 + 0.000193987758823583*x_87 + 0.00013004606528032*x_88 + 5.34354032849528e-5*x_89 + 0.000996214472999301*x_90 - 0.000460357540245776*x_91 - 0.010400332443573*x_92 + 0.00145347812744645*x_93 + 0.000536420079583015*x_94 - 0.00492867658601658*x_95 - 0.0222100336682846*x_96 + 0.00357035052171259*x_97 - 0.00274276844531618*x_98 + 0.00189901118987229*x_99 - 0.143654618861575*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.291917986849036*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.194162359394358*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0730253295549161*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0581593646948821*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0746000304212746*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.0044489664042302*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.115956766451433*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.267866582642228*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.008566696784581*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0933312381881493*std::sin(0.366319835186005*x_9 + 5.02328014373779) - 2.15149552936452) + 0.21361353683519);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000160179141038702*x_1 + 0.000438157710391022*x_10 - 5.83742882409474e-5*x_100 - 8.8148825545213e-5*x_101 + 0.000439812547394161*x_102 - 0.000497861238807498*x_103 - 1.80065709267552e-5*x_104 - 5.32423227887441e-5*x_105 + 0.000446438871363206*x_106 - 0.000415687355214871*x_107 + 0.000505018605175021*x_108 + 7.9999034516779e-6*x_109 + 0.000439466694129615*x_11 + 0.000548349924807885*x_110 + 0.000107270869626981*x_111 + 1.95565616646026e-5*x_112 + 0.000505475133154569*x_113 - 0.000410819496579989*x_114 + 0.000545511071065989*x_115 + 4.29154307055952e-5*x_116 + 0.000306986268477683*x_117 - 0.000651405035075417*x_118 - 0.000473778835174284*x_119 - 0.000383857364454022*x_12 + 0.000177458110809812*x_120 + 1.54261714483305e-5*x_13 + 6.98671130126046e-5*x_14 + 8.99098338654319e-5*x_16 + 0.000125426675332513*x_17 - 1.09644442279107e-5*x_18 + 0.000149285515404554*x_19 + 4.09104184733852e-5*x_2 + 0.000118527151548915*x_20 + 2.83200666470353e-5*x_21 + 0.000415432131998957*x_22 + 6.17415487829961e-5*x_23 + 0.000112374867092167*x_24 - 8.6338029072543e-5*x_25 + 0.000654256159943006*x_26 + 6.88225143312844e-5*x_27 + 9.83035726288641e-5*x_28 + 2.59644519817543e-5*x_29 + 0.000248199854060642*x_3 + 0.000167343369700414*x_30 - 6.76780769651715e-6*x_31 - 4.75056350851322e-7*x_32 + 0.00133843528250526*x_33 - 0.000576836824507448*x_34 - 0.000380276135017144*x_35 - 0.00131001686939163*x_36 + 7.21987178053961e-6*x_37 + 0.00131970754911801*x_38 + 0.00015548853756084*x_39 + 3.4461104556283e-5*x_4 + 0.000152781384168924*x_40 + 0.000614075342608239*x_41 + 0.00113793164365393*x_42 - 0.000236455473741236*x_43 - 2.56142327736704e-6*x_44 + 0.00022332794824499*x_45 + 0.000214734311009545*x_46 + 1.28714504384237e-6*x_47 + 0.000734529150610968*x_48 + 0.000465518627457078*x_49 + 1.59450109757671e-5*x_5 + 0.00208057786755136*x_50 - 0.000978646674044321*x_51 + 3.93447712915956e-5*x_52 + 1.51401786179166e-5*x_53 + 0.000812972765666391*x_54 + 0.000880062009836792*x_55 - 0.000113110564773056*x_56 + 0.00084155578161887*x_57 + 0.00114772293942797*x_58 + 0.00101112443063784*x_59 + 5.03177488523764e-5*x_6 + 0.000836273008368016*x_60 - 4.73203358323061e-5*x_61 - 9.89983944833169e-7*x_62 - 5.47503180607414e-6*x_63 - 4.47442321195746e-5*x_64 - 8.31716227558607e-6*x_65 - 3.66926289425581e-5*x_66 - 8.57096501075138e-6*x_67 + 4.34043757602061e-6*x_68 - 1.50756356935265e-5*x_69 + 4.07580857241103e-5*x_7 - 9.94023555644076e-6*x_70 + 9.24047154494154e-6*x_71 + 9.15700510147652e-6*x_72 + 1.24839790745279e-5*x_73 + 4.1754870858156e-6*x_74 + 3.8971022497614e-6*x_75 - 4.08653752151456e-5*x_76 - 6.424885421976e-6*x_77 + 3.40096011679607e-6*x_78 - 7.84568780702972e-6*x_79 - 3.41110672921098e-6*x_8 - 7.78251002264115e-6*x_80 - 7.10662477240115e-6*x_81 - 1.85973655234822e-5*x_82 - 2.60448874632845e-5*x_83 - 8.32312998151241e-7*x_84 - 3.26441032592687e-5*x_85 - 1.58103030511137e-5*x_86 + 7.40060143160873e-6*x_87 - 1.11989504289493e-5*x_88 - 3.93503811525971e-5*x_89 + 8.73746373849493e-5*x_9 - 1.64085858813882e-5*x_90 - 3.39100664278863e-5*x_91 + 2.7842373438317e-7*x_92 - 0.000315611009905723*x_93 - 4.06902187804401e-5*x_94 - 0.000143387656474511*x_95 + 0.000174984361212176*x_96 - 3.91887545508262e-5*x_97 + 0.00030348954920758*x_98 - 0.000227564164669227*x_99 + 2.22472688575183e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) + 8.5823527113054e-8*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) + 1.81432947308349e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 2.71089754284477e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 0.000553573914797621*std::exp(0.226479843258858*x_10) + 1.1141954924868e-5*std::exp(0.253039866685867*x_15) + 0.000171632596628784*std::exp(0.364639848470688*x_22) + 0.023997219566047*std::sin(0.130640044808388*x_1 - 7.68408012390137) - 0.000904642625431023*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.00103106007459299*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00665742795068161*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.00251631656398495*std::sin(0.293919920921326*x_112 + 1.76895987987518) - 0.00235000288960039*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 0.00139065953566161*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00632054944113684*std::sin(0.33231982588768*x_15 - 4.33975982666016) + 0.000828377298963579*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 0.00222288505681661*std::sin(0.414319843053818*x_15 - 1.39479982852936) + 0.000100247442100843*std::sin(0.403359860181808*x_16 - 7.78911972045898) + 0.00028866972435018*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.0104865191715874*std::sin(0.180800005793571*x_19 + 7.99456024169922) + 0.000507253060931462*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.0071766617989376*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 0.00297624590071214*std::sin(0.35455983877182*x_21 - 1.396479845047) + 0.000425518747260277*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00408727131474133*std::sin(0.308639913797379*x_25 - 1.38775980472565) + 0.000100104106155077*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00691980573448446*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 0.00133871050030419*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00583079459544602*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 0.0036021920893004*std::sin(0.407679855823517*x_29 - 7.6049599647522) - 0.000201945450280847*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.00373998246978785*std::sin(0.273759961128235*x_32 + 1.80263984203339) - 0.00346937768619199*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 0.00288127956962141*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00466593991092471*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.00493349526999594*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 0.00836817319049585*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 0.00450568635749081*std::sin(0.272719949483871*x_44 - 4.44063997268677) - 0.000601804096481719*std::sin(0.228959992527962*x_48 + 1.77615988254547) - 0.000709920854853534*std::sin(0.347999840974808*x_5 - 4.38783979415894) + 0.000103529458504109*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 0.0030974315053797*std::sin(0.269599944353104*x_53 - 1.22887980937958) - 0.00168955488173166*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 0.00239730764981682*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 0.00276778623360171*std::sin(0.410799860954285*x_6 - 4.4031195640564) - 0.000404204171104347*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00737839887403431*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.00497714395775646*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 0.00115923295513865*std::sin(0.176720008254051*x_8 + 1.78079986572266) - 0.000775257078207708*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00426867769499973*std::sin(0.278399974107742*x_97 - 7.60279989242554) + 0.000787715577736423*std::sin(0.289119929075241*x_98 + 4.9695200920105) - 0.179445579648018*std::sin(0.00204555475401114*x_1 + 0.00219757934340528*x_10 - 0.0129633641304506*x_101 - 0.0145222240404192*x_102 + 0.00034735212269674*x_103 + 0.00996772318925598*x_104 - 0.010904898430824*x_105 + 0.00042226680300247*x_106 + 0.000731418062907445*x_107 + 0.000833254290613743*x_108 + 0.0252537536883851*x_109 + 0.00237881284408789*x_11 + 0.012624852101955*x_110 - 0.0180627043630999*x_111 - 0.00958350289794405*x_112 - 0.000437187999870534*x_113 - 1.06378877441066e-5*x_114 + 0.000150270448689399*x_116 + 0.0205260795333672*x_117 + 0.0152684095912467*x_119 - 0.0296349735867298*x_12 - 4.96626836740032e-5*x_120 - 0.0236106207317455*x_13 + 0.00161583487208193*x_14 + 0.00474171833108483*x_15 + 0.00128716421599969*x_16 + 0.00153271181494544*x_17 - 0.0329531122314419*x_19 + 0.00154017875642094*x_2 - 0.00105631712023817*x_20 + 0.00121449022915107*x_23 + 0.00136354088474559*x_24 + 0.0268564678042824*x_25 + 0.00273203297980879*x_26 - 0.0350437408232124*x_27 + 0.00107318456603146*x_28 + 0.00298757047459996*x_29 + 0.00614472313293534*x_30 + 0.000103028063176389*x_31 + 0.000685448371138566*x_33 - 0.0303704041248942*x_34 + 0.00266983083653159*x_35 + 0.00201284940682865*x_36 + 0.00524948430219851*x_37 + 0.00145587871166888*x_38 + 0.00281769878072199*x_39 + 0.00157939737351621*x_4 + 0.000628641505709075*x_41 - 0.0223695993592107*x_42 - 0.0188932837455222*x_43 + 0.000504147534980451*x_44 + 0.00236278312308962*x_45 + 0.000958868908104723*x_46 + 0.0199686037070148*x_47 + 0.00336161600256876*x_48 + 0.0112112200811703*x_49 + 0.000925412734100152*x_50 + 0.00163935827794754*x_51 - 0.0282735048211517*x_52 + 0.00395243735277739*x_53 + 0.00160172162064948*x_54 - 0.0424527922278913*x_55 + 0.0277177787044523*x_56 + 0.00041297285449292*x_57 + 0.0113989179378733*x_58 + 0.00552474404592254*x_59 - 0.0108720521682348*x_6 - 0.0121530850938334*x_60 + 9.47733280359452e-5*x_61 - 0.000435677189363241*x_62 + 0.000237748089892254*x_63 - 0.000122532777676181*x_64 + 0.000688800469313294*x_65 + 7.60897588543546e-5*x_66 - 0.000389220544557012*x_67 - 1.05204771473467e-5*x_68 + 4.32679555192825e-5*x_69 + 0.00175846729153284*x_7 + 0.00311001760995856*x_70 - 0.000375181831745747*x_71 - 0.000131205155355451*x_72 - 0.000122177252285884*x_73 + 0.000315007571697578*x_74 - 0.000425678413405511*x_75 + 0.000352785453777936*x_76 + 0.000309696984763879*x_77 + 0.000869060880292586*x_78 - 0.00169839417549831*x_79 + 0.0080638708228586*x_8 - 6.82974690366581e-5*x_80 - 0.000934017458408344*x_81 - 0.000108778439562073*x_82 - 0.000186854662174936*x_83 + 0.000230802218576916*x_84 + 0.000947499753585268*x_85 - 0.000337798613876672*x_86 + 0.000201448138285266*x_87 + 0.000135047375674201*x_88 + 5.54904215377095e-5*x_89 + 0.00103452688012678*x_90 - 0.000478061966334868*x_91 - 0.0108003083339449*x_92 + 0.00150937597603116*x_93 + 0.000557049718117037*x_94 - 0.00511822358526325*x_95 - 0.0230641869407746*x_96 + 0.00370765902955209*x_97 - 0.00284824980920058*x_98 + 0.00197204334491313*x_99 - 0.149179286885115*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.303144566128015*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.201629453643202*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0758337370137063*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0603960570125084*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0774689977116383*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00462006471367571*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.1204162307193*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.27816819323732*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.00889615473148309*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0969205700961773*std::sin(0.366319835186005*x_9 + 5.02328014373779) + 4.03601264597326) - 0.00722443349802408);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000114969487727453*x_1 + 0.000369531597169015*x_10 + 0.000169531928772343*x_100 - 0.000755808016314452*x_101 - 0.000546810883457782*x_102 - 0.000339224410217215*x_103 + 0.000554069948253855*x_104 - 0.000565375423111867*x_105 - 3.59852120285315e-5*x_106 + 6.84466782258529e-6*x_107 + 0.000277861149295985*x_108 + 0.00139529439446082*x_109 + 0.00023659544950054*x_11 + 0.000668717027111949*x_110 - 0.00097892464401226*x_111 - 0.000542368832327642*x_112 - 4.77645088793607e-6*x_113 + 1.77128555135438e-5*x_114 + 9.94627464264676e-6*x_115 + 1.03372499711743e-5*x_116 + 0.000914936922732138*x_117 - 0.00037629968374943*x_118 + 0.000677905719759635*x_119 - 0.00159637464904625*x_12 + 0.000102238508468056*x_120 - 0.00128645481668834*x_13 + 0.000127306376226492*x_14 + 0.000261932207601314*x_15 + 0.000122818852734842*x_16 + 0.000241235605933006*x_17 - 1.47433282547089e-5*x_18 - 0.00174857110503588*x_19 + 0.000102868543063226*x_2 - 1.36332191081606e-5*x_20 + 1.4870003714408e-5*x_21 + 0.000110689161213698*x_22 + 0.000101081201746963*x_23 + 0.000129594700998046*x_24 + 0.00148069001245598*x_25 + 0.000210307556290186*x_26 - 0.00189834180048831*x_27 + 0.000109637533377997*x_28 + 0.00015439587739988*x_29 + 0.000150846568226262*x_3 + 0.00032739330910033*x_30 + 5.37456919316148e-6*x_31 - 1.21647698026655e-7*x_32 + 0.000812507546211755*x_33 - 0.00178265131087696*x_34 - 6.89112367873701e-5*x_35 - 0.00032337922680564*x_36 + 0.000278176541249901*x_37 + 0.000344364215747323*x_38 + 0.000161080903255455*x_39 + 0.000122804252247384*x_4 - 8.24386548625426e-5*x_40 + 0.00045433924865912*x_41 - 0.000523458348436511*x_42 - 0.00116779647488443*x_43 + 1.43095115555791e-5*x_44 + 9.93107390196585e-5*x_45 + 0.000408820997889912*x_46 + 0.00112433942648183*x_47 + 0.000617067826808149*x_48 + 0.000578147569905344*x_49 + 1.48621012076025e-5*x_5 + 0.00101299306497845*x_50 - 0.000369226150920089*x_51 - 0.00155497174049508*x_52 + 0.000216767217489827*x_53 + 0.000103036255128686*x_54 - 0.00160210387884157*x_55 + 0.00148379330732155*x_56 + 0.00098457539108095*x_57 + 0.00120524232517227*x_58 + 0.000844502859965334*x_59 - 0.000574531563638193*x_6 - 0.000662883940693015*x_60 - 2.43125323492546e-5*x_61 - 2.30288425883569e-5*x_62 + 1.27002135769228e-5*x_63 - 2.43323743896125e-5*x_64 + 3.34752717956492e-5*x_65 - 2.08290508427514e-5*x_66 - 2.53683358419909e-5*x_67 + 4.29574947642783e-6*x_68 - 9.07359507873238e-6*x_69 + 9.46530465148723e-5*x_7 + 0.000165339964149617*x_70 - 1.39475677424293e-5*x_71 + 1.62582689184726e-6*x_72 + 4.72368774715213e-6*x_73 + 2.30264316015462e-5*x_74 - 2.29357465589662e-5*x_75 - 6.37421759589229e-8*x_76 + 2.37170410199779e-5*x_77 + 5.55335298579332e-5*x_78 - 9.40276540933867e-5*x_79 + 0.00040994882276768*x_8 - 6.19390193949399e-6*x_80 - 3.74530058316852e-5*x_81 - 1.78026400324557e-5*x_82 - 1.30802863542225e-5*x_83 + 6.22418763376307e-6*x_84 + 3.93286765641332e-5*x_85 - 1.83758088301734e-5*x_86 + 1.37760985302346e-5*x_87 + 1.01489305210956e-5*x_88 - 3.82568077044944e-6*x_89 + 1.99572344437158e-5*x_9 + 4.37558704502259e-5*x_90 - 4.44003317723148e-5*x_91 - 0.000595018096153735*x_92 - 9.9130911639115e-5*x_93 + 1.79739592195375e-5*x_94 - 0.000360389728071635*x_95 - 0.001296300033715*x_96 + 0.000207543034571511*x_97 - 0.000156174166528981*x_98 - 0.000118589986019135*x_99 + 1.30734928148439e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) + 7.02115062153304e-9*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) + 1.48428769314333e-9*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 1.59304496094055e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 5.41376265792545e-6*std::exp(0.226479843258858*x_10) + 9.11513967991314e-7*std::exp(0.253039866685867*x_15) - 8.72371977935439e-5*std::exp(0.364639848470688*x_22) + 0.0141018423242062*std::sin(0.130640044808388*x_1 - 7.68408012390137) - 0.00824065395998928*std::sin(0.249999970197678*x_100 + 1.79223990440369) + 0.000459810602399064*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.00060589713565261*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00391220320282881*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.00147870045216865*std::sin(0.293919920921326*x_112 + 1.76895987987518) - 0.0167456858218922*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.0111379977093932*std::sin(0.254879981279373*x_118 + 8.16423988342285) - 0.000192251761305352*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 1.3600172375906e-5*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00371423828397899*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.000421046559318021*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 2.17390519888456e-5*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 5.0953642295367e-5*std::sin(0.403359860181808*x_16 - 7.78911972045898) + 2.36158275325736e-5*std::sin(0.324799835681915*x_18 + 4.99583959579468) + 0.00418905062674045*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.000102554553936151*std::sin(0.180800005793571*x_19 + 7.99456024169922) + 4.14979465868603e-5*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00421732829606489*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 2.91066621590537e-5*std::sin(0.35455983877182*x_21 - 1.396479845047) - 0.00333627420253828*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.000216282127339092*std::sin(0.445919841527939*x_21 - 7.63576030731201) - 0.00427938231974825*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00240186391002913*std::sin(0.308639913797379*x_25 - 1.38775980472565) + 8.18943279064822e-6*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00406638815439702*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 1.30921286617508e-5*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00342643637457696*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 3.52282007848192e-5*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.000102644576471449*std::sin(0.335599839687347*x_3 + 1.7707998752594) + 0.000255212069806169*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.00219778141126253*std::sin(0.273759961128235*x_32 + 1.80263984203339) - 0.00665178463608138*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 3.39293215624378e-5*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 2.81779240749856e-5*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00274191552637945*std::sin(0.253279983997345*x_40 + 1.75911998748779) - 0.0153659926321374*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 4.82478884062307e-5*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 8.18378581843432e-5*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 4.4064064253146e-5*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.000305884220299304*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.000360837668654329*std::sin(0.347999840974808*x_5 - 4.38783979415894) + 0.000491423000118848*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 5.26218214161002e-5*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 3.02918157287756e-5*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.000858764805146305*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 2.34448450102315e-5*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 2.70679982492873e-5*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.000205448381695646*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00433587804788637*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.0029247929796193*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 1.13368999452594e-5*std::sin(0.176720008254051*x_8 + 1.78079986572266) - 0.00535388589424324*std::sin(0.366319835186005*x_9 + 5.02328014373779) + 0.000394046681113419*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00250846643387437*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.000400379071399094*std::sin(0.289119929075241*x_98 + 4.9695200920105) + 0.01598430020879);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000274680077490135*x_1 + 0.000124950183847901*x_10 + 0.000705191200011827*x_100 + 4.22088358998651e-5*x_101 + 0.000136163466959761*x_102 - 0.000301930977859253*x_103 + 2.25136890863774e-5*x_104 + 0.000134800382245961*x_105 - 0.000793763933869167*x_106 + 0.000701025886923206*x_107 + 2.21804825505936e-5*x_108 - 1.31465339610261e-5*x_109 - 0.00039279048939048*x_11 - 0.000981469681626492*x_110 - 0.000172496296412071*x_111 - 4.18892535311928e-5*x_112 - 0.000869200032552939*x_113 + 0.00068973257519589*x_114 - 0.000893812508953969*x_115 - 6.85638519052014e-5*x_116 - 0.00131427692111112*x_117 - 0.000199833202182335*x_118 + 0.000140580079285763*x_119 + 0.000828519817012819*x_12 - 4.96532177145741e-6*x_120 - 1.73936345294272e-5*x_13 + 1.64671974383171e-5*x_14 + 2.83646040929569e-5*x_16 + 0.000389247810359907*x_17 - 2.50121064878217e-5*x_18 + 1.42037408710426e-5*x_19 + 7.60491333448327e-6*x_2 - 0.000181461801010041*x_20 + 4.18241100311897e-6*x_21 - 0.000331385226832664*x_22 + 1.2948456642972e-5*x_23 + 5.68828549497672e-6*x_24 + 0.000148311746805829*x_25 - 0.00103608272426251*x_26 - 9.93849059101853e-5*x_27 + 1.58928927137696e-5*x_28 - 4.8145767029685e-5*x_29 + 0.00010064877324357*x_3 - 0.000301778909980595*x_30 + 7.98375116928428e-6*x_31 + 9.04144057718233e-7*x_32 + 0.000493022868876227*x_33 + 0.000655548356454177*x_34 + 6.9912079753853e-5*x_35 + 0.00067048457988546*x_36 - 3.19697511341155e-5*x_37 - 0.00131123091636424*x_38 - 0.000230734336585876*x_39 + 4.25094814169287e-5*x_4 - 0.000311805181994643*x_40 + 0.000330184541550628*x_41 + 0.00082662655820898*x_42 - 6.33551919879685e-5*x_43 - 2.68095977354433e-5*x_44 - 0.000316306553772598*x_45 + 0.000786985127458601*x_46 + 4.54146987840659e-6*x_47 + 0.000244821199995115*x_48 - 0.000642015982668539*x_49 + 2.54738554313062e-5*x_5 - 0.000212311283991928*x_50 + 0.000104105347386897*x_51 - 3.57672332187479e-5*x_52 - 1.73035520851749e-5*x_53 - 0.00132544274476633*x_54 + 0.00110973568544414*x_55 + 6.48659173722701e-5*x_56 + 0.00177422319422917*x_57 + 0.000160509542680415*x_58 + 0.000216223993292073*x_59 + 8.02672327485714e-6*x_6 - 0.00143795099836661*x_60 - 2.2981647608457e-5*x_61 + 6.13911417687208e-6*x_62 + 8.11723229728281e-6*x_63 + 1.50859465968984e-5*x_64 + 1.4280253193945e-6*x_65 - 2.4714438644247e-5*x_66 + 2.17337763302472e-6*x_67 + 7.98703698261195e-6*x_68 - 1.26040639168768e-5*x_69 - 7.46230684651502e-5*x_7 - 4.79388955092522e-6*x_70 + 3.98723845007503e-6*x_71 + 1.59522944818142e-5*x_72 + 1.83094315000713e-5*x_73 + 1.2202930880242e-5*x_74 - 3.94402521696741e-6*x_75 + 3.35008441247586e-6*x_76 + 2.31918948576185e-5*x_77 + 1.86947484637784e-5*x_78 + 9.29496852611086e-6*x_79 - 7.32027193450205e-5*x_8 + 9.20064743250414e-6*x_80 + 3.49444752874142e-5*x_81 - 7.55356073656687e-6*x_82 + 3.95124268448016e-5*x_83 - 2.09400471792828e-5*x_84 + 1.12793378185462e-5*x_85 + 2.56857981110217e-5*x_86 - 8.67139773786186e-6*x_87 + 2.7627212862371e-5*x_88 + 4.27350211307594e-5*x_89 - 7.97658554313107e-5*x_9 - 2.05858090671657e-5*x_90 - 2.90505948911071e-6*x_91 + 1.10934716496687e-5*x_92 - 9.0675835370028e-5*x_93 + 2.60413180568659e-5*x_94 - 2.48490365078508e-5*x_95 - 0.000367331548234419*x_96 + 5.92638133030381e-5*x_97 - 0.000528727870763325*x_98 - 0.00022713228409818*x_99 + 7.42927395973233e-7*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 1.00558890615785e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 2.12583851027775e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 9.05279684061211e-7*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) + 0.000953238484097785*std::exp(0.226479843258858*x_10) - 1.3054958986478e-5*std::exp(0.253039866685867*x_15) - 0.000341758399443225*std::exp(0.364639848470688*x_22) + 0.00801365415097965*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.00180134322854831*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.000344313174446342*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00222318777327484*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.000840301128331032*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.00275348370628967*std::sin(0.0867200791835785*x_13 + 1.7151198387146) + 0.00239467603554772*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00211069024584425*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.00164948212279983*std::sin(0.335759848356247*x_15 + 5.07039976119995) - 0.0038277446339901*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 0.000199614793655786*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000338232512825765*std::sin(0.324799835681915*x_18 + 4.99583959579468) + 0.0180574867626137*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.000594345242902167*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00239658121462557*std::sin(0.348719835281372*x_20 + 8.23320007324219) - 0.00512501050873086*std::sin(0.35455983877182*x_21 - 1.396479845047) - 0.000847301787965663*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00136490724049963*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000117291355874702*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00231080645803579*std::sin(0.274079948663712*x_27 - 7.57639980316162) - 0.00230522127911732*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00194714105043307*std::sin(0.380559861660004*x_29 - 7.58888006210327) - 0.00620287198302882*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.000402117984686185*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.00124893327583715*std::sin(0.273759961128235*x_32 + 1.80263984203339) + 0.00597416937096355*std::sin(0.228079989552498*x_37 + 1.79159986972809) + 0.00496148119662021*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00155814837766902*std::sin(0.253279983997345*x_40 + 1.75911998748779) - 0.00849533806916065*std::sin(0.266879975795746*x_41 - 1.23359990119934) - 0.0144097554338199*std::sin(0.13984003663063*x_43 - 1.42143988609314) + 0.00775866333008991*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.00119832484523208*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.00141360918526953*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 0.000206150013042768*std::sin(0.296719938516617*x_51 - 4.88095998764038) + 0.00533368866172874*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.00336427685354532*std::sin(0.184640005230904*x_55 + 1.80663990974426) - 0.00412809536168778*std::sin(0.267279952764511*x_58 + 8.13583946228027) + 0.00476604891072182*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.000804859760198545*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00246394948388717*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.00166207215078911*std::sin(0.341199845075607*x_7 - 7.59463977813721) - 0.00199616606804268*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.00154370803337752*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.00142548625833838*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.00156851565699931*std::sin(0.289119929075241*x_98 + 4.9695200920105) + 0.203167989850044*std::sin(0.00201362964381357*x_1 + 0.00216328157524799*x_10 - 0.0127610440372904*x_101 - 0.0142955747161246*x_102 + 0.000341930974828315*x_103 + 0.00981215626511871*x_104 - 0.0107347049498553*x_105 + 0.000415676456695584*x_106 + 0.000720002772159042*x_107 + 0.000820249635031545*x_108 + 0.02485961666134*x_109 + 0.00234168655253398*x_11 + 0.0124278151887203*x_110 - 0.0177807985250247*x_111 - 0.00943393252565475*x_112 - 0.000430364777443682*x_113 - 1.04718615168281e-5*x_114 + 0.00014792516772127*x_116 + 0.0202057276338437*x_117 + 0.0150301144990296*x_119 - 0.0291724585669762*x_12 - 4.88875948400863e-5*x_120 - 0.0232421281909245*x_13 + 0.00159061642889378*x_14 + 0.0046677140151657*x_15 + 0.00126707535777794*x_16 + 0.00150879067888331*x_17 - 0.0324388107993835*x_19 + 0.00151614108330255*x_2 - 0.00103983110811796*x_20 + 0.00119553559871476*x_23 + 0.00134226001073377*x_24 + 0.0264373171105706*x_25 + 0.00268939395791374*x_26 - 0.0344968108105484*x_27 + 0.00105643530255381*x_28 + 0.00294094326189026*x_29 + 0.00604882202700412*x_30 + 0.000101420097286501*x_31 + 0.000674750532451807*x_33 - 0.0298964111914218*x_34 + 0.00262816260765724*x_35 + 0.00198143473117741*x_36 + 0.00516755524872318*x_37 + 0.00143315671500114*x_38 + 0.00277372276692832*x_39 + 0.00155474761281125*x_4 + 0.000618830255579898*x_41 - 0.0220204755221597*x_42 - 0.0185984149993363*x_43 + 0.000496279270599591*x_44 + 0.0023259070084661*x_45 + 0.00094390377676505*x_46 + 0.0196569523700912*x_47 + 0.0033091510362248*x_48 + 0.0110362458176661*x_49 + 0.00091096975551136*x_50 + 0.00161377270338683*x_51 - 0.0278322383357072*x_52 + 0.00389075139800694*x_53 + 0.0015767234439227*x_54 - 0.0417902286531875*x_55 + 0.0272851854737718*x_56 + 0.00040652755946357*x_57 + 0.0112210142613346*x_58 + 0.0054385189951711*x_59 - 0.0107023713210885*x_6 - 0.0119634110799258*x_60 + 9.32941943508629e-5*x_61 - 0.000428877546257274*x_62 + 0.000234037539512613*x_63 - 0.00012062040039933*x_64 + 0.000678050314205568*x_65 + 7.49022208861978e-5*x_66 - 0.000383145953421392*x_67 - 1.0356283355124e-5*x_68 + 4.25926696364343e-5*x_69 + 0.001731022774611*x_7 + 0.0030614793565974*x_70 - 0.000369326343742249*x_71 - 0.000129157427698687*x_72 - 0.000120270423717636*x_73 + 0.000310091227405256*x_74 - 0.000419034821866321*x_75 + 0.000347279507547029*x_76 + 0.000304863523157899*x_77 + 0.000855497388864486*x_78 - 0.00167188722372625*x_79 + 0.00793801745025446*x_8 - 6.72315458581487e-5*x_80 - 0.000919440185310339*x_81 - 0.000107080727162378*x_82 - 0.000183938408934016*x_83 + 0.000227200072876605*x_84 + 0.000932712061402467*x_85 - 0.000332526568260952*x_86 + 0.000198304123684219*x_87 + 0.000132939682227307*x_88 + 5.46243788082117e-5*x_89 + 0.00101838094974499*x_90 - 0.000470600821172862*x_91 - 0.0106317471976307*x_92 + 0.00148581904397159*x_93 + 0.000548355805816943*x_94 - 0.00503834312659798*x_95 - 0.022704222628767*x_96 + 0.00364979334648427*x_97 - 0.00280379698345703*x_98 + 0.0019412655322062*x_99 - 0.146851035752427*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.298413368559016*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.198482609241206*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0746501947955824*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0594534517012391*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0762599338701597*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00454795905392019*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.118536886532716*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.273826803594659*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.00875731184811351*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0954079242602912*std::sin(0.366319835186005*x_9 + 5.02328014373779) - 5.35650974958799) - 0.215302638134386);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000175848578722141*x_1 - 0.000493604129022394*x_10 - 0.00096401040578689*x_100 + 0.000912038462900717*x_101 + 0.000797004446288969*x_102 + 0.000388366041298187*x_103 - 0.000755686833262296*x_104 + 0.000783314663089208*x_105 + 0.00067474375917228*x_106 - 0.00105494024456792*x_107 - 0.000405888906054922*x_108 - 0.00191493979290338*x_109 + 0.000294589023137551*x_11 + 0.000140554651166207*x_110 + 0.00165546508059082*x_111 + 0.000743542890677505*x_112 + 0.00118289638713553*x_113 - 0.000889578061181481*x_114 + 0.000911981726014041*x_115 + 0.000130710065986906*x_116 + 0.000108800436017233*x_117 + 0.000454508194147907*x_118 - 0.00109828315624473*x_119 + 0.0011758633820859*x_12 + 2.93547690672496e-5*x_120 + 0.00189601328680708*x_13 - 0.000175848457516277*x_14 - 0.000361651575695086*x_15 - 0.000204840887343757*x_16 - 0.000786981087976778*x_17 + 2.63804606144325e-5*x_18 + 0.00240342147673095*x_19 - 0.000176691930211179*x_2 + 0.000487523806794913*x_20 - 3.2512593260431e-5*x_21 + 0.000265793015883269*x_22 - 9.48929696559137e-5*x_23 - 0.000161603260599736*x_24 - 0.00224859674953655*x_25 + 0.00120029313547819*x_26 + 0.00294970354619421*x_27 - 0.000157578111531169*x_28 - 0.000238936714279574*x_29 - 0.000206723850436884*x_3 - 7.71796177369208e-5*x_30 - 1.13020178098985e-5*x_31 - 3.28388278395175e-6*x_32 - 0.00120493942557911*x_33 + 0.0013696887235677*x_34 - 0.000638191683993707*x_35 - 0.000891468376956789*x_36 - 0.000393390845640054*x_37 + 0.000942860478036652*x_38 - 0.000246943825282179*x_39 - 0.000173349667555519*x_4 + 9.45691265791534e-5*x_40 - 0.000549768561745321*x_41 - 0.000164972913169614*x_42 + 0.00145979712878818*x_43 - 2.88824285732201e-5*x_44 - 0.000418172418775758*x_45 - 0.00110031307220121*x_46 - 0.00143209340932968*x_47 - 0.000803277345695912*x_48 - 0.000548797445938684*x_49 - 5.11215571606101e-5*x_5 - 0.000546345017130483*x_50 - 0.000392530180878448*x_51 + 0.00216773739920557*x_52 - 0.000304053421801734*x_53 + 0.00141249084118495*x_54 + 0.00122354253304281*x_55 - 0.00253031068364174*x_56 - 0.00240236939175094*x_57 - 0.00173169731608292*x_58 - 0.0011024429011262*x_59 + 0.000784249657757582*x_6 + 0.00268992689477189*x_60 + 4.14624104896467e-5*x_61 + 2.27320457780183e-5*x_62 - 2.1585932302059e-5*x_63 + 6.82913543788734e-8*x_64 - 4.42738324621808e-5*x_65 + 3.53806358662206e-5*x_66 + 2.84211421494564e-5*x_67 - 1.13852102998622e-5*x_68 + 1.79082156807135e-5*x_69 - 2.00735689947118e-5*x_7 - 0.000230717404139024*x_70 + 2.6889059880586e-5*x_71 - 1.69678996780551e-5*x_72 - 2.20863924905559e-5*x_73 - 4.25531660724978e-5*x_74 + 3.47050375703831e-5*x_75 - 2.07842097572303e-5*x_76 - 4.09497233976899e-5*x_77 - 9.56618569786786e-5*x_78 + 0.00012502551015076*x_79 - 0.000589591543867064*x_8 - 1.6048927845748e-5*x_80 + 5.82537303106929e-5*x_81 + 1.14148385164282e-5*x_82 - 4.36668508835367e-5*x_83 + 7.39752715229486e-6*x_84 - 7.65314246942383e-5*x_85 - 1.01419797748272e-6*x_86 - 2.45738654833364e-6*x_87 - 4.61029142053831e-5*x_88 - 4.30140861626068e-5*x_89 + 6.35810693373573e-5*x_9 - 4.45158543539579e-5*x_90 + 4.33955940012903e-5*x_91 + 0.000802112645344852*x_92 + 8.99048796089079e-5*x_93 - 6.96128901735863e-5*x_94 + 0.000461298381637955*x_95 + 0.00219698466854713*x_96 - 0.000231237673819989*x_97 + 0.000868700923403196*x_98 - 3.61380227671451e-5*x_99 - 1.63072009107981e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 3.50850954790625e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 7.4170713946257e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) - 1.98708215210062e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 0.00118265900450993*std::exp(0.226479843258858*x_10) - 4.5548879836581e-5*std::exp(0.253039866685867*x_15) + 5.28564569511363e-5*std::exp(0.364639848470688*x_22) - 0.0175899110704466*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.0113779268180883*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.000278596286057928*std::sin(0.241839975118637*x_102 + 8.17535972595215) - 0.000755764848942718*std::sin(0.276639938354492*x_107 - 1.60879981517792) - 0.00487988057483466*std::sin(0.267839968204498*x_109 + 4.97111988067627) + 0.00184445470708664*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.0231208819985977*std::sin(0.231439992785454*x_115 + 4.96000003814697) - 0.015378308985283*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.00960693163415347*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 0.00297101430918953*std::sin(0.205119997262955*x_14 - 7.59024047851563) + 0.00463294934148373*std::sin(0.33231982588768*x_15 - 4.33975982666016) + 0.000255109401722026*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 0.00474898646442874*std::sin(0.414319843053818*x_15 - 1.39479982852936) + 3.08724840848565e-5*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.00118009655177645*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.00578385061425172*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0224034695145955*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.00207367637680322*std::sin(0.239519983530045*x_20 - 7.58616018295288) + 0.00526047788488766*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 0.00635847159705818*std::sin(0.35455983877182*x_21 - 1.396479845047) + 0.00460641642105863*std::sin(0.439759850502014*x_21 + 1.78055989742279) + 0.000131043949624032*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00590857219549842*std::sin(0.398879855871201*x_22 - 1.57831990718842) - 0.0029959612091398*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000409230690049663*std::sin(0.297839939594269*x_26 - 4.39071989059448) - 0.00507220293415012*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 0.00286003004349573*std::sin(0.293279945850372*x_28 + 1.99383985996246) - 0.00427396007781876*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 0.00769574721009571*std::sin(0.407679855823517*x_29 - 7.6049599647522) - 6.21916885772809e-5*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.000352373035859306*std::sin(1.61759984493256*x_3 - 6.38495969772339) + 0.00274139922200305*std::sin(0.273759961128235*x_32 + 1.80263984203339) + 0.00918416416542706*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.00741200163327928*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 0.00615558489378787*std::sin(0.299759924411774*x_4 + 8.02079963684082) - 0.00342012406342845*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.0212159302531824*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.0105399522065647*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 0.0178778210289345*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 0.00962597839194093*std::sin(0.272719949483871*x_44 - 4.44063997268677) - 0.000185333281343415*std::sin(0.228959992527962*x_48 + 1.77615988254547) - 0.000218629222189292*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 0.000678511069537123*std::sin(0.413919866085052*x_5 - 1.21863985061646) + 3.18832230828066e-5*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 0.0066173733313089*std::sin(0.269599944353104*x_53 - 1.22887980937958) - 0.000520320071052601*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 0.00512162405570158*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 0.00591311697359218*std::sin(0.410799860954285*x_6 - 4.4031195640564) - 0.000124479852831543*std::sin(0.386159837245941*x_60 + 1.82519996166229) - 0.00540835073327314*std::sin(0.44175985455513*x_60 + 4.94255971908569) - 0.00364823597003777*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 0.00247659301869487*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.00739214656905386*std::sin(0.366319835186005*x_9 + 5.02328014373779) - 0.000238750349206551*std::sin(0.273759961128235*x_94 + 1.98055982589722) - 0.00312893170130764*std::sin(0.278399974107742*x_97 - 7.60279989242554) + 0.000242587103744732*std::sin(0.289119929075241*x_98 + 4.9695200920105) + 0.142414655075601);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000142168287193698*x_1 - 0.000524580038211316*x_10 - 3.16125946573399e-5*x_100 + 6.38202443332929e-5*x_101 - 0.000516885744515051*x_102 + 0.000501739195794914*x_103 + 3.97627761134735e-5*x_104 + 0.00013708967936301*x_105 - 0.000608077172271212*x_106 + 0.00027863164363234*x_107 - 0.000659493139416044*x_108 - 6.72407316092635e-6*x_109 - 0.000452617026379485*x_11 - 0.000572970192552072*x_110 - 4.30523792334418e-5*x_111 - 5.82060688229061e-5*x_112 - 0.000398852280861808*x_113 + 0.000486002689521011*x_114 - 0.000512210753492644*x_115 - 4.33015958316224e-5*x_116 - 0.000163304942912499*x_117 + 0.00077157589661657*x_118 + 0.000626197564331932*x_119 + 0.000310957018932109*x_12 - 0.000127606188903096*x_120 + 4.15272098540108e-5*x_13 - 8.50030231955477e-5*x_14 - 0.000104960182237437*x_16 - 0.000249962151600848*x_17 + 7.25584170756533e-6*x_18 - 0.000191689619281611*x_19 - 6.32441767112716e-5*x_2 + 3.06699312957466e-5*x_20 - 3.22988874490545e-5*x_21 - 0.000422825885938041*x_22 - 7.48961481575892e-5*x_23 - 0.000138151876242936*x_24 + 7.05315296064625e-5*x_25 - 0.000493519167191058*x_26 + 5.3878705808594e-5*x_27 - 0.000122339848549944*x_28 - 5.82088660184539e-5*x_29 - 0.000295033961019103*x_3 - 0.0001897841908711*x_30 + 9.32549166662254e-6*x_31 - 3.10275955779615e-10*x_32 - 0.00167866331587017*x_33 + 0.000558878492714763*x_34 + 0.000255744145238853*x_35 + 0.00150185715137866*x_36 - 2.73924365054803e-5*x_37 - 0.00135749482642021*x_38 - 0.000145605398916068*x_39 - 1.87631296663736e-5*x_4 - 0.000397560380410736*x_40 - 0.000653080761527324*x_41 - 0.00171089483505849*x_42 + 0.000330765418082708*x_43 - 1.07739772629956e-5*x_44 - 0.000377299326316363*x_45 - 0.000243834335159449*x_46 + 7.05375535461617e-5*x_47 - 0.000865597038625795*x_48 - 0.000776949318224633*x_49 - 2.13859627384442e-5*x_5 - 0.00233302363986381*x_50 + 0.00110077651932576*x_51 - 4.77827498372312e-5*x_52 - 3.02755186264105e-5*x_53 - 0.000788123165080507*x_54 - 0.00114645128657599*x_55 + 0.000107615658139387*x_56 - 0.00102846285808429*x_57 - 0.00144586706289056*x_58 - 0.00125237397084665*x_59 - 6.0858953803534e-5*x_6 - 0.000746888439775301*x_60 + 5.76074245945563e-5*x_61 - 3.80212440814703e-7*x_62 + 4.50444896872547e-6*x_63 + 4.97920850924188e-5*x_64 + 4.9521315941551e-6*x_65 + 4.53702203258226e-5*x_66 + 8.42025877854611e-6*x_67 - 4.00040383718846e-6*x_68 + 1.68703724196078e-5*x_69 - 4.42854480642662e-5*x_7 + 1.13163966173355e-5*x_70 - 6.97868545946036e-6*x_71 - 1.29485121555183e-5*x_72 - 1.58001604715085e-5*x_73 - 5.83557515775878e-6*x_74 - 4.67045020158626e-6*x_75 + 4.45095497362796e-5*x_76 + 1.65481915147469e-5*x_77 - 3.78777134854969e-6*x_78 + 1.14566854983936e-5*x_79 - 3.47396232198139e-5*x_8 + 3.54409245056494e-6*x_80 + 3.30128259203925e-5*x_81 + 2.10876922831996e-5*x_82 + 2.06191630442625e-5*x_83 + 3.26136410005709e-6*x_84 + 3.49143640964772e-5*x_85 + 1.75668840267313e-5*x_86 - 1.44731095548763e-6*x_87 + 1.07502347782409e-5*x_88 + 3.99774712413188e-5*x_89 - 8.90651986436595e-5*x_9 + 2.34042113593538e-5*x_90 + 3.75093021509784e-5*x_91 - 8.29132162223365e-6*x_92 + 0.000365548278907519*x_93 + 4.24900772170989e-5*x_94 + 0.000166514457124736*x_95 - 0.000167283063048869*x_96 + 4.86456920300231e-5*x_97 - 0.000270132596153053*x_98 + 9.71472473064196e-5*x_99 - 2.62240730127909e-6*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 7.46214476498964e-8*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 1.57751488839441e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) - 3.19548325455383e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) + 0.000494465106715128*std::exp(0.226479843258858*x_10) - 9.68765598561702e-6*std::exp(0.253039866685867*x_15) - 0.000432026757511083*std::exp(0.364639848470688*x_22) - 0.0282868356576416*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.00227713049763259*std::sin(0.241839975118637*x_102 + 8.17535972595215) - 0.0012153669221093*std::sin(0.276639938354492*x_107 - 1.60879981517792) - 0.00784747457201108*std::sin(0.267839968204498*x_109 + 4.97111988067627) + 0.00296612000870102*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.00204326975949638*std::sin(0.0867200791835785*x_13 + 1.7151198387146) + 0.00124216946883546*std::sin(0.205119997262955*x_14 - 7.59024047851563) + 0.0074503774412432*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.00208515844598603*std::sin(0.335759848356247*x_15 + 5.07039976119995) - 0.00198553267676299*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 0.000252338880901973*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000250991231056391*std::sin(0.324799835681915*x_18 + 4.99583959579468) + 0.00936680302782119*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.000441044070371112*std::sin(0.239519983530045*x_20 - 7.58616018295288) + 0.00845952391768957*std::sin(0.348719835281372*x_20 + 8.23320007324219) - 0.00265845211916119*std::sin(0.35455983877182*x_21 - 1.396479845047) - 0.00107109889525615*std::sin(0.445919841527939*x_21 - 7.63576030731201) - 0.00481789032475507*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 8.7038060171435e-5*std::sin(0.297839939594269*x_26 - 4.39071989059448) - 0.00815675362120345*std::sin(0.274079948663712*x_27 - 7.57639980316162) - 0.00119576738119167*std::sin(0.293279945850372*x_28 + 1.99383985996246) - 0.00687307660876713*std::sin(0.380559861660004*x_29 - 7.58888006210327) - 0.00321756182549801*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.000508329069143256*std::sin(0.335599839687347*x_3 + 1.7707998752594) + 0.00440852196206231*std::sin(0.273759961128235*x_32 + 1.80263984203339) + 0.00309892890900606*std::sin(0.228079989552498*x_37 + 1.79159986972809) + 0.00257362598161768*std::sin(0.299759924411774*x_4 + 8.02079963684082) - 0.00549999865965722*std::sin(0.253279983997345*x_40 + 1.75911998748779) - 0.00440671281638867*std::sin(0.266879975795746*x_41 - 1.23359990119934) - 0.00747464708694217*std::sin(0.13984003663063*x_43 - 1.42143988609314) + 0.00402458393726172*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.00151483737685455*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.00178698458822029*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 0.000260600242278845*std::sin(0.296719938516617*x_51 - 4.88095998764038) + 0.00276669792219219*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.00425288046401981*std::sin(0.184640005230904*x_55 + 1.80663990974426) - 0.00214133099701605*std::sin(0.267279952764511*x_58 + 8.13583946228027) + 0.00247225109200253*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.00101744669045798*std::sin(0.386159837245941*x_60 + 1.82519996166229) - 0.00869732244570687*std::sin(0.44175985455513*x_60 + 4.94255971908569) - 0.00586683189650344*std::sin(0.341199845075607*x_7 - 7.59463977813721) - 0.00103545385999606*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.00195144633545339*std::sin(0.273759961128235*x_94 + 1.98055982589722) - 0.00503172395041716*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.00198280637579867*std::sin(0.289119929075241*x_98 + 4.9695200920105) - 0.172795370221138*std::sin(0.00191244317737502*x_1 + 0.00205457498206514*x_10 - 0.012119791581474*x_101 - 0.0135772108920336*x_102 + 0.000324748675583237*x_103 + 0.00931908772907458*x_104 - 0.010195277619972*x_105 + 0.000394788389237924*x_106 + 0.000683822069036916*x_107 + 0.000779031448548572*x_108 + 0.0236104014569919*x_109 + 0.00222401496953681*x_11 + 0.01180330774349*x_110 - 0.0168872994753208*x_111 - 0.00895987002869885*x_112 - 0.000408738610366272*x_113 - 9.94564227528238e-6*x_114 + 0.000140491812205756*x_116 + 0.0191903739975036*x_117 + 0.0142748394756429*x_119 - 0.0277065196795616*x_12 - 4.64309549163816e-5*x_120 - 0.0220741930488408*x_13 + 0.00151068670775894*x_14 + 0.00443315773070129*x_15 + 0.00120340382882582*x_16 + 0.00143297276576276*x_17 - 0.0308087351544691*x_19 + 0.00143995380660396*x_2 - 0.000987578780662117*x_20 + 0.00113545899867706*x_23 + 0.00127481039409488*x_24 + 0.0251088212231801*x_25 + 0.00255424980551286*x_26 - 0.0327633190534904*x_27 + 0.00100334860132513*x_28 + 0.00279315855998086*x_29 + 0.00574486398342416*x_30 + 9.63236579776122e-5*x_31 + 0.000640843789811178*x_33 - 0.0283940931177146*x_34 + 0.00249609537855591*x_35 + 0.00188186608431008*x_36 + 0.00490788155085588*x_37 + 0.00136113946779326*x_38 + 0.00263434102583809*x_39 + 0.00147662032777278*x_4 + 0.00058773355064224*x_41 - 0.0209139293833355*x_42 - 0.0176638300815376*x_43 + 0.000471340848624651*x_44 + 0.00220902835991501*x_45 + 0.000896471872828649*x_46 + 0.0186691751204906*x_47 + 0.00314286360531824*x_48 + 0.0104816658230441*x_49 + 0.000865192811932993*x_50 + 0.00153267936132545*x_51 - 0.026433646564416*x_52 + 0.00369523809348012*x_53 + 0.00149749185616201*x_54 - 0.0396902369381934*x_55 + 0.02591408353718*x_56 + 0.000386099231256154*x_57 + 0.0106571495077295*x_58 + 0.005165229156858*x_59 - 0.0101645687813706*x_6 - 0.0113622403048289*x_60 + 8.86060880277376e-5*x_61 - 0.000407326113711604*x_62 + 0.000222276969881544*x_63 - 0.000114559130823612*x_64 + 0.000643977754947814*x_65 + 7.11383256320934e-5*x_66 - 0.000363892569227308*x_67 - 9.83587200671108e-6*x_68 + 4.0452354633655e-5*x_69 + 0.0016440375246542*x_7 + 0.00290763762153933*x_70 - 0.000350767405756428*x_71 - 0.000122667165815985*x_72 - 0.000114226740744234*x_73 + 0.000294508900401316*x_74 - 0.000397977993928957*x_75 + 0.000329828440344496*x_76 + 0.000289543892386109*x_77 + 0.00081250797514953*x_78 - 0.00158787358150939*x_79 + 0.00753912585726143*x_8 - 6.38531080309705e-5*x_80 - 0.000873237596001533*x_81 - 0.00010169983676949*x_82 - 0.000174695359846244*x_83 + 0.000215783091298292*x_84 + 0.000885842549927066*x_85 - 0.000315816847810304*x_86 + 0.000188339186180718*x_87 + 0.000126259359092727*x_88 + 5.1879460997737e-5*x_89 + 0.00096720650954462*x_90 - 0.000446952761389943*x_91 - 0.0100974935754211*x_92 + 0.00141115547349403*x_93 + 0.000520800497167139*x_94 - 0.00478516243905115*x_95 - 0.0215633176624058*x_96 + 0.00346638837273635*x_97 - 0.00266290398943567*x_98 + 0.00184371541904295*x_99 - 0.13947165620948*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.28341786310682*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.188508702698698*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0708989640498885*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0564658691963302*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0724278124754107*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00431942055003631*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.112580315160358*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.260066792285215*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.00831725007005346*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0906136013539935*std::sin(0.366319835186005*x_9 + 5.02328014373779) + 7.25587133116729) + 0.103681165702476);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000112425398700546*x_1 - 0.000174007865537066*x_10 - 0.000379219185961381*x_100 + 4.111567855869e-6*x_101 - 0.00017468730740939*x_102 + 0.000308782050750155*x_103 - 1.46688963824856e-5*x_104 - 9.30988298945437e-5*x_105 + 0.00041011787926915*x_106 - 0.000275518074230475*x_107 - 0.000133859150514301*x_108 + 2.25686799229061e-6*x_109 + 0.000158054092903935*x_11 + 0.000453368675453357*x_110 + 5.28509991793998e-5*x_111 + 4.003507179702e-5*x_112 + 0.00035979190684581*x_113 - 0.000437399624260506*x_114 + 0.000293620215005603*x_115 + 6.55430775615686e-5*x_116 + 0.000622254998571731*x_117 + 0.000249530449233711*x_118 - 1.22827632333266e-5*x_119 - 0.000386961706732785*x_12 - 7.50164622169822e-5*x_120 - 1.06878784310376e-5*x_13 - 2.69395422673079e-5*x_14 - 6.04307395077564e-5*x_16 - 0.000241232981383815*x_17 + 1.89974381129607e-5*x_18 - 4.72509173969111e-5*x_19 - 1.77381086297896e-5*x_2 + 3.33967693498585e-5*x_20 - 1.95691612805336e-5*x_21 + 4.45881368797058e-5*x_22 + 4.58821772149543e-7*x_23 - 2.83301721997145e-5*x_24 - 6.61356156042526e-5*x_25 + 0.00040447197409524*x_26 + 4.94422473654686e-6*x_27 - 3.65377136551537e-5*x_28 + 1.84035879167056e-5*x_29 - 0.000110866508438821*x_3 + 0.000184163578775503*x_30 - 2.57725829498265e-6*x_31 - 1.16814012155776e-6*x_32 - 0.000531462598253577*x_33 - 0.000339736685324247*x_34 - 2.78620840790457e-5*x_35 - 0.000287352417728388*x_36 + 2.10080877949373e-5*x_37 + 0.000254226311303884*x_38 - 7.7447902237553e-5*x_39 - 4.98391567461011e-5*x_4 + 0.000252304619290339*x_40 - 0.000342885190071577*x_41 - 0.000623140616453606*x_42 - 4.27783435412423e-5*x_43 + 1.7759482804836e-5*x_44 - 4.21884227627313e-5*x_45 - 0.000528727301092528*x_46 - 2.39857009705908e-5*x_47 - 0.000303692169749916*x_48 + 0.000349921656322003*x_49 - 2.42640938054271e-5*x_5 - 0.000452591134259919*x_50 - 6.37227917794326e-5*x_51 + 4.23088001576219e-6*x_52 + 9.85442588199719e-6*x_53 + 0.000561497560568725*x_54 - 0.000946889479025361*x_55 - 0.000197574349597208*x_56 - 0.00117129106867605*x_57 - 0.000398072499018306*x_58 - 0.000323735068683879*x_59 - 2.39928176525308e-5*x_6 + 0.000608419365992348*x_60 + 2.46119533932688e-5*x_61 - 3.76218599476606e-6*x_62 + 8.24243860060506e-7*x_63 + 4.15342361909274e-8*x_64 + 9.93634030081631e-6*x_65 + 1.97601443217704e-5*x_66 + 1.40221825869082e-6*x_67 - 7.45882557011127e-6*x_68 + 1.21655833017118e-5*x_69 + 5.31630541305109e-5*x_7 + 3.90453307497279e-6*x_70 - 4.95016784859398e-6*x_71 - 1.18184190636009e-5*x_72 - 1.53004369160893e-5*x_73 - 8.56578074186177e-6*x_74 + 9.46990319891992e-7*x_75 + 8.40237503308469e-6*x_76 - 1.71269138486827e-5*x_77 - 1.5291320442045e-5*x_78 - 3.94479567211079e-6*x_79 + 4.9168145502637e-5*x_8 - 5.12704554934011e-6*x_80 - 3.01096405371506e-5*x_81 + 2.48044982431378e-6*x_82 - 1.82639704354888e-5*x_83 + 1.00320570459547e-5*x_84 + 2.91111061240503e-6*x_85 - 1.15472741500084e-5*x_86 - 1.18394820431717e-6*x_87 - 1.5099177996458e-5*x_88 - 1.08895703558873e-5*x_89 + 1.30561247184409e-5*x_9 + 1.37900674449527e-5*x_90 + 6.99012458616658e-6*x_91 - 2.95634168060779e-6*x_92 + 0.000121508323965168*x_93 - 6.56243116327641e-6*x_94 + 4.35782792324618e-5*x_95 + 0.000172270790525411*x_96 + 3.13761146085534e-5*x_97 + 0.000225828275798242*x_98 + 0.000230066596577731*x_99 - 9.04690676536268e-7*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 2.321707411155e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 4.90814386873898e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) - 1.10239317363575e-6*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 0.000411403783914166*std::exp(0.226479843258858*x_10) - 3.01413379221119e-5*std::exp(0.253039866685867*x_15) + 0.000239191780376577*std::exp(0.364639848470688*x_22) - 0.00975852853814891*std::sin(0.130640044808388*x_1 - 7.68408012390137) - 0.00126073417539322*std::sin(0.241839975118637*x_102 + 8.17535972595215) - 0.000419283122978862*std::sin(0.276639938354492*x_107 - 1.60879981517792) - 0.00270725950015127*std::sin(0.267839968204498*x_109 + 4.97111988067627) + 0.00102326633854727*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.00635725343452009*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 0.00103350714297415*std::sin(0.205119997262955*x_14 - 7.59024047851563) + 0.00257026702315894*std::sin(0.33231982588768*x_15 - 4.33975982666016) + 0.00115444877520083*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 0.00165199858435335*std::sin(0.414319843053818*x_15 - 1.39479982852936) + 0.000139707518415981*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000780912485124309*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.00779334710678466*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.00137222651003877*std::sin(0.239519983530045*x_20 - 7.58616018295288) + 0.00291840722550476*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 0.00221187955696872*std::sin(0.35455983877182*x_21 - 1.396479845047) + 0.000593014315112486*std::sin(0.445919841527939*x_21 - 7.63576030731201) - 0.00166209896351884*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000270802719213738*std::sin(0.297839939594269*x_26 - 4.39071989059448) - 0.00281395607322589*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 0.000994899778816561*std::sin(0.293279945850372*x_28 + 1.99383985996246) - 0.00237110700692386*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 0.00267706880022634*std::sin(0.407679855823517*x_29 - 7.6049599647522) - 0.000281436584544013*std::sin(0.335599839687347*x_3 + 1.7707998752594) + 0.00152087309795005*std::sin(0.273759961128235*x_32 + 1.80263984203339) - 0.0025783640987646*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 0.00214130269828589*std::sin(0.299759924411774*x_4 + 8.02079963684082) - 0.0018974159757437*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.00366646362435808*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 0.00621903963137006*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 0.00334852558448284*std::sin(0.272719949483871*x_44 - 4.44063997268677) - 0.000838690296032253*std::sin(0.228959992527962*x_48 + 1.77615988254547) - 0.000989364704224255*std::sin(0.347999840974808*x_5 - 4.38783979415894) + 0.000144281424318134*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 0.00230194199485362*std::sin(0.269599944353104*x_53 - 1.22887980937958) - 0.00235460890380514*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 0.00178162556431435*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 0.00205695698285489*std::sin(0.410799860954285*x_6 - 4.4031195640564) - 0.000563309751300894*std::sin(0.386159837245941*x_60 + 1.82519996166229) - 0.00300044410478219*std::sin(0.44175985455513*x_60 + 4.94255971908569) - 0.00202396786913437*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 0.00086151607117614*std::sin(0.176720008254051*x_8 + 1.78079986572266) - 0.00108041901380256*std::sin(0.273759961128235*x_94 + 1.98055982589722) - 0.00173586831558405*std::sin(0.278399974107742*x_97 - 7.60279989242554) + 0.00109778151219522*std::sin(0.289119929075241*x_98 + 4.9695200920105) + 0.0560062080621719*std::sin(0.00189747258321713*x_1 + 0.00203849178096022*x_10 - 0.0120249179229042*x_101 - 0.0134709285635099*x_102 + 0.000322206544824537*x_103 + 0.00924613796410156*x_104 - 0.0101154690455885*x_105 + 0.000391697988004858*x_106 + 0.000678469113826077*x_107 + 0.000772933194864265*x_108 + 0.0234255793706162*x_109 + 0.00220660539318761*x_11 + 0.0117109115185779*x_110 - 0.016755105792466*x_111 - 0.00888973221781172*x_112 - 0.000405539006882704*x_113 - 9.8677878449368e-6*x_114 + 0.000139392043110432*x_116 + 0.0190401518605776*x_117 + 0.0141630961145919*x_119 - 0.0274896332033737*x_12 - 4.6067493669198e-5*x_120 - 0.0219013963930203*x_13 + 0.00149886106092711*x_14 + 0.00439845499756422*x_15 + 0.00119398359059729*x_16 + 0.00142175546322047*x_17 - 0.0305675645534431*x_19 + 0.00142868185651425*x_2 - 0.000979848019665321*x_20 + 0.0011265706321869*x_23 + 0.00126483118568543*x_24 + 0.0249122695155203*x_25 + 0.00253425515277306*x_26 - 0.0325068479809806*x_27 + 0.000995494394263173*x_28 + 0.00277129373088956*x_29 + 0.00569989322130918*x_30 + 9.5569636938741e-5*x_31 + 0.000635827268322139*x_33 - 0.0281718243206201*x_34 + 0.00247655595833479*x_35 + 0.00186713484746028*x_36 + 0.00486946268239375*x_37 + 0.001350484475893*x_38 + 0.00261371941948771*x_39 + 0.00146506135236692*x_4 + 0.000583132775798974*x_41 - 0.020750215264794*x_42 - 0.0175255577215778*x_43 + 0.000467651195181205*x_44 + 0.00219173609865946*x_45 + 0.000889454296180697*x_46 + 0.0185230329253666*x_47 + 0.00311826128714981*x_48 + 0.0103996154034594*x_49 + 0.000858420087593255*x_50 + 0.0015206815561284*x_51 - 0.0262267241316292*x_52 + 0.00366631179100549*x_53 + 0.00148576949855234*x_54 - 0.0393795419924498*x_55 + 0.0257112282407726*x_56 + 0.000383076848701634*x_57 + 0.0105737254028736*x_58 + 0.00512479577282096*x_59 - 0.0100850005955986*x_6 - 0.0112732967532817*x_60 + 8.79124800819045e-5*x_61 - 0.0004041375672437*x_62 + 0.000220536987043827*x_63 - 0.000113662362608519*x_64 + 0.000638936700797768*x_65 + 7.05814552295062e-5*x_66 - 0.000361044020295019*x_67 - 9.75887685739451e-6*x_68 + 4.01356938349887e-5*x_69 + 0.00163116800839714*x_7 + 0.00288487665101469*x_70 - 0.000348021600528059*x_71 - 0.000121706927949754*x_72 - 0.000113332574476764*x_73 + 0.000292203486428261*x_74 - 0.000394862624488773*x_75 + 0.000327246545216556*x_76 + 0.000287277344467149*x_77 + 0.000806147667408147*x_78 - 0.0015754437162752*x_79 + 0.00748010962355077*x_8 - 6.33532662697299e-5*x_80 - 0.000866401897138524*x_81 - 0.000100903731034056*x_82 - 0.000173327845577342*x_83 + 0.000214093942504655*x_84 + 0.000878908179557456*x_85 - 0.000313344635347876*x_86 + 0.000186864868117993*x_87 + 0.000125271001558253*x_88 + 5.14733488763859e-5*x_89 + 0.000959635222568586*x_90 - 0.000443454017752654*x_91 - 0.0100184504539742*x_92 + 0.00140010895658974*x_93 + 0.000516723673880279*x_94 - 0.00474770421508815*x_95 - 0.0213945201361626*x_96 + 0.00343925350455527*x_97 - 0.00264205879237104*x_98 + 0.00182928282538073*x_99 - 0.138379872889409*std::sin(0.249999970197678*x_100 + 1.79223990440369) - 0.281199269709711*std::sin(0.231439992785454*x_115 + 4.96000003814697) + 0.187033057661648*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.0703439673683857*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.0560238546980636*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.0718608479772542*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.00428560815089324*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.111699037102859*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.258030990935765*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.00825214268449476*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 0.0899042786054256*std::sin(0.366319835186005*x_9 + 5.02328014373779) - 2.1478304683865) + 0.107761329593124);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0001155942834997*x_1 - 0.000193913897265957*x_10 - 0.000226871587872741*x_100 + 0.00144082453893447*x_101 + 0.00176901842283283*x_102 - 0.00018578176655617*x_103 - 0.00114916522193421*x_104 + 0.00129838680275877*x_105 + 0.000123288398330425*x_106 - 0.000505893074159532*x_107 - 8.42591178421706e-5*x_108 - 0.00293321864173876*x_109 - 8.00711641110623e-7*x_11 - 0.00109817297484839*x_110 + 0.00222758867906137*x_111 + 0.00110467872787508*x_112 + 0.000506274219150307*x_113 - 0.000354387704911001*x_114 + 0.00028993398045775*x_115 + 5.69594817116487e-5*x_116 - 0.00195706415104723*x_117 - 0.00012249031039433*x_118 - 0.00185791937020351*x_119 + 0.00306414425138287*x_12 + 0.000102195880020715*x_120 + 0.00280622583749917*x_13 - 0.000180816980488571*x_14 - 0.000551242184233077*x_15 - 0.000163629584561949*x_16 - 0.000325598098705508*x_17 - 3.42006563222754e-6*x_18 + 0.00383358329986537*x_19 - 0.000196200120037915*x_2 + 0.000339101331797535*x_20 - 6.93284239770953e-6*x_21 + 0.000156436769601686*x_22 - 0.00010449378191922*x_23 - 0.000142207224382252*x_24 - 0.00320292664800405*x_25 + 0.000275877164670155*x_26 + 0.00423151313097888*x_27 - 0.000121016809485927*x_28 - 0.000375192684103482*x_29 + 3.96390695530012e-5*x_3 - 0.000563546635109746*x_30 - 1.21903293334464e-5*x_31 - 1.92978969101829e-6*x_32 + 7.55863836456176e-5*x_33 + 0.00303647431183619*x_34 - 0.000746867835132685*x_35 - 0.000919479243180698*x_36 - 0.000623276429275756*x_37 + 0.000299624309491589*x_38 - 0.000436965194623902*x_39 - 0.000176438435188255*x_4 - 6.77667849362584e-5*x_40 + 8.53214036466659e-5*x_41 + 0.00238619452673388*x_42 + 0.00205218744284729*x_43 - 7.10226777159243e-5*x_44 - 0.000553014169847116*x_45 - 0.000201000830119353*x_46 - 0.00225509316728289*x_47 - 0.000263948499995006*x_48 - 0.00129871333854481*x_49 - 1.13012879093996e-5*x_5 + 0.000390057634678761*x_50 - 0.000772823335105986*x_51 + 0.00328904500303184*x_52 - 0.000465678431276067*x_53 + 0.000376648531848974*x_54 + 0.00468284784484678*x_55 - 0.00352781694963035*x_56 - 0.00011764491548478*x_57 - 0.00128254668916348*x_58 - 0.000497683501704273*x_59 + 0.00126126955700941*x_6 + 0.00207006668217966*x_60 - 1.46063779160679e-5*x_61 + 4.69636181820835e-5*x_62 - 2.70443409337955e-5*x_63 - 3.12820965889582e-6*x_64 - 7.69789186796284e-5*x_65 - 1.39556428636036e-5*x_66 + 4.18291144901676e-5*x_67 + 4.75979731615221e-8*x_68 - 5.69780882823239e-6*x_69 - 0.000155179686677939*x_7 - 0.000364930608237668*x_70 + 4.93914087573228e-5*x_71 + 1.13998168487233e-5*x_72 + 1.03553459520835e-5*x_73 - 3.94302879903218e-5*x_74 + 5.02191824084884e-5*x_75 - 5.36109842642123e-5*x_76 - 3.57367992268459e-5*x_77 - 0.000107521724459471*x_78 + 0.000196833323550407*x_79 - 0.000970103217716517*x_8 - 4.41346200857486e-6*x_80 + 0.000119220307735076*x_81 + 8.62659666549316e-7*x_82 - 4.44524918341342e-6*x_83 - 2.38794794995586e-5*x_84 - 0.000120802470238824*x_85 + 3.03793118793605e-5*x_86 - 1.69021676280263e-5*x_87 - 2.74647187867386e-5*x_88 - 2.31632133834144e-5*x_89 + 3.14501509304465e-5*x_9 - 0.000117819069134568*x_90 + 4.25073460905477e-5*x_91 + 0.00124816651230941*x_92 - 0.000241159415066986*x_93 - 8.53222997008102e-5*x_94 + 0.000560554458881102*x_95 + 0.00282263655928252*x_96 - 0.000372026540217155*x_97 + 0.000573180907728457*x_98 - 0.000406671288418051*x_99 + 4.03551551631483e-7*std::pow(-8.55999946594238*x_13 - 8.80208015441895, 2) - 2.80112876091862e-7*std::pow(-8.96776008605957*x_27 - 5.77671957015991, 2) - 5.92165183579769e-8*std::pow(-6.81127977371216*x_3 - 9.01232051849365, 2) + 4.91739870064669e-7*std::pow(-7.10703992843628*x_30 - 7.08999967575073, 2) - 0.000445267617983677*std::exp(0.226479843258858*x_10) - 3.63653784023512e-5*std::exp(0.253039866685867*x_15) - 0.000108868511900251*std::exp(0.364639848470688*x_22) + 0.00435294563694139*std::sin(0.130640044808388*x_1 - 7.68408012390137) + 0.0173426404107116*std::sin(0.249999970197678*x_100 + 1.79223990440369) + 0.000573825126267969*std::sin(0.241839975118637*x_102 + 8.17535972595215) + 0.000187027852988193*std::sin(0.276639938354492*x_107 - 1.60879981517792) + 0.00120761581863314*std::sin(0.267839968204498*x_109 + 4.97111988067627) - 0.000456444096709407*std::sin(0.293919920921326*x_112 + 1.76895987987518) + 0.0352416700239899*std::sin(0.231439992785454*x_115 + 4.96000003814697) - 0.0234401650775768*std::sin(0.254879981279373*x_118 + 8.16423988342285) + 0.00766999551723187*std::sin(0.0867200791835785*x_13 + 1.7151198387146) - 0.00111857810189035*std::sin(0.205119997262955*x_14 - 7.59024047851563) - 0.00114650816262882*std::sin(0.33231982588768*x_15 - 4.33975982666016) - 0.00052544916059954*std::sin(0.335759848356247*x_15 + 5.07039976119995) + 0.00178797936073648*std::sin(0.414319843053818*x_15 - 1.39479982852936) - 6.3588094905598e-5*std::sin(0.403359860181808*x_16 - 7.78911972045898) - 0.000942167135846772*std::sin(0.324799835681915*x_18 + 4.99583959579468) - 0.00881595065568317*std::sin(0.404319852590561*x_18 - 1.20223987102509) - 0.00843484002345*std::sin(0.180800005793571*x_19 + 7.99456024169922) - 0.0016555846465823*std::sin(0.239519983530045*x_20 - 7.58616018295288) - 0.00130180159328497*std::sin(0.348719835281372*x_20 + 8.23320007324219) + 0.00239394575379923*std::sin(0.35455983877182*x_21 - 1.396479845047) + 0.00702126361415982*std::sin(0.439759850502014*x_21 + 1.78055989742279) - 0.000269911390434071*std::sin(0.445919841527939*x_21 - 7.63576030731201) + 0.00900605572223871*std::sin(0.398879855871201*x_22 - 1.57831990718842) + 0.000741405469393292*std::sin(0.308639913797379*x_25 - 1.38775980472565) - 0.000326722170795503*std::sin(0.297839939594269*x_26 - 4.39071989059448) + 0.00125520950864759*std::sin(0.274079948663712*x_27 - 7.57639980316162) + 0.0010767928540457*std::sin(0.293279945850372*x_28 + 1.99383985996246) + 0.00105766969478661*std::sin(0.380559861660004*x_29 - 7.58888006210327) + 0.00289742606768025*std::sin(0.407679855823517*x_29 - 7.6049599647522) + 0.000128096300405297*std::sin(0.335599839687347*x_3 + 1.7707998752594) - 0.000537099504069889*std::sin(1.61759984493256*x_3 - 6.38495969772339) - 0.000678409443614639*std::sin(0.273759961128235*x_32 + 1.80263984203339) + 0.0139988294124664*std::sin(0.30295991897583*x_32 - 1.35095977783203) - 0.00279059669706653*std::sin(0.228079989552498*x_37 + 1.79159986972809) - 0.00231755950996966*std::sin(0.299759924411774*x_4 + 8.02079963684082) + 0.00084637233582791*std::sin(0.253279983997345*x_40 + 1.75911998748779) + 0.0323380748744786*std::sin(0.26335996389389*x_40 - 7.62576007843018) + 0.00396826083831628*std::sin(0.266879975795746*x_41 - 1.23359990119934) + 0.00673094675129185*std::sin(0.13984003663063*x_43 - 1.42143988609314) - 0.00362415239980182*std::sin(0.272719949483871*x_44 - 4.44063997268677) + 0.000381731196324812*std::sin(0.228959992527962*x_48 + 1.77615988254547) + 0.000450310888216769*std::sin(0.347999840974808*x_5 - 4.38783979415894) - 0.00103421068546183*std::sin(0.413919866085052*x_5 - 1.21863985061646) - 6.56699153107777e-5*std::sin(0.296719938516617*x_51 - 4.88095998764038) - 0.00249142149115213*std::sin(0.269599944353104*x_53 - 1.22887980937958) + 0.00107170391499561*std::sin(0.184640005230904*x_55 + 1.80663990974426) + 0.00192827631193248*std::sin(0.267279952764511*x_58 + 8.13583946228027) - 0.00222627105501241*std::sin(0.410799860954285*x_6 - 4.4031195640564) + 0.000256391311885708*std::sin(0.386159837245941*x_60 + 1.82519996166229) + 0.00133839543776911*std::sin(0.44175985455513*x_60 + 4.94255971908569) + 0.000902822804771879*std::sin(0.341199845075607*x_7 - 7.59463977813721) + 0.000932429948061172*std::sin(0.176720008254051*x_8 + 1.78079986572266) + 0.0112673725064366*std::sin(0.366319835186005*x_9 + 5.02328014373779) + 0.000491754399236624*std::sin(0.273759961128235*x_94 + 1.98055982589722) + 0.000774311452908832*std::sin(0.278399974107742*x_97 - 7.60279989242554) - 0.000499656967459924*std::sin(0.289119929075241*x_98 + 4.9695200920105) + 0.183730046904427);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
