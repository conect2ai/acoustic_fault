
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.42668065014523e-5*x_1 + 0.000103246625544093*x_10 + 9.10872232012799e-6*x_100 - 0.000929222231991359*x_101 + 4.01652649379301e-5*x_102 + 2.49212067896846e-5*x_103 + 0.000908766236023959*x_104 + 8.60219872132038e-5*x_105 + 0.000550833154193966*x_106 - 0.000945685317322051*x_107 - 4.79516042431315e-6*x_108 - 0.00139896588617994*x_109 + 0.000105206417952341*x_11 + 0.000774163409447968*x_110 + 1.36286538262924e-5*x_111 - 0.000656202184029877*x_112 + 0.000210199868933062*x_113 + 0.000274554386587552*x_114 - 0.000196110919563606*x_115 - 3.73668011416569e-5*x_116 - 4.18083582897349e-5*x_117 - 0.000448506470245622*x_118 - 4.71540357145037e-6*x_119 + 0.000526991472410606*x_12 + 0.000631055207351102*x_120 + 1.37612385105852e-7*x_13 + 2.40870085226136e-5*x_14 - 0.000488120366728055*x_15 + 3.28901228833741e-5*x_16 + 0.000161465480905419*x_17 + 7.04381147822798e-5*x_18 + 8.31196761500082e-5*x_19 + 5.56374481460978e-6*x_2 + 5.74911927258883e-5*x_20 - 0.000745912833763968*x_21 + 8.35098171140168e-5*x_22 + 0.000112020206200807*x_23 + 0.000478431436456173*x_24 - 5.19921316616555e-5*x_25 - 0.00057302738619087*x_26 + 9.013338926245e-5*x_27 - 1.15079261022088e-6*x_28 - 0.000171241410338376*x_29 + 0.000384545422809092*x_3 + 8.52158908449122e-5*x_30 + 1.74473199132395e-5*x_31 + 6.02031088767973e-5*x_32 + 0.000435135590429298*x_33 + 0.00080225972127194*x_34 - 6.04197181309459e-5*x_35 + 0.000356160105879826*x_36 - 3.40354348203296e-5*x_37 - 4.11195648564123e-5*x_38 + 0.00100313781079124*x_39 + 1.7821742133147e-6*x_4 + 0.000506047087218028*x_40 + 0.000161837794065767*x_41 - 0.000399880122277688*x_42 - 0.000595209664361225*x_43 + 0.000298180280405533*x_44 + 9.82464149952668e-6*x_45 - 0.000573445126686415*x_46 + 0.000465191816264499*x_47 + 2.01002693153357e-5*x_48 + 2.57604736891149e-5*x_49 + 1.21790889128555e-5*x_5 + 6.00260036974899e-5*x_50 + 8.15172996308626e-5*x_51 - 0.00011915976492521*x_52 + 0.000191753828316111*x_53 + 0.000763112485529341*x_54 - 0.00156621400330578*x_55 + 1.54055109250604e-5*x_56 - 0.000188816232588361*x_57 - 0.000455975025209652*x_58 - 4.28679163111756e-5*x_59 + 1.34742194006607e-5*x_6 + 4.81215693349959e-5*x_60 + 5.11716369197667e-5*x_61 + 1.66583020893962e-6*x_62 + 5.25341421690771e-5*x_63 + 5.05869210770765e-5*x_64 - 4.42069697378059e-5*x_65 + 3.26247007563475e-5*x_66 - 1.72543995060707e-5*x_67 + 3.42427038305432e-5*x_68 - 1.97404868192255e-7*x_69 - 4.99755264141642e-6*x_7 + 2.28474814226127e-5*x_70 + 5.54808077337419e-5*x_71 + 3.02705331791551e-5*x_72 + 9.33027070686526e-6*x_73 + 1.79379437510847e-5*x_74 + 3.46223969011347e-5*x_75 - 9.95513869219278e-6*x_76 + 3.41029463800505e-5*x_77 + 2.85121944069751e-5*x_78 + 1.78177630256829e-6*x_79 + 3.6506733567067e-6*x_8 + 1.07048912828549e-5*x_80 + 3.78283397143813e-7*x_81 + 3.25328435212703e-5*x_82 + 8.29543232303976e-5*x_83 + 4.47082422748866e-6*x_84 + 1.2219534379456e-5*x_85 - 2.0562534347311e-5*x_86 + 2.24137315989722e-5*x_87 + 3.5195124656606e-5*x_88 - 0.000127948286820627*x_89 + 2.74061713713734e-5*x_9 - 2.12412209555575e-6*x_90 - 7.56620940431812e-6*x_91 + 8.38416085342222e-6*x_92 - 2.30242315693099e-6*x_93 - 0.000660399473561107*x_94 + 0.000496337238639398*x_95 - 8.41840787967648e-6*x_96 + 3.91137104288099e-5*x_97 - 0.00174122735155712*x_98 - 0.000409115927172873*x_99 + 4.47915590428758e-8*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) - 7.41237760903143e-8*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 5.64726473735019e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 4.42766030400751e-8*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) + 7.45904338404605e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) + 2.99995291343292e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) + 4.55299791230561e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) + 4.93837663950832e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 0.001615458750166*std::pow(-0.00123405230655545*x_1 - 0.00489137090877847*x_10 - 0.000648464020381185*x_100 - 0.00573434206646885*x_101 + 0.0551447138227259*x_103 - 0.0280799117438689*x_104 + 0.00750783171640539*x_105 - 0.0968724595579549*x_106 + 0.0592911689178912*x_107 + 0.074980790530591*x_108 + 0.0689244259035945*x_111 - 0.0023702235901689*x_112 + 8.6048962031767e-5*x_113 + 0.00123529749177034*x_114 + 0.143623753111788*x_115 - 0.00510488965632137*x_116 + 0.0357717595987376*x_117 - 0.00302649825395478*x_119 + 0.0817559291787918*x_12 - 0.00244211168389702*x_120 - 0.0157049709773126*x_13 + 0.0284163157745914*x_16 - 0.00452701035872245*x_17 - 0.0128489724012777*x_18 - 0.00742823634789594*x_19 - 0.00224278174623141*x_2 - 0.00556483850317468*x_20 - 0.00523066512512404*x_22 - 0.0486310174141154*x_23 - 0.00548472713969381*x_24 - 0.00547848422437854*x_25 - 0.0401751838614307*x_27 + 0.026855674437019*x_28 - 0.00509796149233389*x_29 - 0.0121010727258447*x_30 + 0.000977600029564554*x_31 + 0.0054653866536137*x_33 - 0.00962083165030603*x_34 - 0.00325470257678477*x_36 + 0.010932945654135*x_37 + 0.0197325986133717*x_38 - 0.0636158806560649*x_39 - 0.00931746290223539*x_4 - 0.00315787251804899*x_40 + 0.00634371224810215*x_41 - 0.00355077217829401*x_42 + 0.0484667682248672*x_43 + 0.0665536504651949*x_45 + 0.11500338788926*x_46 + 0.0245315838296889*x_47 + 0.0012481249498113*x_50 + 0.0911326000391642*x_51 - 0.00305786234772277*x_52 - 0.00271004947281453*x_53 + 0.027213337080923*x_54 + 0.11114860743643*x_55 + 0.0358935121345921*x_57 - 0.0196199094078726*x_58 + 0.000702636257568586*x_6 - 0.0024196867406314*x_61 - 0.002282246601511*x_62 - 0.00501780527291915*x_63 - 0.000302671206464504*x_64 + 0.000235774985035675*x_65 + 0.000979633765977982*x_66 - 0.000648470788782028*x_67 + 0.00100798486699234*x_68 + 0.00151674819474894*x_69 - 0.00508169064402144*x_7 - 0.00260805820827781*x_70 + 0.000535167714671984*x_71 + 0.00052598683973777*x_72 + 0.000349880392964418*x_73 + 0.00180434185432504*x_74 + 0.00051100869381981*x_75 - 0.00468555531715873*x_76 - 0.00051120225054262*x_77 + 0.00246568772738453*x_78 + 1.69222870797857e-5*x_79 - 0.00605723362599923*x_8 - 0.000544938165182009*x_80 + 0.00143946857796006*x_81 + 0.000797836798441812*x_82 + 0.0130856486781545*x_83 + 0.00160554517691248*x_84 + 0.0242272893104266*x_85 - 0.000695141434288969*x_86 - 0.000420209448094527*x_87 - 0.000454453801626122*x_88 - 0.00213082391215871*x_89 - 0.0072875955925749*x_9 - 0.00241617343064823*x_90 + 0.00127031819750898*x_91 + 0.000311674324688155*x_92 + 0.070021230068609*x_93 + 0.0323192455902004*x_94 - 0.00213955391126246*x_95 - 0.00101202958986032*x_96 - 0.00238746547625715*x_98 + 0.00061686036473529*x_99 + 0.00109042095273555*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) + 0.201975848778882*std::exp(0.203039854764938*x_49) - 1.00483948059119*std::sin(0.233679980039597*x_102 - 1.20599985122681) + 0.740660449780314*std::sin(0.266719967126846*x_109 - 4.43391990661621) + 0.183057661598031*std::sin(0.254879981279373*x_11 - 1.3887197971344) + 1.12088848396161*std::sin(0.244719967246056*x_110 - 4.43903970718384) - 0.616371488208635*std::sin(0.244239971041679*x_118 + 1.9443998336792) + 0.2144709592599*std::sin(0.358239859342575*x_15 - 1.36047983169556) - 0.626269323541635*std::sin(0.294639945030212*x_21 + 1.81559991836548) - 0.472335918842312*std::sin(0.352479845285416*x_26 - 1.17263984680176) + 0.376482406872451*std::sin(0.291519939899445*x_3 - 7.52311992645264) - 0.0457721888958451*std::sin(0.23463998734951*x_32 + 5.02007961273193) - 0.425723717078025*std::sin(0.233519986271858*x_35 + 4.99319982528687) - 0.986472362404513*std::sin(0.279679954051971*x_44 + 1.9159197807312) - 0.818151765475754*std::sin(0.22511999309063*x_48 - 7.4060001373291) + 0.31275072657316*std::sin(0.27551993727684*x_5 + 1.99671983718872) + 1.82568590187935*std::sin(0.142560034990311*x_56 - 1.40511989593506) + 0.796847593808636*std::sin(0.376559853553772*x_59 + 1.83519995212555) - 0.573293037149504*std::sin(0.521919846534729*x_60 + 8.08527946472168) + 0.323765237024897*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 7.22189778218479, 2) + 6.99629368938113e-5*std::exp(0.451999843120575*x_30) + 0.000196421861568625*std::exp(0.423199862241745*x_5) + 4.23952193056533e-5*std::exp(0.243439853191376*x_59) + 9.22687384872945e-6*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 0.00144279158502103*std::sin(0.435199856758118*x_10 - 4.42439985275269) + 0.000132845777073149*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.0030274374515796*std::sin(0.262959957122803*x_100 + 7.99488019943237) + 5.29583610974844e-5*std::sin(0.272479951381683*x_102 - 4.62847995758057) - 9.81963797468719e-5*std::sin(0.27567994594574*x_106 + 4.76656007766724) + 0.000111914230875528*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 3.15634883789197e-5*std::sin(0.265439957380295*x_108 + 1.95447981357574) - 0.000156756159530107*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 3.06353776727694e-5*std::sin(0.265599936246872*x_109 - 7.6308798789978) - 0.00205493888705505*std::sin(0.281919956207275*x_109 + 1.55823993682861) - 2.11240698374936e-5*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 2.93563528569261e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) + 4.57953688775646e-5*std::sin(0.227439999580383*x_111 - 4.42759990692139) - 0.000160578294841782*std::sin(0.281759947538376*x_113 - 1.19703996181488) + 0.00877556817890402*std::sin(0.256719976663589*x_114 - 4.44536018371582) + 0.00493886286989747*std::sin(0.249599978327751*x_119 - 1.20399987697601) - 0.000569859600816486*std::sin(0.453279852867126*x_12 - 4.64311981201172) + 0.00025239456023344*std::sin(0.26639997959137*x_120 - 7.42495965957642) + 0.0026867064448882*std::sin(0.286079943180084*x_120 - 1.40863978862762) - 0.00145934436204247*std::sin(0.320559918880463*x_13 - 7.45679998397827) - 0.000101493403839025*std::sin(0.395359843969345*x_13 - 1.17983984947205) + 0.00237540901319499*std::sin(0.504719853401184*x_13 - 7.56504011154175) + 5.87296852259545e-5*std::sin(0.325839847326279*x_14 - 4.31423997879028) + 0.00259063140092635*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 3.35731497778382e-5*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 5.80383921376147e-5*std::sin(0.254399985074997*x_15 - 7.59144020080566) + 0.0024746525093195*std::sin(0.453919857740402*x_16 + 4.96103954315186) + 0.00093001917812099*std::sin(0.566639840602875*x_18 - 1.36271989345551) + 0.000158758067074229*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 3.73956389626055e-5*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 0.00393879429114874*std::sin(0.261199951171875*x_2 + 1.8419998884201) + 0.000113607598720705*std::sin(0.380239844322205*x_2 - 1.18343985080719) + 8.45140321461793e-5*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 3.42821203550803e-5*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.000116468912284936*std::sin(0.399439841508865*x_24 + 1.99847972393036) + 0.000183279441177249*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.00348221323499954*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 1.98654473935523e-5*std::sin(0.417679876089096*x_25 + 8.1997594833374) - 0.000111457920277991*std::sin(0.452719867229462*x_26 - 1.2228798866272) + 9.05063757654669e-5*std::sin(0.345679849386215*x_27 + 5.02919960021973) - 0.000244656165300815*std::sin(0.632799863815308*x_28 - 4.41735982894897) - 0.000217931706867649*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.00525508860678751*std::sin(0.240079984068871*x_29 + 8.21415996551514) - 6.86579660020588e-5*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 1.81382260441549e-5*std::sin(0.307679921388626*x_30 + 2.00319981575012) - 0.000835277232263212*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 3.91483939517966e-5*std::sin(0.257999986410141*x_33 + 4.97671937942505) + 0.00887425490900831*std::sin(0.238559976220131*x_36 + 1.95983982086182) - 0.00874637149870543*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 4.783086345568e-5*std::sin(0.280399948358536*x_4 + 5.04743957519531) + 6.67595853413833e-5*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.00313763489855413*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.00475188407632909*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 4.66212311128048e-5*std::sin(0.334879845380783*x_44 + 1.85615992546082) - 3.50897025021498e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.0112571846630602*std::sin(0.206240013241768*x_45 - 4.39103984832764) - 0.000229051812995599*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00721306370162527*std::sin(0.19896000623703*x_50 - 7.59376001358032) + 0.000283507826233051*std::sin(0.189920008182526*x_51 - 7.59376001358032) + 0.00310804124182259*std::sin(0.19344000518322*x_51 + 4.99503993988037) + 0.000137503980351381*std::sin(0.248239979147911*x_53 + 4.99720001220703) - 0.00710666056019859*std::sin(0.252879977226257*x_53 - 7.42528009414673) + 0.00707968336914457*std::sin(0.206960007548332*x_54 + 4.99703979492188) - 0.000166532427036905*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.00635975141858009*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 5.22107421073914e-5*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 0.0024417232243409*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 5.4126381409746e-5*std::sin(0.343599855899811*x_59 - 7.51183986663818) - 0.00213365590654145*std::sin(0.354799836874008*x_59 + 5.07823991775513) + 0.00181851294524579*std::sin(0.465519845485687*x_6 + 8.16063976287842) + 0.00295764378160864*std::sin(0.460559874773026*x_60 - 4.47903966903687) + 7.87954417889046e-5*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 2.40590679610555e-5*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 8.33898440238778e-5*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.00469829062077795*std::sin(0.350959837436676*x_7 + 2.00847983360291) - 0.000115503126061125*std::sin(0.350399851799011*x_8 - 1.15535986423492) - 0.0012059780539586*std::sin(0.454559862613678*x_8 - 7.64487981796265) + 0.000223035970854837*std::sin(0.309599906206131*x_9 - 7.42199993133545) + 0.007116153319051*std::sin(0.211359992623329*x_92 + 2.00551986694336) + 0.00011554035461926*std::sin(0.291999936103821*x_92 - 7.57456016540527) + 0.00723075533656133*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 5.26083211325716e-5*std::sin(0.253359973430634*x_93 + 4.98847961425781) + 3.6345435457985e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 4.77220783971213e-5*std::sin(0.309519916772842*x_95 + 1.76439988613129) + 0.00814461316607029*std::sin(0.281679958105087*x_97 - 4.41967964172363) - 0.000122954444036315*std::sin(0.210240006446838*x_98 + 1.97111988067627) - 0.0251145484554156);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.85323616007836e-5*x_1 + 1.5745281923999e-5*x_10 - 5.77415918791207e-7*x_100 - 0.000502701455895117*x_101 + 3.86880428631788e-5*x_102 - 8.70532171026058e-5*x_103 + 0.000478538725507758*x_104 + 0.00010466350503027*x_105 + 0.000204670868094378*x_106 - 0.000486010970779574*x_107 - 6.74019958072912e-6*x_108 - 0.000738828533294377*x_109 + 6.15003186964242e-5*x_11 + 0.000408852840408232*x_110 + 0.000157500736540848*x_111 - 0.0003083126387738*x_112 + 0.000113463963468077*x_113 - 7.64217271295407e-5*x_114 - 0.000101371136885286*x_115 + 1.40173582363511e-5*x_116 + 2.67207567813563e-6*x_117 - 0.000249490069568882*x_118 - 1.23119011497006e-5*x_119 + 0.000300908382005133*x_12 + 0.00033544542671586*x_120 + 4.82201142907005e-7*x_13 + 3.66698288391147e-6*x_14 - 0.000261092540691004*x_15 + 1.30919110100015e-5*x_16 + 8.69898568755213e-5*x_17 + 3.63372859354966e-5*x_18 + 3.87597168831495e-5*x_19 + 1.28378160039642e-6*x_2 + 2.92781673607663e-5*x_20 - 0.000286794868797862*x_21 + 1.31463862702382e-5*x_22 + 3.30198981779557e-5*x_23 + 0.000168666474519118*x_24 - 7.91523184468386e-6*x_25 - 0.000146936664929126*x_26 + 4.31009544286639e-5*x_27 + 7.5047617989603e-6*x_28 - 2.79148880132998e-5*x_29 + 0.000201946152585791*x_3 + 4.50046225346072e-5*x_30 + 3.17152957891625e-6*x_31 + 9.78618571651599e-6*x_32 + 0.000232132936175384*x_33 + 0.00043605891851398*x_34 + 6.34776139643758e-5*x_35 - 6.71903100047627e-5*x_36 - 8.31122073137898e-5*x_37 + 8.44645867498426e-5*x_38 + 0.000468372380975288*x_39 + 2.71316478766467e-7*x_4 + 0.000297440235738031*x_40 + 0.00014594379466236*x_41 - 7.17951454372862e-5*x_42 - 0.000237616536924704*x_43 + 0.000148303922327559*x_44 + 2.53062186307103e-5*x_45 - 2.68861871296973e-5*x_46 + 0.000235950529116738*x_47 - 2.75847568829183e-5*x_48 + 6.05003154268171e-6*x_49 + 1.43602151478949e-5*x_5 + 7.86321605443978e-5*x_50 + 4.12246362545037e-5*x_51 - 0.000369846153057717*x_52 + 3.01029503681236e-5*x_53 + 0.00015480569372112*x_54 - 0.00084755609810524*x_55 + 5.3639638118793e-5*x_56 - 0.000106912007290781*x_57 - 0.000165911680097703*x_58 - 2.26396083324496e-5*x_59 + 1.31640499445196e-5*x_6 + 7.32598117913739e-6*x_60 + 2.81796921414887e-5*x_61 + 2.3753721500887e-6*x_62 + 2.0622690684456e-5*x_63 + 2.40114178158789e-5*x_64 - 2.32078942562016e-5*x_65 + 1.7651495670935e-5*x_66 - 6.67037186064324e-6*x_67 + 1.29943509761538e-5*x_68 + 2.1470300061336e-6*x_69 + 8.24075029705408e-6*x_7 + 9.06218290192125e-6*x_70 + 2.75311052529736e-5*x_71 + 6.48435809443915e-6*x_72 - 1.4017541139286e-5*x_73 + 3.34131291074177e-8*x_74 + 2.32304529685384e-5*x_75 - 1.57044929199207e-6*x_76 + 1.36999456855789e-5*x_77 + 1.08046618677639e-6*x_78 - 1.87848258472923e-6*x_79 + 3.64491663435314e-6*x_8 + 1.43441466733756e-6*x_80 - 2.67717678300471e-7*x_81 - 6.25888213749277e-7*x_82 + 6.24170776931907e-5*x_83 - 9.53056366175821e-7*x_84 + 1.15918254393426e-5*x_85 + 9.71718730876074e-6*x_86 + 1.87453513543565e-6*x_87 + 6.11236112497957e-6*x_88 - 1.69453053924053e-5*x_89 + 1.68748542338358e-5*x_9 - 3.4296493591147e-6*x_90 + 4.94637736979951e-6*x_91 + 3.00268645664079e-7*x_92 + 1.83291257657361e-6*x_93 - 0.000325029930840782*x_94 + 0.000259292141701948*x_95 - 6.0229530032063e-7*x_96 - 8.20231634462167e-5*x_97 - 0.000736938021509361*x_98 - 0.000272499804224089*x_99 - 1.51456573890847e-7*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 2.50639482312837e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 2.98246037608157e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 1.55147580456085e-7*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) + 3.93930555251942e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 1.01439333618079e-6*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) + 2.4045509635883e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) + 2.6080790142683e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 1.06510898543887e-5*std::exp(0.451999843120575*x_30) + 2.99030742535737e-5*std::exp(0.423199862241745*x_5) - 0.000143353676509427*std::exp(0.243439853191376*x_59) + 3.23314584795093e-5*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 0.000761973970302698*std::sin(0.435199856758118*x_10 - 4.42439985275269) - 0.000449199953770451*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.00159886470005269*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 0.000179071505928638*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.000332037722346511*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.000378422772956205*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.000110600148080711*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.000530049664848473*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 0.000107347998625517*std::sin(0.265599936246872*x_109 - 7.6308798789978) - 0.00031284190891702*std::sin(0.281919956207275*x_109 + 1.55823993682861) - 7.40198682745864e-5*std::sin(0.475119858980179*x_11 + 4.90399980545044) + 9.92645203839578e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 0.000154850820522324*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.000542973696331714*std::sin(0.281759947538376*x_113 - 1.19703996181488) + 0.00463459490363194*std::sin(0.256719976663589*x_114 - 4.44536018371582) + 0.000751887707138769*std::sin(0.249599978327751*x_119 - 1.20399987697601) - 8.67548745401423e-5*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.000853437928451026*std::sin(0.26639997959137*x_120 - 7.42495965957642) + 0.000409021590964699*std::sin(0.286079943180084*x_120 - 1.40863978862762) - 0.000222169174404467*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.000343186161554779*std::sin(0.395359843969345*x_13 - 1.17983984947205) + 0.00125451233266696*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 0.000198586454682151*std::sin(0.325839847326279*x_14 - 4.31423997879028) + 0.00136817660613534*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 0.000117642108894552*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.000203369624032863*std::sin(0.254399985074997*x_15 - 7.59144020080566) + 0.0003767387048825*std::sin(0.453919857740402*x_16 + 4.96103954315186) + 0.000141585220293227*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.000536818843335625*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 0.000131036315035421*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 0.00208017481900441*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.000384148666353261*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.000285772722094992*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.000120126379640754*std::sin(0.527199864387512*x_22 - 4.35599946975708) - 0.000393823809583955*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.00061973453968779*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.0018390430549084*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 6.96095880480641e-5*std::sin(0.417679876089096*x_25 + 8.1997594833374) + 0.000376879820640863*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.000306035018240684*std::sin(0.345679849386215*x_27 + 5.02919960021973) - 3.72462180083191e-5*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.00073690647009547*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.00277534244833288*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.000232157587795328*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 6.35573122438756e-5*std::sin(0.307679921388626*x_30 + 2.00319981575012) - 0.000441130594036401*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 0.000137178062076385*std::sin(0.257999986410141*x_33 + 4.97671937942505) + 0.00468671381001762*std::sin(0.238559976220131*x_36 + 1.95983982086182) - 0.00461917541369206*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 0.000167601898672251*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 0.000225738471404864*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.00165706270110852*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.000723422236425543*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 0.000163363282374866*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 1.18651063579578e-5*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.00594519803220062*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.000774507598777543*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00380939758994614*std::sin(0.19896000623703*x_50 - 7.59376001358032) - 0.000958643212025658*std::sin(0.189920008182526*x_51 - 7.59376001358032) + 0.000473165192994159*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.000464951035538624*std::sin(0.248239979147911*x_53 + 4.99720001220703) - 0.00375320345562535*std::sin(0.252879977226257*x_53 - 7.42528009414673) + 0.00373895613287378*std::sin(0.206960007548332*x_54 + 4.99703979492188) + 0.000563106785735978*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.00335874223890975*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 0.000182949227257717*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 0.000371725582381937*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 0.000189661729626472*std::sin(0.343599855899811*x_59 - 7.51183986663818) - 0.000324825711839586*std::sin(0.354799836874008*x_59 + 5.07823991775513) + 0.000276848652173939*std::sin(0.465519845485687*x_6 + 8.16063976287842) + 0.00156200493433054*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.000266436085427155*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 8.43042583643505e-5*std::sin(0.551119863986969*x_60 - 1.34527981281281) + 0.000281971432632181*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.00248128364146089*std::sin(0.350959837436676*x_7 + 2.00847983360291) + 0.000390558134628782*std::sin(0.350399851799011*x_8 - 1.15535986423492) - 0.000183596932682084*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.000754165845572754*std::sin(0.309599906206131*x_9 - 7.42199993133545) + 0.00375821681668664*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.000390684017942214*std::sin(0.291999936103821*x_92 - 7.57456016540527) + 0.00381874098053236*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 0.000184342365383986*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 0.000122897154032258*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.000167220710020315*std::sin(0.309519916772842*x_95 + 1.76439988613129) + 0.00430137193421443*std::sin(0.281679958105087*x_97 - 4.41967964172363) + 0.000415753754419851*std::sin(0.210240006446838*x_98 + 1.97111988067627) - 0.0699119120836258*std::sin(0.000390769546089311*x_1 + 0.0015488798810425*x_10 + 0.000205339749015104*x_100 + 0.00181581139999611*x_101 - 0.0174618812146463*x_103 + 0.00889166067604327*x_104 - 0.00237739678970638*x_105 + 0.0306752046480749*x_106 - 0.0187748793483642*x_107 - 0.0237430855445999*x_108 - 0.0218253039046557*x_111 + 0.000750544520309489*x_112 - 2.72478837857908e-5*x_113 - 0.000391163840932923*x_114 - 0.0454792625182902*x_115 + 0.00161649178340326*x_116 - 0.0113273272023876*x_117 + 0.000958357553124401*x_119 - 0.0258884709874904*x_12 + 0.000773308286161339*x_120 + 0.00497306665815507*x_13 - 0.00899818488874458*x_16 + 0.00143350308056014*x_17 + 0.00406869877904627*x_18 + 0.00235219247230587*x_19 + 0.000710189349589667*x_2 + 0.00176213715123281*x_20 + 0.00165631928714204*x_22 + 0.0153992829151779*x_23 + 0.00173676944114652*x_24 + 0.0017347925871906*x_25 + 0.0127216960563094*x_27 - 0.0085039991043562*x_28 + 0.00161429794163315*x_29 + 0.00383187217523314*x_30 - 0.000309562502156932*x_31 - 0.00173064516835312*x_33 + 0.00304649000453276*x_34 + 0.00103061972481209*x_36 - 0.00346197822247131*x_37 - 0.00624843741415865*x_38 + 0.0201443234423591*x_39 + 0.00295042659834526*x_4 + 0.000999957946620854*x_40 - 0.00200877186691656*x_41 + 0.00112437181552819*x_42 - 0.0153472724932638*x_43 - 0.0210745846385259*x_45 - 0.0364164642337224*x_46 - 0.00776806285038025*x_47 - 0.000395225727069771*x_50 - 0.0288576461160262*x_51 + 0.000968289168356683*x_52 + 0.000858152281508439*x_53 - 0.00861725497549636*x_54 - 0.0351958265023844*x_55 - 0.0113658808219695*x_57 + 0.00621275374868667*x_58 - 0.000222493690078956*x_6 + 0.000766207302795858*x_61 + 0.000722686116138509*x_62 + 0.00158891602766521*x_63 + 9.58425257472053e-5*x_64 - 7.46594641022741e-5*x_65 - 0.00031020649613589*x_66 + 0.000205341892266983*x_67 - 0.000319184030407054*x_68 - 0.000480286775888941*x_69 + 0.00160914568676051*x_7 + 0.000825856178712494*x_70 - 0.000169463841875351*x_71 - 0.000166556666618932*x_72 - 0.000110791577972803*x_73 - 0.00057135491231535*x_74 - 0.000161813753169859*x_75 + 0.00148370722597098*x_76 + 0.000161875043985746*x_77 - 0.000780773771832616*x_78 - 5.35853659187156e-6*x_79 + 0.00191805681332542*x_8 + 0.000172557709526349*x_80 - 0.000455815754187407*x_81 - 0.00025263947234999*x_82 - 0.0041436436422372*x_83 - 0.000508404835577189*x_84 - 0.00767170629358119*x_85 + 0.000220120412483316*x_86 + 0.000133061665556686*x_87 + 0.000143905331108445*x_88 + 0.000674737276959255*x_89 + 0.00230765779267639*x_9 + 0.00076509479359337*x_90 - 0.000402253342741329*x_91 - 9.8693413349745e-5*x_92 - 0.0221726130611921*x_93 - 0.010234069384371*x_94 + 0.000677501679869091*x_95 + 0.0003204648144636*x_96 + 0.00075600425971003*x_98 - 0.000195332275177969*x_99 - 0.000345287876764404*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 0.0639567790838864*std::exp(0.203039854764938*x_49) + 0.318188026258994*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.234534262631723*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.0579662295924077*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.354935590466994*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.195177469698979*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0679134255121339*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.198311674464691*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.149567803266688*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.119215254055804*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.0144940189190756*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.13480778958745*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.312371975838239*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.25907231997282*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 0.0990342620105178*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.578113624024894*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.252326235185372*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.181536437890859*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.102522068181097*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 7.71853673599416) - 0.0361227023361286);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.74954685116419e-5*x_1 + 7.12624117720325e-5*x_10 - 7.12201270671788e-6*x_100 + 0.000448466569758074*x_101 + 8.20498493777005e-5*x_102 + 0.000312927404231986*x_103 - 0.000462969854809672*x_104 - 0.000145080531462924*x_105 - 0.000386601332420118*x_106 + 0.000712842448659466*x_107 + 0.000327294197786131*x_108 + 0.000639591831539529*x_109 - 5.47595649035109e-5*x_11 - 0.000365192758971991*x_110 - 0.000117680506531362*x_111 + 0.000173646876684681*x_112 - 0.000107132110053632*x_113 + 0.000215453665243617*x_114 + 0.000578235565842566*x_115 - 2.22733264965345e-5*x_116 + 0.000142109971906957*x_117 + 0.000237987527702013*x_118 - 1.34079527721149e-5*x_119 + 6.09514489966791e-7*x_12 - 0.000283921621557613*x_120 - 6.25711242516237e-5*x_13 + 1.77792353363233e-5*x_14 + 0.000253408729836036*x_15 + 5.01982533283158e-5*x_16 - 8.16116001982108e-5*x_17 - 9.14843162710498e-5*x_18 - 5.25448572641678e-5*x_19 - 2.73796054542203e-6*x_2 - 4.91411428749142e-5*x_20 - 8.05541109839064e-5*x_21 + 4.75761852910861e-5*x_22 - 0.000121241686399297*x_23 + 4.20920358822311e-5*x_24 - 6.11526854435515e-5*x_25 - 0.000241997711479468*x_26 - 0.000138213435174721*x_27 + 0.000120135205771717*x_28 - 0.000158066449557808*x_29 - 0.000174586467703038*x_3 - 8.92681428894467e-5*x_30 + 1.59867333244369e-5*x_31 + 3.83100092698905e-5*x_32 - 0.000177928723523192*x_33 - 0.000447738935183435*x_34 - 2.31537880544006e-5*x_35 + 0.000222354447734786*x_36 + 4.9035441876696e-5*x_37 + 6.87486030638272e-5*x_38 - 0.000527770603757953*x_39 - 3.74204701683848e-5*x_4 - 0.000425439093333952*x_40 - 8.26576894357742e-6*x_41 - 0.000276930256286726*x_42 - 0.000224101120091492*x_43 - 0.000107156348378318*x_44 + 0.000408719791885895*x_45 + 0.000106697258881499*x_46 - 6.42565926287207e-5*x_47 - 0.000154790627579621*x_48 + 2.10792913130181e-6*x_49 - 8.31964389280197e-6*x_5 + 0.000207556833048631*x_50 + 0.000329188463406081*x_51 + 0.0010194704395312*x_52 + 0.000135440496137328*x_53 + 0.000893662484009192*x_54 + 0.000986164592187728*x_55 + 1.66949468416002e-5*x_56 + 0.000238458810563945*x_57 - 0.000300946385594238*x_58 + 1.95987403114e-5*x_59 - 4.04842117401267e-6*x_6 + 3.55197576800315e-5*x_60 - 3.65141137634668e-5*x_61 - 1.32064857869642e-5*x_62 - 2.22910762139144e-5*x_63 - 1.40715741625321e-5*x_64 + 2.302412567128e-5*x_65 - 1.00493332470775e-5*x_66 - 3.180903707987e-6*x_67 + 1.17306893244755e-5*x_68 + 4.69569421394517e-6*x_69 + 2.62830776792827e-5*x_7 - 1.78333289224198e-5*x_70 - 1.09900068299268e-5*x_71 + 1.67782694302886e-5*x_72 + 7.01291257236794e-5*x_73 + 1.98838838763233e-5*x_74 - 3.33373960480311e-5*x_75 - 2.48976860733701e-5*x_76 + 1.28041394427863e-6*x_77 + 6.24422446787642e-5*x_78 - 1.14936541494873e-5*x_79 - 1.5184264210821e-5*x_8 - 5.80480617453769e-6*x_80 + 8.68478592419166e-6*x_81 + 4.48530270352895e-5*x_82 + 1.76532090334443e-5*x_83 + 2.43043834605552e-5*x_84 + 9.72862722612382e-5*x_85 + 1.26867228439897e-5*x_86 + 1.7298911114749e-5*x_87 + 1.02484653079676e-5*x_88 - 0.000106878281404761*x_89 - 3.05125822139185e-5*x_9 - 4.08393122516174e-5*x_90 - 2.18034188680462e-5*x_91 + 1.94322188301019e-6*x_92 + 0.000289163763393175*x_93 + 0.000389058098346196*x_94 - 0.000226796825049342*x_95 - 7.11860906983617e-6*x_96 + 4.23338655348745e-5*x_97 + 0.000201713260320921*x_98 + 0.000331523884851771*x_99 + 4.53325967695427e-6*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) + 5.04157545687403e-8*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) - 8.34310343942342e-8*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) + 2.58186738664036e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 8.75127414080631e-7*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 3.41019267636466e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) + 3.37663821115571e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) - 2.08158061786551e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) - 2.25777153746042e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 5.16414281452845e-5*std::exp(0.451999843120575*x_30) + 0.000839683948378763*std::exp(0.203039854764938*x_49) + 0.000144983985817446*std::exp(0.423199862241745*x_5) + 4.7718521459719e-5*std::exp(0.243439853191376*x_59) + 0.000182369235597824*std::sin(0.397759824991226*x_1 - 1.00775980949402) + 0.000659628459499641*std::sin(0.435199856758118*x_10 - 4.42439985275269) + 0.000149526389246741*std::sin(0.259839981794357*x_100 + 1.77871990203857) + 0.00138411113784522*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 0.00417746769057218*std::sin(0.233679980039597*x_102 - 1.20599985122681) + 5.96080108061823e-5*std::sin(0.272479951381683*x_102 - 4.62847995758057) - 0.000110526284117912*std::sin(0.27567994594574*x_106 + 4.76656007766724) + 0.000125966599893722*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.000623852600873809*std::sin(0.265439957380295*x_108 + 1.95447981357574) - 0.000176439048670826*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 0.000605508485325496*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.00307918345009847*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.00151680280431726*std::sin(0.281919956207275*x_109 + 1.55823993682861) + 0.000761034455361525*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.000417517409703098*std::sin(0.475119858980179*x_11 + 4.90399980545044) + 0.00465992381562194*std::sin(0.244719967246056*x_110 - 4.43903970718384) - 3.3042446217409e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) + 5.15456065172048e-5*std::sin(0.227439999580383*x_111 - 4.42759990692139) - 0.000180741105574393*std::sin(0.281759947538376*x_113 - 1.19703996181488) - 0.00401209334680182*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.0025624709489585*std::sin(0.244239971041679*x_118 + 1.9443998336792) + 0.00364550065132821*std::sin(0.249599978327751*x_119 - 1.20399987697601) - 0.000420627905788618*std::sin(0.453279852867126*x_12 - 4.64311981201172) + 0.000284086164338103*std::sin(0.26639997959137*x_120 - 7.42495965957642) + 0.00198312655215936*std::sin(0.286079943180084*x_120 - 1.40863978862762) - 0.00107717929460318*std::sin(0.320559918880463*x_13 - 7.45679998397827) - 0.000114237294875052*std::sin(0.395359843969345*x_13 - 1.17983984947205) - 0.00108601090020395*std::sin(0.504719853401184*x_13 - 7.56504011154175) + 6.61040039579072e-5*std::sin(0.325839847326279*x_14 - 4.31423997879028) - 0.00118440821104424*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 0.00066357357453616*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.00114712928593047*std::sin(0.254399985074997*x_15 - 7.59144020080566) + 0.000891630474498411*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.00182660413382211*std::sin(0.453919857740402*x_16 + 4.96103954315186) + 0.000686470875766223*std::sin(0.566639840602875*x_18 - 1.36271989345551) + 0.000178692323206709*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 0.0007391251039204*std::sin(0.348159849643707*x_19 + 2.01871991157532) - 0.00180077347104749*std::sin(0.261199951171875*x_2 + 1.8419998884201) + 0.00012787259333314*std::sin(0.380239844322205*x_2 - 1.18343985080719) + 9.51259298257022e-5*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.00260361969769784*std::sin(0.294639945030212*x_21 + 1.81559991836548) - 0.000677586383679615*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.000131093184120355*std::sin(0.399439841508865*x_24 + 1.99847972393036) + 0.000206292692671025*std::sin(0.203359991312027*x_25 + 8.21024036407471) - 0.00159202962901847*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 0.000392640727007425*std::sin(0.417679876089096*x_25 + 8.1997594833374) - 0.00196366492178391*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.000125452993232464*std::sin(0.452719867229462*x_26 - 1.2228798866272) + 0.000101870694501394*std::sin(0.345679849386215*x_27 + 5.02919960021973) - 0.000180586955631368*std::sin(0.632799863815308*x_28 - 4.41735982894897) - 0.000245296026326496*std::sin(0.162320017814636*x_29 - 1.2279999256134) - 0.00240256876891809*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.00156516848825766*std::sin(0.291519939899445*x_3 - 7.52311992645264) - 7.72789167672265e-5*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 0.000358502183188358*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 0.000381879572693013*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 0.000190290930972042*std::sin(0.23463998734951*x_32 + 5.02007961273193) - 0.000773768320334707*std::sin(0.257999986410141*x_33 + 4.97671937942505) - 0.00176988176475452*std::sin(0.233519986271858*x_35 + 4.99319982528687) - 0.00405721183545089*std::sin(0.238559976220131*x_36 + 1.95983982086182) + 0.00399874494542365*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 0.000945377399691815*std::sin(0.280399948358536*x_4 + 5.04743957519531) + 7.5142168337125e-5*std::sin(0.408399850130081*x_4 + 4.98151969909668) - 0.00143449219976938*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.0035074868348498*std::sin(0.213279992341995*x_41 + 1.78087985515594) - 0.00410110918329238*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.000921469006736499*std::sin(0.334879845380783*x_44 + 1.85615992546082) - 3.94956966678718e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) - 0.00514666113573788*std::sin(0.206240013241768*x_45 - 4.39103984832764) - 0.000257812414532327*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00340134183844839*std::sin(0.22511999309063*x_48 - 7.4060001373291) + 0.00130021369651368*std::sin(0.27551993727684*x_5 + 1.99671983718872) + 0.00329773346834879*std::sin(0.19896000623703*x_50 - 7.59376001358032) + 0.000319106128277442*std::sin(0.189920008182526*x_51 - 7.59376001358032) + 0.0022941245120366*std::sin(0.19344000518322*x_51 + 4.99503993988037) + 0.000154769493934879*std::sin(0.248239979147911*x_53 + 4.99720001220703) + 0.00324908712122986*std::sin(0.252879977226257*x_53 - 7.42528009414673) - 0.00323675344590119*std::sin(0.206960007548332*x_54 + 4.99703979492188) - 0.000187442860856719*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.00759001215173892*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.00290760846860462*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 0.00103194573635915*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 0.00180229818870892*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 0.00106980836252908*std::sin(0.343599855899811*x_59 - 7.51183986663818) - 0.00157490584409942*std::sin(0.354799836874008*x_59 + 5.07823991775513) + 0.00331277297692094*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.00134229078655912*std::sin(0.465519845485687*x_6 + 8.16063976287842) - 0.00135220223881661*std::sin(0.460559874773026*x_60 - 4.47903966903687) + 8.86892918945342e-5*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 0.00238337882436012*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.000475527671147034*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 9.38605844420152e-5*std::sin(0.271759957075119*x_7 + 5.01319980621338) - 0.00214800684772513*std::sin(0.350959837436676*x_7 + 2.00847983360291) - 0.000130006130169432*std::sin(0.350399851799011*x_8 - 1.15535986423492) - 0.000890163160429051*std::sin(0.454559862613678*x_8 - 7.64487981796265) + 0.000251041200772998*std::sin(0.309599906206131*x_9 - 7.42199993133545) - 0.00325342710627221*std::sin(0.211359992623329*x_92 + 2.00551986694336) + 0.000130048033284439*std::sin(0.291999936103821*x_92 - 7.57456016540527) - 0.00330582188944859*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 0.00103980388897948*std::sin(0.253359973430634*x_93 + 4.98847961425781) + 4.0909104145934e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.000943227262137205*std::sin(0.309519916772842*x_95 + 1.76439988613129) - 0.00372362764777085*std::sin(0.281679958105087*x_97 - 4.41967964172363) + 0.00134600485264195*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 0.000138393063472898*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.0923672733242562);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.97571277651913e-5*x_1 - 0.000219537779944657*x_10 + 2.94938918218173e-5*x_100 + 0.000405400705913572*x_101 - 0.000422543990148109*x_102 + 0.000276453636534746*x_103 - 0.00079755299524529*x_104 + 0.000142871753622321*x_105 - 0.00109547191370535*x_106 + 0.000922476846274748*x_107 + 0.000521148133409246*x_108 + 0.000698582641144824*x_109 - 4.60670359423833e-5*x_11 - 0.00035522551657429*x_110 + 0.000529274999372777*x_111 + 0.000367833126015771*x_112 - 8.9874773718882e-5*x_113 - 0.000381379022542199*x_114 + 0.000806279299601174*x_115 + 4.1104147961785e-5*x_116 + 0.000315857667484809*x_117 + 0.000232856642036921*x_118 - 1.17953697543504e-6*x_119 + 0.000661483936529853*x_12 - 0.00038857607585408*x_120 - 0.000120963990269999*x_13 - 2.85866012842443e-5*x_14 + 0.000230611207575932*x_15 + 0.000382778016149401*x_16 - 0.000155190804157896*x_17 - 0.00010299411546195*x_18 - 0.000103057374237108*x_19 - 3.23248320549881e-5*x_2 - 6.09339312456413e-5*x_20 + 0.000573197277833175*x_21 - 0.000138297793381273*x_22 - 0.000462803933626437*x_23 - 0.000476985079129686*x_24 + 2.32394689314084e-5*x_25 + 0.000595609580424797*x_26 - 0.000490461753746797*x_27 + 0.00015404565444299*x_28 + 0.000209579512900045*x_29 - 0.000187408227394354*x_3 - 0.000127516186485704*x_30 - 9.80642468707987e-6*x_31 - 5.84769021033722e-5*x_32 - 0.000176702795857295*x_33 - 0.000430481078846854*x_34 + 0.0001544642506905*x_35 - 0.000369462557873995*x_36 - 2.15037779374073e-5*x_37 + 0.000246155134720694*x_38 - 0.00105217872790422*x_39 - 6.75341181654887e-5*x_4 + 0.000417863182625003*x_40 - 0.000223450474985615*x_41 + 0.000434925533197909*x_42 + 0.00094967346188863*x_43 - 0.000165673578125185*x_44 - 4.58931772041087e-5*x_45 + 0.001220853157677*x_46 - 0.000121020816208811*x_47 + 0.000590633294324236*x_48 + 3.88720077741967e-5*x_49 - 1.19196075058432e-6*x_5 - 0.000686766461961611*x_50 + 0.00064655601650422*x_51 - 0.000509144838014628*x_52 - 0.000267397153212819*x_53 - 0.00158856463883578*x_54 + 0.00224053894606078*x_55 - 2.56435580944812e-5*x_56 + 0.000340315980144884*x_57 - 0.000228962033414462*x_58 + 2.14063705862121e-5*x_59 - 2.86300494940502e-6*x_6 - 5.71109573220833e-5*x_60 - 4.32759572218142e-5*x_61 - 1.93846891996421e-5*x_62 - 3.98406073642839e-5*x_63 - 4.24966625466101e-5*x_64 + 1.31198265696082e-5*x_65 - 9.69083442377651e-6*x_66 + 6.79487594435601e-6*x_67 - 1.69532965467596e-5*x_68 - 9.85563649779782e-8*x_69 - 0.000235328569130709*x_7 - 3.38626389324607e-5*x_70 - 3.69017472106264e-5*x_71 + 1.15835867340079e-5*x_72 - 7.53807675426726e-5*x_73 + 5.5334603303807e-6*x_74 + 5.60324569146669e-6*x_75 - 2.6996321884568e-5*x_76 - 3.45375260513137e-5*x_77 - 7.66689193326307e-5*x_78 + 5.84129260746284e-6*x_79 - 8.89120652554675e-5*x_8 - 1.31595704363927e-5*x_80 - 2.97698539951144e-6*x_81 - 5.10904883155062e-5*x_82 + 5.22272882963277e-6*x_83 - 2.97562031367493e-5*x_84 + 0.000137613289368333*x_85 + 7.05598837365733e-6*x_86 - 3.08315340958283e-5*x_87 - 3.61403022785129e-5*x_88 + 0.000142985927570965*x_89 - 0.000116024016028812*x_9 + 8.85010044510824e-5*x_90 + 3.58134766606891e-5*x_91 + 1.45310243366581e-5*x_92 + 0.000495944482618014*x_93 + 0.000595916697229031*x_94 - 0.000268057686460899*x_95 + 1.68228513522388e-5*x_96 - 0.000125809134697076*x_97 + 0.00119683556748689*x_98 + 0.000104111480227092*x_99 + 7.65597616661417e-6*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 1.68018827113105e-7*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 2.78047698852533e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) + 2.81999808175073e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) + 3.44190881101072e-6*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 3.72472143825422e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 1.12532044135157e-6*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) - 2.27356888264839e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) - 2.46601023647255e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) - 8.30324188983645e-5*std::exp(0.451999843120575*x_30) + 0.00141809663561904*std::exp(0.203039854764938*x_49) - 0.000233114603455209*std::exp(0.423199862241745*x_5) - 0.000159029852390719*std::exp(0.243439853191376*x_59) - 0.000717265016227233*std::sin(0.397759824991226*x_1 - 1.00775980949402) + 0.000720467286616796*std::sin(0.435199856758118*x_10 - 4.42439985275269) - 0.000498321383039904*std::sin(0.259839981794357*x_100 + 1.77871990203857) + 0.00151177042393814*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 0.00705509839606393*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.000198653538915986*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.000368347092719618*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.000419804494658735*std::sin(0.253759980201721*x_108 - 1.41743981838226) - 0.002453635583997*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.00058801226458297*std::sin(0.258399993181229*x_109 - 1.24367988109589) + 0.0023814874922791*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.00520026576602937*std::sin(0.266719967126846*x_109 - 4.43391990661621) + 0.00243881337828154*std::sin(0.281919956207275*x_109 + 1.55823993682861) + 0.00128526977658924*std::sin(0.254879981279373*x_11 - 1.3887197971344) + 0.00164211156922466*std::sin(0.475119858980179*x_11 + 4.90399980545044) + 0.00786989235406185*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.000110119408226396*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 0.00017178424530066*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.000602349579600751*std::sin(0.281759947538376*x_113 - 1.19703996181488) - 0.00438213658855206*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.00432761807416429*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0058614710717094*std::sin(0.249599978327751*x_119 - 1.20399987697601) + 0.000676312676239793*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.0009467640530118*std::sin(0.26639997959137*x_120 - 7.42495965957642) - 0.00318859877662777*std::sin(0.286079943180084*x_120 - 1.40863978862762) + 0.00173195834488754*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.000380714648856634*std::sin(0.395359843969345*x_13 - 1.17983984947205) - 0.00118617581645843*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 0.000220302508759319*std::sin(0.325839847326279*x_14 - 4.31423997879028) - 0.00129364850434893*std::sin(0.429519861936569*x_14 + 1.77279984951019) - 0.00260985965723552*std::sin(0.453119844198227*x_14 + 1.75431990623474) - 0.0045117023339515*std::sin(0.254399985074997*x_15 - 7.59144020080566) + 0.00150582630350729*std::sin(0.358239859342575*x_15 - 1.36047983169556) - 0.00293693193717088*std::sin(0.453919857740402*x_16 + 4.96103954315186) - 0.0011037521494911*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.000595521674050731*std::sin(0.199760004878044*x_19 + 5.00815963745117) - 0.00290700664462151*std::sin(0.348159849643707*x_19 + 2.01871991157532) - 0.00196686234169039*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.000426156532526972*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.000317022869023328*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.00439711196202513*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.00266497255906198*std::sin(0.527199864387512*x_22 - 4.35599946975708) - 0.000436889683132531*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.000687504462862508*std::sin(0.203359991312027*x_25 + 8.21024036407471) - 0.00173886564552194*std::sin(0.350159853696823*x_25 + 8.2388801574707) + 0.00154427064688433*std::sin(0.417679876089096*x_25 + 8.1997594833374) - 0.00331632708287617*std::sin(0.352479845285416*x_26 - 1.17263984680176) + 0.000418092815649662*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.000339500911049229*std::sin(0.345679849386215*x_27 + 5.02919960021973) + 0.00029035935461311*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.000817489512780942*std::sin(0.162320017814636*x_29 - 1.2279999256134) - 0.00262416240070311*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.00264332808988498*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.000257544750978525*std::sin(0.408879846334457*x_3 + 1.80935990810394) + 0.00141000247875779*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 0.000417101074991847*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 0.000321372022796538*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.00304325970891778*std::sin(0.257999986410141*x_33 + 4.97671937942505) - 0.00298905722907748*std::sin(0.233519986271858*x_35 + 4.99319982528687) - 0.00443141644393899*std::sin(0.238559976220131*x_36 + 1.95983982086182) + 0.00436755703792306*std::sin(0.221199989318848*x_37 + 1.96463978290558) - 0.00371820462869177*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 0.00025042368399991*std::sin(0.408399850130081*x_4 + 4.98151969909668) - 0.00156679823005934*std::sin(0.415839850902557*x_4 - 1.18935990333557) + 0.00563956355607373*std::sin(0.213279992341995*x_41 + 1.78087985515594) - 0.00692614065847296*std::sin(0.279679954051971*x_44 + 1.9159197807312) - 0.00362417202607189*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 1.31625930959791e-5*std::sin(0.47079986333847*x_44 - 7.70144033432007) - 0.00562134779086682*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.000859202443273111*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00574434157876528*std::sin(0.22511999309063*x_48 - 7.4060001373291) + 0.00219586032598557*std::sin(0.27551993727684*x_5 + 1.99671983718872) + 0.00360188989681993*std::sin(0.19896000623703*x_50 - 7.59376001358032) - 0.00106347386558851*std::sin(0.189920008182526*x_51 - 7.59376001358032) - 0.00368864135500913*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.000515794895192359*std::sin(0.248239979147911*x_53 + 4.99720001220703) + 0.00354875680165423*std::sin(0.252879977226257*x_53 - 7.42528009414673) - 0.00353528556724933*std::sin(0.206960007548332*x_54 + 4.99703979492188) + 0.000624684285721237*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.0128183594761698*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.00317578290286114*std::sin(0.294719934463501*x_56 - 4.30647993087769) + 0.00405868113066819*std::sin(0.236479982733727*x_57 + 7.99480009078979) - 0.00289785127095304*std::sin(0.324399828910828*x_57 + 8.07800006866455) + 0.00420759625379823*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.00253223519312539*std::sin(0.354799836874008*x_59 + 5.07823991775513) + 0.0055947624367617*std::sin(0.376559853553772*x_59 + 1.83519995212555) - 0.00215822170059736*std::sin(0.465519845485687*x_6 + 8.16063976287842) - 0.0014769185045417*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.000295571710253661*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 0.00402515910749094*std::sin(0.521919846534729*x_60 + 8.08527946472168) + 0.00187026809452638*std::sin(0.551119863986969*x_60 - 1.34527981281281) + 0.000312805896589241*std::sin(0.271759957075119*x_7 + 5.01319980621338) - 0.00234612173402695*std::sin(0.350959837436676*x_7 + 2.00847983360291) + 0.000433266896338897*std::sin(0.350399851799011*x_8 - 1.15535986423492) + 0.00143126174234951*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.000836636255308526*std::sin(0.309599906206131*x_9 - 7.42199993133545) - 0.00355349707203279*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.000433406545389002*std::sin(0.291999936103821*x_92 - 7.57456016540527) - 0.00361072432886855*std::sin(0.242639973759651*x_93 - 1.19775986671448) - 0.00408958753847464*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 0.000136336344772464*std::sin(0.281999945640564*x_95 + 7.99368000030518) - 0.00370974805736852*std::sin(0.309519916772842*x_95 + 1.76439988613129) - 0.0040670651320832*std::sin(0.281679958105087*x_97 - 4.41967964172363) + 0.00227319452365837*std::sin(0.324719846248627*x_97 - 1.58567976951599) + 0.000461217736483572*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.0590784757962593);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.82932214394884e-5*x_1 - 0.000158464242242359*x_10 - 1.07895383206945e-5*x_100 - 0.000538685967806988*x_101 - 8.33685571922216e-6*x_102 - 7.34657145721479e-5*x_103 + 0.000366006667167838*x_104 + 0.000231858581731039*x_105 - 0.000186727177338596*x_106 - 0.000562357889838019*x_107 - 2.47658721329162e-5*x_108 - 0.000681008141837492*x_109 + 5.82167718794452e-5*x_11 + 0.000385585725728986*x_110 + 0.000745841500554961*x_111 - 0.000120071892205925*x_112 + 0.00011818339428499*x_113 - 0.000314008943644678*x_114 + 0.000295235077761697*x_115 - 3.27991846815174e-5*x_116 - 4.28092381733272e-6*x_117 - 0.000286123558450726*x_118 + 2.39268446429883e-6*x_119 + 0.000277077404214283*x_12 + 0.000301964680922096*x_120 - 9.20075950970323e-7*x_13 - 3.65414092197196e-5*x_14 - 0.000295040266918376*x_15 + 3.34178030432053e-5*x_16 + 7.49544154231701e-5*x_17 + 3.63684946657794e-5*x_18 + 1.30722351738298e-5*x_19 - 9.11407333758544e-6*x_2 + 2.46657825753854e-5*x_20 + 0.0003835990139751*x_21 - 0.00014265087540745*x_22 - 0.000183700981872674*x_23 - 0.000227733200936033*x_24 + 7.88751229722215e-5*x_25 + 0.000557945143605798*x_26 - 2.33464788165574e-5*x_27 - 6.06957947937934e-6*x_28 + 0.00026262893064049*x_29 + 0.0001829757024125*x_3 + 4.14825808496205e-5*x_30 - 2.68070250169423e-5*x_31 - 8.49369210371141e-5*x_32 + 0.00021275237316605*x_33 + 0.000452347418599857*x_34 - 5.10568317047469e-5*x_35 - 0.000430941325929786*x_36 + 0.000116424918637814*x_37 - 7.16586377883185e-5*x_38 + 0.000156904648485995*x_39 - 2.70366314556766e-6*x_4 + 0.000268123205640294*x_40 + 4.3665115024233e-5*x_41 + 0.00054955355521577*x_42 + 0.0010299355347485*x_43 + 9.62537821555158e-5*x_44 - 5.04029216256087e-5*x_45 + 0.000848261519204044*x_46 + 0.000162559343817722*x_47 + 5.09121560069138e-5*x_48 - 3.89539777995025e-5*x_49 + 3.68029646334201e-6*x_5 - 0.000170433627093811*x_50 + 4.4084893155777e-5*x_51 - 0.00170518170004477*x_52 - 0.000292306001862325*x_53 - 0.00121702028119099*x_54 - 0.000671849747598928*x_55 - 6.88643370750896e-5*x_56 - 8.9998328820459e-5*x_57 + 0.000827939356979863*x_58 - 2.08678426828801e-5*x_59 + 4.45994498868924e-6*x_6 - 7.30032521769703e-5*x_60 + 3.11738099729522e-5*x_61 + 7.51716492772013e-6*x_62 - 2.99858398479965e-5*x_63 + 1.16347757716939e-5*x_64 - 2.02276007905908e-5*x_65 + 1.39683310673149e-5*x_66 + 6.8440971783617e-6*x_67 - 2.71080515692438e-5*x_68 + 7.54632894914958e-6*x_69 - 6.30002595918278e-6*x_7 + 7.83612764937635e-6*x_70 + 8.18954083897915e-6*x_71 - 5.26485083283059e-5*x_72 - 0.000104683889281652*x_73 - 3.05909675388432e-5*x_74 + 4.65669883842196e-5*x_75 + 1.39202145466216e-5*x_76 - 1.49323992065013e-5*x_77 - 7.86486278235592e-5*x_78 + 2.32055102625938e-5*x_79 - 2.36107990059933e-6*x_8 + 7.35727044747873e-6*x_80 + 7.9885374270736e-7*x_81 - 7.45853820592702e-5*x_82 + 4.7308794420637e-5*x_83 - 1.88492643154766e-5*x_84 + 1.0950617115822e-5*x_85 - 3.95145994256583e-5*x_86 - 3.77282374105904e-5*x_87 - 2.79969242502598e-5*x_88 + 0.000197006030100939*x_89 + 1.06590984197726e-5*x_9 + 1.71569987890383e-5*x_90 + 4.51671385569387e-5*x_91 - 1.12139479536893e-5*x_92 + 1.61120360552942e-6*x_93 - 0.000254974811846861*x_94 + 0.000226496023879671*x_95 - 2.1237469383179e-6*x_96 + 1.6033780517964e-5*x_97 + 0.000128881120917364*x_98 - 0.000416712608306719*x_99 + 6.84524181758189e-8*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) - 1.13279194252828e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 2.74905435739309e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) + 2.96033221257642e-7*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) + 3.63101725712923e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) + 4.58465915735386e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) + 2.21637187774172e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) + 2.40397191396036e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) - 0.000106137891920037*std::exp(0.451999843120575*x_30) - 0.000297983521554358*std::exp(0.423199862241745*x_5) + 6.4790227055687e-5*std::exp(0.243439853191376*x_59) - 6.16908479881578e-5*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 0.000702342227269698*std::sin(0.435199856758118*x_10 - 4.42439985275269) + 0.000203020722641025*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.00147373826180939*std::sin(0.262959957122803*x_100 + 7.99488019943237) + 8.09332820114821e-5*std::sin(0.272479951381683*x_102 - 4.62847995758057) - 0.000150067999270802*std::sin(0.27567994594574*x_106 + 4.76656007766724) + 0.000171032218913917*std::sin(0.253759980201721*x_108 - 1.41743981838226) - 0.000211033378745939*std::sin(0.265439957380295*x_108 + 1.95447981357574) - 0.000239561614131779*std::sin(0.258399993181229*x_109 - 1.24367988109589) + 0.000204828033639028*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.00311746320523351*std::sin(0.281919956207275*x_109 + 1.55823993682861) + 0.000141235460959022*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 4.4863661475941e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) + 6.9986484237403e-5*std::sin(0.227439999580383*x_111 - 4.42759990692139) - 0.000245402768364185*std::sin(0.281759947538376*x_113 - 1.19703996181488) + 0.00427189357376152*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.00749254557864953*std::sin(0.249599978327751*x_119 - 1.20399987697601) + 0.00086451054524565*std::sin(0.453279852867126*x_12 - 4.64311981201172) + 0.000385720398029979*std::sin(0.26639997959137*x_120 - 7.42495965957642) - 0.00407589176396675*std::sin(0.286079943180084*x_120 - 1.40863978862762) + 0.00221391126572733*std::sin(0.320559918880463*x_13 - 7.45679998397827) - 0.00015510665558718*std::sin(0.395359843969345*x_13 - 1.17983984947205) + 0.00115633475709491*std::sin(0.504719853401184*x_13 - 7.56504011154175) + 8.97532717843781e-5*std::sin(0.325839847326279*x_14 - 4.31423997879028) + 0.00126110371522226*std::sin(0.429519861936569*x_14 + 1.77279984951019) - 0.000224469968202011*std::sin(0.453119844198227*x_14 + 1.75431990623474) - 0.000388044497577228*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 0.00375419346635569*std::sin(0.453919857740402*x_16 + 4.96103954315186) - 0.00141089381597557*std::sin(0.566639840602875*x_18 - 1.36271989345551) + 0.00024262101673548*std::sin(0.199760004878044*x_19 + 5.00815963745117) - 0.000250027118229193*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 0.00191738126554311*std::sin(0.261199951171875*x_2 + 1.8419998884201) + 0.000173620097664746*std::sin(0.380239844322205*x_2 - 1.18343985080719) + 0.000129158037670828*std::sin(0.303359925746918*x_20 + 1.98871982097626) + 0.000229210143132954*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.00017799288210932*std::sin(0.399439841508865*x_24 + 1.99847972393036) + 0.000280095652363565*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.00169512036574704*std::sin(0.350159853696823*x_25 + 8.2388801574707) + 0.000132820315468075*std::sin(0.417679876089096*x_25 + 8.1997594833374) - 0.000170334865115387*std::sin(0.452719867229462*x_26 - 1.2228798866272) + 0.000138315799089403*std::sin(0.345679849386215*x_27 + 5.02919960021973) + 0.000371157798445217*std::sin(0.632799863815308*x_28 - 4.41735982894897) - 0.000333052759293205*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.00255814538628387*std::sin(0.240079984068871*x_29 + 8.21415996551514) - 0.000104926104388894*std::sin(0.408879846334457*x_3 + 1.80935990810394) + 0.000121272119247505*std::sin(0.307679921388626*x_30 + 2.00319981575012) - 0.000406607910515961*std::sin(0.545839846134186*x_31 - 4.60487985610962) + 0.000261746032280842*std::sin(0.257999986410141*x_33 + 4.97671937942505) + 0.00431993367778139*std::sin(0.238559976220131*x_36 + 1.95983982086182) - 0.00425768080622638*std::sin(0.221199989318848*x_37 + 1.96463978290558) - 0.000319796994622724*std::sin(0.280399948358536*x_4 + 5.04743957519531) + 0.000102024916093191*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.00152738171326215*std::sin(0.415839850902557*x_4 - 1.18935990333557) + 0.00720888774688611*std::sin(0.213279992341995*x_41 + 1.78087985515594) - 0.000311709396785224*std::sin(0.334879845380783*x_44 + 1.85615992546082) - 5.36256169838383e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.0054799294860905*std::sin(0.206240013241768*x_45 - 4.39103984832764) - 0.000350046991489974*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00351127583376074*std::sin(0.19896000623703*x_50 - 7.59376001358032) + 0.000433269050957691*std::sin(0.189920008182526*x_51 - 7.59376001358032) - 0.00471508144245392*std::sin(0.19344000518322*x_51 + 4.99503993988037) + 0.000210139592480861*std::sin(0.248239979147911*x_53 + 4.99720001220703) - 0.00345947942732618*std::sin(0.252879977226257*x_53 - 7.42528009414673) + 0.00344634709369805*std::sin(0.206960007548332*x_54 + 4.99703979492188) - 0.000254502133414296*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.00309588856947904*std::sin(0.294719934463501*x_56 - 4.30647993087769) + 0.000349080848779516*std::sin(0.236479982733727*x_57 + 7.99480009078979) - 0.00370423780346853*std::sin(0.324399828910828*x_57 + 8.07800006866455) + 0.000361888806809415*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.00323688155554084*std::sin(0.354799836874008*x_59 + 5.07823991775513) - 0.0027587911400952*std::sin(0.465519845485687*x_6 + 8.16063976287842) + 0.00143976312491115*std::sin(0.460559874773026*x_60 - 4.47903966903687) + 0.000120418637951839*std::sin(0.480959862470627*x_60 - 1.33383989334106) + 0.000160858848690839*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 0.000127440004248897*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.00228709949047105*std::sin(0.350959837436676*x_7 + 2.00847983360291) - 0.000176516925391727*std::sin(0.350399851799011*x_8 - 1.15535986423492) + 0.00182953966817133*std::sin(0.454559862613678*x_8 - 7.64487981796265) + 0.000340853318603863*std::sin(0.309599906206131*x_9 - 7.42199993133545) + 0.00346410044498705*std::sin(0.211359992623329*x_92 + 2.00551986694336) + 0.00017657381970137*std::sin(0.291999936103821*x_92 - 7.57456016540527) + 0.00351988801476736*std::sin(0.242639973759651*x_93 - 1.19775986671448) - 0.000351739060824872*std::sin(0.253359973430634*x_93 + 4.98847961425781) + 5.55446829696349e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) - 0.000319069658081556*std::sin(0.309519916772842*x_95 + 1.76439988613129) + 0.00396474848529459*std::sin(0.281679958105087*x_97 - 4.41967964172363) - 0.000187904355186489*std::sin(0.210240006446838*x_98 + 1.97111988067627) - 0.0474231764674187*std::sin(0.00045505518132022*x_1 + 0.00180368665410264*x_10 + 0.000239120263222765*x_100 + 0.00211453117096208*x_101 - 0.0203345414243384*x_103 + 0.0103544308958252*x_104 - 0.00276850317031278*x_105 + 0.0357215933351526*x_106 - 0.0218635413420432*x_107 - 0.0276490688840169*x_108 - 0.0254157923131299*x_111 + 0.000874016862870558*x_112 - 3.17304427144418e-5*x_113 - 0.000455514341746996*x_114 - 0.0529610719634748*x_115 + 0.00188242141426009*x_116 - 0.0131907897776094*x_117 + 0.00111601729067944*x_119 - 0.0301473924393873*x_12 + 0.00090052550383532*x_120 + 0.00579118760019*x_13 - 0.0104784794441599*x_16 + 0.00166932917566278*x_17 + 0.00473804184375488*x_18 + 0.00273915248180718*x_19 + 0.000827022848846446*x_2 + 0.00205202695268907*x_20 + 0.00192880095462284*x_22 + 0.0179326243544221*x_23 + 0.00202248599170959*x_24 + 0.00202018392481529*x_25 + 0.014814546741269*x_27 - 0.00990299498286734*x_28 + 0.0018798666628101*x_29 + 0.00446225481219586*x_30 - 0.000360488738077783*x_31 - 0.00201535421264864*x_33 + 0.00354766914483669*x_34 + 0.00120016733760356*x_36 - 0.00403150947539109*x_37 - 0.00727637004706131*x_38 + 0.0234582731647691*x_39 + 0.00343580231396831*x_4 + 0.00116446137951638*x_40 - 0.00233923563204629*x_41 + 0.00130934261768082*x_42 - 0.0178720576797375*x_43 - 0.0245415719569428*x_45 - 0.0424073495510584*x_46 - 0.00904598959735398*x_47 - 0.000460244450198393*x_50 - 0.0336050276108305*x_51 + 0.00112758275942069*x_52 + 0.00099932721464669*x_53 - 0.0100348826171342*x_54 - 0.0409859042779578*x_55 - 0.0132356858666853*x_57 + 0.00723481604925359*x_58 - 0.000259096205153981*x_6 + 0.000892256335203146*x_61 + 0.000841575462847999*x_62 + 0.0018503091612634*x_63 + 0.000111609613309309*x_64 - 8.69417187555498e-5*x_65 - 0.000361238675732332*x_66 + 0.000239122759061763*x_67 - 0.000371693107318563*x_68 - 0.000559298922024732*x_69 + 0.00187386680867934*x_7 + 0.000961718068640245*x_70 - 0.000197342398003002*x_71 - 0.000193956962324405*x_72 - 0.000129017939365327*x_73 - 0.000665348709549737*x_74 - 0.000188433790518533*x_75 + 0.00172779242266242*x_76 + 0.000188505164308061*x_77 - 0.000909219139175598*x_78 - 6.24007132804519e-6*x_79 + 0.00223359701313776*x_8 + 0.000200945238907557*x_80 - 0.000530802163951017*x_81 - 0.000294201280650959*x_82 - 0.00482531591270336*x_83 - 0.000592042693584874*x_84 - 0.008933781389564*x_85 + 0.000256332498827797*x_86 + 0.000154951686876923*x_87 + 0.000167579247655939*x_88 + 0.000785738543299968*x_89 + 0.00268729138639521*x_9 + 0.000890960806721141*x_90 - 0.000468428181391556*x_91 - 0.000114929501432323*x_92 - 0.0258202374209525*x_93 - 0.0119176797320953*x_94 + 0.000788957719103116*x_95 + 0.00037318459360995*x_96 + 0.00088037478591686*x_98 - 0.000227466456350942*x_99 - 0.000402091306605526*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 0.0744783312669493*std::exp(0.203039854764938*x_49) + 0.370533250178397*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.273117576524989*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.0675022743752756*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.413326169076754*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.22728618376825*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0790858869883326*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.230935997660424*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.174173255097095*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.138827397358394*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.0168784350604723*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.156985066385072*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.36376039926084*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.301692398294868*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 0.115326423225955*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.673219299295681*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.293836512730408*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.21140106102785*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.119388009614266*std::sin(0.324719846248627*x_97 - 1.58567976951599) + 2.46518318121158) + 0.0453778452737296);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.03141324605402e-5*x_1 - 5.51331799881238e-5*x_10 - 3.06272461952603e-5*x_100 + 0.000112726361661423*x_101 + 0.000201752169470657*x_102 - 0.00012145101725884*x_103 - 8.75605104318592e-5*x_104 + 5.21815752358248e-5*x_105 - 0.00024269532285995*x_106 + 0.000123920173081253*x_107 - 6.70629213849926e-6*x_108 + 0.000211506919927994*x_109 - 8.80830250424719e-6*x_11 - 0.000129822189518655*x_110 + 0.000354111879192081*x_111 + 0.000171919039797312*x_112 - 3.15225147053512e-5*x_113 - 0.000341878770862998*x_114 + 0.000259879545910303*x_115 + 2.38731870002108e-5*x_116 + 2.51004156773239e-5*x_117 + 3.0410705379342e-5*x_118 - 2.07536138434725e-5*x_119 - 0.000206891828943344*x_12 - 6.70245559709598e-5*x_120 + 5.33687879678753e-6*x_13 - 1.9631751463e-5*x_14 + 6.24887531729116e-5*x_15 - 0.000100944009273594*x_16 - 2.67868513604005e-6*x_17 - 2.19375005054823e-5*x_18 - 2.16405773845439e-5*x_19 + 6.25092037530973e-7*x_2 - 1.42033944410051e-5*x_20 + 0.000338551518688147*x_21 - 6.98107611640342e-5*x_22 - 7.66976297270612e-5*x_23 - 0.000201983527221372*x_24 + 4.23753994131291e-5*x_25 + 0.000351533487801079*x_26 + 4.16192554668781e-5*x_27 + 2.7134034354228e-5*x_28 + 0.000117768535223748*x_29 - 6.28864075155716e-5*x_3 - 1.28836240966131e-5*x_30 - 1.54427319815194e-5*x_31 - 5.28396859793504e-5*x_32 - 6.32552012189799e-5*x_33 - 0.000107426140967802*x_34 + 8.39385005124216e-5*x_35 - 0.000477269960569589*x_36 - 5.5605712393325e-6*x_37 + 0.000107443107192767*x_38 - 0.000264625551472214*x_39 - 1.45253409889878e-6*x_4 - 0.000352894577494848*x_40 + 0.000142945492713771*x_41 + 0.000304422300511158*x_42 + 0.000346196949657272*x_43 - 6.12806698110933e-5*x_44 + 0.000253726232228773*x_45 + 0.000675183088395729*x_46 - 6.99288957134456e-5*x_47 - 0.000330822104012578*x_48 - 5.04548371117995e-5*x_49 + 6.82802969472158e-6*x_5 + 0.000326714020206455*x_50 - 3.62221824488682e-5*x_51 - 0.000533082167657236*x_52 - 0.000145529379140301*x_53 - 0.000169431812220369*x_54 - 9.06179648651942e-5*x_55 + 5.49798284568061e-5*x_56 + 2.13786084224049e-5*x_57 + 0.000558787705758345*x_58 + 6.48111653920744e-6*x_59 + 6.74123121442932e-6*x_6 - 3.92207562141741e-5*x_60 - 4.33888572941982e-6*x_61 + 4.57794067712354e-6*x_62 - 4.06556314488968e-5*x_63 - 7.34330633679254e-6*x_64 + 1.21453213315947e-5*x_65 - 4.61580447473213e-6*x_66 + 8.2266448042298e-6*x_67 - 1.8959913121215e-5*x_68 + 1.00589387295174e-5*x_69 + 0.000110414178632821*x_7 - 6.58037250748547e-6*x_70 - 9.03068759534112e-6*x_71 - 4.39923046694461e-5*x_72 - 1.86211435544101e-5*x_73 - 2.59023534321872e-5*x_74 - 5.71015478450479e-7*x_75 + 1.05459234724048e-5*x_76 - 1.18295381728033e-5*x_77 - 7.57231104478133e-6*x_78 - 2.50785304149215e-6*x_79 + 2.19098070704219e-5*x_8 - 5.37231430136112e-6*x_80 + 5.4494296426983e-6*x_81 - 3.16765538264155e-5*x_82 + 3.70917597614299e-5*x_83 + 8.07856187589534e-6*x_84 + 1.90584118688848e-5*x_85 + 2.55463031529078e-5*x_86 - 2.07135125726305e-5*x_87 - 2.61177403528451e-5*x_88 + 0.000105726339910232*x_89 + 2.27287862008378e-5*x_9 - 4.79501130698131e-5*x_90 + 1.40266394911827e-5*x_91 - 1.83649697282899e-5*x_92 + 3.873547737467e-6*x_93 + 0.000130468846804108*x_94 - 8.00486094773254e-5*x_95 - 1.98436440713471e-6*x_96 - 0.000105155236852162*x_97 + 0.000581723776925603*x_98 - 1.87951907912635e-5*x_99 - 1.8126745657807e-7*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 2.99972330746338e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) + 8.53798925631044e-8*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 1.71713369967822e-6*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 1.12771820053226e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 1.21405426846479e-6*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) - 6.88358861630231e-7*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) - 7.46623518689874e-7*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) - 5.7022232023183e-5*std::exp(0.451999843120575*x_30) - 0.000160090663172009*std::exp(0.423199862241745*x_5) - 0.000171569682744222*std::exp(0.243439853191376*x_59) + 0.00035783630496659*std::sin(0.397759824991226*x_1 - 1.00775980949402) + 0.000218132841737198*std::sin(0.435199856758118*x_10 - 4.42439985275269) - 0.000537615047159584*std::sin(0.259839981794357*x_100 + 1.77871990203857) + 0.000457712355236015*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 0.000214317778300482*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.000397392017206887*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.000452906940932311*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.00122409412316001*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.000634378238850074*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 0.00118810016560368*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.00167484681480659*std::sin(0.281919956207275*x_109 + 1.55823993682861) - 0.000819232951531661*std::sin(0.475119858980179*x_11 + 4.90399980545044) + 0.000118802549643106*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 0.000185329785720218*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.000649846080591894*std::sin(0.281759947538376*x_113 - 1.19703996181488) - 0.00132676101288389*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.00402534537572977*std::sin(0.249599978327751*x_119 - 1.20399987697601) + 0.000464455436279298*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.00102141834232343*std::sin(0.26639997959137*x_120 - 7.42495965957642) - 0.00218975939376478*std::sin(0.286079943180084*x_120 - 1.40863978862762) + 0.00118941651835474*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.000410734780536226*std::sin(0.395359843969345*x_13 - 1.17983984947205) - 0.000359133449152202*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 0.000237673813861871*std::sin(0.325839847326279*x_14 - 4.31423997879028) - 0.00039167250158965*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 0.00130203274256815*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.00225084293220134*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 0.00201692804544989*std::sin(0.453919857740402*x_16 + 4.96103954315186) - 0.000757998044612047*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.000642479780671384*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 0.001450276386957*std::sin(0.348159849643707*x_19 + 2.01871991157532) - 0.000595498615785178*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.00045975985002736*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.000342020773102155*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.0013295280151653*std::sin(0.527199864387512*x_22 - 4.35599946975708) - 0.00047133933159361*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.000741715601224069*std::sin(0.203359991312027*x_25 + 8.21024036407471) - 0.000526469017681621*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 0.000770421099102357*std::sin(0.417679876089096*x_25 + 8.1997594833374) + 0.00045106029251925*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.000366271254889814*std::sin(0.345679849386215*x_27 + 5.02919960021973) + 0.000199403301849087*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.000881950239191318*std::sin(0.162320017814636*x_29 - 1.2279999256134) - 0.000794506582433818*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.000277852683339369*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 0.000703436060002371*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 0.00012628393331619*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 0.00151825167079924*std::sin(0.257999986410141*x_33 + 4.97671937942505) - 0.00134168126685743*std::sin(0.238559976220131*x_36 + 1.95983982086182) + 0.00132234682383044*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 0.00185497490514611*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 0.000270170105609751*std::sin(0.408399850130081*x_4 + 4.98151969909668) - 0.0004743728920109*std::sin(0.415839850902557*x_4 - 1.18935990333557) + 0.00387295114210213*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 0.00180806298513518*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 1.42004905847489e-5*std::sin(0.47079986333847*x_44 - 7.70144033432007) - 0.00170195176213059*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.000926952319890545*std::sin(0.199760004878044*x_47 - 1.17887985706329) + 0.00109052901278463*std::sin(0.19896000623703*x_50 - 7.59376001358032) - 0.00114733096323015*std::sin(0.189920008182526*x_51 - 7.59376001358032) - 0.00253316193826773*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.000556466381618843*std::sin(0.248239979147911*x_53 + 4.99720001220703) + 0.00107444212965464*std::sin(0.252879977226257*x_53 - 7.42528009414673) - 0.00107036350082994*std::sin(0.206960007548332*x_54 + 4.99703979492188) + 0.000673941924143723*std::sin(0.220319986343384*x_55 + 8.19007968902588) - 0.000961518395366042*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 0.00202483520871429*std::sin(0.236479982733727*x_57 + 7.99480009078979) - 0.00199008953049078*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 0.0020991274664*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.00173900392925334*std::sin(0.354799836874008*x_59 + 5.07823991775513) - 0.0014821514319554*std::sin(0.465519845485687*x_6 + 8.16063976287842) - 0.000447160386591277*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.000318878146423704*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 0.000933057948040511*std::sin(0.551119863986969*x_60 - 1.34527981281281) + 0.000337471283734084*std::sin(0.271759957075119*x_7 + 5.01319980621338) - 0.000710325382444326*std::sin(0.350959837436676*x_7 + 2.00847983360291) + 0.00046743088062362*std::sin(0.350399851799011*x_8 - 1.15535986423492) + 0.000982914146558321*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.000902606741675971*std::sin(0.309599906206131*x_9 - 7.42199993133545) - 0.00107587732132466*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.000467581541288029*std::sin(0.291999936103821*x_92 - 7.57456016540527) - 0.00109320377651602*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 0.00204025410482527*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 0.000147086745459895*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.00185075600673822*std::sin(0.309519916772842*x_95 + 1.76439988613129) - 0.00123136815684936*std::sin(0.281679958105087*x_97 - 4.41967964172363) + 0.000497585701897517*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.116263881325722*std::sin(0.000370489619671357*x_1 + 0.00146849703050529*x_10 + 0.000194683148360364*x_100 + 0.00172157549561376*x_101 - 0.0165556548474791*x_103 + 0.00843020653754097*x_104 - 0.00225401605944213*x_105 + 0.0290832410486994*x_106 - 0.0178005117818502*x_107 - 0.0225108809559914*x_108 - 0.020692627211537*x_111 + 0.000711593205403806*x_112 - 2.58337892542417e-5*x_113 - 0.000370863451634748*x_114 - 0.0431190066932291*x_115 + 0.00153260005040942*x_116 - 0.010739468285347*x_117 + 0.000908621280546466*x_119 - 0.0245449264560553*x_12 + 0.000733175590820329*x_120 + 0.00471497739068713*x_13 - 0.00853120241975456*x_16 + 0.00135910798686718*x_17 + 0.00385754386003673*x_18 + 0.00223011978077548*x_19 + 0.00067333236342831*x_2 + 0.0016706868012171*x_20 + 0.00157036060995228*x_22 + 0.0146001000527097*x_23 + 0.00164663560952149*x_24 + 0.00164476134916112*x_25 + 0.0120614730104874*x_27 - 0.00806266359645743*x_28 + 0.00153052006333991*x_29 + 0.00363300794301639*x_30 - 0.000293497010799359*x_31 - 0.00164082917060961*x_33 + 0.00288838507096447*x_34 + 0.000977133232854739*x_36 - 0.00328231052749634*x_37 - 0.00592415971070278*x_38 + 0.0190988852774896*x_39 + 0.00279730710652503*x_4 + 0.000948062721464579*x_40 - 0.00190452181452836*x_41 + 0.00106601983310395*x_42 - 0.014550788836862*x_43 - 0.019980868329168*x_45 - 0.0345265441453919*x_46 - 0.00736492052623466*x_47 - 0.000374714536411056*x_50 - 0.0273600090926573*x_51 + 0.000918037470694737*x_52 + 0.000813616402756993*x_53 - 0.00817004178148794*x_54 - 0.0333692543479506*x_55 - 0.0107760210720183*x_57 + 0.0058903279349631*x_58 - 0.000210946844352577*x_6 + 0.000726443130083053*x_61 + 0.000685180580189664*x_62 + 0.00150645540490727*x_63 + 9.0868547121399e-5*x_64 - 7.07848314612442e-5*x_65 - 0.000294107583160288*x_66 + 0.000194685180383027*x_67 - 0.00030261920667598*x_68 - 0.000455361137307273*x_69 + 0.00152563519713854*x_7 + 0.00078299638397231*x_70 - 0.000160669107797096*x_71 - 0.000157912807399975*x_72 - 0.000105041782290148*x_73 - 0.000541703073536582*x_74 - 0.000153416038863464*x_75 + 0.00140670666727954*x_76 + 0.000153474148844895*x_77 - 0.000740253637138661*x_78 - 5.08044243412919e-6*x_79 + 0.00181851463705049*x_8 + 0.000163602411737495*x_80 - 0.000432160098193804*x_81 - 0.000239528138673138*x_82 - 0.00392859927911379*x_83 - 0.000482019942590464*x_84 - 0.00727356462494044*x_85 + 0.000208696733711708*x_86 + 0.00012615611006101*x_87 + 0.000136437017481559*x_88 + 0.000639720161462088*x_89 + 0.00218789633556786*x_9 + 0.000725388357224125*x_90 - 0.000381377437047526*x_91 - 9.35714810479576e-5*x_92 - 0.0210219119232073*x_93 - 0.00970294771394318*x_94 + 0.000642341099027293*x_95 + 0.000303833521360273*x_96 + 0.000716769598483191*x_98 - 0.000185195036472178*x_99 - 0.000327368331078534*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 0.0606375880498589*std::exp(0.203039854764938*x_49) + 0.301674892561181*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.222362542403623*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.0549579325471932*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.336515353450523*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.185048264996233*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0643888947856208*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.188019812659661*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.141805622014083*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.113028291421831*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.0137418169112147*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.127811614781198*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.296160680079836*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.245627138180744*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 0.0938946405468464*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.548111025629566*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.239231157705333*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.172115167376184*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.0972014386188995*std::sin(0.324719846248627*x_97 - 1.58567976951599) + 1.6499267856766) - 0.0657762723108963);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.12149443816553e-5*x_1 + 8.74873616876329e-5*x_10 - 5.91863304696932e-7*x_100 + 0.000463490521227752*x_101 + 4.84473098734713e-5*x_102 + 9.83051227589231e-5*x_103 - 0.000347060826535724*x_104 - 0.000178213080049453*x_105 + 3.22780815952403e-5*x_106 + 0.000443496338321385*x_107 + 5.44983956418522e-6*x_108 + 0.00062693816503633*x_109 - 5.49669295621442e-5*x_11 - 0.00035569390871804*x_110 - 0.000425634136190602*x_111 + 0.000178150574480191*x_112 - 0.000104716953526049*x_113 + 0.000246940301323242*x_114 - 4.36009425788801e-5*x_115 - 8.21565842156584e-6*x_116 - 1.59856672385254e-5*x_117 + 0.000235619540529922*x_118 + 4.07482186920942e-6*x_119 - 0.000328014945105741*x_12 - 0.000272459082762105*x_120 + 3.90992234715669e-6*x_13 + 1.76763077306051e-5*x_14 + 0.000246665298616981*x_15 - 5.58028015240119e-5*x_16 - 6.43256051064352e-5*x_17 - 3.38500540751639e-5*x_18 - 2.01095004517764e-5*x_19 + 6.01714509861043e-6*x_2 - 2.40846962689181e-5*x_20 - 7.55426354338927e-5*x_21 + 6.8658376638277e-5*x_22 + 8.19703463212619e-5*x_23 + 6.33147612984412e-5*x_24 - 3.74289640628944e-5*x_25 - 0.000239696391980874*x_26 + 2.24347326021965e-5*x_27 - 2.83821587329032e-7*x_28 - 0.000131907408945032*x_29 - 0.000170614922147632*x_3 - 3.65862945089382e-5*x_30 + 1.18112008612373e-5*x_31 + 3.90077537065299e-5*x_32 - 0.000197993168560479*x_33 - 0.000397935190393114*x_34 - 4.67789894529539e-5*x_35 + 0.000283540788464424*x_36 + 2.0682029092914e-5*x_37 - 4.66217821441089e-5*x_38 - 0.00024762985756424*x_39 + 2.54188016779664e-6*x_4 - 0.000369280795578854*x_40 - 6.75256365128283e-5*x_41 - 0.000259973942545928*x_42 - 0.00038344957141329*x_43 - 0.000104784297248219*x_44 + 8.01701002586129e-5*x_45 - 0.000422497889649958*x_46 - 0.000169065671476009*x_47 - 0.000100061592357336*x_48 + 6.00839958093744e-6*x_49 - 1.0514400409643e-5*x_5 + 0.000134126559480701*x_50 - 5.70386660257135e-5*x_51 + 0.00102111033317838*x_52 + 0.000144490918415525*x_53 + 0.000699742904968865*x_54 + 0.00055141867303497*x_55 - 2.26182088591173e-6*x_56 + 8.4756887915007e-5*x_57 - 0.000220698122712807*x_58 + 1.92109993935926e-5*x_59 - 9.03949728213872e-6*x_6 + 3.53141265859751e-5*x_60 - 2.58177406328447e-5*x_61 - 3.75843056834578e-6*x_62 + 1.02948971732597e-6*x_63 - 1.30351349951977e-5*x_64 + 2.09086324160868e-5*x_65 - 1.4193573217267e-5*x_66 - 4.88866812817975e-7*x_67 + 6.97218106781353e-6*x_68 - 2.9323314936547e-6*x_69 + 3.07466080704623e-5*x_7 - 5.89983960366413e-6*x_70 - 1.39108267977472e-5*x_71 + 1.64561534736757e-5*x_72 + 6.50832021828954e-5*x_73 + 1.37382435074699e-5*x_74 - 3.42030825343233e-5*x_75 - 5.18801546715082e-6*x_76 + 2.84958241394303e-6*x_77 + 4.71875552446553e-5*x_78 - 9.22948030783527e-6*x_79 + 7.09656798235247e-6*x_8 - 2.19588538250608e-6*x_80 + 1.81940674065877e-6*x_81 + 4.0758334245445e-5*x_82 - 4.64359679095533e-5*x_83 + 1.49848552607495e-5*x_84 - 9.7404079066292e-6*x_85 + 7.72660333975602e-6*x_86 + 1.92492748295485e-5*x_87 + 1.35067098475031e-5*x_88 - 9.7463770868288e-5*x_89 - 3.34052095536443e-6*x_9 - 2.19182112578753e-5*x_90 - 2.64968206506225e-5*x_91 + 2.45258858258197e-6*x_92 - 1.18764977260801e-5*x_93 + 0.000242385348250695*x_94 - 0.000213229687248047*x_95 - 2.66640038828498e-6*x_96 + 6.82430332265612e-5*x_97 + 0.000203478296712838*x_98 + 0.000326715386794594*x_99 - 1.44418001969961e-7*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) + 9.9058795214017e-8*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) - 1.63928474764442e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) + 2.53078779610307e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 5.88773636829147e-7*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 3.34272552198513e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) + 6.63454739360566e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) - 2.04039868645373e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) - 2.21310384993434e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 5.13424654253299e-5*std::exp(0.451999843120575*x_30) - 2.67501724482245e-5*std::exp(0.203039854764938*x_49) + 0.000144144644065937*std::exp(0.423199862241745*x_5) + 9.37591688476852e-5*std::exp(0.243439853191376*x_59) + 0.000122695502804566*std::sin(0.397759824991226*x_1 - 1.00775980949402) + 0.000646578388921916*std::sin(0.435199856758118*x_10 - 4.42439985275269) + 0.000293795145945674*std::sin(0.259839981794357*x_100 + 1.77871990203857) + 0.00135672792267892*std::sin(0.262959957122803*x_100 + 7.99488019943237) + 0.000133083383736764*std::sin(0.233679980039597*x_102 - 1.20599985122681) + 0.000117120090457312*std::sin(0.272479951381683*x_102 - 4.62847995758057) - 0.000217166253641496*std::sin(0.27567994594574*x_106 + 4.76656007766724) + 0.000247503974291701*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.00041971941314131*std::sin(0.265439957380295*x_108 + 1.95447981357574) - 0.000346674164446133*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 0.00040737774557152*std::sin(0.265599936246872*x_109 - 7.6308798789978) - 9.80948706342282e-5*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.00150802172470153*std::sin(0.281919956207275*x_109 + 1.55823993682861) - 2.42446017448203e-5*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.000280899946447945*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 0.000148453195877035*std::sin(0.244719967246056*x_110 - 4.43903970718384) - 6.49230571121902e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) + 0.000101278771365172*std::sin(0.227439999580383*x_111 - 4.42759990692139) - 0.000355127009741316*std::sin(0.281759947538376*x_113 - 1.19703996181488) - 0.00393271820677239*std::sin(0.256719976663589*x_114 - 4.44536018371582) + 8.16337383971111e-5*std::sin(0.244239971041679*x_118 + 1.9443998336792) + 0.00362439610737077*std::sin(0.249599978327751*x_119 - 1.20399987697601) - 0.000418192805379513*std::sin(0.453279852867126*x_12 - 4.64311981201172) + 0.00055818331823109*std::sin(0.26639997959137*x_120 - 7.42495965957642) + 0.00197164582962047*std::sin(0.286079943180084*x_120 - 1.40863978862762) - 0.00107094328480718*std::sin(0.320559918880463*x_13 - 7.45679998397827) - 0.000224457788951701*std::sin(0.395359843969345*x_13 - 1.17983984947205) - 0.00106452529161364*std::sin(0.504719853401184*x_13 - 7.56504011154175) + 0.000129883665273018*std::sin(0.325839847326279*x_14 - 4.31423997879028) - 0.00116097591287038*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 0.000446443135590511*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.0007717727392874*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 2.84050552579646e-5*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.00181602955136495*std::sin(0.453919857740402*x_16 + 4.96103954315186) + 0.000682496756390374*std::sin(0.566639840602875*x_18 - 1.36271989345551) + 0.000351101484094927*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 0.000497273161033486*std::sin(0.348159849643707*x_19 + 2.01871991157532) - 0.00176514702019743*std::sin(0.261199951171875*x_2 + 1.8419998884201) + 0.00025124894281215*std::sin(0.380239844322205*x_2 - 1.18343985080719) + 0.000186907050836642*std::sin(0.303359925746918*x_20 + 1.98871982097626) + 8.29446317718518e-5*std::sin(0.294639945030212*x_21 + 1.81559991836548) - 0.000455870760035635*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.000257576882282418*std::sin(0.399439841508865*x_24 + 1.99847972393036) + 0.000405331741481417*std::sin(0.203359991312027*x_25 + 8.21024036407471) - 0.00156053296036916*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 0.000264163257930007*std::sin(0.417679876089096*x_25 + 8.1997594833374) + 6.25573174164745e-5*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.000246494820357316*std::sin(0.452719867229462*x_26 - 1.2228798866272) + 0.000200159421419832*std::sin(0.345679849386215*x_27 + 5.02919960021973) - 0.000179541501053854*std::sin(0.632799863815308*x_28 - 4.41735982894897) - 0.000481966977317733*std::sin(0.162320017814636*x_29 - 1.2279999256134) - 0.00235503641710598*std::sin(0.240079984068871*x_29 + 8.21415996551514) - 4.98622452557984e-5*std::sin(0.291519939899445*x_3 - 7.52311992645264) - 0.000151840559679974*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 0.000241195317174181*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 0.000374324478148403*std::sin(0.545839846134186*x_31 - 4.60487985610962) + 6.06217997695861e-6*std::sin(0.23463998734951*x_32 + 5.02007961273193) - 0.000520580638540792*std::sin(0.257999986410141*x_33 + 4.97671937942505) + 5.63838840930124e-5*std::sin(0.233519986271858*x_35 + 4.99319982528687) - 0.00397694407253239*std::sin(0.238559976220131*x_36 + 1.95983982086182) + 0.00391963388978533*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 0.000636036856847166*std::sin(0.280399948358536*x_4 + 5.04743957519531) + 0.000147642194962995*std::sin(0.408399850130081*x_4 + 4.98151969909668) - 0.00140611224711484*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.00348718128091737*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 0.000130650797950686*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.000619951620292407*std::sin(0.334879845380783*x_44 + 1.85615992546082) - 7.76026494401313e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) - 0.00504483973902016*std::sin(0.206240013241768*x_45 - 4.39103984832764) - 0.000506559653688571*std::sin(0.199760004878044*x_47 - 1.17887985706329) + 0.000108358008878852*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 4.14214665749396e-5*std::sin(0.27551993727684*x_5 + 1.99671983718872) + 0.00323249120372437*std::sin(0.19896000623703*x_50 - 7.59376001358032) + 0.000626991877498796*std::sin(0.189920008182526*x_51 - 7.59376001358032) + 0.00228084335911993*std::sin(0.19344000518322*x_51 + 4.99503993988037) + 0.000304096997778115*std::sin(0.248239979147911*x_53 + 4.99720001220703) + 0.00318480727454558*std::sin(0.252879977226257*x_53 - 7.42528009414673) - 0.00317271760829687*std::sin(0.206960007548332*x_54 + 4.99703979492188) - 0.000368294873829935*std::sin(0.220319986343384*x_55 + 8.19007968902588) - 0.000241798279382555*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.00285008442581778*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 0.00069427883806475*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 0.00179186431830647*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 0.000719752289988768*std::sin(0.343599855899811*x_59 - 7.51183986663818) - 0.00156578839418112*std::sin(0.354799836874008*x_59 + 5.07823991775513) - 0.000105536432589372*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.00133451999247127*std::sin(0.465519845485687*x_6 + 8.16063976287842) - 0.00132545030839611*std::sin(0.460559874773026*x_60 - 4.47903966903687) + 0.000174260099419481*std::sin(0.480959862470627*x_60 - 1.33383989334106) + 7.59283236081592e-5*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.00031992844910277*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 0.000184420852022207*std::sin(0.271759957075119*x_7 + 5.01319980621338) - 0.00210551074168157*std::sin(0.350959837436676*x_7 + 2.00847983360291) - 0.000255440997267264*std::sin(0.350399851799011*x_8 - 1.15535986423492) - 0.000885009825031421*std::sin(0.454559862613678*x_8 - 7.64487981796265) + 0.000493255314938247*std::sin(0.309599906206131*x_9 - 7.42199993133545) - 0.00318906139744797*std::sin(0.211359992623329*x_92 + 2.00551986694336) + 0.00025552333010397*std::sin(0.291999936103821*x_92 - 7.57456016540527) - 0.00324041960373245*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 0.000699565694609966*std::sin(0.253359973430634*x_93 + 4.98847961425781) + 8.03797662981647e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.00063459027399838*std::sin(0.309519916772842*x_95 + 1.76439988613129) - 0.00364995950488108*std::sin(0.281679958105087*x_97 - 4.41967964172363) - 4.28802551172237e-5*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 0.000271919963330319*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.118997801925372);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00012827606200093*x_1 + 9.59050876319512e-5*x_10 + 7.23511540306449e-6*x_100 - 1.85864993623729e-5*x_101 + 3.95984153251301e-5*x_102 - 0.000873130834636027*x_103 + 0.000178957713864969*x_104 + 0.000233945502619268*x_105 + 0.000145021253762239*x_106 + 0.000500082135055964*x_107 + 0.000171339451423992*x_108 - 0.000176767544178009*x_109 + 6.65982621698291e-5*x_11 + 9.11889144273247e-5*x_110 - 0.000299722240451976*x_111 - 0.00020819378282687*x_112 + 1.65661503506975e-5*x_113 - 0.00138551829835863*x_114 - 0.00108753286635425*x_115 + 0.000468285160413018*x_116 + 0.000343439783160024*x_117 + 6.91892870831097e-6*x_118 - 0.000126787344260649*x_119 + 0.000670219256005494*x_12 + 8.02157181774414e-5*x_120 - 3.20385086068457e-5*x_13 + 3.27970675387412e-5*x_14 + 6.6773265152638e-5*x_15 + 8.82378370252273e-5*x_16 + 1.49349055516162e-5*x_17 - 2.04336040562908e-5*x_18 + 1.17223836529519e-5*x_19 + 3.69111093488287e-6*x_2 - 2.77593177711085e-6*x_20 - 0.000981868760025522*x_21 + 0.000155216971454304*x_22 + 0.000289552361829143*x_23 + 0.00033466956123123*x_24 - 8.23458028588813e-5*x_25 - 0.000589283753447536*x_26 - 2.57035114179179e-5*x_27 + 0.000147314234995678*x_28 - 0.000247484137322576*x_29 + 5.0922639118307e-5*x_3 - 1.47509146388645e-5*x_30 + 3.55826664192722e-5*x_31 + 7.80825641637051e-5*x_32 + 9.27521084237225e-5*x_33 + 6.27459637520969e-5*x_34 + 0.00127328981623782*x_35 - 0.00125266804078076*x_36 - 0.00123820987158597*x_37 + 0.00151382657746859*x_38 + 0.000211767626046856*x_39 - 1.72218118469128e-5*x_4 + 0.000795085138745489*x_40 + 0.000740454304042979*x_41 - 0.000516136875991562*x_42 - 0.00290870318820184*x_43 + 6.78197996425431e-5*x_44 + 0.000223240390174505*x_45 + 7.49806325531408e-5*x_46 + 0.000151619765466744*x_47 - 0.000191618602075221*x_48 + 0.000104674897941418*x_49 + 0.000105882582239617*x_5 + 0.000752884161482067*x_50 + 0.000197739755955931*x_51 + 0.00102995583285205*x_52 + 0.000257140278379556*x_53 + 0.00117577722030094*x_54 - 4.78838819414067e-5*x_55 + 0.000765936446209932*x_56 - 4.34564879299684e-5*x_57 - 0.00263464186772365*x_58 - 5.41661263166806e-6*x_59 + 8.0874706759428e-5*x_6 + 6.55227218468566e-5*x_60 - 4.59380333346254e-6*x_61 - 9.0164701543351e-6*x_62 + 9.57269503829574e-5*x_63 + 3.72064023071912e-6*x_64 - 1.42264823489712e-5*x_65 + 1.68941445946103e-5*x_66 - 1.9514299278235e-5*x_67 + 7.5771282342417e-5*x_68 - 4.75284219162584e-7*x_69 - 1.05740474664637e-7*x_7 - 3.09274835584481e-5*x_70 + 3.64957134300341e-5*x_71 + 0.000113463266475405*x_72 + 6.4639174561674e-5*x_73 + 1.56148223534766e-5*x_74 - 1.44739826912441e-5*x_75 - 2.42648438647063e-5*x_76 + 3.97585558269302e-5*x_77 + 7.51544151139219e-5*x_78 - 9.75609239932395e-5*x_79 - 7.8581978869344e-6*x_8 - 5.91301810097544e-5*x_80 - 1.26582081688564e-5*x_81 + 4.54095871326755e-5*x_82 + 0.00020904232175657*x_83 + 4.08611311426705e-6*x_84 + 8.14287700473365e-5*x_85 + 0.000332284190893614*x_86 + 2.19491496582233e-5*x_87 - 1.63130575349336e-5*x_88 - 0.000153554571212242*x_89 - 8.03509240666412e-6*x_9 - 2.14679267205022e-5*x_90 - 2.69311621918226e-5*x_91 + 1.01847034813282e-5*x_92 + 0.000177287247141132*x_93 + 8.83002563940591e-5*x_94 + 6.75225684489387e-5*x_95 + 4.91506175375434e-5*x_96 - 0.00127550443540066*x_97 - 0.000827402839762715*x_98 - 0.000121360059670275*x_99 + 2.29945267635706e-6*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 2.31399659701137e-6*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 3.82934127089512e-6*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 7.13565018851408e-8*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 3.47406495776329e-7*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) + 9.42493876327059e-8*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 1.54981897956112e-5*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) + 5.75297988004226e-7*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) + 6.23992850301466e-7*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 9.5262106307672e-5*std::exp(0.451999843120575*x_30) + 0.000425921663435537*std::exp(0.203039854764938*x_49) + 0.000267449611017635*std::exp(0.423199862241745*x_5) - 0.00219019822705716*std::exp(0.243439853191376*x_59) + 7.23966088332487e-5*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 0.000182305178249401*std::sin(0.435199856758118*x_10 - 4.42439985275269) - 0.00686300460719261*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.000382534476898192*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 0.0021189805892468*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.00273590537997514*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.00507296672472575*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.00578165071582401*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.000247655875548369*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.00809824947968475*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 0.000240373661783588*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.00156188639740143*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.00279802157264389*std::sin(0.281919956207275*x_109 + 1.55823993682861) + 0.000386027459242469*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.000165745305079883*std::sin(0.475119858980179*x_11 + 4.90399980545044) + 0.00236370185099369*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.00151659156464205*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 0.00236585486207629*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.00829570650715877*std::sin(0.281759947538376*x_113 - 1.19703996181488) + 0.00110884450512757*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.00129978891604741*std::sin(0.244239971041679*x_118 + 1.9443998336792) + 0.00672479602257526*std::sin(0.249599978327751*x_119 - 1.20399987697601) - 0.000775925486887752*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.0130390673145648*std::sin(0.26639997959137*x_120 - 7.42495965957642) + 0.0036582414394483*std::sin(0.286079943180084*x_120 - 1.40863978862762) - 0.00198705520277678*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.00524329574859838*std::sin(0.395359843969345*x_13 - 1.17983984947205) + 0.00030014685978324*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 0.00303406031538933*std::sin(0.325839847326279*x_14 - 4.31423997879028) + 0.000327341470679212*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 0.00026342423572865*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.000455385306202726*std::sin(0.254399985074997*x_15 - 7.59144020080566) + 0.000452271042695789*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.0033695070687948*std::sin(0.453919857740402*x_16 + 4.96103954315186) + 0.00126632170900436*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.00820167091317843*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 0.000293416545021686*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 0.00049768975837569*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.00586913254309145*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.00436611689713161*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.00132066122585539*std::sin(0.294639945030212*x_21 + 1.81559991836548) - 0.000268987015321865*std::sin(0.527199864387512*x_22 - 4.35599946975708) - 0.00601695213214116*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.00946848049607586*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.000439998064238614*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 0.000155869804640987*std::sin(0.417679876089096*x_25 + 8.1997594833374) - 0.000996050277644406*std::sin(0.352479845285416*x_26 - 1.17263984680176) + 0.00575807705166846*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.00467569001848426*std::sin(0.345679849386215*x_27 + 5.02919960021973) - 0.000333125832940487*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.0112586665623738*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.000664011264775175*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.000793916767567979*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.00354696963180958*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 0.000142317547348775*std::sin(0.307679921388626*x_30 + 2.00319981575012) - 0.00010554217691337*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 9.65232573670081e-5*std::sin(0.23463998734951*x_32 + 5.02007961273193) - 0.000307169146326674*std::sin(0.257999986410141*x_33 + 4.97671937942505) - 0.000897755621962218*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.00112131415224036*std::sin(0.238559976220131*x_36 + 1.95983982086182) - 0.00110515533335588*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 0.000375294207824703*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 0.00344889654655639*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.000396458570593974*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.00647020417007447*std::sin(0.213279992341995*x_41 + 1.78087985515594) - 0.00208024846568905*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.00036580309729313*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 0.000181278468343536*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.00142241130173746*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.0118331472968767*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00172529816312666*std::sin(0.22511999309063*x_48 - 7.4060001373291) + 0.000659520979899656*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.000911412900866007*std::sin(0.19896000623703*x_50 - 7.59376001358032) - 0.0146464235482715*std::sin(0.189920008182526*x_51 - 7.59376001358032) + 0.004231934340271*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.00710365411268761*std::sin(0.248239979147911*x_53 + 4.99720001220703) - 0.000897968239928505*std::sin(0.252879977226257*x_53 - 7.42528009414673) + 0.000894559513626779*std::sin(0.206960007548332*x_54 + 4.99703979492188) + 0.00860330557118071*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.003849961175757*std::sin(0.142560034990311*x_56 - 1.40511989593506) + 0.000803591889516895*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 0.000409659949318906*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 0.00332467028541293*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 0.000424690586077558*std::sin(0.343599855899811*x_59 - 7.51183986663818) - 0.00290520330930995*std::sin(0.354799836874008*x_59 + 5.07823991775513) + 0.00168037245399146*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.00247610207923113*std::sin(0.465519845485687*x_6 + 8.16063976287842) + 0.000373715637381221*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.00407068626445886*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 0.00120894614625953*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.000188774113597416*std::sin(0.551119863986969*x_60 - 1.34527981281281) + 0.00430803971596192*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.000593656573812031*std::sin(0.350959837436676*x_7 + 2.00847983360291) + 0.00596705822170145*std::sin(0.350399851799011*x_8 - 1.15535986423492) - 0.00164206956828146*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.0115223602079845*std::sin(0.309599906206131*x_9 - 7.42199993133545) + 0.00089916770568131*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.00596898150275436*std::sin(0.291999936103821*x_92 - 7.57456016540527) + 0.0009136483426956*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 0.000412779464513127*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 0.00187765766059108*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.000374440650112688*std::sin(0.309519916772842*x_95 + 1.76439988613129) + 0.00102911963891945*std::sin(0.281679958105087*x_97 - 4.41967964172363) + 0.000682748106518482*std::sin(0.324719846248627*x_97 - 1.58567976951599) + 0.00635200406431733*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.0528717644717006);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.41921645362597e-5*x_1 - 0.000187141948471469*x_10 - 1.90967907148723e-5*x_100 - 0.00039934329983009*x_101 + 3.15519872386536e-5*x_102 - 9.43516957747819e-5*x_103 + 0.000230579124853725*x_104 + 0.00023281225626529*x_105 - 0.000318416478162067*x_106 - 0.000422711227142346*x_107 - 2.60809930190178e-5*x_108 - 0.000458541584753041*x_109 + 4.25980248401657e-5*x_11 + 0.000259757956060406*x_110 + 0.0008371899938162*x_111 + 4.22167363327916e-6*x_112 + 8.51011531121338e-5*x_113 - 0.000415309267803285*x_114 + 0.000397421391952716*x_115 - 2.80804107591353e-5*x_116 + 3.86525222683038e-6*x_117 - 0.000224689004851468*x_118 - 3.73051743706131e-7*x_119 + 0.000160144085605583*x_12 + 0.000207907388404361*x_120 + 2.46188447515362e-7*x_13 - 4.48423385098818e-5*x_14 - 0.000221989921073053*x_15 + 6.43912695867558e-6*x_16 + 5.41039049238747e-5*x_17 + 2.26639670335502e-5*x_18 - 2.68253889894306e-6*x_19 - 9.88221423684366e-6*x_2 + 1.42228950747539e-5*x_20 + 0.00057107136677595*x_21 - 0.000172565700965922*x_22 - 0.00022172413662995*x_23 - 0.000341313078451059*x_24 + 9.67927904220015e-5*x_25 + 0.000723803473913813*x_26 - 2.64577657569428e-5*x_27 - 8.2873256711265e-7*x_28 + 0.000316787173124759*x_29 + 0.000120679633354073*x_3 + 2.79313670334506e-5*x_30 - 3.32042898748599e-5*x_31 - 0.000106423476924494*x_32 + 0.000143857799572421*x_33 + 0.00032879010287053*x_34 - 3.84985522493207e-5*x_35 - 0.000576185132564677*x_36 + 0.000134357150760755*x_37 - 5.86375359405213e-5*x_38 - 3.41882113257912e-5*x_39 - 3.3178407888224e-6*x_4 + 0.000117548980116142*x_40 + 4.78003976285739e-5*x_41 + 0.00068148358442657*x_42 + 0.00122863974104852*x_43 + 4.43074380877812e-5*x_44 + 4.20825647498891e-6*x_45 + 0.00108603034877053*x_46 + 8.75207203723118e-5*x_47 - 2.38078918575471e-5*x_48 - 5.52312898674058e-5*x_49 + 2.56046056983774e-6*x_5 - 0.000114288135554271*x_50 + 2.58221502681704e-5*x_51 - 0.00184040621904679*x_52 - 0.00035599283638231*x_53 - 0.00137927056356029*x_54 - 0.000494849197432364*x_55 - 6.73954447018474e-5*x_56 - 6.05506958309395e-5*x_57 + 0.00104999690861439*x_58 - 1.40508946462323e-5*x_59 + 3.44571763312871e-6*x_6 - 8.958703608714e-5*x_60 + 2.39378063413731e-5*x_61 + 8.46569707105184e-6*x_62 - 4.74187639061539e-5*x_63 + 3.53584200604324e-6*x_64 - 1.18514174886991e-5*x_65 + 8.71587079820322e-6*x_66 + 1.1198472388824e-5*x_67 - 3.68985471446019e-5*x_68 + 9.96818246926361e-6*x_69 + 1.91080544581307e-5*x_7 + 3.76288037243133e-6*x_70 - 1.29207200754955e-6*x_71 - 6.82823826809955e-5*x_72 - 0.000111947801327953*x_73 - 3.92247034118927e-5*x_74 + 4.26601674427213e-5*x_75 + 1.78961769463096e-5*x_76 - 2.26066216648883e-5*x_77 - 8.56635025833269e-5*x_78 + 2.37129251874217e-5*x_79 + 2.03961527739022e-6*x_8 + 5.46580392367301e-6*x_80 + 2.15824218803794e-6*x_81 - 8.72388538212237e-5*x_82 + 4.35792461190605e-5*x_83 - 1.78185265969313e-5*x_84 + 1.34787239287038e-5*x_85 - 3.51045601641636e-5*x_86 - 4.59644596370619e-5*x_87 - 3.85848828304647e-5*x_88 + 0.000241189367907423*x_89 + 1.23012004681226e-5*x_9 + 6.96369022930019e-6*x_90 + 5.01335494551516e-5*x_91 - 1.66718021533181e-5*x_92 + 2.48420024706303e-6*x_93 - 0.000143403001103556*x_94 + 0.000146167159283564*x_95 - 2.05919006495776e-6*x_96 + 1.06147042422499e-6*x_97 + 0.000495088073766814*x_98 - 0.000371547266266959*x_99 + 4.72511925310532e-8*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) - 7.81941260811994e-8*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 1.85101420110787e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 7.92108076268383e-8*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) + 2.44486417277958e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) + 3.16468896653105e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) + 1.49234438002399e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) + 1.61866066410735e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) - 0.000130248706326167*std::exp(0.451999843120575*x_30) - 0.000365674948756389*std::exp(0.423199862241745*x_5) + 4.47232628783942e-5*std::exp(0.243439853191376*x_59) + 1.65068699775206e-5*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 0.000472906413515507*std::sin(0.435199856758118*x_10 - 4.42439985275269) + 0.000140140721233036*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.000992308662063736*std::sin(0.262959957122803*x_100 + 7.99488019943237) + 5.58664572034868e-5*std::sin(0.272479951381683*x_102 - 4.62847995758057) - 0.000103588625723664*std::sin(0.27567994594574*x_106 + 4.76656007766724) + 0.000118059763559522*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 5.64670556083906e-5*std::sin(0.265439957380295*x_108 + 1.95447981357574) - 0.000165364091642701*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 5.48066662931863e-5*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.00382564173977565*std::sin(0.281919956207275*x_109 + 1.55823993682861) - 3.77909441399362e-5*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 3.09683947264339e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) + 4.83101244543212e-5*std::sin(0.227439999580383*x_111 - 4.42759990692139) - 0.000169396111410506*std::sin(0.281759947538376*x_113 - 1.19703996181488) + 0.00287638389156935*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.00919458970830296*std::sin(0.249599978327751*x_119 - 1.20399987697601) + 0.0010608970847886*std::sin(0.453279852867126*x_12 - 4.64311981201172) + 0.000266254272327626*std::sin(0.26639997959137*x_120 - 7.42495965957642) - 0.00500179172375221*std::sin(0.286079943180084*x_120 - 1.40863978862762) + 0.00271683442233013*std::sin(0.320559918880463*x_13 - 7.45679998397827) - 0.00010706669890278*std::sin(0.395359843969345*x_13 - 1.17983984947205) + 0.000778592118726611*std::sin(0.504719853401184*x_13 - 7.56504011154175) + 6.19547013588737e-5*std::sin(0.325839847326279*x_14 - 4.31423997879028) + 0.000849135950938386*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 6.00623382528322e-5*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.000103830637377998*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 0.00460701483179418*std::sin(0.453919857740402*x_16 + 4.96103954315186) - 0.00173139951218228*std::sin(0.566639840602875*x_18 - 1.36271989345551) + 0.000167475929694735*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 6.69007683644698e-5*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 0.00129102574560369*std::sin(0.261199951171875*x_2 + 1.8419998884201) + 0.000119846119109276*std::sin(0.380239844322205*x_2 - 1.18343985080719) + 8.91549410167248e-5*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 6.13306860516953e-5*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.000122864555640717*std::sin(0.399439841508865*x_24 + 1.99847972393036) + 0.00019334384306115*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.00114137134507605*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 3.55392695886699e-5*std::sin(0.417679876089096*x_25 + 8.1997594833374) - 0.00011757839563309*std::sin(0.452719867229462*x_26 - 1.2228798866272) + 9.54763414796145e-5*std::sin(0.345679849386215*x_27 + 5.02919960021973) + 0.000455471860386852*std::sin(0.632799863815308*x_28 - 4.41735982894897) - 0.000229898964444779*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.00172246991980193*std::sin(0.240079984068871*x_29 + 8.21415996551514) - 7.24281726217292e-5*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 3.24492719682053e-5*std::sin(0.307679921388626*x_30 + 2.00319981575012) - 0.0002737803327256*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 7.0036445646219e-5*std::sin(0.257999986410141*x_33 + 4.97671937942505) + 0.00290873062000866*std::sin(0.238559976220131*x_36 + 1.95983982086182) - 0.00286681404276886*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 8.55693766837585e-5*std::sin(0.280399948358536*x_4 + 5.04743957519531) + 7.04255464124262e-5*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.00102842827903983*std::sin(0.415839850902557*x_4 - 1.18935990333557) + 0.00884649474468426*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 8.34053453843392e-5*std::sin(0.334879845380783*x_44 + 1.85615992546082) - 3.70165791103485e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.00368978782560059*std::sin(0.206240013241768*x_45 - 4.39103984832764) - 0.000241629707621513*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00236423896632636*std::sin(0.19896000623703*x_50 - 7.59376001358032) + 0.000299076057356591*std::sin(0.189920008182526*x_51 - 7.59376001358032) - 0.0057861829266858*std::sin(0.19344000518322*x_51 + 4.99503993988037) + 0.000145054719866972*std::sin(0.248239979147911*x_53 + 4.99720001220703) - 0.00232936301575853*std::sin(0.252879977226257*x_53 - 7.42528009414673) + 0.00232052065293875*std::sin(0.206960007548332*x_54 + 4.99703979492188) - 0.000175677202149898*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.0020845472523095*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 9.3404976108484e-5*std::sin(0.236479982733727*x_57 + 7.99480009078979) - 0.00454571099065871*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 9.68320532969459e-5*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.00397218775984221*std::sin(0.354799836874008*x_59 + 5.07823991775513) - 0.00338549193432451*std::sin(0.465519845485687*x_6 + 8.16063976287842) + 0.000969432264325686*std::sin(0.460559874773026*x_60 - 4.47903966903687) + 8.31223263957611e-5*std::sin(0.480959862470627*x_60 - 1.33383989334106) - 4.30416534488722e-5*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 8.79690204874317e-5*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.00153996723448679*std::sin(0.350959837436676*x_7 + 2.00847983360291) - 0.000121845735314292*std::sin(0.350399851799011*x_8 - 1.15535986423492) + 0.00224514705013408*std::sin(0.454559862613678*x_8 - 7.64487981796265) + 0.00023528351826567*std::sin(0.309599906206131*x_9 - 7.42199993133545) + 0.00233247447453738*std::sin(0.211359992623329*x_92 + 2.00551986694336) + 0.000121885008199757*std::sin(0.291999936103821*x_92 - 7.57456016540527) + 0.00237003778558321*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 9.41162446683488e-5*std::sin(0.253359973430634*x_93 + 4.98847961425781) + 3.83412679787793e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 8.53747603005106e-5*std::sin(0.309519916772842*x_95 + 1.76439988613129) + 0.00266957462312988*std::sin(0.281679958105087*x_97 - 4.41967964172363) - 0.000129706226616208*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.159080937504768*std::sin(0.000364868849100633*x_1 + 0.0014462181744888*x_10 + 0.000191729572192993*x_100 + 0.00169545713664433*x_101 - 0.0163044857657966*x_103 + 0.00830231022332475*x_104 - 0.00221981994041432*x_105 + 0.0286420135035584*x_106 - 0.0175304567318437*x_107 - 0.0221693639728416*x_108 - 0.0203786953120017*x_111 + 0.000700797485537731*x_112 - 2.54418597785945e-5*x_113 - 0.000365237009586102*x_114 - 0.0424648397989578*x_115 + 0.00150934867492508*x_116 - 0.0105765377089463*x_117 + 0.000894836409169613*x_119 - 0.0241725505703095*x_12 + 0.000722052440358755*x_120 + 0.00464344554538817*x_13 - 0.00840177387723189*x_16 + 0.00133848869345271*x_17 + 0.00379902030673717*x_18 + 0.00219628619687078*x_19 + 0.000663117106288229*x_2 + 0.00164534048459558*x_20 + 0.0015465363616247*x_22 + 0.0143785990757628*x_23 + 0.00162165417823897*x_24 + 0.00161980835264956*x_25 + 0.0118784860415217*x_27 - 0.00794034334817406*x_28 + 0.0015073002437467*x_29 + 0.00357789086808343*x_30 - 0.000289044310174819*x_31 - 0.00161593582994887*x_33 + 0.00284456481543829*x_34 + 0.000962308953233145*x_36 - 0.00323251395172914*x_37 - 0.00583428312364018*x_38 + 0.0188091323489283*x_39 + 0.0027548686126326*x_4 + 0.000933679476263984*x_40 - 0.00187562794112943*x_41 + 0.00104984703746386*x_42 - 0.0143300359700271*x_43 - 0.0196777346630164*x_45 - 0.0340027351830427*x_46 - 0.00725318587470435*x_47 - 0.000369029668801135*x_50 - 0.0269449250369713*x_51 + 0.00090410974445323*x_52 + 0.000801272868985301*x_53 - 0.00804609247773226*x_54 - 0.0328630028557433*x_55 - 0.0106125359461332*x_57 + 0.0058009646163953*x_58 - 0.000207746528468489*x_6 + 0.000715422119101701*x_61 + 0.000674785571432934*x_62 + 0.00148360067495959*x_63 + 8.9489962598795e-5*x_64 - 6.97109409217902e-5*x_65 - 0.000289645619422895*x_66 + 0.000191731573387442*x_67 - 0.000298028111431452*x_68 - 0.000448452764322631*x_69 + 0.00150248948680705*x_7 + 0.00077111739250173*x_70 - 0.000158231565299869*x_71 - 0.000155517081275822*x_72 - 0.000103448172841342*x_73 - 0.000533484790129598*x_74 - 0.000151088534095353*x_75 + 0.00138536524496358*x_76 + 0.000151145762478876*x_77 - 0.000729023104250341*x_78 - 5.00336604708942e-6*x_79 + 0.00179092559538333*x_8 + 0.000161120367511777*x_80 - 0.000425603712716868*x_81 - 0.000235894210376015*x_82 - 0.00386899773013707*x_83 - 0.000474707123650441*x_84 - 0.00716321595167832*x_85 + 0.000205530554696778*x_86 + 0.000124242171010904*x_87 + 0.000134367104771729*x_88 + 0.000630014841620107*x_89 + 0.00215470333181876*x_9 + 0.000714383348408365*x_90 - 0.000375591485267295*x_91 - 9.2151889785455e-5*x_92 - 0.0207029843808294*x_93 - 0.00955574239410674*x_94 + 0.000632596016428268*x_95 + 0.000299224003509878*x_96 + 0.000705895346544047*x_98 - 0.000182385406308261*x_99 - 0.000322401762021227*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 0.0597176433272709*std::exp(0.203039854764938*x_49) + 0.297098123691008*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.218989036728937*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.0541241549904479*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.331410013125605*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.182240861531119*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0634120382539494*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.185167327263045*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.13965426115359*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.111313517079039*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.0135333371158797*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.125872559744795*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.291667568407032*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.241900680767762*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 0.0924701465683038*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.53979552592655*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.235601734964629*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.169503974467672*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.095726776559256*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 7.75762844933495) + 0.184073293538811);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.44991761782055e-5*x_1 - 9.83175355062299e-5*x_10 - 9.13622124382467e-6*x_100 - 3.66182453958848e-5*x_101 + 4.60931875987498e-6*x_102 - 0.000118186276274574*x_103 - 2.50023967416781e-5*x_104 + 0.000111587216636866*x_105 - 0.000214633103457142*x_106 - 1.74789049285319e-5*x_107 - 1.0549371590947e-5*x_108 + 7.57802171456842e-6*x_11 + 2.82498991133844e-6*x_110 + 0.000356729308893313*x_111 + 9.44444540401193e-5*x_112 + 7.05047333603043e-6*x_113 - 0.000337701655927365*x_114 + 0.000114899062211175*x_115 + 2.71893012649054e-5*x_116 + 2.78515810443068e-5*x_117 - 3.15380962694801e-5*x_118 - 7.50482431738948e-6*x_119 + 2.96452116182209e-5*x_12 - 2.26994163526601e-5*x_14 - 2.00879826090861e-5*x_15 + 2.80495010504962e-6*x_16 + 1.58650224326202e-7*x_17 - 1.28812138089487e-5*x_19 - 5.12043176007338e-6*x_2 - 1.92186557340144e-6*x_20 + 0.000320448256874645*x_21 - 8.30305022198009e-5*x_22 - 9.48544168077507e-5*x_23 - 0.000214756101513822*x_24 + 4.89969953114868e-5*x_25 + 0.00039257331660634*x_26 - 2.5284340491851e-5*x_27 + 5.55176307822984e-6*x_28 + 0.000160857810347278*x_29 - 2.257577697788e-6*x_3 - 1.60358502636524e-5*x_31 - 5.41730898610314e-5*x_32 + 2.43202274606708e-6*x_33 + 2.99106352428756e-5*x_34 + 8.23121618242996e-5*x_35 - 0.000414389029159196*x_36 - 2.15718566008488e-5*x_37 + 8.30867978036984e-5*x_38 - 0.000155092070487164*x_39 - 1.67950762515923e-6*x_4 + 3.97376974300999e-5*x_40 + 4.37374764446739e-5*x_41 + 0.000349842782660285*x_42 + 0.0004624482071267*x_43 - 2.29965257689314e-5*x_44 - 1.86476557624268e-6*x_45 + 0.000587414309096656*x_46 - 2.82870186660208e-5*x_47 - 1.8167708765402e-5*x_48 - 2.17252624209664e-5*x_49 + 6.66517903218557e-6*x_5 - 2.11018534930231e-5*x_50 - 0.000772608555897122*x_52 - 0.00018045136656109*x_53 - 0.000708153280374878*x_54 + 1.34095980695428e-5*x_55 + 1.9160889358745e-5*x_56 - 6.09648791449844e-6*x_57 + 0.000376101674172992*x_58 + 4.93272432577222e-6*x_6 - 4.53494063761782e-5*x_60 + 2.90400785725616e-6*x_61 + 3.33362633516254e-6*x_62 - 2.2768404762428e-5*x_63 - 6.44124299031912e-6*x_64 + 4.23833246728537e-7*x_65 - 1.79129729921584e-7*x_66 + 6.76513644709509e-6*x_67 - 1.76528901703956e-5*x_68 + 4.23792475577658e-6*x_69 + 7.24052868811668e-6*x_7 - 3.76489922840874e-6*x_70 - 7.28370930979036e-6*x_71 - 2.84350547081612e-5*x_72 - 5.02350365707496e-5*x_73 - 2.02678984052768e-5*x_74 + 1.34693414540367e-5*x_75 + 8.9348724922734e-6*x_76 - 1.33796086756579e-5*x_77 - 4.07934208061534e-5*x_78 + 4.05203153687609e-6*x_79 - 3.27790000086032e-6*x_80 - 3.51909971770188e-7*x_81 - 4.33779180503249e-5*x_82 + 1.87888289830268e-5*x_83 - 9.56248413008002e-6*x_84 + 5.98868633964565e-6*x_85 + 1.02263487062578e-5*x_86 - 2.36458439911049e-5*x_87 - 2.49097118826374e-5*x_88 + 0.00012381171171989*x_89 + 1.00557891671854e-6*x_9 + 4.08336416122883e-6*x_90 + 2.28215188837448e-5*x_91 - 8.17561743381117e-6*x_92 + 3.63478205471638e-6*x_93 + 4.17683350768104e-5*x_94 - 7.10982286257863e-6*x_95 + 4.27480450851274e-6*x_96 - 9.61472047826511e-5*x_97 + 0.000458827834502956*x_98 - 0.000116921734469713*x_99 - 1.48407874615804e-7*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 2.45594310694371e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 9.939744124644e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) - 6.59325475106855e-5*std::exp(0.451999843120575*x_30) - 0.000185106490593253*std::exp(0.423199862241745*x_5) - 0.000140468082055377*std::exp(0.243439853191376*x_59) - 0.00724405177801786*std::exp(-0.0008455684588085*x_1 + 0.0581101138581448*x_101 - 0.00238236312452932*x_102 + 0.00293389281558127*x_103 - 0.0524982187829068*x_104 - 0.0113114510609032*x_105 - 0.019350814755248*x_106 + 0.0589600587054369*x_107 + 0.000957057431601677*x_108 + 0.0837361210816303*x_109 - 0.00660886795354711*x_11 - 0.0465402466183687*x_110 - 0.0233120430018295*x_111 + 0.0332944286278989*x_112 - 0.0130367145792255*x_113 + 0.00136605689845137*x_115 + 0.00188762033892984*x_116 + 0.00155503882085885*x_117 + 0.0288925332581455*x_118 + 0.000398384229172801*x_119 - 0.0323281785684446*x_12 - 0.0377286319880196*x_120 + 0.0307666468624015*x_15 - 0.00217195103469998*x_16 - 0.00964147007566831*x_17 - 0.00423347890928291*x_18 - 0.00415704294732141*x_19 - 0.00332550244234894*x_20 + 0.0230527566772137*x_21 + 0.000400833612199566*x_22 - 0.0149634504395855*x_24 + 0.00934691909579358*x_26 - 0.00367675550137161*x_27 - 0.0228787110831707*x_3 - 0.0051006591542796*x_30 - 0.000169767872114597*x_32 - 0.0261208645089149*x_33 - 0.0498714841573093*x_34 + 0.00209228723926674*x_35 + 0.00143832511240181*x_38 - 0.0501545273855786*x_39 - 0.0310245811900693*x_40 - 0.0102987300560448*x_41 + 0.00171363869132348*x_42 - 0.0163871814340888*x_44 - 0.001017230064253*x_46 - 0.026016501377643*x_47 - 0.00094629759639958*x_48 - 0.000848116655026132*x_5 - 0.00491601760992873*x_51 + 0.0563003085310013*x_52 + 0.0923772900552797*x_55 + 0.011411867819498*x_57 - 0.00179047327003703*x_58 + 0.00256589032385319*x_59 - 0.000891041078799342*x_6 - 0.00325170484512934*x_61 - 0.00030905321029633*x_62 - 0.00152983430894397*x_63 - 0.00264171839750529*x_64 + 0.00260155757006821*x_65 - 0.00191315258122984*x_66 + 0.000585105357498845*x_67 - 0.000807174421724637*x_68 - 0.000245173098359154*x_69 - 0.00121717187561165*x_70 - 0.0028037509797852*x_71 + 0.000163744094626909*x_72 + 0.00264227452495091*x_73 + 0.000159417878171412*x_74 - 0.00293875640510238*x_75 + 2.73984037008244e-5*x_76 - 0.00113826181376864*x_77 + 0.000944313088008703*x_78 - 0.000614746303915426*x_79 - 0.000183981082416881*x_8 - 0.000602932089505913*x_80 - 3.74861107364465e-5*x_81 + 0.000765925577059234*x_82 - 0.00560262264866672*x_83 + 0.00032250018033964*x_84 - 0.000997628205175391*x_85 + 0.00152514054873846*x_86 + 0.000130414633730977*x_87 - 0.000667027577762421*x_88 - 0.000128232700682464*x_89 - 0.00166406098652215*x_9 - 0.000212466616770211*x_90 - 0.000996504379454915*x_91 + 0.0372973444826822*x_94 - 0.0292570486899245*x_95 + 0.000379882288107365*x_96 + 0.0750728552257109*x_98 + 0.0313206693758964*x_99 + 3.38021140113744e-5*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 4.46466469361268e-5*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 0.000272523003052125*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) - 0.000295590127191547*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 0.086359340175747*std::sin(0.435199856758118*x_10 - 4.42439985275269) + 0.181209471593881*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 0.525268018933161*std::sin(0.256719976663589*x_114 - 4.44536018371582) - 0.142181834962706*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 0.155064127587984*std::sin(0.429519861936569*x_14 + 1.77279984951019) - 0.235759398379528*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.208430407030292*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 0.314547152450046*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.0499961265306545*std::sin(0.545839846134186*x_31 - 4.60487985610962) - 0.531174984973433*std::sin(0.238559976220131*x_36 + 1.95983982086182) + 0.523520430394768*std::sin(0.221199989318848*x_37 + 1.96463978290558) - 0.18780541996825*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.673806979352634*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.43174317648166*std::sin(0.19896000623703*x_50 - 7.59376001358032) + 0.425374339026803*std::sin(0.252879977226257*x_53 - 7.42528009414673) - 0.42375959962618*std::sin(0.206960007548332*x_54 + 4.99703979492188) - 0.380667548863158*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 0.177031920692066*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.281219603840682*std::sin(0.350959837436676*x_7 + 2.00847983360291) - 0.425942535015366*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.432802122164162*std::sin(0.242639973759651*x_93 - 1.19775986671448) - 0.487501747522515*std::sin(0.281679958105087*x_97 - 4.41967964172363)) - 0.00147899936021928*std::exp(-0.0254010592939575*x_10 + 0.0187557060288127*x_100 + 0.00307247235318789*x_101 - 0.168183887346714*x_102 + 0.00206900970162588*x_103 - 0.0536722991519698*x_104 + 0.0192230292897494*x_105 + 0.00675978975180573*x_106 + 0.0164224272443484*x_107 + 0.0121407570220808*x_110 - 0.0862242370894918*x_111 - 0.00502786454333077*x_112 + 0.00387156980903853*x_113 + 0.00874599440690623*x_114 - 0.151360190271239*x_115 + 0.0127147742972742*x_116 + 0.00781977068333695*x_117 + 0.0130620489849027*x_118 + 0.0103934141494501*x_119 + 0.133240924623489*x_12 - 0.0233341050221267*x_120 - 0.00440456576253686*x_13 + 0.0816096504608306*x_16 - 0.0177748501227973*x_17 + 0.00927997531729023*x_18 - 0.00417071904164937*x_2 + 0.00341797282691666*x_20 - 0.0107927589617621*x_21 - 0.0177817506199002*x_24 + 0.00956983307172203*x_26 - 0.0600606092607784*x_27 - 0.0167975096496805*x_28 + 0.0176207137310895*x_29 + 0.00259573718847672*x_3 + 0.00148412983874242*x_31 + 0.00459780867242312*x_32 + 0.00643523046480125*x_34 + 0.0180383272356171*x_35 + 0.0665370543326745*x_36 - 0.0332724880158822*x_37 + 0.00118950468468351*x_38 + 0.00343381952756937*x_39 + 0.269786480472858*x_40 - 0.0953537306122311*x_41 + 0.00205486389539146*x_42 + 0.00391596591191753*x_43 - 0.210238119372247*x_45 - 0.128890849532865*x_46 - 0.016712266516497*x_47 + 0.255373345941773*x_48 + 0.0275161664065372*x_49 - 0.000684446254644379*x_5 - 0.273427168256602*x_50 + 0.0196463937704226*x_51 + 0.00655510374932787*x_52 - 0.00869483416519068*x_53 - 0.365530389517695*x_54 + 0.276930901988386*x_55 - 0.0180675241586749*x_56 - 0.232910306654433*x_58 - 0.0024486792749926*x_6 - 0.00116710731921853*x_61 - 0.00205238917809189*x_62 + 0.0153901714690861*x_63 - 0.00424383640250567*x_64 - 0.00446562259607972*x_65 - 0.00012523985496949*x_66 - 0.000867965248433865*x_67 + 0.00217622236133202*x_68 - 0.00577899665226769*x_69 - 0.0859575489234757*x_7 - 0.00037290940215005*x_70 - 0.00327758978364471*x_71 + 0.0176641105750672*x_72 - 0.0150976116092807*x_73 + 0.00697658731266816*x_74 + 0.00393615597153946*x_75 - 0.00230326599400895*x_76 - 0.00183768386576097*x_77 - 0.0207624499390831*x_78 + 0.00208226524160716*x_79 - 0.0184658578975261*x_8 - 0.000269147858451597*x_80 - 0.00512972006232495*x_81 - 0.00353673453742424*x_82 - 0.0255902173975644*x_83 - 0.0130906608200523*x_84 - 0.0129519046807915*x_85 - 0.00454870799976786*x_86 + 0.000299456850553874*x_87 + 0.00147987432560574*x_88 + 0.00136569880908699*x_89 - 0.0215094208205559*x_9 + 0.0420346100793756*x_90 + 0.0026688196623956*x_91 + 0.00932121112578979*x_92 + 0.00264858893125569*x_94 + 0.00651478882790253*x_96 - 0.00629896825200682*x_97 + 0.00389655180927948*x_98 - 0.00657432633394194*x_99 + 0.00141716321304758*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 0.295324963796679*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 1.01025398370272*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.980547902836456*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.676119047715751*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 1.074577305947*std::sin(0.453119844198227*x_14 + 1.75431990623474) - 1.85763741196253*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 1.1969238881819*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 1.09726935890986*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.635834262881303*std::sin(0.417679876089096*x_25 + 8.1997594833374) + 0.580551011929533*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 1.25302439548412*std::sin(0.257999986410141*x_33 + 4.97671937942505) - 1.53092458507577*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 1.49220782859642*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 1.67111155689923*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 1.7324255096952*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.770059663876182*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 1.68383688653337*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 1.52744269684285*std::sin(0.309519916772842*x_95 + 1.76439988613129)) - 0.000440157919223994*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.000175466940235116*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.000325354069485499*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.000370805426254552*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.000519380190507104*std::sin(0.258399993181229*x_109 - 1.24367988109589) + 0.00193655900992197*std::sin(0.281919956207275*x_109 + 1.55823993682861) + 9.7266405257241e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 0.000151733797786775*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.000532044071609273*std::sin(0.281759947538376*x_113 - 1.19703996181488) - 0.0046543473626974*std::sin(0.249599978327751*x_119 - 1.20399987697601) + 0.000537031417967487*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.000836258907911201*std::sin(0.26639997959137*x_120 - 7.42495965957642) - 0.00253193202271824*std::sin(0.286079943180084*x_120 - 1.40863978862762) + 0.00137527519221863*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.00033627809956012*std::sin(0.395359843969345*x_13 - 1.17983984947205) - 0.000194589068732703*std::sin(0.325839847326279*x_14 - 4.31423997879028) - 0.00233209398271526*std::sin(0.453919857740402*x_16 + 4.96103954315186) - 0.000876443105016863*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.000526013110864178*std::sin(0.199760004878044*x_19 + 5.00815963745117) - 0.000376416062013065*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.000280020346557264*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.000385896452375688*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.000607259780795999*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.000369293532330961*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.000299874778943838*std::sin(0.345679849386215*x_27 + 5.02919960021973) + 0.000230562137020652*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.000722073134285476*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.000227484441880134*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 0.000221194537150698*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.00447813994863259*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 1.1626271289776e-5*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.000758917382425431*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.000939346493564079*std::sin(0.189920008182526*x_51 - 7.59376001358032) - 0.00292899477837336*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.000455591944357818*std::sin(0.248239979147911*x_53 + 4.99720001220703) + 0.000551771898082425*std::sin(0.220319986343384*x_55 + 8.19007968902588) - 0.00230106167128386*std::sin(0.324399828910828*x_57 + 8.07800006866455) + 0.00201074133927535*std::sin(0.354799836874008*x_59 + 5.07823991775513) - 0.00171375297385237*std::sin(0.465519845485687*x_6 + 8.16063976287842) - 0.000261072940866178*std::sin(0.480959862470627*x_60 - 1.33383989334106) + 0.000276295574000466*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.000382696512836367*std::sin(0.350399851799011*x_8 - 1.15535986423492) + 0.00113650468190256*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.000738985092386587*std::sin(0.309599906206131*x_9 - 7.42199993133545) - 0.000382819862219733*std::sin(0.291999936103821*x_92 - 7.57456016540527) - 0.000120423332957493*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.00040738496502277*std::sin(0.210240006446838*x_98 + 1.97111988067627) - 0.1821309030056*std::sin(0.000369049146483767*x_1 + 0.00146278747621231*x_10 + 0.00019392621526319*x_100 + 0.00171488196572744*x_101 - 0.016491286034847*x_103 + 0.00839742967730412*x_104 - 0.00224525238692439*x_105 + 0.0289701646581219*x_106 - 0.0177313029333813*x_107 - 0.0224233580708026*x_108 - 0.0206121737437572*x_111 + 0.000708826512685764*x_112 - 2.57333468159689e-5*x_113 - 0.000369421524978852*x_114 - 0.0429513588841698*x_115 + 0.00152664126192334*x_116 - 0.0106977129559325*x_117 + 0.000905088537595499*x_119 - 0.0244494951495516*x_12 + 0.00073032498523168*x_120 + 0.00469664543710257*x_13 - 0.00849803288492534*x_16 + 0.00135382373999446*x_17 + 0.00384254563011261*x_18 + 0.00222144901760492*x_19 + 0.000670714429849725*x_2 + 0.00166419112788583*x_20 + 0.00156425500743772*x_22 + 0.0145433344875079*x_23 + 0.00164023344784325*x_24 + 0.00163836647465546*x_25 + 0.0120145776926379*x_27 - 0.0080313157526459*x_28 + 0.00152456936189714*x_29 + 0.0036188827145232*x_30 - 0.000292355886858912*x_31 - 0.00163444958451547*x_33 + 0.00287715495538431*x_34 + 0.000973334113667868*x_36 - 0.00326954881959102*x_37 - 0.00590112642510133*x_38 + 0.0190246283194148*x_39 + 0.0027864311044174*x_4 + 0.000944376629175045*x_40 - 0.00189711698464017*x_41 + 0.00106187512052499*x_42 - 0.014494214994938*x_43 - 0.0199031821982625*x_45 - 0.0343923040521184*x_46 - 0.00733628552545872*x_47 - 0.00037325763663832*x_50 - 0.027253632672327*x_51 + 0.000914468117353849*x_52 + 0.000810453041218837*x_53 - 0.00813827644852622*x_54 - 0.0332395138272291*x_55 - 0.0107341236244274*x_57 + 0.00586742618817745*x_58 - 0.000210126677586323*x_6 + 0.000723618700475224*x_61 + 0.000682516580439021*x_62 + 0.00150059826747656*x_63 + 9.05152478688054e-5*x_64 - 7.0509618212629e-5*x_65 - 0.000292964085298769*x_66 + 0.000193928239385297*x_67 - 0.000301442615402916*x_68 - 0.000453590681472253*x_69 + 0.00151970348818143*x_7 + 0.000779952073856166*x_70 - 0.000160044422166063*x_71 - 0.000157298838335906*x_72 - 0.00010463337713402*x_73 - 0.000539596918028754*x_74 - 0.000152819553351333*x_75 + 0.00140123735551092*x_76 + 0.000152877437399658*x_77 - 0.000737375511923547*x_78 - 5.06068954303889e-6*x_79 + 0.00181144420528446*x_8 + 0.000162966321345159*x_80 - 0.000430479848596672*x_81 - 0.000238596847098119*x_82 - 0.00391332478388943*x_83 - 0.000480145836633593*x_84 - 0.00724528481826267*x_85 + 0.000207885315433604*x_86 + 0.000125665611854462*x_87 + 0.000135906546842054*x_88 + 0.000637232912990825*x_89 + 0.00217938973824023*x_9 + 0.000722568028600349*x_90 - 0.000379894631745435*x_91 - 9.32076727186117e-5*x_92 - 0.0209401781879839*x_93 - 0.0096652224032181*x_94 + 0.000639843660283243*x_95 + 0.000302652208800427*x_96 + 0.000713982779815477*x_98 - 0.000184474993398503*x_99 - 0.000326095514572088*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 0.0604018275450885*std::exp(0.203039854764938*x_49) + 0.300501972805726*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.221497991109201*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.0547442546893633*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.335206973085405*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.184328792573838*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0641385491036028*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.187288786783384*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.141254278101824*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.112588834512413*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.0136883883729821*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.127314679929641*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.295009199724593*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.244672133538488*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 0.0935295757650421*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.545979955838888*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.23830102079997*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.17144597917058*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.0968235169209857*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 7.76810217727308) - 0.12265331770194);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-9.99257421610376e-6*x_1 - 1.72072300537215e-5*x_10 - 2.66561784693165e-6*x_100 + 0.000453488286302875*x_101 - 8.28499536801153e-6*x_102 - 4.09715448769464e-5*x_103 - 0.000410527663692563*x_104 - 5.83319377891135e-5*x_105 - 0.000185473518669366*x_106 + 0.000473424901509251*x_107 + 1.40507973433823e-6*x_108 + 0.000659462083538723*x_109 - 4.85053226328894e-5*x_11 - 0.000366721269762356*x_110 - 0.000119087078729063*x_111 + 0.000279515604855874*x_112 - 0.000101643190393579*x_113 - 0.000125315138198045*x_114 - 1.16891356600353e-5*x_115 + 3.73936288276829e-5*x_116 + 2.55384998267338e-5*x_117 + 0.000222062943518603*x_118 - 3.0347098349768e-6*x_119 - 0.000244188388935312*x_12 - 0.000295652607859761*x_120 + 1.14420469415101e-6*x_13 - 4.03853604240591e-6*x_14 + 0.000242271864469325*x_15 - 2.12558971159497e-5*x_16 - 7.46254134000203e-5*x_17 - 3.31443275138212e-5*x_18 - 3.46088800599079e-5*x_19 - 5.4422720439624e-7*x_2 - 2.64122959973769e-5*x_20 + 0.000222867052539493*x_21 - 9.69246646480599e-6*x_22 - 5.31504201986515e-6*x_23 - 0.000154720078643992*x_24 + 9.02815066830917e-6*x_25 + 0.000142906115272723*x_26 - 2.77259011904762e-5*x_27 + 3.6919023395701e-6*x_28 + 2.78963317792843e-5*x_29 - 0.000180731516561452*x_3 - 3.94833721275875e-5*x_30 - 2.62394094023706e-6*x_31 - 1.12191389121003e-5*x_32 - 0.000204570450285922*x_33 - 0.000386485768617266*x_34 + 7.8431420015641e-5*x_35 - 0.00014044604530361*x_36 - 4.74261120347109e-5*x_37 + 7.99791582727199e-5*x_38 - 0.000418591029212861*x_39 + 2.29979702060568e-7*x_4 - 0.000222907219223626*x_40 - 4.24983430068856e-5*x_41 + 7.58534794003025e-5*x_42 - 1.50538830937328e-6*x_43 - 0.000133148303112785*x_44 + 8.95211606096171e-6*x_45 + 0.0001197127736604*x_46 - 0.000210357660145074*x_47 - 3.07750105156437e-5*x_48 - 2.6836660899072e-6*x_49 - 1.53587585360654e-6*x_5 + 3.43984857767624e-5*x_50 - 4.50160801150038e-5*x_51 + 0.000307131159000016*x_52 - 3.14516987316348e-5*x_53 - 0.000106351916885842*x_54 + 0.000707691748571886*x_55 + 3.16783406851181e-5*x_56 + 8.31682420560556e-5*x_57 - 5.53314871073493e-6*x_58 + 2.02076159874962e-5*x_59 - 3.13920123516098e-6*x_6 - 8.06827846613095e-6*x_60 - 2.49721304053424e-5*x_61 - 1.61219929303625e-6*x_62 - 1.41460332518003e-5*x_63 - 2.20889756401874e-5*x_64 + 2.0471759771038e-5*x_65 - 1.47849501330599e-5*x_66 + 5.64462081462233e-6*x_67 - 8.05900522540126e-6*x_68 - 9.13342204543335e-7*x_69 + 6.51230782287896e-6*x_7 - 1.1243140750832e-5*x_70 - 2.25936357146705e-5*x_71 - 2.19296173217937e-6*x_72 + 1.2483971472589e-5*x_73 - 3.38577673262041e-6*x_74 - 2.10486222182023e-5*x_75 + 2.13521237534905e-6*x_76 - 1.05666402452071e-5*x_77 + 1.50470367070387e-6*x_78 - 7.43385966264577e-6*x_79 - 4.4859573041048e-8*x_8 - 7.49549723066534e-6*x_80 - 7.5016883459405e-7*x_81 - 2.15560601783414e-6*x_82 - 3.34805836128282e-5*x_83 + 9.59281431585897e-7*x_84 - 6.25936285565132e-6*x_85 + 2.62301263696064e-5*x_86 - 3.5520822292914e-6*x_87 - 1.15519185153828e-5*x_88 + 2.20918410067181e-5*x_89 - 1.12777033375505e-5*x_9 - 3.24460380069656e-6*x_90 - 3.94697925833483e-6*x_91 - 2.00747034778446e-6*x_92 - 2.12361699742308e-6*x_93 + 0.000304696146744115*x_94 - 0.000231556789727947*x_95 + 5.50119320950323e-6*x_96 - 6.56036433131236e-5*x_97 + 0.00067277820067001*x_98 + 0.000218369893095769*x_99 - 6.18838485773995e-8*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 1.13649724837231e-7*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 1.88074425998366e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) + 2.66207847294763e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) - 8.13741557061794e-8*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 3.51613741252877e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 7.61178736399733e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) - 2.14624925400813e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) - 2.32791391138342e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) - 1.17303002576249e-5*std::exp(0.451999843120575*x_30) - 1.1462584986805e-5*std::exp(0.203039854764938*x_49) - 3.29329715940701e-5*std::exp(0.423199862241745*x_5) - 0.000107569486560837*std::exp(0.243439853191376*x_59) + 1.69576936281269e-5*std::sin(0.397759824991226*x_1 - 1.00775980949402) + 0.000680121191066504*std::sin(0.435199856758118*x_10 - 4.42439985275269) - 0.00033706989291664*std::sin(0.259839981794357*x_100 + 1.77871990203857) + 0.00142711143232628*std::sin(0.262959957122803*x_100 + 7.99488019943237) + 5.70269069990794e-5*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.000134371370302127*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.00024915389811642*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.000283960233047461*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 5.8009242842132e-5*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.000397737760815256*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 5.63035061792157e-5*std::sin(0.265599936246872*x_109 - 7.6308798789978) - 4.20341511289626e-5*std::sin(0.266719967126846*x_109 - 4.43391990661621) + 0.000344540284133749*std::sin(0.281919956207275*x_109 + 1.55823993682861) - 1.03889351931893e-5*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 3.8823062974108e-5*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 6.36129496958166e-5*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 7.44859410055515e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 0.00011619669381842*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.000407435673452026*std::sin(0.281759947538376*x_113 - 1.19703996181488) - 0.00413673738056527*std::sin(0.256719976663589*x_114 - 4.44536018371582) + 3.49804722185856e-5*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.000828071933044552*std::sin(0.249599978327751*x_119 - 1.20399987697601) + 9.55452203559361e-5*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.000640401292874998*std::sin(0.26639997959137*x_120 - 7.42495965957642) - 0.000450465270639922*std::sin(0.286079943180084*x_120 - 1.40863978862762) + 0.000244680230791518*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.000257519444859194*std::sin(0.395359843969345*x_13 - 1.17983984947205) - 0.00111975009010101*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 0.000149014964165856*std::sin(0.325839847326279*x_14 - 4.31423997879028) - 0.00122120431828457*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 6.17027172363685e-5*std::sin(0.453119844198227*x_14 + 1.75431990623474) + 0.000106666384376143*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 1.21717106900715e-5*std::sin(0.358239859342575*x_15 - 1.36047983169556) - 0.000414911355303188*std::sin(0.453919857740402*x_16 + 4.96103954315186) - 0.000155931192843818*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.000402817205389206*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 6.87279135872472e-5*std::sin(0.348159849643707*x_19 + 2.01871991157532) - 0.00185671824848007*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.00028825681914013*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.00021443764636779*std::sin(0.303359925746918*x_20 + 1.98871982097626) + 3.55421966988927e-5*std::sin(0.294639945030212*x_21 + 1.81559991836548) - 6.30057052296294e-5*std::sin(0.527199864387512*x_22 - 4.35599946975708) - 0.000295516836567446*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.000465035343783795*std::sin(0.203359991312027*x_25 + 8.21024036407471) - 0.00164148934435386*std::sin(0.350159853696823*x_25 + 8.2388801574707) - 3.6509892321972e-5*std::sin(0.417679876089096*x_25 + 8.1997594833374) + 2.68061287762079e-5*std::sin(0.352479845285416*x_26 - 1.17263984680176) + 0.000282802435128422*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.000229642033489263*std::sin(0.345679849386215*x_27 + 5.02919960021973) + 4.10201516156126e-5*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.000552958616490843*std::sin(0.162320017814636*x_29 - 1.2279999256134) - 0.00247720957033183*std::sin(0.240079984068871*x_29 + 8.21415996551514) - 2.13662257685908e-5*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.000174206013605125*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 3.33355029295047e-5*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 0.000393743456764968*std::sin(0.545839846134186*x_31 - 4.60487985610962) + 2.59767496174806e-6*std::sin(0.23463998734951*x_32 + 5.02007961273193) - 7.19492302107497e-5*std::sin(0.257999986410141*x_33 + 4.97671937942505) + 2.41607811894765e-5*std::sin(0.233519986271858*x_35 + 4.99319982528687) - 0.00418325756900954*std::sin(0.238559976220131*x_36 + 1.95983982086182) + 0.00412297428330437*std::sin(0.221199989318848*x_37 + 1.96463978290558) + 8.79063853855421e-5*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 0.000169389248028477*std::sin(0.408399850130081*x_4 + 4.98151969909668) - 0.00147905768684211*std::sin(0.415839850902557*x_4 - 1.18935990333557) + 0.000796722228647572*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 5.59845316138523e-5*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 8.5683251634128e-5*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 8.90331821263971e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) - 0.00530655288025159*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.00058117368711146*std::sin(0.199760004878044*x_47 - 1.17887985706329) + 4.64319580809747e-5*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 1.77493091609905e-5*std::sin(0.27551993727684*x_5 + 1.99671983718872) + 0.00340018442505432*std::sin(0.19896000623703*x_50 - 7.59376001358032) - 0.000719345053601401*std::sin(0.189920008182526*x_51 - 7.59376001358032) - 0.000521108155236481*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.000348889162710315*std::sin(0.248239979147911*x_53 + 4.99720001220703) + 0.00335002677787115*std::sin(0.252879977226257*x_53 - 7.42528009414673) - 0.00333730993123732*std::sin(0.206960007548332*x_54 + 4.99703979492188) + 0.000422543106639885*std::sin(0.220319986343384*x_55 + 8.19007968902588) - 0.000103611792875366*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.0029979393798783*std::sin(0.294719934463501*x_56 - 4.30647993087769) - 9.59559850139497e-5*std::sin(0.236479982733727*x_57 + 7.99480009078979) - 0.000409390283472624*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 9.94766600468918e-5*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.000357738333200247*std::sin(0.354799836874008*x_59 + 5.07823991775513) - 4.52228982860328e-5*std::sin(0.376559853553772*x_59 + 1.83519995212555) - 0.000304900048757071*std::sin(0.465519845485687*x_6 + 8.16063976287842) - 0.00139421121690891*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.000199927854021893*std::sin(0.480959862470627*x_60 - 1.33383989334106) + 3.25356729549578e-5*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 4.4217175844237e-5*std::sin(0.551119863986969*x_60 - 1.34527981281281) + 0.000211585241283106*std::sin(0.271759957075119*x_7 + 5.01319980621338) - 0.00221473915301045*std::sin(0.350959837436676*x_7 + 2.00847983360291) + 0.00029306634498079*std::sin(0.350399851799011*x_8 - 1.15535986423492) + 0.000202199697512869*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.0005659096771379*std::sin(0.309599906206131*x_9 - 7.42199993133545) - 0.00335450159358552*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.00029316080508619*std::sin(0.291999936103821*x_92 - 7.57456016540527) - 0.00340852412979723*std::sin(0.242639973759651*x_93 - 1.19775986671448) + 9.66866792244167e-5*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 9.22193562169909e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 8.77064537809056e-5*std::sin(0.309519916772842*x_95 + 1.76439988613129) - 0.0038393098939532*std::sin(0.281679958105087*x_97 - 4.41967964172363) - 1.83744074730135e-5*std::sin(0.324719846248627*x_97 - 1.58567976951599) + 0.000311972591060424*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.0781467585179862);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.87889689524579e-5*x_1 + 5.60332837324591e-5*x_10 + 5.45549777067142e-6*x_100 - 0.000877676067413302*x_101 + 3.4293441967842e-5*x_102 - 4.84076953798487e-5*x_103 + 0.000836242841073046*x_104 + 0.000132167385253052*x_105 + 0.000429069117908865*x_106 - 0.000875975305148446*x_107 - 8.58293340790032e-6*x_108 - 0.00130209846902062*x_109 + 0.000102287508204733*x_11 + 0.00072201494578966*x_110 + 0.000149489541180369*x_111 - 0.000573977381998473*x_112 + 0.000198511151473847*x_113 + 8.24761936284598e-5*x_114 - 0.000169895972904528*x_115 - 1.21717776312993e-5*x_116 - 2.08775756465547e-5*x_117 - 0.000428822574389955*x_118 - 9.84504838538975e-6*x_119 + 0.000517122580619003*x_12 + 0.0005866810322149*x_120 + 1.35544676516216e-5*x_14 - 0.000459895609828557*x_15 + 3.51381448433864e-5*x_16 + 0.000149830330776858*x_17 + 6.58306873450059e-5*x_18 + 7.23338459399581e-5*x_19 + 3.05755555896119e-6*x_2 + 5.28592345563604e-5*x_20 - 0.000579891751606371*x_21 + 4.63440807170454e-5*x_22 + 7.28610291439444e-5*x_23 + 0.000360918954852909*x_24 - 2.9257500618441e-5*x_25 - 0.000379761493414805*x_26 + 7.2271625912318e-5*x_27 + 2.7002433509622e-6*x_28 - 9.60527774366033e-5*x_29 + 0.000357112509282364*x_3 + 7.93153586527961e-5*x_30 + 1.02569499582491e-5*x_31 + 3.50250585520798e-5*x_32 + 0.000406610208670509*x_33 + 0.000759076188810973*x_34 + 7.41722196435935e-6*x_35 + 0.000131173816580309*x_36 - 6.98326632430033e-5*x_37 + 2.9495573726595e-5*x_38 + 0.000873582351457894*x_39 + 1.0028818108006e-6*x_4 + 0.000513385381569019*x_40 + 0.000181418323274342*x_41 - 0.000235488443190944*x_42 - 0.000425071884909942*x_43 + 0.000268552901001558*x_44 + 2.93627495292115e-6*x_45 - 0.00029376841595096*x_46 + 0.000421448135434577*x_47 + 1.55619234225584e-5*x_48 + 1.80625004478874e-5*x_49 + 1.6430014031951e-5*x_5 + 5.41126151064567e-5*x_50 + 7.64441786994939e-5*x_51 - 0.000411544664552762*x_52 + 0.000107752647589839*x_53 + 0.000423215514126181*x_54 - 0.00144447608360492*x_55 + 3.87488683867474e-5*x_56 - 0.000180419972366251*x_57 - 0.000330976016127324*x_58 - 3.98996492697224e-5*x_59 + 1.62548656490335e-5*x_6 + 2.70794214351734e-5*x_60 + 4.86744631763043e-5*x_61 + 2.78066645981252e-6*x_62 + 4.20879437793012e-5*x_63 + 4.41895444465219e-5*x_64 - 4.13251488933238e-5*x_65 + 3.05243052254691e-5*x_66 - 1.36054881196913e-5*x_67 + 2.60797551914897e-5*x_68 + 1.31462209296139e-6*x_69 - 4.32352578405456e-6*x_7 + 1.90428756676682e-5*x_70 + 4.91001514968835e-5*x_71 + 1.92630962150544e-5*x_72 - 1.1523340384079e-5*x_73 + 8.64245793968001e-6*x_74 + 3.75702556795068e-5*x_75 - 5.88732217902087e-6*x_76 + 2.6875541164358e-5*x_77 + 1.01784178227476e-5*x_78 + 1.25512821617013e-6*x_79 + 2.86090975614024e-6*x_8 + 7.25916216171934e-6*x_80 - 3.2237454978738e-7*x_81 + 1.28347376871574e-5*x_82 + 8.80164466688693e-5*x_83 - 2.99778569487059e-7*x_84 + 1.4081018478289e-5*x_85 - 7.5233259487563e-6*x_86 + 1.13933264058985e-5*x_87 + 2.19146940681708e-5*x_88 - 7.00364738041752e-5*x_89 + 2.52757240416667e-5*x_9 + 8.26327561211073e-7*x_90 + 1.99001853833935e-6*x_91 + 4.88189389176258e-6*x_92 + 4.7831711392175e-8*x_93 - 0.000594747701765791*x_94 + 0.000459193208834575*x_95 - 4.65284706387012e-6*x_96 - 3.26392326396572e-5*x_97 - 0.00144136366085134*x_98 - 0.000431661926488355*x_99 - 7.21820025485545e-8*std::pow(-6.09200000762939*x_17 - 3.14800000190735, 2) + 1.1945113563781e-7*std::pow(-4.83143997192383*x_18 - 9.77624034881592, 2) - 5.2562359392029e-7*std::pow(-8.98360061645508*x_23 - 4.78751993179321, 2) + 6.94256312228297e-7*std::pow(-7.40000009536743*x_28 - 9.99979972839355, 2) - 4.83445125532866e-7*std::pow(-4.50992012023926*x_30 - 8.42679977416992, 2) + 4.23773851073356e-6*std::pow(-3.68111991882324*x_43 - 8.79135990142822, 2) + 4.59643278315359e-6*std::pow(-3.87639999389648*x_49 - 9.98935985565186, 2) + 3.93702009134636e-5*std::exp(0.451999843120575*x_30) + 0.000110532354659305*std::exp(0.423199862241745*x_5) - 6.83202793865225e-5*std::exp(0.243439853191376*x_59) - 0.0115329674929529*std::exp(-0.0145603986039505*x_10 + 0.0107511483169914*x_100 + 0.00176120301300487*x_101 - 0.0964063903867421*x_102 + 0.00118599801773936*x_103 - 0.0307660424944977*x_104 + 0.0110190274190946*x_105 + 0.00387484758514006*x_106 + 0.00941366594026138*x_107 + 0.00695932636310402*x_110 - 0.0494254687104007*x_111 - 0.0028820731856242*x_112 + 0.00221926176346634*x_113 + 0.00501338008304123*x_114 - 0.086762708500243*x_115 + 0.00728836462232173*x_116 + 0.00448244999640457*x_117 + 0.00748742946518585*x_118 + 0.00595771424807985*x_119 + 0.0763763806235601*x_12 - 0.013375578799953*x_120 - 0.0025247857751785*x_13 + 0.046780294746268*x_16 - 0.01018890196343*x_17 + 0.00531946869187106*x_18 - 0.00239074012657208*x_2 + 0.0019592508407402*x_20 - 0.00618662673477549*x_21 - 0.0101928574673018*x_24 + 0.00548562099261298*x_26 - 0.0344279504690216*x_27 - 0.00962867072678476*x_28 + 0.0101005478803712*x_29 + 0.00148792881816191*x_3 + 0.000850733104553905*x_31 + 0.00263555650181511*x_32 + 0.00368880366725813*x_34 + 0.0103399323492607*x_35 + 0.038140379178868*x_36 - 0.0190724600281396*x_37 + 0.000681848034360454*x_38 + 0.00196833448860664*x_39 + 0.154647042400163*x_40 - 0.0546586782078837*x_41 + 0.00117788935679873*x_42 + 0.00224471050349326*x_43 - 0.120512722889987*x_45 - 0.0738828299986192*x_46 - 0.00957980764658645*x_47 + 0.146385143497589*x_48 + 0.0157728205857588*x_49 - 0.000392338373580106*x_5 - 0.156733957938227*x_50 + 0.011261708463299*x_51 + 0.00375751744743844*x_52 - 0.00498405400244623*x_53 - 0.209529378741342*x_54 + 0.158742368656319*x_55 - 0.0103566686133988*x_56 - 0.13350887711457*x_58 - 0.00140363226133668*x_6 - 0.000669009413534668*x_61 - 0.00117647079901746*x_62 + 0.00882195614677952*x_63 - 0.00243265246993604*x_64 - 0.00255978478146367*x_65 - 7.17900064069575e-5*x_66 - 0.000497535155731884*x_67 + 0.00124745447286768*x_68 - 0.00331263723351606*x_69 - 0.0492725976842276*x_7 - 0.000213759177348845*x_70 - 0.00187878045391025*x_71 + 0.0101254238250772*x_72 - 0.00865425494483412*x_73 + 0.00399912031195788*x_74 + 0.00225628385216864*x_75 - 0.00132027844097322*x_76 - 0.00105339739118255*x_77 - 0.0119014543294866*x_78 + 0.00119359636013935*x_79 - 0.01058500153243*x_8 - 0.000154280971399769*x_80 - 0.0029404588198375*x_81 - 0.00202732744431274*x_82 - 0.0146688278373856*x_83 - 0.00750383034515493*x_84 - 0.00742429253245972*x_85 - 0.00260741100767216*x_86 + 0.000171654695904168*x_87 + 0.000848293758744846*x_88 + 0.000782846053903637*x_89 - 0.0123296330780153*x_9 + 0.0240950848086456*x_90 + 0.00152982116363093*x_91 + 0.00534310588753134*x_92 + 0.00151822450122258*x_94 + 0.00373440812278995*x_96 - 0.00361069542342535*x_97 + 0.00223358194898391*x_98 - 0.00376853621996049*x_99 + 0.000812346486421395*std::pow(-5.25311994552612*x_23 - 6.26200008392334, 2) - 0.169286215224882*std::sin(0.397759824991226*x_1 - 1.00775980949402) - 0.579097923583038*std::sin(0.265439957380295*x_108 + 1.95447981357574) + 0.562069799937941*std::sin(0.265599936246872*x_109 - 7.6308798789978) + 0.387565050911345*std::sin(0.475119858980179*x_11 + 4.90399980545044) - 0.615969346958281*std::sin(0.453119844198227*x_14 + 1.75431990623474) - 1.06483516560349*std::sin(0.254399985074997*x_15 - 7.59144020080566) - 0.686100871181559*std::sin(0.348159849643707*x_19 + 2.01871991157532) + 0.628976888590991*std::sin(0.527199864387512*x_22 - 4.35599946975708) + 0.364473001163503*std::sin(0.417679876089096*x_25 + 8.1997594833374) + 0.332783528662981*std::sin(0.307679921388626*x_30 + 2.00319981575012) + 0.718258811476531*std::sin(0.257999986410141*x_33 + 4.97671937942505) - 0.877556795302361*std::sin(0.280399948358536*x_4 + 5.04743957519531) - 0.855363570977836*std::sin(0.334879845380783*x_44 + 1.85615992546082) + 0.957914790030401*std::sin(0.236479982733727*x_57 + 7.99480009078979) + 0.993061182248205*std::sin(0.343599855899811*x_59 - 7.51183986663818) + 0.441413703464271*std::sin(0.551119863986969*x_60 - 1.34527981281281) - 0.96520920518433*std::sin(0.253359973430634*x_93 + 4.98847961425781) - 0.875560906864052*std::sin(0.309519916772842*x_95 + 1.76439988613129)) - 0.00134288958189084*std::sin(0.435199856758118*x_10 - 4.42439985275269) - 0.000214082171376972*std::sin(0.259839981794357*x_100 + 1.77871990203857) - 0.00281781114872051*std::sin(0.262959957122803*x_100 + 7.99488019943237) - 8.53428779303427e-5*std::sin(0.272479951381683*x_102 - 4.62847995758057) + 0.000158244354173131*std::sin(0.27567994594574*x_106 + 4.76656007766724) - 0.000180350795348387*std::sin(0.253759980201721*x_108 - 1.41743981838226) + 0.000252613968981806*std::sin(0.258399993181229*x_109 - 1.24367988109589) - 0.00115637450970706*std::sin(0.281919956207275*x_109 + 1.55823993682861) + 4.73080281645597e-5*std::sin(0.304159939289093*x_110 - 1.66063988208771) - 7.37996511768689e-5*std::sin(0.227439999580383*x_111 - 4.42759990692139) + 0.000258773374608749*std::sin(0.281759947538376*x_113 - 1.19703996181488) + 0.0081679288990663*std::sin(0.256719976663589*x_114 - 4.44536018371582) + 0.00277924329801982*std::sin(0.249599978327751*x_119 - 1.20399987697601) - 0.000320676746470256*std::sin(0.453279852867126*x_12 - 4.64311981201172) - 0.000406736116788708*std::sin(0.26639997959137*x_120 - 7.42495965957642) + 0.00151188868316508*std::sin(0.286079943180084*x_120 - 1.40863978862762) - 0.000821215965000814*std::sin(0.320559918880463*x_13 - 7.45679998397827) + 0.00016355753832005*std::sin(0.395359843969345*x_13 - 1.17983984947205) + 0.00221093056659506*std::sin(0.504719853401184*x_13 - 7.56504011154175) - 9.46434189664561e-5*std::sin(0.325839847326279*x_14 - 4.31423997879028) + 0.00241125049171433*std::sin(0.429519861936569*x_14 + 1.77279984951019) + 0.00139255970101412*std::sin(0.453919857740402*x_16 + 4.96103954315186) + 0.00052334912628913*std::sin(0.566639840602875*x_18 - 1.36271989345551) - 0.000255840061096919*std::sin(0.199760004878044*x_19 + 5.00815963745117) + 0.00366606367385879*std::sin(0.261199951171875*x_2 + 1.8419998884201) - 0.000183079672947829*std::sin(0.380239844322205*x_2 - 1.18343985080719) - 0.000136195127254326*std::sin(0.303359925746918*x_20 + 1.98871982097626) - 0.000187690705637892*std::sin(0.399439841508865*x_24 + 1.99847972393036) - 0.000295356477265955*std::sin(0.203359991312027*x_25 + 8.21024036407471) + 0.00324109727541494*std::sin(0.350159853696823*x_25 + 8.2388801574707) + 0.000179615446693012*std::sin(0.452719867229462*x_26 - 1.2228798866272) - 0.000145851843199069*std::sin(0.345679849386215*x_27 + 5.02919960021973) - 0.000137675215053225*std::sin(0.632799863815308*x_28 - 4.41735982894897) + 0.000351198916864527*std::sin(0.162320017814636*x_29 - 1.2279999256134) + 0.00489121493030146*std::sin(0.240079984068871*x_29 + 8.21415996551514) + 0.000110642933240954*std::sin(0.408879846334457*x_3 + 1.80935990810394) - 0.000777440834034618*std::sin(0.545839846134186*x_31 - 4.60487985610962) + 0.00825978234699585*std::sin(0.238559976220131*x_36 + 1.95983982086182) - 0.00814075386001593*std::sin(0.221199989318848*x_37 + 1.96463978290558) - 0.000107583675634943*std::sin(0.408399850130081*x_4 + 4.98151969909668) + 0.00292037828664216*std::sin(0.415839850902557*x_4 - 1.18935990333557) - 0.00267402483527122*std::sin(0.213279992341995*x_41 + 1.78087985515594) + 5.65473729774326e-6*std::sin(0.47079986333847*x_44 - 7.70144033432007) + 0.0104777129021199*std::sin(0.206240013241768*x_45 - 4.39103984832764) + 0.000369119068473885*std::sin(0.199760004878044*x_47 - 1.17887985706329) - 0.00671361560393793*std::sin(0.19896000623703*x_50 - 7.59376001358032) - 0.000456875426374427*std::sin(0.189920008182526*x_51 - 7.59376001358032) + 0.00174898615710786*std::sin(0.19344000518322*x_51 + 4.99503993988037) - 0.000221588908094469*std::sin(0.248239979147911*x_53 + 4.99720001220703) - 0.00661458004565924*std::sin(0.252879977226257*x_53 - 7.42528009414673) + 0.00658947081353505*std::sin(0.206960007548332*x_54 + 4.99703979492188) + 0.00026836851249782*std::sin(0.220319986343384*x_55 + 8.19007968902588) + 0.00591938850496011*std::sin(0.294719934463501*x_56 - 4.30647993087769) + 0.00137402942451198*std::sin(0.324399828910828*x_57 + 8.07800006866455) - 0.00120067089019195*std::sin(0.354799836874008*x_59 + 5.07823991775513) + 0.00102333068331204*std::sin(0.465519845485687*x_6 + 8.16063976287842) + 0.00275285014308464*std::sin(0.460559874773026*x_60 - 4.47903966903687) - 0.000126979567167484*std::sin(0.480959862470627*x_60 - 1.33383989334106) + 0.000134383487926672*std::sin(0.271759957075119*x_7 + 5.01319980621338) + 0.00437297083850553*std::sin(0.350959837436676*x_7 + 2.00847983360291) + 0.000186134332402439*std::sin(0.350399851799011*x_8 - 1.15535986423492) - 0.000678639296598454*std::sin(0.454559862613678*x_8 - 7.64487981796265) - 0.000359424484449237*std::sin(0.309599906206131*x_9 - 7.42199993133545) + 0.00662341550540177*std::sin(0.211359992623329*x_92 + 2.00551986694336) - 0.000186194326560616*std::sin(0.291999936103821*x_92 - 7.57456016540527) + 0.00673008223188953*std::sin(0.242639973759651*x_93 - 1.19775986671448) - 5.85709979941826e-5*std::sin(0.281999945640564*x_95 + 7.99368000030518) + 0.00758066257302666*std::sin(0.281679958105087*x_97 - 4.41967964172363) + 0.00019814219871851*std::sin(0.210240006446838*x_98 + 1.97111988067627) + 0.177818313241005*std::sin(0.000360971090695097*x_1 + 0.00143076876284474*x_10 + 0.000189681396380103*x_100 + 0.00167734519773294*x_101 - 0.0161303109997177*x_103 + 0.00821361972662136*x_104 - 0.00219610642841445*x_105 + 0.0283360415107173*x_106 - 0.0173431853732504*x_107 - 0.0219325368910462*x_108 - 0.0201609972784699*x_111 + 0.000693311126270377*x_112 - 2.51700738394854e-5*x_113 - 0.000361335318258832*x_114 - 0.0420112036864913*x_115 + 0.00149322486359102*x_116 - 0.0104635524846442*x_117 + 0.000885277204145622*x_119 - 0.023914324190061*x_12 + 0.000714339022302971*x_120 + 0.00459384134116576*x_13 - 0.00831202084725382*x_16 + 0.00132419011584467*x_17 + 0.00375843678372641*x_18 + 0.00217282408711294*x_19 + 0.000656033272518202*x_2 + 0.00162776392326509*x_20 + 0.00153001528804484*x_22 + 0.0142249978419344*x_23 + 0.00160433064892239*x_24 + 0.00160250454160222*x_25 + 0.0117515925867159*x_27 - 0.00785551960916626*x_28 + 0.00149119831504215*x_29 + 0.00353966958874007*x_30 - 0.000285956557157993*x_31 - 0.00159867338762331*x_33 + 0.00281417738596385*x_34 + 0.000952028964079693*x_36 - 0.00319798220571294*x_37 - 0.00577195764383695*x_38 + 0.0186082013736077*x_39 + 0.00272543937438027*x_4 + 0.000923705325180232*x_40 - 0.00185559130442773*x_41 + 0.00103863191146752*x_42 - 0.0141769535178213*x_43 - 0.0194675247317665*x_45 - 0.0336394965914293*x_46 - 0.00717570278378077*x_47 - 0.000365087461904034*x_50 - 0.0266570824099335*x_51 + 0.000894451475832447*x_52 + 0.00079271316851234*x_53 - 0.00796013906004778*x_54 - 0.0325119396012948*x_55 - 0.0104991661660326*x_57 + 0.00573899506583075*x_58 - 0.000205527249460278*x_6 + 0.000707779530305456*x_61 + 0.000667577087783342*x_62 + 0.00146775191994655*x_63 + 8.85339745642167e-5*x_64 - 6.8966244830015e-5*x_65 - 0.000286551442842693*x_66 + 0.000189683376196534*x_67 - 0.000294844387802315*x_68 - 0.000443662109993183*x_69 + 0.00148643894963221*x_7 + 0.000762879831784537*x_70 - 0.000156541236253723*x_71 - 0.000153855750054367*x_72 - 0.000102343074430711*x_73 - 0.000527785770248677*x_74 - 0.000149474511398699*x_75 + 0.00137056590256533*x_76 + 0.000149531128432656*x_77 - 0.000721235221181052*x_78 - 4.94991694581895e-6*x_79 + 0.00177179380238346*x_8 + 0.00015939917846448*x_80 - 0.000421057146319767*x_81 - 0.000233374240135813*x_82 - 0.00382766666430119*x_83 - 0.000469636003750956*x_84 - 0.00708669397602831*x_85 + 0.000203334948113375*x_86 + 0.000122914938040554*x_87 + 0.000132931710894333*x_88 + 0.00062328462704961*x_89 + 0.00213168543636472*x_9 + 0.000706751856413646*x_90 - 0.000371579180921892*x_91 - 9.11674653713603e-5*x_92 - 0.0204818220876138*x_93 - 0.00945366194703767*x_94 + 0.000625838228125924*x_95 + 0.000296027504609811*x_96 + 0.000698354528720868*x_98 - 0.000180437050749168*x_99 - 0.00031895766373502*std::pow(-3.93032002449036*x_14 - 5.9935998916626, 2) - 0.0590797019222663*std::exp(0.203039854764938*x_49) + 0.293924334775511*std::sin(0.233679980039597*x_102 - 1.20599985122681) - 0.216649658180359*std::sin(0.266719967126846*x_109 - 4.43391990661621) - 0.0535459667439682*std::sin(0.254879981279373*x_11 - 1.3887197971344) - 0.327869683038443*std::sin(0.244719967246056*x_110 - 4.43903970718384) + 0.180294050090197*std::sin(0.244239971041679*x_118 + 1.9443998336792) - 0.0627346310000121*std::sin(0.358239859342575*x_15 - 1.36047983169556) + 0.183189253475575*std::sin(0.294639945030212*x_21 + 1.81559991836548) + 0.138162386548174*std::sin(0.352479845285416*x_26 - 1.17263984680176) - 0.110124396117044*std::sin(0.291519939899445*x_3 - 7.52311992645264) + 0.0133887655016451*std::sin(0.23463998734951*x_32 + 5.02007961273193) + 0.124527909937115*std::sin(0.233519986271858*x_35 + 4.99319982528687) + 0.288551792096769*std::sin(0.279679954051971*x_44 + 1.9159197807312) + 0.23931654563512*std::sin(0.22511999309063*x_48 - 7.4060001373291) - 0.0914823223351959*std::sin(0.27551993727684*x_5 + 1.99671983718872) - 0.534029090798867*std::sin(0.142560034990311*x_56 - 1.40511989593506) - 0.233084889130623*std::sin(0.376559853553772*x_59 + 1.83519995212555) + 0.167693226460869*std::sin(0.521919846534729*x_60 + 8.08527946472168) - 0.0947041629574414*std::sin(0.324719846248627*x_97 - 1.58567976951599) - 1.56906824224845) + 0.229254564473912);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
