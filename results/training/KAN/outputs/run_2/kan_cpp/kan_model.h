
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.87465936821658e-6*x_1 + 9.57251670895221e-7*x_10 - 1.17761659821935e-6*x_100 + 4.07983717724757e-7*x_101 + 1.93423959997143e-6*x_102 - 6.21104206248591e-7*x_103 - 1.55441492822059e-7*x_104 + 2.19797858939603e-7*x_105 + 1.01717085915849e-6*x_106 + 2.80730478190484e-7*x_107 - 1.3315732257909e-7*x_108 - 8.77326609058643e-7*x_109 - 8.07677281543977e-8*x_11 + 1.2294144082441e-6*x_110 + 1.32434784540945e-7*x_111 + 3.3224860572341e-7*x_112 - 4.29603203955121e-7*x_113 + 4.49028936279057e-7*x_114 + 7.49975453675627e-8*x_115 - 2.06421432721686e-7*x_116 + 1.09489210828834e-6*x_117 - 1.05480027896897e-6*x_118 - 7.35750578248372e-7*x_119 - 6.67552736984322e-8*x_12 + 5.42884863889089e-7*x_120 + 9.88083612398239e-7*x_13 + 1.64628373573842e-6*x_14 + 7.85035517406622e-8*x_15 + 9.81578578985223e-7*x_16 + 5.88502849623995e-8*x_17 - 3.06396943596718e-8*x_18 - 1.67867572454417e-7*x_19 + 5.08898030497475e-7*x_2 + 1.18883638055211e-7*x_20 + 5.99383114685628e-7*x_21 + 1.70928844289812e-7*x_22 - 4.92417023719495e-8*x_23 - 1.20469107375288e-7*x_24 - 6.49686009168532e-8*x_25 + 2.4487111037195e-7*x_26 + 1.34081655467934e-7*x_27 + 4.31007210304266e-7*x_28 - 3.00951612594303e-7*x_29 + 5.78924722833619e-8*x_3 + 1.19024273054591e-6*x_30 - 1.12285026729227e-5*x_31 + 9.92588381453902e-7*x_32 - 1.65078529746607e-7*x_33 - 4.48375281215901e-6*x_34 - 1.78921467062127e-7*x_35 + 3.12147293291333e-7*x_36 + 1.8855032670681e-8*x_37 + 3.45941612570005e-7*x_38 - 5.33889006482662e-7*x_39 + 8.2039041998723e-7*x_4 - 1.835891868691e-7*x_40 + 2.86882778204237e-7*x_41 - 1.49978109492196e-7*x_42 + 5.64414060041765e-7*x_43 + 3.11676962582411e-7*x_44 + 9.3648960962992e-7*x_45 + 2.06146557714586e-7*x_46 + 8.22655875621494e-9*x_47 - 6.5966870410513e-7*x_48 - 5.27713021563221e-8*x_49 + 6.2111200251592e-7*x_5 + 4.88236894290964e-7*x_50 - 5.05246510197115e-7*x_51 + 2.2273382947078e-6*x_52 - 6.01162514993299e-7*x_53 - 1.20705494156607e-6*x_54 + 3.29011358238964e-7*x_55 + 3.68377836996635e-7*x_56 - 6.33898481482913e-7*x_57 - 8.00465511895863e-7*x_58 + 7.42338352088043e-7*x_59 - 1.45563209851549e-7*x_6 + 5.32357486030556e-7*x_60 - 6.48506111029789e-7*x_61 + 7.06251077422679e-8*x_62 + 8.19092887856393e-7*x_63 - 1.89333103296275e-6*x_64 - 1.42493907017134e-7*x_65 - 2.11691805312439e-8*x_66 + 2.63251540781247e-8*x_67 + 8.50942931032718e-7*x_68 + 2.75072437384706e-7*x_69 + 2.23716595643667e-7*x_7 - 1.98823755404538e-8*x_70 + 1.06018069607519e-7*x_71 + 8.2995016474547e-8*x_72 + 7.64810321912369e-7*x_73 - 1.1267830604833e-6*x_74 + 2.95768612412625e-6*x_75 - 1.44228901565973e-6*x_76 - 1.30243672149949e-7*x_77 - 3.69019006240861e-7*x_78 + 5.98451982696435e-7*x_79 + 2.56000080755845e-6*x_8 - 2.03110643764502e-7*x_80 + 7.21743633146619e-7*x_81 + 1.31651866811219e-6*x_82 - 4.04630722114875e-7*x_83 - 1.64646802377448e-7*x_84 - 3.33491105463647e-7*x_85 + 4.19577324882096e-7*x_86 - 9.94919880525658e-8*x_87 - 6.73626335875824e-7*x_88 + 2.73800844337784e-7*x_89 + 6.69766924034498e-7*x_9 + 6.07090455071462e-7*x_90 + 7.43978266563521e-6*x_91 + 8.70232784482771e-6*x_92 + 1.47260898488312e-6*x_93 + 2.95184547879598e-7*x_94 + 6.0148511805515e-7*x_95 + 6.40441342290515e-7*x_96 + 8.41630128557649e-6*x_97 + 1.46990237618434e-6*x_98 + 3.48247997638992e-7*x_99 + 3.55100908787334e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) + 8.2932040159728e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 9.85723988347175e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) + 0.000242595675881321*std::exp(-0.000750976979070472*x_1 + 0.00018811207262229*x_10 - 0.0135748954011925*x_100 - 0.000718871091265902*x_101 - 0.00304476184079856*x_102 + 0.00691451617204138*x_103 + 0.00368034947981102*x_104 - 7.17896508259951e-5*x_106 - 0.000583410750900107*x_107 + 0.000423790112091144*x_108 - 0.0100469777890226*x_109 + 0.00021382980459213*x_11 + 0.00489799493507565*x_110 + 0.000622219333100233*x_111 - 0.000163372528138934*x_112 - 0.000461978367627754*x_113 + 0.000794661234388202*x_114 - 0.00121118065322829*x_115 - 0.00832174472294564*x_116 - 0.00251596362594709*x_117 - 0.00151843467192048*x_118 - 0.00363412561322659*x_119 - 0.00382072854784645*x_12 + 0.0119752282435733*x_120 - 0.00227608170742745*x_14 - 0.00132918071164929*x_15 - 0.00270092967430584*x_16 - 0.00154878352842944*x_17 - 0.000370574229057265*x_18 - 0.00473865408883875*x_2 + 0.000511515713596485*x_20 - 0.00453988675566705*x_21 + 0.00661425291954739*x_22 - 0.0065021336675072*x_23 + 0.0114136047923913*x_24 + 0.00624275819579775*x_25 - 0.00776073088185264*x_26 - 0.00312777687795284*x_27 - 0.000795113470764108*x_28 - 0.00374623233491025*x_29 - 0.00357431633847234*x_3 + 0.00207682743026612*x_30 - 0.000827418618576715*x_32 + 0.00438121833958417*x_33 - 0.000913769747114737*x_34 - 0.0126749742123096*x_35 - 0.00783801956146888*x_36 + 0.00115846840845732*x_37 - 0.00443927261833538*x_38 - 0.00342576474488814*x_4 + 0.00365650834632261*x_40 + 0.00473956689589416*x_41 + 5.05171578749652e-6*x_42 + 0.00527673658472116*x_43 + 0.000328804556967483*x_44 + 0.000815301474120545*x_45 + 0.00242623738505696*x_46 - 0.00389778495116146*x_47 - 0.00250100410033567*x_48 + 0.00231870596105093*x_49 - 0.000932090484852216*x_5 + 0.0074469733408446*x_50 - 0.00737574923300932*x_51 - 0.000846567198810211*x_52 - 0.00223293400677545*x_53 + 0.000882138932626716*x_54 - 0.00152690658226821*x_55 + 0.00305583263913369*x_56 + 0.00110814778929736*x_57 - 0.00281722227919699*x_58 + 0.0076310340328006*x_59 - 0.00206988133597297*x_6 - 0.00401057135993565*x_60 + 0.0038425744421349*x_61 - 0.00208533409554354*x_62 - 0.0165498287608018*x_63 + 0.000118290552769582*x_64 - 0.00245694711225238*x_65 + 0.000500173241029471*x_66 - 0.00181894762474854*x_67 + 0.000984352020310022*x_68 + 5.56192661436847e-5*x_69 - 0.000151171940427139*x_7 + 0.00406827402034103*x_70 + 0.00177225510939688*x_71 + 0.00365791255812979*x_72 + 0.00741400790258794*x_73 - 0.00237469213918137*x_74 + 0.00218389636197429*x_75 - 0.00198123951793812*x_76 - 0.00104305612559553*x_77 - 0.000106934859037755*x_78 - 0.0112224059034515*x_79 - 0.0229066672493892*x_8 - 0.00441123734247629*x_80 - 0.00188433305103077*x_81 - 0.00516681971808574*x_82 + 0.000765189576373153*x_85 + 0.00270661555770346*x_87 - 0.00195938366325759*x_88 - 0.00187051109841592*x_89 + 0.00554550603372809*x_9 - 0.00147555045098589*x_90 + 0.00209479027950353*x_91 + 0.0207941172372725*x_92 - 0.00441371320527829*x_93 + 0.00129262355521801*x_94 + 0.00168272100919825*x_95 + 0.004288866555347*x_96 + 0.00270046906473797*x_97 + 0.00230670352632576*x_98 + 0.000437385131238485*x_99 - 1.90277118976507e-5*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) + 0.0159285293510592*std::sin(1.64135980606079*x_105 - 2.38775992393494) + 0.0126020568482144*std::sin(1.28351986408234*x_13 - 8.60632038116455) - 0.00931745765943404*std::sin(0.576479852199554*x_19 + 5.37559986114502) + 0.0601312839528467*std::sin(0.408479869365692*x_31 + 0.78743988275528) - 0.00891714507108704*std::sin(0.364079833030701*x_39 + 5.18728017807007) + 0.00440564385603789*std::sin(1.44671988487244*x_84 + 7.00112009048462) + 0.029171796311267*std::sin(0.746719837188721*x_86 + 2.37591981887817)) + 5.23559215424205e-5*std::exp(0.000768634421274674*x_10 - 0.00576985849416553*x_100 + 0.00346950213068438*x_101 + 0.0082451488296828*x_102 - 0.00595297299984532*x_103 + 0.00014327996232718*x_104 - 0.00432521915952576*x_105 + 0.000782569461015899*x_106 + 0.001618893080805*x_107 + 0.00747931934288633*x_108 + 0.00236637444142568*x_109 - 0.00274008895106419*x_11 - 0.000849576942728155*x_110 + 0.0196822552496032*x_111 - 0.000628545181657328*x_112 + 0.0042873201293878*x_113 - 0.00344064026094257*x_114 - 0.00972177836587325*x_115 - 0.000522181204975283*x_116 - 0.00216005665740968*x_117 + 0.000843901062691742*x_118 + 0.00190660255000351*x_119 - 0.00696765952128572*x_12 + 0.00274609215627228*x_120 + 0.00105168620030027*x_13 - 0.0233214428181486*x_14 - 0.00276993226196023*x_15 + 0.00254377210831339*x_16 + 0.000957263389357119*x_17 - 0.00207603615411901*x_18 - 0.00527335603390328*x_2 - 0.0047629328229204*x_20 - 0.000519046935833819*x_21 + 0.0227814871380252*x_22 - 0.00431855288157437*x_23 + 0.00130877847633643*x_24 + 0.00507324538608824*x_25 - 0.000751730479682409*x_26 - 0.00153286304416807*x_27 - 0.00206041114625397*x_28 - 0.000399653842107911*x_29 - 0.00228652151234479*x_3 + 0.000682499468923712*x_30 - 0.0393857638046857*x_31 + 0.000834689391548092*x_32 - 0.00642179201737134*x_33 - 0.000187665506717286*x_34 + 0.00406677805545798*x_35 + 0.00183719354979251*x_36 - 0.00107538384284032*x_37 + 0.00292091311378112*x_38 + 0.00121948524641664*x_39 - 0.00580590479005313*x_4 + 0.00621325247589927*x_40 + 0.00854161160532385*x_41 - 0.00166517456818838*x_42 - 0.00223646381671081*x_43 - 0.00157829901891294*x_44 + 0.0042986615881091*x_45 - 0.00302499372207228*x_46 + 0.000635932329493458*x_47 + 0.00290617842148594*x_48 + 0.00158525383159816*x_49 + 0.000228493322348608*x_5 + 0.00192679185048839*x_50 + 0.00343149616767457*x_51 - 0.000267459729726097*x_52 - 0.000128758424482514*x_53 + 0.00426133926811231*x_54 - 0.00384943636692073*x_55 - 0.000561109306704954*x_56 + 0.00702642537634274*x_57 + 0.00673250238418535*x_58 - 0.0159228174583298*x_59 - 0.00275039904969777*x_6 - 0.00389381865245592*x_60 - 0.00122869838321436*x_61 + 0.000856699355425688*x_62 + 0.0100063280798096*x_63 - 0.00448490976869061*x_64 - 0.00770752237678321*x_65 - 0.000204150606199567*x_66 - 0.00151911119097868*x_67 - 0.0262073083255551*x_68 + 0.0025258505073952*x_69 - 0.00410798089905268*x_7 - 0.0141677224773717*x_70 + 0.00403906482377037*x_71 - 0.016264442820102*x_72 - 0.0044164099781252*x_73 + 0.0107321486182771*x_74 - 0.000561165030551671*x_75 - 0.00177116830081541*x_76 - 0.000568558452756327*x_77 - 0.0036199255684783*x_78 - 0.00402351943193935*x_79 - 0.00659270474261862*x_8 - 0.0223486465536865*x_80 - 0.000421182183291075*x_81 - 0.00062659748950838*x_82 - 0.0164990668489751*x_83 + 0.00296633723443601*x_84 + 0.00180268517964819*x_85 + 0.00184202082543215*x_86 + 0.000345111385651681*x_87 - 0.0053357747519843*x_88 + 0.00215864884867103*x_89 - 0.00329910375368031*x_9 - 0.0203024484882856*x_90 + 0.00538984579496714*x_91 + 0.00146307605329606*x_92 + 0.0107374304207042*x_93 + 0.00232929890136645*x_94 + 0.035724184727195*x_95 - 0.00255932120521966*x_96 + 0.00266880175736672*x_97 - 0.00119912503657206*x_98 + 0.000245724844888948*x_99 - 0.0148942088708282*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 0.0496720895171165*std::sin(0.907839834690094*x_19 - 7.23472023010254)) + 2.4569892935562e-6*std::sin(0.381599843502045*x_110 + 5.17392015457153) + 6.89168291910057e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) + 4.60920943855942e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 2.31572206280793e-5*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 5.60956245866148e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) - 3.63921684302611e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) + 3.48255220490378e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) + 2.47641641225726e-7*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 2.19091620361919e-5*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0830347579867699);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.23396684103683e-6*x_1 - 2.3839669927212e-7*x_10 + 5.81371019934172e-7*x_100 + 2.48039254965012e-7*x_101 + 1.45235349146815e-8*x_102 + 1.92597007012638e-8*x_103 - 5.89305670530971e-7*x_104 - 4.32235346582347e-8*x_105 - 3.31175334841008e-7*x_106 - 1.02028843271589e-7*x_107 - 2.71133690400883e-8*x_108 + 6.28651609299549e-7*x_109 - 2.4601193431647e-7*x_11 - 9.08850817294503e-7*x_110 + 3.84616614482313e-7*x_111 - 4.24837183961295e-8*x_112 + 4.20724949448541e-7*x_113 + 2.3365570852292e-7*x_114 - 1.38676285373626e-7*x_115 + 3.38939197564675e-8*x_116 - 1.29668786224753e-7*x_117 - 5.19756294436292e-8*x_118 - 1.70292789568378e-7*x_119 + 5.26421563296797e-8*x_12 - 7.46830759030833e-7*x_120 - 1.90246283576291e-7*x_13 + 1.50820153603515e-8*x_14 + 2.82772451321021e-8*x_15 - 6.6203936339722e-8*x_16 - 2.03446100760443e-8*x_17 - 3.49195466712352e-9*x_18 + 1.84708194084041e-7*x_19 - 4.08818978731456e-7*x_2 + 2.06407127319563e-7*x_20 - 1.11955150972774e-7*x_21 - 3.22569751272539e-7*x_22 + 7.40259430772721e-8*x_23 + 1.20571745827907e-7*x_24 + 5.36430690243713e-7*x_25 - 2.97204969634562e-7*x_26 + 7.4240543584764e-9*x_27 - 1.32607459639648e-7*x_28 + 2.53609515657591e-7*x_29 + 2.02420783563424e-7*x_3 - 2.59390977782874e-8*x_30 + 1.72458639244834e-5*x_31 + 1.22536398527052e-7*x_32 - 1.30709587367572e-6*x_33 + 6.09184020017865e-6*x_34 - 3.43555864381106e-7*x_35 - 2.12955173082571e-8*x_36 - 5.12567225421639e-9*x_37 - 1.04439224024786e-7*x_38 + 2.22193672443357e-7*x_39 - 1.0424133719764e-6*x_4 + 1.77317358613094e-7*x_40 - 3.15144276344625e-7*x_41 + 2.62613496178556e-7*x_42 + 2.64942312855982e-7*x_43 - 6.81961267496087e-8*x_44 - 7.50256979368332e-8*x_45 - 6.10624482164648e-8*x_46 + 3.03318683490265e-7*x_47 - 1.89176006277552e-7*x_48 - 3.55305780770775e-7*x_49 - 5.09409853426279e-8*x_5 - 7.24735968121104e-7*x_50 + 1.06389731534401e-8*x_51 - 6.59283399812751e-7*x_52 + 6.7322049834236e-7*x_53 + 9.5092859964124e-7*x_54 + 3.56805836428873e-7*x_55 + 8.63496002684003e-8*x_56 + 2.16724526337925e-7*x_57 + 1.56111799172608e-8*x_58 + 1.3270370465181e-7*x_59 - 3.14764921402568e-8*x_6 - 2.57817057892e-8*x_60 + 6.54897662937339e-7*x_61 + 3.88733498423756e-7*x_62 + 3.18582193706508e-9*x_63 + 2.4529117206354e-6*x_64 + 1.69740766812649e-7*x_65 + 1.41422537408769e-7*x_66 - 9.92890555660605e-9*x_67 - 2.63708752945278e-7*x_68 - 2.58952416105443e-7*x_69 + 1.72084039272563e-7*x_7 - 6.87862234279551e-7*x_70 - 4.32318593681932e-7*x_71 - 2.39064025292678e-7*x_72 + 4.71911910803593e-8*x_73 + 2.06830708827594e-7*x_74 - 3.87813162220713e-6*x_75 + 2.12836763412273e-8*x_76 + 1.71504859150384e-7*x_77 + 2.12626419588562e-7*x_78 - 6.41391786893669e-8*x_79 - 2.40572757576544e-7*x_8 + 1.25211299812874e-7*x_80 - 8.27216884563459e-7*x_81 - 2.00074613195933e-7*x_82 + 4.42867562730043e-7*x_83 + 1.74867842389813e-7*x_84 + 1.79398581058996e-8*x_85 - 1.60926421671284e-7*x_86 - 3.3477747323743e-7*x_87 + 5.31330805284989e-7*x_88 - 1.69876276589941e-7*x_89 + 1.93725581939131e-7*x_9 + 8.50825816225687e-8*x_90 - 1.51599068670573e-5*x_91 - 1.16117548896235e-5*x_92 + 6.56289264362929e-8*x_93 - 6.8213694744004e-7*x_94 - 1.01427183165873e-6*x_95 - 1.7171200297152e-7*x_96 - 1.08807439024937e-5*x_97 - 1.21690004234112e-6*x_98 - 2.76007097677945e-7*x_99 - 5.02540245259379e-11*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) - 5.97315553684634e-11*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 0.000316796070739273*std::exp(-0.000442692390195902*x_1 + 0.000110889927886927*x_10 - 0.00800224648597291*x_100 - 0.000423766334394352*x_101 - 0.00179485248475759*x_102 + 0.0040760286620743*x_103 + 0.00216952417102109*x_104 - 4.23191828793817e-5*x_106 - 0.000343914003997342*x_107 + 0.000249819452382191*x_108 - 0.0059225791677033*x_109 + 0.000126050238460278*x_11 + 0.00288731232169047*x_110 + 0.000366791221932242*x_111 - 9.63062477143987e-5*x_112 - 0.000272330994802358*x_113 + 0.000468443761994902*x_114 - 0.000713977223376844*x_115 - 0.0049055738919731*x_116 - 0.00148313194979036*x_117 - 0.000895099973771271*x_118 - 0.00214227572725695*x_119 - 0.00225227603545107*x_12 + 0.00705926088553432*x_120 - 0.00134172428639476*x_14 - 0.000783536916099125*x_15 - 0.00159216733214572*x_16 - 0.000912990279602337*x_17 - 0.00021844929442367*x_18 - 0.00279338270461517*x_2 + 0.000301532696987693*x_20 - 0.00267621162178976*x_21 + 0.00389902688886537*x_22 - 0.003832933864637*x_23 + 0.00672819024698884*x_24 + 0.003680034973287*x_25 - 0.00457486261164351*x_26 - 0.00184378890523951*x_27 - 0.000468710350196355*x_28 - 0.00220836136498262*x_29 - 0.00210701883984928*x_3 + 0.00122426615562425*x_30 - 0.000487753867506961*x_32 + 0.00258267839464441*x_33 - 0.000538656875926641*x_34 - 0.00747175317765925*x_35 - 0.00462042340946816*x_36 + 0.000682903954447699*x_37 - 0.00261690073186343*x_38 - 0.00201944936453381*x_4 + 0.00215547009391472*x_40 + 0.00279392079399528*x_41 + 2.97792901631322e-6*x_42 + 0.00311057621768344*x_43 + 0.000193826547667822*x_44 + 0.000480610948627756*x_45 + 0.00143023935101575*x_46 - 0.00229769990903723*x_47 - 0.00147431347953937*x_48 + 0.00136685079924773*x_49 - 0.000549456742507366*x_5 + 0.00438990610879203*x_50 - 0.00434792030707519*x_51 - 0.000499041737826124*x_52 - 0.00131628920747033*x_53 + 0.000520010870443388*x_54 - 0.000900094068591597*x_55 + 0.0018013785944959*x_56 + 0.000653240521622326*x_57 - 0.00166072050042672*x_58 + 0.00449840779384231*x_59 - 0.00122017151201884*x_6 - 0.0023641862145744*x_60 + 0.00226515394173588*x_61 - 0.00122928073808045*x_62 - 0.00975593587505259*x_63 + 6.97309358377102e-5*x_64 - 0.00144834238601321*x_65 + 0.000294846438378757*x_66 - 0.00107224894248792*x_67 + 0.000580264323421179*x_68 + 3.27869249741398e-5*x_69 - 8.91141399847926e-5*x_7 + 0.00239820127677663*x_70 + 0.00104472423560427*x_71 + 0.00215629786080849*x_72 + 0.00437047335777248*x_73 - 0.0013998540146661*x_74 + 0.00128738207344144*x_75 - 0.00116791816818701*x_76 - 0.000614869725993331*x_77 - 6.30368835024481e-5*x_78 - 0.00661548067598134*x_79 - 0.0135032198837918*x_8 - 0.00260037425551894*x_80 - 0.00111079290781784*x_81 - 0.00304578147460902*x_82 + 0.000451070554701827*x_85 + 0.00159551909575742*x_87 - 0.00115503439036432*x_88 - 0.00110264502391358*x_89 + 0.00326901275183631*x_9 - 0.000869820213144358*x_90 + 0.00123485505100355*x_91 + 0.0122578956723494*x_92 - 0.00260183374848898*x_93 + 0.000761986888055175*x_94 + 0.000991944901582567*x_95 + 0.0025282380679204*x_96 + 0.00159189580804282*x_97 + 0.00135977550045064*x_98 + 0.000257833561587702*x_99 - 1.12166198095128e-5*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) + 0.00938968693747966*std::sin(1.64135980606079*x_105 - 2.38775992393494) + 0.00742876922063029*std::sin(1.28351986408234*x_13 - 8.60632038116455) - 0.0054925353463024*std::sin(0.576479852199554*x_19 + 5.37559986114502) + 0.0354467081688481*std::sin(0.408479869365692*x_31 + 0.78743988275528) - 0.00525655562721675*std::sin(0.364079833030701*x_39 + 5.18728017807007) + 0.00259707695886412*std::sin(1.44671988487244*x_84 + 7.00112009048462) + 0.0171964422282656*std::sin(0.746719837188721*x_86 + 2.37591981887817)) - 0.000276466507987269*std::exp(-6.57281121400992e-5*x_1 + 0.0019421745911714*x_10 - 0.00219732608584084*x_100 + 0.000553478747120302*x_101 + 0.00608464883320706*x_102 - 0.00261580550839667*x_103 - 0.000596581164233196*x_104 - 0.000117374489241596*x_105 + 0.00379447030084533*x_106 + 0.0010278411094591*x_107 - 0.0015494641267554*x_108 - 0.00118220761712898*x_109 - 0.000725356060262851*x_11 + 0.00166785647579123*x_110 + 0.00210226003238679*x_111 + 0.000342481433025249*x_112 - 0.000365257253454971*x_113 + 0.000716336038522595*x_114 + 0.000163896210044703*x_116 - 0.000162417496247334*x_117 - 0.00358702432622885*x_118 - 0.00129959710158042*x_119 + 0.000125692508583581*x_12 - 0.000648936863082739*x_120 + 0.00103273653424205*x_13 + 0.00570561945618144*x_14 + 0.000366721905616267*x_15 + 0.000733609080545404*x_16 + 0.000378106519167665*x_17 + 0.000110252830081611*x_18 - 8.1126256050752e-5*x_19 + 0.000140123623034469*x_2 + 0.0011780040658641*x_20 + 0.00335141230783926*x_21 + 0.000723167438032313*x_22 + 0.000236417275782668*x_23 + 0.000297129402179076*x_24 + 0.000831730295610147*x_25 - 0.00201922556870079*x_26 - 0.000104079258863484*x_27 + 0.00127255055214188*x_28 + 2.63420709779138e-5*x_29 + 0.000663893099136961*x_3 + 0.00278987713921435*x_30 - 0.000685697601720927*x_31 - 0.00015868313305219*x_32 - 0.00315336338549076*x_33 + 0.000321402617197805*x_34 - 0.00186503812505043*x_35 - 0.000420441794179976*x_36 - 2.35957402277251e-5*x_37 + 0.00110638502613722*x_38 - 0.00322474856342924*x_39 - 0.000158270209057618*x_4 + 0.000454400660437786*x_40 - 0.00172879823972166*x_41 - 0.000303742509267705*x_43 + 0.000513502668201972*x_44 + 0.00253624198659083*x_45 + 0.00100014620380959*x_46 - 0.000893171280215722*x_47 - 0.00232378801514573*x_48 - 0.00118919759487551*x_49 + 0.00175417077074079*x_5 + 0.000589988816760831*x_50 - 0.00109151598286337*x_51 + 0.000481092555293495*x_52 - 0.000527690086819712*x_53 + 7.70937790206738e-6*x_54 + 0.0017809668289793*x_55 + 0.00131454425079485*x_56 - 0.000608988071892108*x_57 - 0.000192650819200004*x_58 + 0.00445243219166758*x_59 - 0.000189920430566789*x_6 + 0.00115352885885205*x_60 + 0.00190029934919605*x_61 + 0.00145488475629096*x_62 + 0.00195500754760274*x_63 + 0.000303920921320604*x_64 + 0.000337205477937274*x_66 + 0.000423619418392241*x_67 + 0.000168486956411939*x_68 + 0.000175359191871123*x_69 + 0.00114074963629251*x_7 - 0.0015150766595971*x_70 - 0.00038498235079653*x_71 - 0.000283818750921336*x_72 + 0.00103062734549604*x_73 - 0.000878190950099594*x_74 - 0.000224871541527199*x_75 - 0.00430340676697563*x_76 - 0.000475752959442785*x_78 + 0.000194646509528741*x_79 + 0.0109201626326238*x_8 + 6.30177792500804e-5*x_81 + 0.000133150957694226*x_82 - 5.29645341527967e-5*x_83 - 0.000649959161088365*x_84 - 0.00106563106890421*x_85 + 0.000894136658428833*x_86 - 0.000750549507727676*x_87 - 0.000794427141457329*x_88 + 0.000374248089380306*x_89 + 0.0026509947835584*x_9 + 0.0010165498999898*x_90 - 0.00154894460934564*x_91 + 0.000425566477349396*x_92 + 0.00600896457940642*x_93 - 3.11319879202649e-5*x_94 - 0.000472650726455672*x_95 + 0.000511478641700207*x_96 + 0.000192843893769186*x_97 - 0.000432002614591656*x_98 - 5.99885465794463e-6*x_99 + 1.07938937165795e-5*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) + 0.0209484377866483*std::sin(0.675279796123505*x_115 - 7.78480005264282) + 0.0017051215436784*std::sin(1.60583984851837*x_42 + 8.61007976531982) - 0.00110620161320778*std::sin(1.35583984851837*x_77 - 6.99119997024536) + 0.00105858074231748*std::sin(1.34311985969543*x_80 + 2.59823989868164)) - 4.86518217624433e-8*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 1.48885280020277e-7*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 1.62253508508808e-7*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 6.13513108877611e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) - 3.08236338788243e-5*std::sin(0.353119850158691*x_37 + 1.94671976566315) - 1.50062498014422e-8*std::sin(0.628639817237854*x_88 + 2.20039987564087) - 2.91623938831655e-5*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0593404386250057);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.57454900388723e-7*x_1 - 8.77394384600355e-7*x_10 + 2.52171681515766e-6*x_100 - 4.45955945122599e-7*x_101 - 2.55733613164755e-6*x_102 + 6.98686607195079e-7*x_103 - 9.63003444851871e-8*x_104 + 2.61790039094243e-7*x_105 - 1.40462606923752e-6*x_106 - 4.23470301665792e-7*x_107 - 4.34103072104353e-8*x_108 + 1.29280727507366e-6*x_109 + 4.05020148480211e-7*x_11 - 1.15450988990052e-6*x_110 - 2.01531415513353e-6*x_111 - 1.30721826892941e-7*x_112 - 3.90532848426378e-8*x_113 - 1.84090461975413e-7*x_114 + 7.34710818096853e-7*x_115 + 7.85246589638666e-7*x_116 + 1.26358133893402e-7*x_117 + 1.40756074733576e-6*x_118 + 7.82563097454202e-7*x_119 + 7.79556847803511e-7*x_12 - 1.17490276377975e-6*x_120 - 6.25679708383123e-7*x_13 - 3.60549927181094e-7*x_14 + 1.72402311011351e-7*x_15 - 3.99432158420925e-7*x_16 - 4.90881653600421e-8*x_17 + 1.46215689464854e-7*x_18 + 6.00489257719938e-8*x_19 + 6.12794028184443e-7*x_2 - 1.15776205631181e-7*x_20 - 6.88490035160268e-7*x_21 - 2.33247172979755e-6*x_22 + 8.07219073183187e-7*x_23 - 1.16689753037759e-6*x_24 - 1.14157658909417e-6*x_25 + 1.27818651682562e-6*x_26 + 3.74618209597964e-7*x_27 - 2.72300341012101e-7*x_28 + 4.22891171020453e-7*x_29 + 2.5260149802623e-7*x_3 - 1.35932836956292e-6*x_30 + 5.00528798164808e-6*x_31 - 2.07228706229322e-7*x_32 + 1.05156171951944e-6*x_33 + 9.21616274332319e-7*x_34 + 1.47190607959371e-6*x_35 + 6.19543600994127e-7*x_36 - 3.08306850815705e-8*x_37 - 2.04402994949726e-7*x_38 + 9.89069335560957e-7*x_39 + 5.62851477036298e-7*x_4 - 8.27075438544388e-7*x_40 - 5.4685689008468e-7*x_41 + 1.37233559853673e-7*x_42 - 4.00683214103353e-7*x_43 - 1.55161144288824e-7*x_44 - 1.34042329765876e-6*x_45 - 3.60854487753153e-7*x_46 + 5.49862967297648e-7*x_47 + 8.93173311779499e-7*x_48 + 6.4172858259726e-8*x_49 - 6.05445734066726e-7*x_5 - 1.06186089731299e-6*x_50 + 8.86177042288738e-7*x_51 - 6.1401669538792e-7*x_52 + 4.91620853127857e-7*x_53 - 8.17200477030563e-8*x_54 - 2.32054937214992e-7*x_55 - 7.2113079854209e-7*x_56 - 2.24711261759353e-7*x_57 + 7.90966600680023e-8*x_58 - 1.13283457403533e-6*x_59 + 4.6198645637978e-7*x_6 + 1.38450500744724e-7*x_60 - 6.70927459462115e-7*x_61 - 3.29312013812287e-7*x_62 + 3.41837444615963e-8*x_63 + 5.90833679585474e-7*x_64 + 7.57629552313504e-7*x_65 - 1.30116875796415e-7*x_66 + 1.33154783794991e-7*x_67 + 1.37202801089487e-6*x_68 - 2.84016764248933e-7*x_69 - 1.15351216498899e-7*x_7 + 1.04599825098653e-6*x_70 - 3.21048078159794e-7*x_71 + 8.14722481420792e-7*x_72 - 8.79509801217266e-7*x_73 + 5.39861916274251e-8*x_74 - 7.07118673033335e-7*x_75 + 1.92981651081113e-6*x_76 + 1.57758542711879e-7*x_77 + 4.75250409369441e-7*x_78 + 1.05468747264794e-6*x_79 - 1.36354699559243e-6*x_8 + 1.9147414338398e-6*x_80 + 2.26613219556716e-8*x_81 + 1.20506664283141e-7*x_82 + 1.18966710175304e-6*x_83 + 2.95080924475166e-8*x_84 + 2.1101139125605e-7*x_85 - 4.86099307572117e-7*x_86 - 4.65094062768175e-9*x_87 + 9.13470649937376e-7*x_88 - 1.49057852623195e-7*x_89 - 1.23763303902505e-6*x_9 + 1.0064187683471e-6*x_90 - 1.38508873578499e-6*x_91 - 3.87743987056665e-6*x_92 - 2.45531350479898e-6*x_93 - 3.07491939808211e-7*x_94 - 2.47956787599499e-6*x_95 - 5.27813136608737e-7*x_96 - 2.22755953260563e-6*x_97 - 3.40234844701463e-7*x_98 - 1.34273033109228e-7*x_99 - 4.08790987962739e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) - 2.20466987023312e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 1.7024754827817e-9*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) - 2.6204540166737e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) + 9.82823052922933e-7*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 1.4251808542621e-6*std::sin(1.64135980606079*x_105 - 2.38775992393494) - 6.53167371326666e-7*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 7.93368250970113e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) - 1.12754980378672e-6*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 8.33665304182033e-7*std::sin(0.576479852199554*x_19 + 5.37559986114502) + 3.27770847633878e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 5.38015486194881e-6*std::sin(0.408479869365692*x_31 + 0.78743988275528) - 9.52507589007529e-6*std::sin(0.307919919490814*x_36 - 7.48960018157959) - 4.78551228417625e-6*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 7.97847946279226e-7*std::sin(0.364079833030701*x_39 + 5.18728017807007) - 6.45770968974976e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) + 4.18945435468383e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) - 4.00910254309439e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 3.9418826031828e-7*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 2.61010195423264e-6*std::sin(0.746719837188721*x_86 + 2.37591981887817) - 6.58331887137828e-8*std::sin(0.628639817237854*x_88 + 2.20039987564087) - 4.52759706115475e-6*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0590851753687222);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.21721005084661e-7*x_1 + 9.97570958715879e-8*x_10 - 2.40563440067934e-7*x_100 + 3.60615337742737e-7*x_101 + 4.01103635267249e-7*x_102 - 2.14462260623897e-7*x_103 - 1.87203311445677e-7*x_104 - 1.16327623350153e-7*x_105 - 1.74181219945926e-7*x_106 + 2.3940927997888e-8*x_107 + 5.3200533209034e-7*x_108 + 1.53586589443e-7*x_109 - 1.50339015969641e-7*x_11 - 6.40493360840024e-8*x_110 + 8.64279449777372e-7*x_111 + 5.27273266613115e-8*x_112 + 2.19935280444786e-7*x_113 - 2.71259000183828e-9*x_114 - 4.95549858150748e-7*x_115 - 9.59443495014158e-8*x_116 + 3.7018417401261e-7*x_117 + 8.70825956804273e-8*x_118 - 8.3377491794376e-8*x_119 - 3.640152371307e-7*x_12 + 1.74566702459892e-7*x_120 + 2.77817769372371e-7*x_13 - 1.25794381039286e-6*x_14 - 1.42674684429402e-7*x_15 + 4.46392876020184e-7*x_16 + 1.85057884435325e-8*x_17 - 1.33543188977531e-7*x_18 - 1.07348972806974e-9*x_19 - 1.75339499357521e-7*x_2 - 2.91624379177669e-7*x_20 - 2.68557459657152e-7*x_21 + 9.77227721569314e-7*x_22 - 2.21182921815783e-7*x_23 - 3.89828475244134e-8*x_24 + 2.57010664242104e-7*x_25 + 3.00226541392484e-7*x_26 + 1.36524945162836e-8*x_27 - 1.38878186390905e-7*x_28 - 5.73918832119036e-8*x_29 - 1.03480770563575e-7*x_3 + 1.3817383030615e-7*x_30 - 1.10553107919711e-6*x_31 + 5.51597400006046e-7*x_32 - 3.89286774724273e-7*x_33 - 1.12884326103911e-8*x_34 + 3.35667274985518e-7*x_35 + 3.18445679611058e-7*x_36 - 4.86508363785453e-8*x_37 + 1.22118580416517e-7*x_38 + 3.7018954938505e-7*x_39 - 2.37094702967856e-7*x_4 + 2.07329217071961e-7*x_40 + 6.84179732798567e-7*x_41 - 6.24706451686254e-8*x_42 + 2.50216352765564e-7*x_43 - 3.9789753313872e-8*x_44 + 2.32568429085222e-7*x_45 - 2.37038468659444e-7*x_46 + 2.84212887868681e-7*x_47 + 1.39626069419747e-7*x_48 + 1.0165400747596e-7*x_49 + 1.79232858530702e-8*x_5 - 4.60191660640024e-8*x_50 + 1.41471352876814e-7*x_51 + 6.90961509402427e-7*x_52 + 3.77227677541008e-8*x_53 - 1.04676420216032e-8*x_54 - 1.81714216030655e-7*x_55 - 4.05880026717259e-8*x_56 + 2.27227710968557e-7*x_57 + 2.6464352357353e-8*x_58 - 1.10792539316525e-6*x_59 - 1.76816930609608e-7*x_6 - 1.19064001930964e-7*x_60 - 4.25809362279729e-7*x_61 + 6.21183343042906e-11*x_62 + 6.5060081782677e-7*x_63 - 2.92464943090359e-7*x_64 - 3.82972172378868e-7*x_65 - 2.38482581106073e-8*x_66 - 1.22239907989722e-7*x_67 - 1.05258947418905e-6*x_68 + 1.36627744581288e-7*x_69 - 2.15339481201814e-7*x_7 - 7.44678874901299e-7*x_70 + 1.54146122385241e-7*x_71 - 8.32546639525508e-7*x_72 - 4.71745474265934e-8*x_73 + 2.44317503631433e-7*x_74 + 1.53006424827578e-8*x_75 - 8.52409593415188e-8*x_76 - 2.47717193229956e-8*x_77 - 2.0461603543563e-7*x_78 + 6.17069534396456e-8*x_79 - 7.75070275689667e-7*x_8 - 1.15104847648359e-6*x_80 + 2.21848291895395e-8*x_81 + 4.90036682504845e-7*x_82 - 8.51822173798284e-7*x_83 + 2.29189851060535e-7*x_84 + 1.00824638305647e-7*x_85 + 9.44048088348876e-8*x_86 - 4.03744876222319e-8*x_87 - 2.65258096836451e-7*x_88 + 1.26371758113122e-7*x_89 - 2.13999683199383e-7*x_9 - 8.6225993874436e-7*x_90 - 1.27033879619743e-6*x_91 - 8.5542721715489e-8*x_92 + 3.54453942971164e-7*x_93 + 1.92159801192673e-8*x_94 + 1.78256444985639e-6*x_95 + 6.49391601394124e-9*x_96 + 2.01981926978383e-7*x_97 + 2.40938435373065e-7*x_98 + 7.41137327375572e-8*x_99 + 3.52502700461726e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 7.96691864934171e-11*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) + 4.18982057034954e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 5.95949022681452e-5*std::pow(0.0857953521381289*x_1 + 0.00475600799323423*x_10 - 0.0122895128379514*x_100 - 0.00537354627374569*x_101 + 0.000354092600750099*x_102 - 0.00114200961925195*x_103 + 0.0126036273024469*x_104 + 0.000288347686018168*x_105 + 0.00746256426817525*x_106 + 0.00237771260001378*x_107 + 0.000616434159634544*x_108 - 0.0126900379727233*x_109 + 0.00488212049210754*x_11 + 0.0185594281107145*x_110 - 0.00614709986492424*x_111 + 0.000582108114073575*x_112 - 0.00832593729531076*x_113 - 0.00553297434361511*x_114 + 0.00219700956060572*x_115 - 0.000425425841328402*x_116 + 0.00113800415054904*x_117 + 0.00101166538313295*x_118 + 0.00418898190998717*x_119 - 0.00147756476676578*x_12 + 0.0152361012236514*x_120 + 0.00331336061647318*x_13 - 0.00165839800021796*x_14 - 0.00074620777419674*x_15 + 0.000636458314593737*x_16 + 0.000588935429468265*x_17 + 1.6420996320355e-5*x_18 - 0.00378030023252666*x_19 + 0.00780187807419352*x_2 - 0.00441406708840638*x_20 + 0.00302054462003338*x_21 + 0.00860652395181984*x_22 - 0.00172617011552595*x_23 - 0.00221198203799817*x_24 - 0.0107160102829641*x_25 + 0.00514311490353218*x_26 - 0.000485665388526541*x_27 + 0.00268528753891338*x_28 - 0.00506791626795438*x_29 - 0.00429555390390238*x_3 + 0.000250242693041762*x_30 - 0.358553768339127*x_31 - 0.00392982565814333*x_32 + 0.0264661014004574*x_33 - 0.124777550949918*x_34 + 0.00709266838771672*x_35 + 0.00246951196806682*x_38 - 0.00536817583233975*x_39 + 0.0208289374646718*x_4 - 0.00293659039785141*x_40 + 0.00624917661957798*x_41 - 0.0055574559188125*x_42 - 0.00670643730765281*x_43 + 0.00116724380585253*x_44 + 0.0017786245954711*x_45 + 0.00125816810077742*x_46 - 0.00685754012404285*x_47 + 0.00412718689205071*x_48 + 0.00729595796956733*x_49 + 0.0010519819844703*x_5 + 0.015305606235133*x_50 + 0.000202296596904165*x_51 + 0.0114390059448898*x_52 - 0.0139005239856799*x_53 - 0.0185355070804887*x_54 - 0.00759292823505703*x_55 - 0.00180908368184142*x_56 - 0.00359462000840895*x_57 + 0.00109545039265183*x_58 - 0.00302457549830454*x_59 + 0.000590734422617825*x_6 + 8.15365573057494e-5*x_60 - 0.0124841151504778*x_61 - 0.0077516979603784*x_62 + 0.000404292734870439*x_63 - 0.0503624410101133*x_64 - 0.00399768057219438*x_65 - 0.00287748878263425*x_66 + 0.000253585369475374*x_67 + 0.00278763459605129*x_68 + 0.00545156760753591*x_69 - 0.00378383665952124*x_7 + 0.0131462485922073*x_70 + 0.00925825085767314*x_71 + 0.00376089721200008*x_72 - 0.00187598262233897*x_73 - 0.00259673687980679*x_74 + 0.0792440545065734*x_75 - 0.000546398448922669*x_76 - 0.00355102845504528*x_77 - 0.00454043610731423*x_78 + 0.000399430486653383*x_79 + 0.00604336197471941*x_8 - 0.00398957899713439*x_80 + 0.0168111796689131*x_81 + 0.00259467021504599*x_82 - 0.0101571181782882*x_83 - 0.0036087281199826*x_84 - 0.000280842383262614*x_85 + 0.0034195526049429*x_86 + 0.00701689823998618*x_87 - 0.0112404221343782*x_88 + 0.00360096851733695*x_89 - 0.00412551354387981*x_9 - 0.00360367258221524*x_90 + 0.315376327769695*x_91 + 0.238159574787834*x_92 + 0.0144049580758915*x_94 + 0.0232864380360714*x_95 + 0.00289155697415241*x_96 + 0.222828779744628*x_97 + 0.0239346603947513*x_98 + 0.00548498243440767*x_99 + 1.25667785631413*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 0.631370016160155*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 0.597342324064268*std::sin(0.358159840106964*x_93 + 1.97975981235504) - 0.649378291391836, 2) + 0.000135903977700376*std::exp(-7.3936655220124e-5*x_1 + 0.00218472565922245*x_10 - 0.00247174208911872*x_100 + 0.000622600679755934*x_101 + 0.00684453833022689*x_102 - 0.00294248387333849*x_103 - 0.000671085999803423*x_104 - 0.000132032959111868*x_105 + 0.00426834779277715*x_106 + 0.00115620441933831*x_107 - 0.00174297102390033*x_108 - 0.00132984919451146*x_109 - 0.000815943120733012*x_11 + 0.00187614895958643*x_110 + 0.00236480358459591*x_111 + 0.000385252684253402*x_112 - 0.000410872893439974*x_113 + 0.000805796621529356*x_114 + 0.000184364607158212*x_116 - 0.000182701222213086*x_117 - 0.00403499465052763*x_118 - 0.00146189902152999*x_119 + 0.000141389785410055*x_12 - 0.000729980210037185*x_120 + 0.00116171121578428*x_13 + 0.00641817336316823*x_14 + 0.000412520460642823*x_15 + 0.000825226830477408*x_16 + 0.000425326856864425*x_17 + 0.000124021902035032*x_18 - 9.12578169009145e-5*x_19 + 0.000157623148865302*x_2 + 0.00132512067713203*x_20 + 0.00376995791050599*x_21 + 0.000813481169491792*x_22 + 0.000265942563059863*x_23 + 0.000334236804456662*x_24 + 0.000935602044549556*x_25 - 0.00227139925100037*x_26 - 0.000117077336129068*x_27 + 0.00143147472763776*x_28 + 2.96318356980443e-5*x_29 + 0.000746804275608623*x_3 + 0.00313829467228459*x_30 - 0.000771331862622847*x_31 - 0.000178500488082193*x_32 - 0.00354717538394891*x_33 + 0.000361541412355613*x_34 - 0.002097955902496*x_35 - 0.000472949229245402*x_36 - 2.65425257637453e-5*x_37 + 0.00124455739796473*x_38 - 0.00362747559518599*x_39 - 0.000178035995523002*x_4 + 0.0005111490938759*x_40 - 0.00194470151710742*x_41 - 0.00034167579825742*x_43 + 0.000577632134824398*x_44 + 0.00285298395483607*x_45 + 0.00112505079840369*x_46 - 0.00100471616858654*x_47 - 0.00261399738538461*x_48 - 0.00133771212496563*x_49 + 0.00197324273055388*x_5 + 0.000663670358211336*x_50 - 0.0012278314143605*x_51 + 0.00054117444167399*x_52 - 0.000593591368166862*x_53 + 8.67217385906101e-6*x_54 + 0.00200338525031796*x_55 + 0.0014787128654395*x_56 - 0.000685042360697672*x_57 - 0.000216710274086439*x_58 + 0.00500848013319815*x_59 - 0.000213638897221687*x_6 + 0.00129758885119986*x_60 + 0.00213762077171873*x_61 + 0.00163657998242237*x_62 + 0.00219916127655916*x_63 + 0.000341876491537856*x_64 + 0.000379317834466982*x_66 + 0.000476523695301883*x_67 + 0.000189528675017545*x_68 + 0.000197259158781542*x_69 + 0.0012832136783613*x_7 - 0.00170428903197339*x_70 - 0.000433061385910557*x_71 - 0.000319263834737083*x_72 + 0.00115933861818441*x_73 - 0.000987864999934088*x_74 - 0.000252954924359847*x_75 - 0.00484084346928492*x_76 - 0.000535168003263174*x_78 + 0.000218955198867597*x_79 + 0.0122839417294539*x_8 + 7.08878387868458e-5*x_81 + 0.000149779692900403*x_82 - 5.9579080747106e-5*x_83 - 0.000731130179094764*x_84 - 0.00119871382834615*x_85 + 0.00100580210934728*x_86 - 0.000844282885536277*x_87 - 0.000893640236163195*x_88 + 0.000420986561919228*x_89 + 0.00298206780813237*x_9 + 0.00114350309209237*x_90 - 0.00174238662586492*x_91 + 0.000478713915317659*x_92 + 0.00675940214729617*x_93 - 3.50199478158056e-5*x_94 - 0.0005316783437657*x_95 + 0.000575355335069395*x_96 + 0.000216927461031091*x_97 - 0.000485953838156399*x_98 - 6.74802963478844e-6*x_99 + 1.21419035511674e-5*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) + 0.0235646114212174*std::sin(0.675279796123505*x_115 - 7.78480005264282) + 0.00191806792525298*std::sin(1.60583984851837*x_42 + 8.61007976531982) - 0.0012443510792666*std::sin(1.35583984851837*x_77 - 6.99119997024536) + 0.00119078301230625*std::sin(1.34311985969543*x_80 + 2.59823989868164)) - 7.63338243403161e-7*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 6.66928836352669e-8*std::sin(1.64135980606079*x_105 - 2.38775992393494) + 1.04434348813318e-6*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 5.27649158575392e-8*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 3.90122719908126e-8*std::sin(0.576479852199554*x_19 + 5.37559986114502) - 2.54572806699548e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 2.51770181359507e-7*std::sin(0.408479869365692*x_31 + 0.78743988275528) + 3.73361598850466e-8*std::sin(0.364079833030701*x_39 + 5.18728017807007) - 1.84464671253298e-8*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 1.22142551514944e-7*std::sin(0.746719837188721*x_86 + 2.37591981887817) + 1.05260098643073e-7*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 0.0275186110180862);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.20523478837476e-6*x_1 - 7.25570453741781e-7*x_10 + 7.16767367005281e-7*x_100 - 1.82040172205234e-6*x_101 - 5.41791306985673e-7*x_102 - 1.19594024822659e-6*x_103 + 2.04109350261189e-6*x_104 - 1.00463200536304e-6*x_105 + 1.4713226989696e-6*x_106 + 5.19647241098542e-7*x_107 - 8.1947251410641e-7*x_108 + 5.13619514433472e-7*x_109 + 3.74169412188172e-7*x_11 + 1.4073449131484e-7*x_110 + 9.82759570941692e-7*x_111 - 7.96458867014208e-7*x_112 - 1.51704436053277e-7*x_113 - 2.11726288417142e-6*x_114 - 3.77500226874893e-8*x_115 + 1.43793260058301e-6*x_116 - 3.95993265845978e-6*x_117 + 5.9850947815678e-7*x_118 + 2.51008444021954e-6*x_119 + 2.00488823481066e-7*x_12 - 6.73957267451963e-7*x_120 - 2.02270524381003e-6*x_13 - 1.06775234809956e-6*x_14 - 3.27949279820713e-8*x_15 - 2.57238385590886e-6*x_16 + 4.08466087261482e-7*x_17 + 2.0547193590494e-7*x_18 - 1.47965081660546e-7*x_19 - 1.35472386761366e-7*x_2 - 2.0596763856085e-7*x_20 + 2.05098617101928e-6*x_21 + 1.79730819684717e-6*x_22 + 4.57329322950511e-7*x_23 - 4.15445872722113e-7*x_24 - 1.18501010168466e-6*x_25 - 1.52602827496247e-6*x_26 - 5.21077039554578e-7*x_27 + 1.83985158767736e-7*x_28 + 4.79065379027123e-7*x_29 - 1.3426255186057e-7*x_3 - 1.69662121273307e-6*x_30 - 2.54991531511862e-5*x_31 - 4.54781042949321e-6*x_32 + 1.78862394542579e-6*x_33 - 5.72219138917772e-6*x_34 + 1.0544192503347e-6*x_35 - 1.01254982120089e-6*x_36 - 2.0362252338564e-7*x_37 + 6.74821485638104e-7*x_38 - 2.26431801314175e-6*x_39 + 6.80292434004894e-7*x_4 + 5.17946933211022e-7*x_40 - 1.82359854703477e-6*x_41 - 5.0188252711886e-7*x_42 - 4.10123747266387e-6*x_43 - 4.93648206894675e-7*x_44 - 5.40192130230032e-7*x_45 + 2.37662415733004e-7*x_46 - 1.92454392587905e-6*x_47 + 1.10447691197466e-6*x_48 + 1.98155251199324e-7*x_49 - 2.70594027769861e-7*x_5 + 1.11572526478813e-6*x_50 + 1.42155133005495e-6*x_51 - 5.73442785113226e-6*x_52 - 6.87380170157051e-7*x_53 + 1.18361615111679e-6*x_54 - 7.97492002472942e-7*x_55 - 5.97575588606185e-7*x_56 + 1.19844906999325e-6*x_57 + 3.38650123951102e-6*x_58 + 2.88832006832281e-7*x_59 + 5.37662917811843e-7*x_6 - 6.21060905586783e-7*x_60 + 1.79564930991614e-6*x_61 - 3.09504582458365e-8*x_62 + 4.12105758773651e-7*x_63 - 1.96078354661645e-6*x_64 - 2.22313130135455e-7*x_65 - 1.44114586837036e-7*x_66 + 4.72472397406015e-7*x_67 - 3.24826217892664e-6*x_68 + 2.08925610450906e-7*x_69 - 4.60047743018658e-7*x_7 + 2.97718976545777e-7*x_70 + 8.89048129328942e-7*x_71 - 5.77784878488764e-7*x_72 - 2.79804376088637e-6*x_73 + 3.29987372451167e-6*x_74 + 3.06827134053014e-6*x_75 + 1.00068960611471e-6*x_76 - 1.05212995254841e-7*x_77 - 1.99978986755856e-8*x_78 - 1.29537968351699e-6*x_79 + 4.14120001896952e-6*x_8 - 2.24674296498331e-7*x_80 + 5.66554065956884e-7*x_81 - 3.99780165881499e-6*x_82 - 8.18710510109507e-7*x_83 - 6.38713190006787e-7*x_84 + 1.00338512921068e-7*x_85 + 1.58750051024059e-8*x_86 + 7.15398017487848e-7*x_87 - 3.4882715755086e-7*x_88 + 2.02874577418897e-7*x_89 - 1.0290026358768e-6*x_9 - 2.31431530728315e-6*x_90 + 2.85094317115629e-5*x_91 + 1.01392669108279e-5*x_92 + 1.21291153448584e-6*x_93 + 1.47968086543654e-6*x_94 + 2.32377879486729e-6*x_95 - 1.71867763899871e-6*x_96 + 9.44991482729783e-6*x_97 - 1.76115519004517e-6*x_98 - 3.31360009553964e-7*x_99 - 2.27549820643785e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) - 3.12413910392736e-9*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 1.33382967943368e-9*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) - 3.71332822844274e-9*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 3.75580807381416e-7*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 1.11657908804035e-6*std::sin(1.64135980606079*x_105 - 2.38775992393494) - 9.25574279270807e-6*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 4.41621289433069e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) - 8.83395625100576e-7*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 6.53147453034238e-7*std::sin(0.576479852199554*x_19 + 5.37559986114502) - 1.25255954491817e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 4.21516216086202e-6*std::sin(0.408479869365692*x_31 + 0.78743988275528) + 5.80358376814361e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 2.91579004043795e-5*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 6.25085812503824e-7*std::sin(0.364079833030701*x_39 + 5.18728017807007) - 3.59462592117156e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) + 2.33202202366194e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) - 2.23163081253353e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 3.08832641770424e-7*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 2.04492310644908e-6*std::sin(0.746719837188721*x_86 + 2.37591981887817) - 9.32892683725074e-7*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 2.7586435127715e-5*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0260279915100095);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.3217307540911e-6*x_1 - 4.00244296450343e-7*x_10 + 1.30507072708251e-6*x_100 - 1.03452813799365e-8*x_101 - 3.848812612638e-7*x_102 - 7.79731080261985e-7*x_103 + 1.42274397065669e-7*x_104 - 4.46973949166329e-7*x_105 - 5.20413320633754e-7*x_106 + 5.51921285734123e-8*x_107 + 8.66801846691884e-7*x_108 + 1.38963313687811e-6*x_109 + 5.8367792472536e-9*x_11 - 6.94260249246759e-7*x_110 + 1.18380134967698e-6*x_111 - 1.89206454307064e-7*x_112 + 3.74431871308278e-7*x_113 - 8.29343709681986e-7*x_114 - 6.87047220273795e-7*x_115 + 9.1864285678755e-7*x_116 - 2.89977149809635e-7*x_117 + 1.10276895618939e-6*x_118 + 1.14288259755958e-6*x_119 - 2.32430185808992e-7*x_12 - 7.24558599463772e-7*x_120 - 3.08159520193968e-7*x_13 - 3.17436730778925e-6*x_14 - 1.96216218325351e-7*x_15 + 7.24568859286584e-8*x_16 + 2.07550636802929e-7*x_17 - 1.43278032983867e-7*x_18 - 4.60393654984084e-8*x_19 + 8.86863988808013e-8*x_2 - 8.02665142733244e-7*x_20 - 7.10653889995429e-8*x_21 + 1.41639042200108e-6*x_22 + 2.69904398205689e-7*x_23 - 1.19856228721608e-6*x_24 - 6.52289512811025e-7*x_25 + 1.0893373554653e-6*x_26 + 1.52167500890093e-7*x_27 - 3.24975357706912e-7*x_28 + 3.29635340261694e-7*x_29 - 4.63356791295115e-8*x_3 - 9.499166675734e-7*x_30 - 1.05111369269802e-5*x_31 - 3.33494937092524e-7*x_32 + 2.27037634619713e-7*x_33 - 2.19714943825203e-6*x_34 + 2.26901239054851e-6*x_35 + 9.51375699094958e-7*x_36 - 2.27542026542836e-7*x_37 + 5.63341109779064e-7*x_38 + 5.17196947087453e-7*x_39 + 2.27242472083754e-7*x_4 + 7.35406874178818e-8*x_40 + 5.2208452963147e-7*x_41 - 2.67627118000936e-7*x_42 - 1.18170807303487e-6*x_43 - 3.20364725197116e-7*x_44 - 3.1241255767975e-7*x_45 - 6.91103521197358e-7*x_46 + 3.64860716176419e-7*x_47 + 1.19276433637441e-6*x_48 + 2.77328709384614e-7*x_49 - 2.89831560848348e-7*x_5 - 4.17582343569098e-7*x_50 + 1.44721383056304e-6*x_51 - 4.94913389254463e-7*x_52 + 8.52367440923747e-8*x_53 + 1.59124428016313e-7*x_54 - 7.51557113449159e-7*x_55 - 7.40687746791503e-7*x_56 + 7.04741664911768e-7*x_57 + 1.27913618685489e-6*x_58 - 3.15335250124019e-6*x_59 + 8.2315068072641e-8*x_6 - 2.4322826711042e-7*x_60 - 8.96729736765977e-7*x_61 - 1.38910938169787e-7*x_62 + 2.17428227209222e-6*x_63 - 1.31831168573112e-6*x_64 - 4.84820054734435e-7*x_65 - 1.96116296265906e-7*x_66 + 1.46419618058423e-8*x_67 - 2.69537232005052e-6*x_68 + 2.64384163096476e-7*x_69 - 6.88380503943735e-7*x_7 - 1.09866274210601e-6*x_70 + 4.62837078158992e-7*x_71 - 1.72310925727136e-6*x_72 - 1.68759503432102e-6*x_73 + 1.67360273799427e-6*x_74 + 1.11758143609564e-6*x_75 + 1.106954047149e-6*x_76 + 1.63529545681367e-9*x_77 - 2.54837288015202e-7*x_78 + 6.33979332586789e-7*x_79 - 1.33412327586636e-7*x_8 - 1.54291689699732e-6*x_80 + 4.1893471397951e-7*x_81 + 6.33014662584235e-8*x_82 - 1.62298756896833e-6*x_83 + 2.86589207314471e-7*x_84 + 3.20464443392326e-7*x_85 + 4.96458516921468e-9*x_86 + 8.36146690970357e-8*x_87 - 2.61585689875768e-7*x_88 + 3.62051964828644e-7*x_89 - 1.60440049553339e-6*x_9 - 2.10835502306557e-6*x_90 + 7.62930057792879e-6*x_91 + 2.0176315274628e-6*x_92 + 1.65687677898115e-7*x_93 + 4.14274803308202e-7*x_94 + 3.54616474525411e-6*x_95 - 9.17047350524608e-7*x_96 + 3.76346519293694e-6*x_97 - 1.19975205576803e-7*x_98 + 1.34757976440456e-8*x_99 - 2.64083837840267e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) - 3.2634519849754e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 2.09497327199307e-9*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) - 3.87891447046732e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 1.31980633598121e-6*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 1.75374965903e-6*std::sin(1.64135980606079*x_105 - 2.38775992393494) - 9.66847863826335e-7*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 5.12525321511993e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) - 1.38750115679468e-6*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 1.0258629552748e-6*std::sin(0.576479852199554*x_19 + 5.37559986114502) - 4.40154552918331e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 6.62052449445555e-6*std::sin(0.408479869365692*x_31 + 0.78743988275528) + 2.22333133496945e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 1.11702830907378e-5*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 9.81788072412355e-7*std::sin(0.364079833030701*x_39 + 5.18728017807007) - 4.17175722739476e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) + 2.70643731642727e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) - 2.58992790215827e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 4.85066526861774e-7*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 3.21184879699992e-6*std::sin(0.746719837188721*x_86 + 2.37591981887817) - 9.7449261354734e-8*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 1.05682605937761e-5*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0203474313980179);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.80288101101655e-7*x_1 - 1.08012460456163e-7*x_10 - 1.62375444680729e-7*x_100 - 4.27908045530704e-7*x_101 - 1.89322873969867e-7*x_102 + 9.30150502887679e-8*x_103 + 3.90898370715725e-7*x_104 - 6.3618683010809e-8*x_105 + 3.89343376027065e-7*x_106 + 5.83261244769127e-8*x_107 - 4.83531897002724e-7*x_108 - 2.90566943940838e-7*x_109 + 9.2434103237256e-8*x_11 + 1.5127256960031e-7*x_110 - 2.78060988033521e-7*x_111 - 1.31464617358237e-7*x_112 - 1.3319217222335e-7*x_113 - 1.89595587112512e-7*x_114 + 2.54014777400253e-7*x_115 + 9.95725406098997e-9*x_116 - 8.27837232976673e-7*x_117 - 1.5747335431532e-7*x_118 + 1.9740618041148e-7*x_119 + 1.53196576288387e-7*x_12 + 4.10511886044308e-8*x_120 - 4.16044517950177e-7*x_13 + 7.92960921848418e-7*x_14 + 6.31098032375197e-8*x_15 - 6.65719431737355e-7*x_16 + 6.12415118587527e-9*x_17 + 1.02462729633449e-7*x_18 + 1.15996936769237e-9*x_19 - 8.90480396662412e-8*x_2 + 2.38447863642587e-7*x_20 + 4.02289144920995e-7*x_21 - 2.05404435857875e-7*x_22 + 2.46771749838892e-8*x_23 + 3.2898456848901e-7*x_24 - 3.55081741763799e-8*x_25 - 7.14938693962416e-7*x_26 - 1.6835022691737e-7*x_27 + 1.16829442124727e-7*x_28 + 1.89303912695396e-8*x_29 - 8.14796690008733e-9*x_3 - 1.44312170448147e-7*x_30 - 4.94187480869846e-7*x_31 - 9.36510506688212e-7*x_32 + 3.28650525900598e-7*x_33 - 2.89982420007205e-9*x_34 - 5.53535679105098e-7*x_35 - 5.73414478172596e-7*x_36 + 3.69701865311147e-8*x_37 - 9.32404299956044e-8*x_38 - 6.0735942056318e-7*x_39 + 4.58677226552367e-9*x_4 + 7.94597521706262e-8*x_40 - 6.21360330635589e-7*x_41 + 7.22365444101224e-9*x_42 - 5.01597081093507e-7*x_43 - 1.77846579507544e-8*x_44 - 1.0875135922185e-7*x_45 + 2.77708107268437e-7*x_46 - 5.30788192682082e-7*x_47 - 1.26217447103376e-7*x_48 - 5.62380774643755e-8*x_49 - 1.59908052853471e-8*x_5 + 3.21057201356711e-7*x_50 - 1.61085772549704e-7*x_51 - 1.24537358958002e-6*x_52 - 1.13876650094313e-7*x_53 + 2.96190380249282e-7*x_54 + 7.49332750378572e-8*x_55 + 9.60466968268091e-8*x_56 + 4.56814513091949e-8*x_57 + 3.25092187873136e-7*x_58 + 1.12816341512703e-6*x_59 + 1.08114568163935e-7*x_6 - 8.2511174407072e-8*x_60 + 7.52370438636484e-7*x_61 + 3.3933225711988e-8*x_62 - 7.66902091698827e-7*x_63 + 2.4315489614655e-7*x_64 + 1.60767651229415e-7*x_65 + 4.02493431319137e-8*x_66 + 9.74670964189007e-8*x_67 + 2.51738590365327e-7*x_68 - 8.23190088694322e-8*x_69 + 1.33744267902355e-7*x_7 + 4.86323592823357e-7*x_70 + 1.94273819541371e-9*x_71 + 5.16401618603642e-7*x_72 - 6.64011998323057e-8*x_73 + 1.88827302976287e-7*x_74 - 3.00753834647872e-8*x_75 - 2.88485664993966e-8*x_76 - 7.60105275141661e-9*x_77 + 1.31072575497561e-7*x_78 - 5.29884841373264e-7*x_79 + 7.05200771392269e-7*x_8 + 5.79748814616901e-7*x_80 - 9.38140188816259e-8*x_81 - 9.82749794410309e-7*x_82 + 4.81470347827735e-7*x_83 - 2.2681592191314e-7*x_84 - 6.41886966113452e-8*x_85 - 4.44707659650239e-8*x_86 + 1.27692713129395e-7*x_87 + 1.00334913067704e-7*x_88 - 1.14919438516382e-7*x_89 + 2.83214293725083e-7*x_9 + 2.51163748165739e-7*x_90 + 2.59538123304139e-6*x_91 + 5.66877722670769e-7*x_92 + 2.56156421646624e-8*x_93 + 1.30069756785742e-7*x_94 - 9.12650484782436e-7*x_95 - 9.91135697784435e-8*x_96 - 1.478347428525e-7*x_97 - 4.68005639238096e-7*x_98 - 1.08940333025053e-7*x_99 + 9.78685062389524e-11*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) - 6.22441063520854e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) - 4.34708997963154e-10*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) - 7.39828763965194e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 0.000205920208693142*std::exp(-0.08754663380654*x_1 - 0.00485308912182448*x_10 + 0.0125403702330251*x_100 + 0.00548323278763072*x_101 - 0.0003613204501051*x_102 + 0.00116532067820215*x_103 - 0.012860896500605*x_104 - 0.000294233529529123*x_105 - 0.00761489247333436*x_106 - 0.00242624721622994*x_107 - 0.000629017007267273*x_108 + 0.0129490710126168*x_109 - 0.00498177586862533*x_11 - 0.0189382689851497*x_110 + 0.00627257639761569*x_111 - 0.000593990287685604*x_112 + 0.00849588894180721*x_113 + 0.00564591515332426*x_114 - 0.00224185560963899*x_115 + 0.000434109767189412*x_116 - 0.00116123344861432*x_117 - 0.00103231581460615*x_118 - 0.00427448872411453*x_119 + 0.00150772528275459*x_12 - 0.0155471053061113*x_120 - 0.0033809939738038*x_13 + 0.00169224974095137*x_14 + 0.000761439601600078*x_15 - 0.00064944990156527*x_16 - 0.000600956964385974*x_17 - 1.67561868535973e-5*x_18 + 0.00385746490792371*x_19 - 0.00796113245930888*x_2 + 0.00450416841187455*x_20 - 0.00308220092529763*x_21 - 0.00878220302125587*x_22 + 0.00176140524195812*x_23 + 0.00225713370994148*x_24 + 0.0109347488497905*x_25 - 0.00524809777993074*x_26 + 0.000495578942940758*x_27 - 0.00274010047136385*x_28 + 0.00517136416619043*x_29 + 0.00438323609903417*x_3 - 0.000255350725470748*x_30 + 0.365872680447805*x_31 + 0.00401004249348049*x_32 - 0.0270063357728545*x_33 + 0.127324549501262*x_34 - 0.00723744616201304*x_35 - 0.00251992042180956*x_38 + 0.00547775272308842*x_39 - 0.0212541042766878*x_4 + 0.00299653300317004*x_40 - 0.0063767367750385*x_41 + 0.00567089645412203*x_42 + 0.00684333121186258*x_43 - 0.0011910699529434*x_44 - 0.00181493043921913*x_45 - 0.0012838502231274*x_46 + 0.00699751838638851*x_47 - 0.00421143232686771*x_48 - 0.00744488535464327*x_49 - 0.00107345537106979*x_5 - 0.0156180290757124*x_50 - 0.000206425938563254*x_51 - 0.011672502526195*x_52 + 0.0141842658461741*x_53 + 0.0189138596713435*x_54 + 0.00774791747044368*x_55 + 0.00184601126602488*x_56 + 0.00366799452076592*x_57 - 0.00111781107004862*x_58 + 0.00308631408312179*x_59 - 0.000602792679148603*x_6 - 8.32009071167393e-5*x_60 + 0.0127389448290618*x_61 + 0.00790992805325352*x_62 - 0.000412545285126431*x_63 + 0.0513904549703037*x_64 + 0.00407928248334424*x_65 + 0.00293622498722459*x_66 - 0.000258761633665356*x_67 - 0.00284453666877002*x_68 - 0.00556284671738572*x_69 + 0.00386107352157657*x_7 - 0.0134145939465202*x_70 - 0.00944723318135998*x_71 - 0.00383766582684941*x_72 + 0.00191427576870278*x_73 + 0.00264974228839782*x_74 - 0.0808616090305586*x_75 + 0.000557551705636459*x_76 + 0.00362351316292683*x_77 + 0.00463311691487743*x_78 - 0.000407583787171975*x_79 - 0.0061667209770213*x_8 + 0.00407101553639017*x_80 - 0.0171543347471874*x_81 - 0.00264763343822697*x_82 + 0.0103644484639764*x_83 + 0.0036823906115431*x_84 + 0.000286575026176986*x_85 - 0.00348935358648748*x_86 - 0.00716012937023447*x_87 + 0.011469865160586*x_88 - 0.00367447261745165*x_89 + 0.00420972482178851*x_9 + 0.00367723187855135*x_90 - 0.321813888403337*x_91 - 0.243020962812805*x_92 - 0.0146989966034323*x_94 - 0.0237617681214297*x_95 - 0.00295058034308557*x_96 - 0.227377230767161*x_97 - 0.0244232221984431*x_98 - 0.00559694361819615*x_99 - 1.28232955932617*std::sin(0.307919919490814*x_36 - 7.48960018157959) - 0.644257739186287*std::sin(0.353119850158691*x_37 + 1.94671976566315) - 0.609535463154316*std::sin(0.358159840106964*x_93 + 1.97975981235504)) + 4.25134501544339e-7*std::sin(0.759199857711792*x_1 + 6.63760042190552) + 3.63904765348089e-7*std::sin(1.64135980606079*x_105 - 2.38775992393494) - 1.84407742290551e-6*std::sin(0.381599843502045*x_110 + 5.17392015457153) + 1.89940013127033e-7*std::sin(0.675279796123505*x_115 - 7.78480005264282) + 2.87907843792735e-7*std::sin(1.28351986408234*x_13 - 8.60632038116455) - 2.12867564134014e-7*std::sin(0.576479852199554*x_19 + 5.37559986114502) + 1.41782079200498e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) + 1.37376529211625e-6*std::sin(0.408479869365692*x_31 + 0.78743988275528) - 2.03721982937052e-7*std::sin(0.364079833030701*x_39 + 5.18728017807007) + 1.54603799905253e-8*std::sin(1.60583984851837*x_42 + 8.61007976531982) - 1.00299578934591e-8*std::sin(1.35583984851837*x_77 - 6.99119997024536) + 9.59817825747169e-9*std::sin(1.34311985969543*x_80 + 2.59823989868164) + 1.00651777593775e-7*std::sin(1.44671988487244*x_84 + 7.00112009048462) + 6.66461759115758e-7*std::sin(0.746719837188721*x_86 + 2.37591981887817) - 1.85865832119542e-7*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 0.102154306517607);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.5109972737391e-6*x_1 + 4.28900923780553e-7*x_10 - 9.65536741962224e-7*x_100 - 2.0255152891376e-7*x_101 + 5.81000109574416e-7*x_102 - 4.0906903127972e-7*x_103 + 7.41215923610972e-7*x_104 - 9.80099944630924e-8*x_105 + 6.80316907447316e-7*x_106 + 2.48997846341038e-7*x_107 + 1.7098853126103e-7*x_108 - 7.41087794808247e-7*x_109 + 1.97792410556287e-7*x_11 + 1.21704145575013e-6*x_110 + 2.38166322884342e-7*x_111 + 4.49999750740891e-8*x_112 - 4.31460733864014e-7*x_113 - 4.03153768847784e-7*x_114 - 1.16579648441298e-7*x_115 + 1.57954031469896e-8*x_116 + 5.62608772880988e-8*x_117 - 8.52923460927097e-8*x_118 + 2.6293485852631e-7*x_119 - 2.5379501105728e-7*x_12 + 9.4068783291992e-7*x_120 + 3.10190485037642e-7*x_13 - 4.36001470946986e-7*x_14 - 9.57077669653065e-8*x_15 + 1.88241155005374e-7*x_16 + 9.11647327493415e-8*x_17 - 4.94013461290275e-8*x_18 - 2.46024924762313e-7*x_19 + 3.99798197727882e-7*x_2 - 3.57792721844378e-7*x_20 + 3.64651922015114e-7*x_21 + 1.15266955422482e-6*x_22 - 1.73903431182158e-7*x_23 - 1.71658197375827e-7*x_24 - 5.44328075067695e-7*x_25 + 2.78162144770701e-7*x_26 - 5.14320729516528e-8*x_27 + 1.84245108498728e-7*x_28 - 3.12086195420683e-7*x_29 - 2.78566179299211e-7*x_3 + 1.73249753727881e-7*x_30 - 2.39726160894584e-5*x_31 - 1.94855871148674e-7*x_32 + 1.32127421588059e-6*x_33 - 7.96193907155464e-6*x_34 + 5.58729436019998e-7*x_35 + 9.50145394196915e-8*x_36 - 3.75590261515853e-8*x_37 + 3.21591740281865e-7*x_38 - 4.55083699183449e-7*x_39 + 1.19190997218849e-6*x_4 - 2.64032183280902e-8*x_40 + 5.30027003526866e-7*x_41 - 3.99180910873206e-7*x_42 - 5.13426536224001e-7*x_43 + 5.90584328012344e-8*x_44 + 3.58047366356871e-7*x_45 + 2.82655201948919e-8*x_46 - 4.24240578549115e-7*x_47 + 2.38178466601579e-7*x_48 + 4.34639491326079e-7*x_49 + 1.70900486279408e-7*x_5 + 1.00340924902386e-6*x_50 + 9.5057165675583e-8*x_51 + 8.05262768864445e-7*x_52 - 9.02176153970427e-7*x_53 - 1.09085691235083e-6*x_54 - 4.87215764406004e-7*x_55 - 8.34171535202337e-8*x_56 - 8.65513329850952e-8*x_57 + 2.38926533674321e-7*x_58 - 4.67011345011769e-7*x_59 - 3.62814714568323e-8*x_6 - 9.48764929019449e-9*x_60 - 7.84209599804644e-7*x_61 - 3.8661575832539e-7*x_62 + 5.16773613554237e-7*x_63 - 3.33237178442989e-6*x_64 - 4.49080933611439e-7*x_65 - 1.76286125922002e-7*x_66 + 5.30514266645468e-9*x_67 - 5.13071267475317e-7*x_68 + 4.26736438278759e-7*x_69 - 2.94215251715238e-7*x_7 + 3.48225172022594e-7*x_70 + 6.66983323793701e-7*x_71 - 2.41235409163299e-7*x_72 - 2.21938751453469e-7*x_73 + 7.44086863814794e-8*x_74 + 5.0296020823153e-6*x_75 - 2.931352677175e-7*x_76 - 2.35537114887949e-7*x_77 - 4.14401369533048e-7*x_78 + 1.76193214566388e-8*x_79 + 8.89223040731498e-7*x_8 - 8.3644359292364e-7*x_80 + 1.08213111922205e-6*x_81 + 2.26623503065303e-7*x_82 - 1.10260336899308e-6*x_83 - 1.7803383732908e-7*x_84 - 2.83794986508313e-8*x_85 + 3.15251366996338e-7*x_86 + 3.97573905690428e-7*x_87 - 8.92238316674475e-7*x_88 + 3.21740602622628e-7*x_89 - 2.55373453056572e-7*x_9 - 7.09003628865564e-7*x_90 + 2.0109632666556e-5*x_91 + 1.51459969000096e-5*x_92 + 6.18692664324662e-7*x_93 + 9.67523019643457e-7*x_94 + 2.42437999014338e-6*x_95 + 1.23849277915004e-7*x_96 + 1.43194542649849e-5*x_97 + 1.4823262172263e-6*x_98 + 3.58741121228021e-7*x_99 + 5.59548118061333e-10*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) + 2.53377738797744e-11*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 1.28547207031975e-10*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) + 3.01162873558952e-11*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 4.06123352387265e-7*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 1.07609783626075e-7*std::sin(1.64135980606079*x_105 - 2.38775992393494) + 7.50670537288731e-8*std::sin(0.381599843502045*x_110 + 5.17392015457153) + 1.08595278475269e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) - 8.51368372303421e-8*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 6.29467781098163e-8*std::sin(0.576479852199554*x_19 + 5.37559986114502) - 1.35441873346376e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 4.06234267628334e-7*std::sin(0.408479869365692*x_31 + 0.78743988275528) + 8.0361900394295e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 4.03747818867622e-5*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 6.02423507226168e-8*std::sin(0.364079833030701*x_39 + 5.18728017807007) + 8.83923425487861e-8*std::sin(1.60583984851837*x_42 + 8.61007976531982) - 5.73447401947341e-8*std::sin(1.35583984851837*x_77 - 6.99119997024536) + 5.487610659626e-8*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 2.9763600369689e-8*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 1.97078501087776e-7*std::sin(0.746719837188721*x_86 + 2.37591981887817) + 7.56605998900854e-9*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 3.81987826924438e-5*std::sin(0.358159840106964*x_93 + 1.97975981235504) - 0.000286132257243261);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.14230006323989e-6*x_1 - 4.28866870446512e-7*x_10 + 1.01730263246076e-6*x_100 - 5.85482594283729e-7*x_101 - 9.10120185849989e-7*x_102 - 2.17015329005244e-7*x_103 + 5.60496801728967e-7*x_104 - 2.10822728035854e-7*x_105 - 8.87937034019797e-8*x_106 + 2.61499487989661e-8*x_107 - 5.40851466431865e-8*x_108 + 6.10066264343941e-7*x_109 + 2.51332555518123e-7*x_11 - 2.38421277460293e-7*x_110 - 2.54784319458991e-7*x_111 - 2.36026357806993e-7*x_112 - 7.16424980029745e-8*x_113 - 7.08248706186598e-7*x_114 + 1.2704627426734e-7*x_115 + 7.1358954696607e-7*x_116 - 8.58373283732262e-7*x_117 + 7.28998742663287e-7*x_118 + 1.01421573580453e-6*x_119 + 2.34238773629135e-7*x_12 - 4.88693027712098e-7*x_120 - 6.40915531510716e-7*x_13 - 8.40007390603657e-7*x_14 + 9.84585658204324e-9*x_15 - 6.54929924915607e-7*x_16 + 1.19433453590662e-7*x_17 + 6.72424630863033e-8*x_18 - 6.14159756343557e-8*x_19 + 2.61028191044026e-7*x_2 - 2.50947574191771e-7*x_20 + 2.87400954359439e-7*x_21 - 7.84128536965317e-10*x_22 + 3.83729719936963e-7*x_23 - 6.81914889690741e-7*x_24 - 8.28812247452967e-7*x_25 + 2.87360314346999e-7*x_26 + 2.45531951143666e-8*x_27 - 5.84342704471192e-8*x_28 + 2.4084539321965e-7*x_29 + 5.439708008223e-9*x_3 - 9.21865971174962e-7*x_30 - 9.49975995566512e-6*x_31 - 1.15059497272214e-6*x_32 + 9.94361370012312e-7*x_33 - 2.62249425511077e-6*x_34 + 1.13235970467999e-6*x_35 + 1.33714806064866e-7*x_36 - 9.32255910648746e-8*x_37 + 2.17839835188757e-7*x_38 - 1.85444393218283e-7*x_39 + 5.77880616395867e-7*x_4 - 1.59820265046206e-7*x_40 - 4.32524006228351e-7*x_41 - 1.69519545306798e-7*x_42 - 1.29107905314432e-6*x_43 - 1.92528014251833e-7*x_44 - 5.42799653514346e-7*x_45 - 1.55669468229638e-7*x_46 - 2.63615412145571e-7*x_47 + 7.40113026625759e-7*x_48 + 1.72515156270858e-7*x_49 - 2.66695823240086e-7*x_5 + 2.85394723542808e-9*x_50 + 8.24244029741869e-7*x_51 - 1.39570494597055e-6*x_52 - 1.30828771470902e-7*x_53 + 6.55237873800155e-8*x_54 - 4.32704033538415e-7*x_55 - 4.86407050695675e-7*x_56 + 2.65776143406189e-7*x_57 + 9.87784922789784e-7*x_58 - 8.13939849924161e-7*x_59 + 2.79536670541314e-7*x_6 - 1.18392884134411e-7*x_60 - 8.29788216363432e-8*x_61 - 1.97260047543102e-7*x_62 + 5.01569371583541e-7*x_63 - 9.86389026207607e-7*x_64 + 6.46169014612851e-8*x_65 - 1.31716454013486e-7*x_66 + 1.54362307096172e-7*x_67 - 7.05972941398688e-7*x_68 + 6.0402462024511e-8*x_69 - 2.80095343701654e-7*x_7 + 3.22454221675092e-7*x_70 + 2.63214075030887e-7*x_71 - 1.30222134331611e-7*x_72 - 1.1798985713616e-6*x_73 + 9.82444733209874e-7*x_74 + 1.45663342503849e-6*x_75 + 9.56040129183407e-7*x_76 - 9.93524042962862e-9*x_77 + 4.80948339676469e-8*x_78 + 1.65862844364821e-7*x_79 + 6.39225813659011e-7*x_8 + 2.45295723515028e-7*x_80 + 3.77531898517122e-7*x_81 - 7.88968783240456e-7*x_82 - 1.89524981778846e-7*x_83 - 1.25093745081162e-7*x_84 + 1.2749872561428e-7*x_85 - 1.02061021348214e-7*x_86 + 2.31981975773476e-7*x_87 + 3.97433791868722e-8*x_88 + 1.01371102341065e-7*x_89 - 8.98773863938283e-7*x_9 - 5.7372944673258e-7*x_90 + 1.03167573258468e-5*x_91 + 3.80908468438216e-6*x_92 - 4.07750316079249e-7*x_93 + 4.44827683657492e-7*x_94 + 5.71985204240435e-7*x_95 - 6.59670419825899e-7*x_96 + 4.31567183473976e-6*x_97 - 2.65255341214107e-7*x_98 - 5.46500687869375e-8*x_99 - 2.1019103147542e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) - 8.02279505532792e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) + 1.1837528350491e-9*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) - 9.53583382779254e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) + 0.000133817166730299*std::exp(0.000296526847954457*x_10 - 0.00222591898705347*x_100 + 0.00133847834849367*x_101 + 0.00318084634998089*x_102 - 0.00229656163026729*x_103 + 5.52751144470662e-5*x_104 - 0.00166860027158227*x_105 + 0.000301902763079014*x_106 + 0.000624543019593501*x_107 + 0.00288540160081946*x_108 + 0.000912909355571512*x_109 - 0.00105708242733452*x_11 - 0.000327753176216316*x_110 + 0.00759309881038265*x_111 - 0.000242482663220732*x_112 + 0.00165397943281121*x_113 - 0.00132734390144871*x_114 - 0.00375050637280016*x_115 - 0.000201449144725524*x_116 - 0.00083331525923927*x_117 + 0.000325563512612942*x_118 + 0.000735536724359679*x_119 - 0.00268801143727128*x_12 + 0.00105939836774613*x_120 + 0.000405723690457515*x_13 - 0.00899703908282875*x_14 - 0.00106859549865633*x_15 + 0.000981346533950086*x_16 + 0.000369296882434088*x_17 - 0.000800901494886886*x_18 - 0.00203437629072321*x_2 - 0.00183746319174367*x_20 - 0.000200239993894602*x_21 + 0.00878873283029773*x_22 - 0.00166602852832721*x_23 + 0.000504905772519382*x_24 + 0.00195717680811311*x_25 - 0.000290005578050816*x_26 - 0.000591354009464274*x_27 - 0.000794873617129601*x_28 - 0.00015418005074066*x_29 - 0.000882103374594211*x_3 + 0.00026329736302327*x_30 - 0.0151943968055897*x_31 + 0.000322009797435719*x_32 - 0.00247742449781563*x_33 - 7.23983465174101e-5*x_34 + 0.00156889783327095*x_35 + 0.000708759843852421*x_36 - 0.000414865861367194*x_37 + 0.00112684149291935*x_38 + 0.000470457874690557*x_39 - 0.00223982507062732*x_4 + 0.00239697328304433*x_40 + 0.00329521694016456*x_41 - 0.000642397676101957*x_42 - 0.000862791917428929*x_43 - 0.000608882480739985*x_44 + 0.00165835478592154*x_45 - 0.00116699412446372*x_46 + 0.000245332506530623*x_47 + 0.00112115708464809*x_48 + 0.000611565536073679*x_49 + 8.81490638193294e-5*x_5 + 0.000743325433100118*x_50 + 0.00132381625673347*x_51 - 0.000103181679632442*x_52 - 4.9672937748566e-5*x_53 + 0.00164395643268537*x_54 - 0.00148505089115226*x_55 - 0.000216466982833277*x_56 + 0.00271068236285708*x_57 + 0.00259729158045986*x_58 - 0.00614276792814288*x_59 - 0.00106105989824305*x_6 - 0.00150217286600858*x_60 - 0.000474012155293645*x_61 + 0.000330500888950189*x_62 + 0.00386028109459828*x_63 - 0.00173020635071811*x_64 - 0.00297343867600387*x_65 - 7.87580338439156e-5*x_66 - 0.000586048764777185*x_67 - 0.0101103597705916*x_68 + 0.00097443266737909*x_69 - 0.00158479323035405*x_7 - 0.00546568039711465*x_70 + 0.00155820651238874*x_71 - 0.00627456152065414*x_72 - 0.00170378022872865*x_73 + 0.00414029103234664*x_74 - 0.000216488480200771*x_75 - 0.00068328836037121*x_76 - 0.000219340744061538*x_77 - 0.00139650930135359*x_78 - 0.00155220934922212*x_79 - 0.00254335988958333*x_8 - 0.00862174986598047*x_80 - 0.000162485339934117*x_81 - 0.000241731274787261*x_82 - 0.00636507571285066*x_83 + 0.00114436539107702*x_84 + 0.000695447067396259*x_85 + 0.000710622129472227*x_86 + 0.00013313844468581*x_87 - 0.00205845643235313*x_88 + 0.00083277214917779*x_89 - 0.00127274138403951*x_9 - 0.0078323594277828*x_90 + 0.00207931617464092*x_91 + 0.000564431306214548*x_92 + 0.00414232866712057*x_93 + 0.000898606206082395*x_94 + 0.0137818182476535*x_95 - 0.000987345126475398*x_96 + 0.00102958096986457*x_97 - 0.000462603231856723*x_98 + 9.4796709205636e-5*x_99 - 0.00574594721105226*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 0.0191626965019287*std::sin(0.907839834690094*x_19 - 7.23472023010254)) - 9.90946356498451e-7*std::sin(1.64135980606079*x_105 - 2.38775992393494) - 2.37687647830331e-6*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 4.07931916117627e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) - 7.83999705364764e-7*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 5.79658078655629e-7*std::sin(0.576479852199554*x_19 + 5.37559986114502) - 3.74089003644803e-6*std::sin(0.408479869365692*x_31 + 0.78743988275528) + 2.64802279833455e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 1.33039839014958e-5*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 5.54753814605882e-7*std::sin(0.364079833030701*x_39 + 5.18728017807007) - 3.32040749582532e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) + 2.15412217504768e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) - 2.06138937412326e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 2.74084106005696e-7*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 1.81483705306685e-6*std::sin(0.746719837188721*x_86 + 2.37591981887817) - 2.39567015461394e-7*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 1.25869655821876e-5*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.059199243864818);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.71187336911846e-7*x_1 - 1.33841918272759e-7*x_10 + 6.40403487049797e-7*x_100 + 1.52585665033533e-7*x_101 + 4.49619802510971e-8*x_102 - 5.42634664870126e-7*x_103 - 4.28455420380505e-8*x_104 - 2.56720913055567e-7*x_105 - 2.95794223333553e-7*x_106 + 4.83301521893476e-8*x_107 + 6.21420792431156e-7*x_108 + 8.08673096568878e-7*x_109 - 5.96201935893908e-8*x_11 - 3.78497640441952e-7*x_110 + 9.08233157354949e-7*x_111 - 6.14756706091054e-8*x_112 + 2.61299266745846e-7*x_113 - 4.00088833188226e-7*x_114 - 5.13302143437611e-7*x_115 + 4.82566858369837e-7*x_116 + 5.53035887392759e-8*x_117 + 5.58541564003072e-7*x_118 + 5.38797352742945e-7*x_119 - 2.20053890754471e-7*x_12 - 3.8399429616186e-7*x_120 - 1.67470525298454e-8*x_13 - 1.97039317988833e-6*x_14 - 1.36362874829429e-7*x_15 + 2.59478974301223e-7*x_16 + 1.24052715229444e-7*x_17 - 1.18906316509671e-7*x_18 - 2.69334710276893e-8*x_19 + 3.25790352354447e-8*x_2 - 5.05640869514345e-7*x_20 - 8.22024585670541e-8*x_21 + 1.00942431085696e-6*x_22 + 1.05440672492287e-7*x_23 - 7.08956291306688e-7*x_24 - 2.77801529091028e-7*x_25 + 7.26801068380901e-7*x_26 + 1.12445983375817e-7*x_27 - 1.9397994467206e-7*x_28 + 1.65785918425203e-7*x_29 - 2.75260935658932e-8*x_3 - 3.9809753382573e-7*x_30 - 5.81275993015398e-6*x_31 + 8.62861016216457e-8*x_32 - 8.65152975585468e-8*x_33 - 1.17427083503298e-6*x_34 + 1.34929836086014e-6*x_35 + 6.68767918354489e-7*x_36 - 1.39979174310414e-7*x_37 + 3.71648402422197e-7*x_38 + 3.83300289503157e-7*x_39 + 7.10895339801535e-8*x_4 + 7.68792032079055e-8*x_40 + 4.82908627337249e-7*x_41 - 1.58043261960046e-7*x_42 - 5.1188735821418e-7*x_43 - 1.66505150062324e-7*x_44 - 4.6140578560393e-8*x_45 - 4.46243783931594e-7*x_46 + 3.25744994953739e-7*x_47 + 6.41509435515693e-7*x_48 + 1.5122509592468e-7*x_49 - 1.09851789879198e-7*x_5 - 2.79719357207522e-7*x_50 + 8.1565335786389e-7*x_51 + 9.32283022233341e-8*x_52 + 6.25526660841808e-8*x_53 + 3.44415636651636e-8*x_54 - 4.13445132008934e-7*x_55 - 3.95711088837645e-7*x_56 + 4.04391262321745e-7*x_57 + 6.37914983673912e-7*x_58 - 2.01846911001924e-6*x_59 - 1.28597977432827e-8*x_6 - 1.13275334818995e-7*x_60 - 6.54988645600203e-7*x_61 - 4.62543654463633e-8*x_62 + 1.48677226150124e-6*x_63 - 8.02501978760878e-7*x_64 - 3.64794066438966e-7*x_65 - 1.09906912823301e-7*x_66 - 2.27271785760108e-8*x_67 - 1.70675238249369e-6*x_68 + 1.87896156130234e-7*x_69 - 4.11444826086033e-7*x_7 - 8.62470733265602e-7*x_70 + 2.70607158982026e-7*x_71 - 1.19373609144695e-6*x_72 - 8.89327576902693e-7*x_73 + 9.0219534696913e-7*x_74 + 6.01591821614691e-7*x_75 + 4.88314247881613e-7*x_76 - 2.17257281567581e-9*x_77 - 2.11542668559269e-7*x_78 + 4.53839491687939e-7*x_79 - 8.84698126314072e-8*x_8 - 1.16078742574831e-6*x_80 + 2.47998876661542e-7*x_81 + 3.04257309084413e-7*x_82 - 1.13004179813074e-6*x_83 + 2.24626502953035e-7*x_84 + 1.79589780575803e-7*x_85 + 4.94155953121231e-8*x_86 - 3.24319590290405e-9*x_87 - 2.28293738366733e-7*x_88 + 2.49576238914008e-7*x_89 - 8.99228389026075e-7*x_9 - 1.33058842901459e-6*x_90 + 3.37317530667861e-6*x_91 + 9.64878909569652e-7*x_92 + 2.95441099986665e-7*x_93 + 2.03572748052515e-7*x_94 + 2.41548142912623e-6*x_95 - 4.67557198268588e-7*x_96 + 2.08998067085776e-6*x_97 + 5.07825736467091e-8*x_98 + 4.00130164438837e-8*x_99 - 1.19660888784204e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) + 1.22939679290596e-9*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) - 4.78040678010955e-5*std::exp(-0.00660170330338389*x_1 - 0.00126721561917822*x_10 + 3.50728693420623e-5*x_100 - 0.0037257201394281*x_101 + 0.000709004478113555*x_102 - 0.00247805306032232*x_103 + 0.00371216258343341*x_104 - 0.00218296513465684*x_105 + 0.00444681987793385*x_106 + 0.00127383622103687*x_107 - 0.00311789809158747*x_108 + 0.000202219940135759*x_109 + 0.000186757411513533*x_11 + 0.00293936494344706*x_111 - 0.00174600800739372*x_112 + 3.57892640659469e-5*x_113 - 0.00366684130557906*x_114 + 4.91825164020094e-5*x_115 + 0.00215566637039147*x_116 - 0.00974691214175695*x_117 - 0.000776563055859865*x_118 + 0.0040679972316243*x_119 + 0.000474864524407354*x_12 - 0.00174002664880728*x_120 - 0.00464014266059124*x_13 + 0.00149687121316051*x_14 + 0.000130118198456278*x_15 - 0.00631443497420017*x_16 + 0.000767548271297641*x_17 + 0.000594663794413581*x_18 + 2.22453858423997e-5*x_19 - 0.00155590230549887*x_2 + 0.000940369041272429*x_20 + 0.00540783557462273*x_21 + 0.0033704085406639*x_22 + 0.000561137469764748*x_23 + 0.00120749501935077*x_24 - 0.000479557889368236*x_25 - 0.00634645050097245*x_26 - 0.00163949608880092*x_27 + 0.000758647922576884*x_28 + 0.00108989674088011*x_29 + 2.61247231718949e-5*x_3 - 0.00231866001844481*x_30 - 0.0189199669073136*x_31 - 0.0104722082711659*x_32 + 0.000866643935330904*x_33 + 0.000113899337918778*x_34 - 0.00153702761888185*x_35 - 0.00396774486617102*x_36 - 0.000234450729972555*x_37 + 0.000956704898281428*x_38 - 0.00637610682802501*x_39 - 0.000955682639215144*x_4 + 0.00198509754281182*x_40 - 0.00551759204245506*x_41 - 0.000474375743444988*x_42 - 0.00801816277957111*x_43 - 0.000880205448065808*x_44 - 0.000324779511136444*x_45 + 0.00148884550608495*x_46 - 0.00487602116503278*x_47 + 0.000410082810738382*x_48 - 0.000624101900408047*x_49 - 4.78726638713889e-5*x_5 + 0.0023538269685719*x_50 + 0.00135271188637482*x_51 - 0.0145290474342677*x_52 - 0.000724715616459978*x_53 + 0.00466609729443952*x_54 - 0.000190208093106003*x_55 - 1.99769812716468e-5*x_56 + 0.00265748391166785*x_57 + 0.00684622889675072*x_58 + 0.00538617158148747*x_59 + 0.000922642904479659*x_6 - 0.00132011688829445*x_60 + 0.00718550143736468*x_61 + 0.001089497874348*x_62 - 0.00141898302032188*x_63 + 0.00128717802491065*x_64 - 3.63946395258242e-5*x_65 + 0.000233981268273223*x_66 + 0.00107757771822542*x_67 - 0.00610638537412753*x_68 - 0.000153534666217504*x_69 + 0.000112640220900781*x_7 + 3.19054308086318e-5*x_70 + 0.000941593412988394*x_71 - 0.000338454865563847*x_72 - 0.00435611620371029*x_73 + 0.00654116344196474*x_74 - 0.00110253457222446*x_75 + 5.72532773933803e-5*x_76 + 0.00040492061134642*x_78 - 0.0045781531280884*x_79 + 0.0110471647015866*x_8 + 0.000500140835019659*x_80 - 0.000743543479780829*x_81 - 0.0103719551579657*x_82 + 0.000129181493712828*x_83 - 0.00159901132353329*x_84 - 0.000241202859521706*x_85 + 0.000968342666089354*x_87 - 0.000163867365118353*x_89 + 0.000449663906540861*x_9 - 0.00356584593150166*x_90 + 0.0318670765160626*x_91 + 0.00152229968994779*x_92 + 0.00444138728083178*x_93 + 0.00196345504230231*x_94 + 0.000855394122406852*x_95 - 0.00322480098997659*x_96 - 0.0015854972701255*x_97 - 0.00646650829553361*x_98 - 0.00131280124304772*x_99 - 7.30473555285807e-6*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) - 8.68235370686228e-6*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 0.0216414030223593*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 0.00218125189920038*std::sin(0.628639817237854*x_88 + 2.20039987564087)) - 9.38282158663015e-7*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 1.02915594924046e-6*std::sin(1.64135980606079*x_105 - 2.38775992393494) - 2.32233960238151e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) - 8.14229706469662e-7*std::sin(1.28351986408234*x_13 - 8.60632038116455) + 6.02008934451002e-7*std::sin(0.576479852199554*x_19 + 5.37559986114502) - 3.12916488425956e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) - 3.88513385332869e-6*std::sin(0.408479869365692*x_31 + 0.78743988275528) + 1.19431798124153e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 6.00039667547338e-6*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 5.76144394619786e-7*std::sin(0.364079833030701*x_39 + 5.18728017807007) - 1.89029431601916e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) + 1.22633288493145e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) - 1.17354048318065e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 2.84652429910272e-7*std::sin(1.44671988487244*x_84 + 7.00112009048462) - 1.88481479125221e-6*std::sin(0.746719837188721*x_86 + 2.37591981887817) + 5.67700524841771e-6*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0620955151001647);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.84926071393651e-8*x_1 + 5.42621564781881e-7*x_10 + 2.09500490298431e-7*x_100 - 3.84750482232825e-7*x_101 + 6.57178324192855e-7*x_102 + 1.58228587656119e-7*x_103 - 2.45330583635607e-7*x_104 + 7.18283036160628e-7*x_105 + 1.13820169785355e-6*x_106 + 6.44885020666127e-8*x_107 - 1.7978219547025e-6*x_108 - 8.36025410606239e-7*x_109 + 2.2201827797315e-7*x_11 + 7.29075753493286e-7*x_110 - 2.68404643905629e-6*x_111 + 2.36611797501007e-7*x_112 - 8.64464274399425e-7*x_113 + 8.63379011572649e-7*x_114 + 1.67032521607169e-6*x_115 + 1.14081804871033e-7*x_116 + 3.73596337683893e-7*x_117 - 1.37415556335402e-6*x_118 - 8.0821484097351e-7*x_119 + 1.23099499848249e-6*x_12 - 6.58004745981664e-7*x_120 + 2.0329081117783e-7*x_13 + 5.95684255492779e-6*x_14 + 5.98833907578718e-7*x_15 - 1.51193018979092e-7*x_16 - 4.33689567433069e-8*x_17 + 3.90495206460232e-7*x_18 - 2.79763579753962e-8*x_19 + 9.55460921149947e-7*x_2 + 1.21895733000771e-6*x_20 + 1.19430375127019e-6*x_21 - 3.68037147278882e-6*x_22 + 8.06641814830474e-7*x_23 - 1.06320233284796e-7*x_24 - 5.71170822354559e-7*x_25 - 5.39209225275306e-7*x_26 + 2.31922794440269e-7*x_27 + 7.84580781056738e-7*x_28 + 6.26360222699008e-8*x_29 + 6.13375834397868e-7*x_3 + 8.59176230681434e-7*x_30 + 6.66598444509471e-6*x_31 - 1.32208136355206e-7*x_32 + 2.73688928012457e-8*x_33 + 1.39843682407549e-7*x_34 - 1.35742540841025e-6*x_35 - 4.51843424542613e-7*x_36 + 1.81029473562745e-7*x_37 - 1.38994880623829e-7*x_38 - 1.2750140649389e-6*x_39 + 9.4372291429702e-7*x_4 - 9.18391286655679e-7*x_40 - 2.01729208625955e-6*x_41 + 2.89681005271868e-7*x_42 + 3.44025354934841e-7*x_43 + 4.54226397093575e-7*x_44 + 1.34128698528441e-7*x_45 + 8.59427291753338e-7*x_46 - 3.92833621947291e-7*x_47 - 1.30552599902211e-6*x_48 - 6.71760010265122e-7*x_49 + 5.60771818093938e-7*x_5 - 1.282491346154e-7*x_50 - 9.89866667107957e-7*x_51 + 3.03164606181488e-7*x_52 - 1.59045829582372e-7*x_53 - 7.59045886254504e-7*x_54 + 1.27146997388622e-6*x_55 + 5.54337416124119e-7*x_56 - 1.433061484894e-6*x_57 - 1.27524601873106e-6*x_58 + 4.24987244526968e-6*x_59 + 3.97767642664087e-7*x_6 + 1.06575468408833e-6*x_60 + 8.25331876124097e-7*x_61 + 3.40110269136643e-7*x_62 - 1.07833379495958e-6*x_63 + 8.6813058452734e-7*x_64 + 1.32148442611719e-6*x_65 + 1.50399793537389e-7*x_66 + 3.95878391795912e-7*x_67 + 4.61011956791051e-6*x_68 - 3.73464761824772e-7*x_69 + 1.09735850478608e-6*x_7 + 1.92734353678615e-6*x_70 - 8.29501637513271e-7*x_71 + 2.71214161037301e-6*x_72 + 1.15799460106746e-6*x_73 - 2.1959092388656e-6*x_74 + 3.13113333612711e-8*x_75 - 1.17623001866752e-6*x_76 + 9.55909142117775e-8*x_77 + 4.56978063538031e-7*x_78 + 7.64492468196059e-7*x_79 + 4.75996717426292e-6*x_8 + 3.83374328153945e-6*x_80 + 9.48228131644109e-8*x_81 + 2.09344314025668e-7*x_82 + 2.82075114780435e-6*x_83 - 7.23204525861371e-7*x_84 - 6.72642542267552e-7*x_85 - 1.02838768841288e-8*x_86 - 3.17271981874776e-7*x_87 + 6.4156468741189e-7*x_88 - 2.46149082887114e-7*x_89 + 1.48647201804287e-6*x_9 + 3.86297884428165e-6*x_90 - 1.66052932964529e-6*x_91 - 7.04587051107644e-8*x_92 + 1.7514820356848e-7*x_93 - 4.21473295256775e-7*x_94 - 6.31273931586313e-6*x_95 + 6.46145503734993e-7*x_96 - 3.77064958645597e-7*x_97 + 1.04993441900389e-7*x_98 - 3.49143713357769e-8*x_99 + 3.70313756486958e-9*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) + 4.72193089685603e-11*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) - 4.13592591528971e-11*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) + 5.61245152944992e-11*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) - 5.11369653395377e-5*std::pow(0.0791141370555526*x_1 + 0.0043856393013954*x_10 - 0.0113324810584414*x_100 - 0.00495508749344638*x_101 + 0.000326518043786321*x_102 - 0.00105307692415316*x_103 + 0.0116221342176851*x_104 + 0.000265892939218494*x_105 + 0.00688142559689903*x_106 + 0.00219255094627213*x_107 + 0.000568430053326608*x_108 - 0.0117018157556815*x_109 + 0.00450193093342016*x_11 + 0.0171141338386232*x_110 - 0.00566840148199189*x_111 + 0.000536777109368601*x_112 - 0.00767756443538641*x_113 - 0.00510210028441721*x_114 + 0.00202591994972271*x_115 - 0.000392296289706248*x_116 + 0.00104938337675186*x_117 + 0.000932883096588735*x_118 + 0.00386276972692408*x_119 - 0.00136250109770705*x_12 + 0.0140496072381587*x_120 + 0.00305533644181679*x_13 - 0.00152925214958806*x_14 - 0.000688097695836408*x_15 + 0.000586894850082878*x_16 + 0.000543072755372681*x_17 + 1.51422299821756e-5*x_18 - 0.00348591366844379*x_19 + 0.00719431572771814*x_2 - 0.00407032665408677*x_20 + 0.00278532315674862*x_21 + 0.00793630072640694*x_22 - 0.00159174658880183*x_23 - 0.00203972646253451*x_24 - 0.00988151321822437*x_25 + 0.00474260070307084*x_26 - 0.000447844750950689*x_27 + 0.00247617383800849*x_28 - 0.00467325807537331*x_29 - 0.00396104254850207*x_3 + 0.000230755329060047*x_30 - 0.330631803043325*x_31 - 0.00362379497227575*x_32 + 0.0244050839741399*x_33 - 0.115060641646588*x_34 + 0.00654033493576664*x_35 + 0.00227720154335888*x_38 - 0.0049501352690327*x_39 + 0.0192069077430739*x_4 - 0.00270790677375618*x_40 + 0.00576252912593301*x_41 - 0.00512467538490032*x_42 - 0.00618418116004584*x_43 + 0.00107634602728581*x_44 + 0.00164011623601626*x_45 + 0.00116018969656507*x_46 - 0.00632351701714583*x_47 + 0.00380578692544895*x_48 + 0.00672779357355627*x_49 + 0.000970060088632329*x_5 + 0.0141136996262352*x_50 + 0.000186542980412051*x_51 + 0.0105482064185281*x_52 - 0.0128180365525691*x_53 - 0.0170920756313121*x_54 - 0.00700163761871563*x_55 - 0.00166820335581511*x_56 - 0.0033146930797608*x_57 + 0.00101014344416101*x_58 - 0.00278904013497706*x_59 + 0.000544731653984894*x_6 + 7.51869910078518e-5*x_60 - 0.011511928938086*x_61 - 0.00714804333296835*x_62 + 0.000372808899782921*x_63 - 0.0464405234226618*x_64 - 0.00368636576237501*x_65 - 0.00265340762933905*x_66 + 0.000233837698383217*x_67 + 0.00257055073493648*x_68 + 0.00502703300495613*x_69 - 0.00348917470022422*x_7 + 0.012122499494096*x_70 + 0.00853727514363944*x_71 + 0.00346802163598544*x_72 - 0.00172989261770978*x_73 - 0.00239451896036851*x_74 + 0.0730730142464738*x_75 - 0.000503848293616342*x_76 - 0.00327449616884044*x_77 - 0.00418685482994127*x_78 + 0.000368325293593823*x_79 + 0.00557274206153394*x_8 - 0.00367889508822206*x_80 + 0.0155020282479945*x_81 + 0.00239261323476614*x_82 - 0.00936614419803071*x_83 - 0.00332770253825497*x_84 - 0.00025897210334512*x_85 + 0.00315325885043946*x_86 + 0.00647046530177269*x_87 - 0.0103650870955077*x_88 + 0.00332054720580506*x_89 - 0.00380424388735616*x_9 - 0.00332304069471859*x_90 + 0.290816756356199*x_91 + 0.219613169843069*x_92 + 0.0132831884139921*x_94 + 0.0214730332635658*x_95 + 0.00266638027650645*x_96 + 0.205476242958428*x_97 + 0.0220707760462344*x_98 + 0.00505784569033987*x_99 + 1.15881550318772*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 0.582202797079752*std::sin(0.353119850158691*x_37 + 1.94671976566315) + 0.550824972651409*std::sin(0.358159840106964*x_93 + 1.97975981235504) - 1.00506350943601, 4) + 2.56353502259622e-6*std::sin(0.759199857711792*x_1 + 6.63760042190552) + 3.46227742409913e-8*std::sin(1.64135980606079*x_105 - 2.38775992393494) + 1.39894468243425e-7*std::sin(0.381599843502045*x_110 + 5.17392015457153) + 7.1869289183305e-6*std::sin(0.675279796123505*x_115 - 7.78480005264282) + 2.73922444195297e-8*std::sin(1.28351986408234*x_13 - 8.60632038116455) - 2.02527318079826e-8*std::sin(0.576479852199554*x_19 + 5.37559986114502) + 8.54937259353627e-6*std::sin(0.907839834690094*x_19 - 7.23472023010254) + 1.30703332569866e-7*std::sin(0.408479869365692*x_31 + 0.78743988275528) - 1.93825992259534e-8*std::sin(0.364079833030701*x_39 + 5.18728017807007) + 5.84988124476814e-7*std::sin(1.60583984851837*x_42 + 8.61007976531982) - 3.79512422092589e-7*std::sin(1.35583984851837*x_77 - 6.99119997024536) + 3.6317479264245e-7*std::sin(1.34311985969543*x_80 + 2.59823989868164) + 9.57625209785408e-9*std::sin(1.44671988487244*x_84 + 7.00112009048462) + 6.34087740072514e-8*std::sin(0.746719837188721*x_86 + 2.37591981887817) + 1.4100059697069e-8*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 0.0567388437510086);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.7345410861666e-7*x_1 - 2.28190108474967e-7*x_10 + 1.33641889659841e-6*x_100 - 1.01456172777253e-6*x_101 - 2.20138235648886e-6*x_102 + 1.47064801440073e-6*x_103 + 2.22451200487148e-7*x_104 + 1.01013074511858e-6*x_105 - 1.32401580188785e-7*x_106 - 3.72549355763422e-7*x_107 - 1.83112071609906e-6*x_108 - 6.8121165777908e-7*x_109 + 7.55289903952526e-7*x_11 + 3.69515819173992e-7*x_110 - 4.87150610139906e-6*x_111 + 1.07504095936588e-7*x_112 - 1.12948161341759e-6*x_113 + 6.61559698588683e-7*x_114 + 2.39430778504508e-6*x_115 + 1.66152541162209e-7*x_116 + 3.19706393660003e-7*x_117 - 8.48614566748646e-8*x_118 - 2.74258358655215e-7*x_119 + 1.68532953990752e-6*x_12 - 5.0413480182486e-7*x_120 - 3.60287155124061e-7*x_13 + 5.49167963960971e-6*x_14 + 6.5556529808251e-7*x_15 - 7.83698137736083e-7*x_16 - 2.21611121692629e-7*x_17 + 5.15516600000277e-7*x_18 - 4.17382673722004e-8*x_19 + 1.33606594247825e-6*x_2 + 1.08716355429351e-6*x_20 + 1.69349653653001e-7*x_21 - 5.39139763385392e-6*x_22 + 1.03547891190777e-6*x_23 - 3.2758563941397e-7*x_24 - 1.40348787790986e-6*x_25 + 1.68774125591559e-7*x_26 + 3.33146867850521e-7*x_27 + 5.06368193337585e-7*x_28 + 6.11104842723762e-8*x_29 + 4.82626396629909e-7*x_3 - 3.15211230157486e-7*x_30 + 4.89669296920255e-6*x_31 - 4.86812805643816e-7*x_32 + 2.01060552224855e-6*x_33 - 1.45209534954031e-6*x_34 - 8.75281629636456e-7*x_35 - 5.24272167501952e-7*x_36 + 2.57230293616985e-7*x_37 - 6.98562372604581e-7*x_38 - 3.94770215017126e-7*x_39 + 1.64559884676166e-6*x_4 - 1.51787527463335e-6*x_40 - 2.07173125337091e-6*x_41 + 3.28120583995302e-7*x_42 + 2.89675017417101e-7*x_43 + 3.59723150082099e-7*x_44 - 1.12231902382705e-6*x_45 + 7.50683398363648e-7*x_46 - 3.17983348973608e-7*x_47 - 5.66874599180647e-7*x_48 - 2.71393144572801e-7*x_49 - 1.06044961203952e-7*x_5 - 2.52804566258661e-7*x_50 - 7.63259376770676e-7*x_51 - 1.51485519808533e-7*x_52 - 1.32697669175303e-7*x_53 - 1.15102022789399e-6*x_54 + 7.79398306380073e-7*x_55 + 6.82037539077205e-8*x_56 - 1.67065359079614e-6*x_57 - 1.46089095257593e-6*x_58 + 3.80821845017413e-6*x_59 + 7.04730666659297e-7*x_6 + 8.7777503587515e-7*x_60 + 2.49398307947958e-7*x_61 - 3.271871621984e-7*x_62 - 2.53317842779181e-6*x_63 + 5.09977073427204e-7*x_64 + 1.82799207462583e-6*x_65 + 8.88654839068875e-9*x_66 + 3.82875053671739e-7*x_67 + 6.2667109392605e-6*x_68 - 5.59643719593742e-7*x_69 + 9.17387324060843e-7*x_7 + 3.66045377130527e-6*x_70 - 8.37537939444582e-7*x_71 + 4.0069468740222e-6*x_72 + 9.1574079214861e-7*x_73 - 2.46162547057082e-6*x_74 + 1.06474091982147e-6*x_75 + 5.77787509133216e-7*x_76 + 9.6048574716921e-8*x_77 + 8.53299903474721e-7*x_78 + 8.71582404309497e-7*x_79 + 1.54773357944687e-6*x_8 + 5.4051610120393e-6*x_80 + 2.83743024865972e-7*x_81 - 6.11439529769905e-8*x_82 + 3.90065224653684e-6*x_83 - 7.79351942321755e-7*x_84 - 4.10250597460845e-7*x_85 - 4.39197731996521e-7*x_86 + 4.85873355338908e-8*x_87 + 1.19296825276694e-6*x_88 - 4.99579309322627e-7*x_89 + 6.70912241240689e-7*x_9 + 4.78165981733626e-6*x_90 + 3.24333416320766e-6*x_91 + 2.50618015017978e-6*x_92 - 2.72337817074998e-6*x_93 - 3.48678864264803e-7*x_94 - 8.38337123036503e-6*x_95 + 5.64975205709469e-7*x_96 + 1.9659703130378e-6*x_97 + 4.43206928185864e-7*x_98 - 2.45309329492238e-8*x_99 - 3.80645350307877e-10*std::pow(-4.69719982147217*x_65 - 7.55855989456177, 2) - 1.69005520743359e-10*std::pow(-6.48256015777588*x_77 - 8.92399978637695, 2) - 2.00878690116601e-10*std::pow(-5.93991947174072*x_86 - 9.30655956268311, 2) + 0.000207723266635861*std::exp(-0.000579397946881111*x_1 + 0.000145133275317987*x_10 - 0.0104733790033245*x_100 - 0.000554627433276569*x_101 - 0.00234911163519846*x_102 + 0.00533472607737695*x_103 + 0.00283948375494393*x_104 - 5.5387551756084e-5*x_106 - 0.000450116316053103*x_107 + 0.000326964910639535*x_108 - 0.00775150033297297*x_109 + 0.000164975163307959*x_11 + 0.00377892836705798*x_110 + 0.000480058129816758*x_111 - 0.000126046083992665*x_112 - 0.000356428126516365*x_113 + 0.000613101467158725*x_114 - 0.000934456851994582*x_115 - 0.00642043889669081*x_116 - 0.00194113028751644*x_117 - 0.00117151118596574*x_118 - 0.00280382085961912*x_119 - 0.00294778979636944*x_12 + 0.00923919487698161*x_120 - 0.00175605525198578*x_14 - 0.00102549691512089*x_15 - 0.00208383632465013*x_16 - 0.00119492610498662*x_17 - 0.000285907495791134*x_18 - 0.00365599282876993*x_2 + 0.000394647455934089*x_20 - 0.00350263874741145*x_21 + 0.00510306529832858*x_22 - 0.0050165624277368*x_23 + 0.00880588801990873*x_24 + 0.00481644761733903*x_25 - 0.00598760236939339*x_26 - 0.00241315985961538*x_27 - 0.000613450379089459*x_28 - 0.00289031406272034*x_29 - 0.00275767647442112*x_3 + 0.00160232548088487*x_30 - 0.00063837462688662*x_32 + 0.00338022200618579*x_33 - 0.000704996731132377*x_34 - 0.0097790667890687*x_35 - 0.00604723256250827*x_36 + 0.000893788006947429*x_37 - 0.00342501236708041*x_38 - 0.00264306512050833*x_4 + 0.00282108971067961*x_40 + 0.00365669708275979*x_41 + 3.89752793637595e-6*x_42 + 0.00407113723672877*x_43 + 0.000253681125442642*x_44 + 0.000629025940021868*x_45 + 0.00187190419776674*x_46 - 0.00300724078237705*x_47 - 0.00192958863089164*x_48 + 0.00178894095384491*x_49 - 0.000719131648881229*x_5 + 0.00574553040161678*x_50 - 0.00569057918074277*x_51 - 0.000653148246294645*x_52 - 0.00172276569735609*x_53 + 0.00068059274874237*x_54 - 0.0011780474814827*x_55 + 0.00235765303926873*x_56 + 0.000854964362229114*x_57 - 0.00217355904370709*x_58 + 0.0058875379331297*x_59 - 0.00159696639147939*x_6 - 0.00309425838145278*x_60 + 0.00296464446255931*x_61 - 0.001608888590719*x_62 - 0.012768616179302*x_63 + 9.12641869461297e-5*x_64 - 0.00189559753775211*x_65 + 0.000385896448245388*x_66 - 0.00140336461520837*x_67 + 0.000759452760165608*x_68 + 4.29116863882733e-5*x_69 - 0.000116633018521995*x_7 + 0.00313877745980035*x_70 + 0.00136734014537315*x_71 + 0.00282217309600398*x_72 + 0.00572009672285397*x_73 - 0.00183213572221537*x_74 + 0.00168493190016985*x_75 - 0.00152857696169851*x_76 - 0.000804744478851865*x_77 - 8.25029787906219e-5*x_78 - 0.00865837318685117*x_79 - 0.0176730796603279*x_8 - 0.00340338243470471*x_80 - 0.00145381114392988*x_81 - 0.00398633356280658*x_82 + 0.000590363329211757*x_85 + 0.00208822312911764*x_87 - 0.0015117146108114*x_88 - 0.0014431471539673*x_89 + 0.00427849974087868*x_9 - 0.00113842491267698*x_90 + 0.00161618427850231*x_91 + 0.0160431932938789*x_92 - 0.0034052926261809*x_93 + 0.000997292133921986*x_94 + 0.00129826229708126*x_95 + 0.00330897024259105*x_96 + 0.00208348095258764*x_97 + 0.00177968076847152*x_98 + 0.000337453815627712*x_99 - 1.46803663955051e-5*std::pow(-5.52223968505859*x_83 - 7.98271989822388, 2) + 0.0122892677938842*std::sin(1.64135980606079*x_105 - 2.38775992393494) + 0.0097228091776822*std::sin(1.28351986408234*x_13 - 8.60632038116455) - 0.00718865689426301*std::sin(0.576479852199554*x_19 + 5.37559986114502) + 0.0463928235306599*std::sin(0.408479869365692*x_31 + 0.78743988275528) - 0.00687980549367015*std::sin(0.364079833030701*x_39 + 5.18728017807007) + 0.00339906691685445*std::sin(1.44671988487244*x_84 + 7.00112009048462) + 0.0225067869730211*std::sin(0.746719837188721*x_86 + 2.37591981887817)) + 3.62627699487685e-6*std::sin(0.759199857711792*x_1 + 6.63760042190552) - 5.00704859326453e-7*std::sin(0.381599843502045*x_110 + 5.17392015457153) - 7.38744113021378e-7*std::sin(0.675279796123505*x_115 - 7.78480005264282) + 1.20936101450931e-5*std::sin(0.907839834690094*x_19 - 7.23472023010254) + 1.49971107048057e-5*std::sin(0.307919919490814*x_36 - 7.48960018157959) + 7.53472815684111e-6*std::sin(0.353119850158691*x_37 + 1.94671976566315) - 6.01309040419801e-8*std::sin(1.60583984851837*x_42 + 8.61007976531982) + 3.90100654709845e-8*std::sin(1.35583984851837*x_77 - 6.99119997024536) - 3.73307212456323e-8*std::sin(1.34311985969543*x_80 + 2.59823989868164) - 5.04663872400643e-8*std::sin(0.628639817237854*x_88 + 2.20039987564087) + 7.12864392226422e-6*std::sin(0.358159840106964*x_93 + 1.97975981235504) + 0.0925582598555786);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
