
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.63605558872113e-6*x_1 + 3.19864031594656e-6*x_10 + 2.2947973355559e-7*x_100 + 7.2276115441069e-6*x_101 - 5.99648080432366e-6*x_102 - 9.11362085404092e-6*x_103 - 1.17098944546124e-6*x_104 + 7.7385814958773e-6*x_105 - 8.72405165422383e-6*x_106 + 4.45498743921356e-6*x_107 - 1.78625485264291e-6*x_108 - 8.52104448814312e-6*x_109 + 1.23968035035907e-7*x_11 + 5.44061719237689e-6*x_110 + 1.02274900457376e-6*x_111 + 6.56680280233958e-6*x_112 - 1.84580653719769e-7*x_113 + 4.3526344277143e-6*x_114 - 6.91685346590424e-6*x_115 + 1.74931444092564e-5*x_116 - 2.0842467224823e-6*x_117 + 5.77545668580075e-7*x_118 + 4.59085141018214e-6*x_119 + 3.14123368869618e-6*x_12 - 1.54787992090491e-5*x_120 - 2.51101133340038e-6*x_13 - 3.25993132830622e-6*x_14 - 1.91743096357896e-6*x_15 + 1.83592742431829e-6*x_16 + 2.160717637757e-7*x_17 - 3.03626599515633e-6*x_18 + 7.69773280629967e-6*x_19 - 9.33081867521357e-6*x_2 - 2.39862226620138e-6*x_20 - 6.31214386862767e-6*x_21 - 2.08476619564905e-6*x_22 - 1.09602981662807e-6*x_23 - 3.25903622323797e-6*x_24 - 8.60945597908481e-6*x_25 + 7.8724868250314e-6*x_26 + 2.44622840289453e-6*x_27 - 1.16705156099312e-6*x_28 - 8.30990435638893e-6*x_29 + 5.95959496736354e-7*x_3 - 4.42265693010257e-6*x_30 + 0.000306773807291884*x_31 + 4.42978902076082e-6*x_32 - 1.9574638818273e-5*x_33 + 1.66707535772798e-5*x_34 - 6.26325793672057e-6*x_35 + 1.22434471847591e-6*x_36 + 3.25403163349415e-6*x_37 - 3.77437511008754e-7*x_38 + 2.32279505495419e-6*x_39 - 5.56853152452802e-7*x_4 - 6.45045021902296e-7*x_40 - 1.53295599951375e-6*x_41 + 4.273262728104e-6*x_42 - 8.35347491961369e-7*x_43 + 5.5903721545672e-6*x_44 - 8.94041752466947e-6*x_45 - 1.14934090641827e-6*x_46 + 7.42001630413834e-6*x_47 - 1.07529943338898e-6*x_48 + 6.06660765486443e-6*x_49 - 1.25421817806993e-6*x_5 - 9.64851973576999e-6*x_50 + 1.43217118898751e-6*x_51 - 9.29725113484674e-6*x_52 - 7.15198243388665e-7*x_53 + 2.03356658627561e-5*x_54 + 1.52105159830232e-6*x_55 + 1.77199403212788e-5*x_56 - 3.33400071953265e-7*x_57 + 9.26957447693596e-6*x_58 - 4.9796625817974e-6*x_59 - 1.98937515611182e-6*x_6 - 8.59023748546039e-6*x_60 - 2.00179797925233e-5*x_61 + 4.29468454575887e-6*x_62 - 6.90508909846507e-6*x_63 + 7.51632766929207e-7*x_64 - 1.22840965901671e-6*x_65 - 2.50819244154777e-6*x_66 - 1.83151566090898e-5*x_67 - 2.68983253024456e-6*x_68 + 2.29968641580417e-9*x_69 + 1.03592283646808e-5*x_7 + 2.10412600846218e-6*x_70 + 8.7806632539077e-7*x_71 - 7.21323021361012e-6*x_72 + 2.25915322075177e-6*x_73 - 1.73258633782564e-5*x_74 - 2.80438501065358e-6*x_75 + 3.32498124835695e-6*x_76 + 5.37257867849222e-7*x_77 - 2.37814388703107e-6*x_78 - 1.24972355840123e-6*x_79 + 3.48778925470931e-5*x_8 - 9.07057535943182e-7*x_80 + 1.17595135037656e-6*x_81 + 3.70812029321321e-7*x_82 + 3.91949489030891e-6*x_83 - 7.65458957429807e-6*x_84 + 5.35287614877776e-7*x_85 - 5.75082918157104e-6*x_86 - 2.22107851231524e-7*x_87 + 1.84944123288784e-6*x_88 + 9.04271279068562e-7*x_89 - 1.65773359680873e-5*x_9 + 1.7486341112859e-6*x_90 + 3.23377090169044e-5*x_91 + 6.24528655597055e-6*x_92 + 1.05075915549543e-5*x_93 + 1.21788336700277e-5*x_94 - 1.9460712963314e-6*x_95 + 2.31789802677209e-6*x_96 - 1.17788320336489e-5*x_97 + 5.86298160711797e-6*x_98 - 1.72574513349516e-6*x_99 - 5.35303761881099e-9*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 2.12191794276079e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) + 4.49995712859225e-8*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) + 1.35742702254524e-6*std::exp(0.480159848928452*x_1) - 0.000123681537118857*std::exp(0.00608163364822121*x_1 - 7.23999497488427e-5*x_10 + 0.00390906963755613*x_100 + 0.000556314745629411*x_101 + 0.0122583495979441*x_102 + 0.00163883101578306*x_104 + 0.000966853628978219*x_105 - 0.003649593254432*x_106 + 0.000317330082154305*x_107 + 0.00137188063139624*x_108 + 0.000928591532295584*x_109 - 0.00343846558247887*x_11 - 0.00383382625178143*x_110 - 0.00254940636258295*x_111 + 0.00129257075053122*x_112 + 0.0112299947317448*x_113 + 0.00030355832918411*x_114 - 0.000547986323432676*x_115 + 0.000770397176117369*x_116 + 0.0049726449448899*x_117 - 6.76802821268212e-5*x_118 + 0.00205058748886973*x_119 + 6.87698301704404e-5*x_12 - 0.000332612924052284*x_120 + 0.00166593552191941*x_13 - 0.00133061547450353*x_14 + 0.0005638207770288*x_15 - 0.000472626769049537*x_16 - 0.000101403136583463*x_17 - 0.000395198722758257*x_18 - 0.00286997565276032*x_19 - 0.00309044100878468*x_2 + 0.00630160291256565*x_20 - 0.000360601752142328*x_21 + 0.00591546481724803*x_22 + 0.0123486579224726*x_23 - 0.00231781507151972*x_24 + 0.00101645454976792*x_25 + 0.0026793841676366*x_26 + 0.00126932725567879*x_27 - 0.0014492650830581*x_28 + 0.000370651515890106*x_29 + 0.00279509687393389*x_3 + 0.00247122403493829*x_30 - 0.00378863743354847*x_31 - 0.000118941375458732*x_32 + 0.00309914837459245*x_33 - 0.00250147232515465*x_34 - 0.000724560305975507*x_35 + 0.00777974719067807*x_36 + 0.000886981903153739*x_37 + 0.012292508174225*x_38 + 0.00255965392368207*x_39 - 0.000474833948675427*x_4 - 0.00085105916100289*x_40 + 0.00390425603687433*x_41 - 0.00157770572579241*x_42 + 0.00164641858821833*x_43 + 0.0050163869290473*x_44 + 0.00256848229474756*x_45 + 0.000324476743087779*x_46 + 0.000967064702910379*x_48 - 0.000472124894752602*x_49 + 0.00813192910993064*x_5 + 0.00282540580778082*x_50 - 0.000761479429671863*x_51 + 0.000514775411949383*x_52 - 0.00137718498704166*x_53 + 0.00119028954018098*x_54 + 0.00977309719957246*x_55 - 0.000689132835065293*x_56 - 0.000709585555589905*x_59 + 0.00013268956436261*x_6 - 0.001431845138557*x_60 - 6.64488429113401e-5*x_61 + 0.00074627415454838*x_62 + 0.00865548982590485*x_63 + 6.98202110613806e-5*x_64 + 0.00797351587491972*x_65 - 0.000222454802019374*x_66 - 2.85246674882722e-5*x_67 - 0.0104639378237129*x_68 + 0.000453573126074913*x_69 - 0.000274213152766412*x_7 - 0.00143753080737328*x_70 + 0.00136990463327864*x_71 - 0.000173698115987265*x_72 + 7.54006582618638e-5*x_73 + 0.000735504367936487*x_74 - 2.87578146615975e-5*x_75 + 0.00359028294076896*x_76 - 0.00193552951237403*x_77 + 0.00177320207301022*x_78 + 0.00150818559427426*x_79 + 0.00261438611508511*x_8 + 0.00482486083894395*x_80 + 0.00294941072800141*x_81 + 0.0027651952819839*x_82 - 0.000753296968216455*x_83 - 0.000799858947811168*x_84 + 0.00201127121672514*x_85 - 0.00129426439185942*x_86 + 0.000902373914401148*x_87 + 0.000503406382634617*x_88 - 0.000374918927611603*x_89 + 0.00338683162896831*x_9 - 0.000954660757370043*x_90 + 0.0188565256828283*x_91 + 0.000692404458402375*x_92 + 0.00207965272084842*x_93 + 0.000360571532046609*x_94 - 0.00507516082683751*x_95 + 0.00602391594547618*x_96 + 0.00105214757846568*x_97 + 0.000430203396010204*x_98 - 0.00683709816225172*x_99 - 1.00637182692052e-5*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 0.0216998591559023*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 0.024847982336698*std::sin(0.956799805164337*x_47 + 0.626479864120483) - 0.0223981260543722*std::sin(1.2753598690033*x_58 + 2.43391990661621)) + 1.57847864856217e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) + 3.69160586468774e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 1.57670210402279e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 2.03833304696931e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 4.83668505182097e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) + 1.42152665159748e-5*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 1.7268850667869e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) - 5.07755734948959e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 1.5544435210495e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) + 7.18164192023196e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) - 5.93295479378261e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 4.40654428319002e-7*std::sin(0.522799849510193*x_35 - 5.14815998077393) + 4.74795717675402e-6*std::sin(1.68991982936859*x_36 - 6.20679998397827) + 5.06259411174455e-5*std::sin(1.90951979160309*x_4 - 3.20263981819153) - 6.5751108655176e-5*std::sin(0.257119953632355*x_42 + 4.82496023178101) + 1.61991007842061e-6*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 1.31152048232131e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) - 1.50274239400245e-6*std::sin(0.434399873018265*x_49 + 5.23328018188477) - 3.41713502687813e-7*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 2.44578809879622e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) - 3.38413994912136e-8*std::sin(1.52071976661682*x_67 - 4.38895988464355) - 6.1004244063372e-8*std::sin(1.37127983570099*x_71 - 1.19743990898132) + 9.99380342799379e-7*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 2.75278053388779e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) + 3.40354990108327e-6*std::sin(1.55535984039307*x_78 - 6.17880010604858) - 4.45002457684805e-6*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 1.57356409778866e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 3.45432327670778e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) - 4.74212658643688e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) - 0.00405223809580378*std::sin(0.226879999041557*x_91 + 4.96575975418091) - 0.000110110393853015*std::sin(0.278159946203232*x_91 - 7.86392021179199) - 9.93315213177139e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 7.9926923382254e-7*std::sin(1.01863980293274*x_94 + 6.77767992019653) + 2.70567546655267e-7*std::sin(1.45119988918304*x_95 - 0.792559862136841) + 8.52741576108421e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0448166262699757);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.10098495000759e-5*x_1 + 1.7486190413561e-7*x_10 + 6.32775809683994e-6*x_100 + 1.18506937443116e-6*x_101 + 1.96422709106363e-5*x_102 + 1.84113171391528e-6*x_103 + 2.49362923611231e-6*x_104 - 1.58510081435338e-6*x_105 - 3.23097856484098e-6*x_106 + 1.31016894710718e-6*x_107 + 1.20006561611124e-6*x_108 - 5.85814976347548e-7*x_109 - 5.00041286706765e-6*x_11 - 1.15414280250176e-6*x_110 - 2.44783788025092e-6*x_111 + 2.83322515812302e-6*x_112 + 1.41180684699068e-5*x_113 + 1.30400730535384e-6*x_114 + 5.64610817280295e-7*x_115 + 9.60933890708772e-7*x_116 + 5.42169964240658e-6*x_117 + 1.29198114155911e-6*x_118 + 6.72280447881899e-7*x_119 + 2.54163463948749e-6*x_12 + 2.6123603524264e-6*x_120 + 2.63472259158818e-6*x_13 - 5.53511114388811e-6*x_14 + 1.5651711617265e-6*x_15 + 1.31938294352297e-7*x_16 + 3.11937531056764e-7*x_17 - 6.71926176307071e-7*x_18 - 3.68708531203159e-6*x_19 - 1.88835412993791e-6*x_2 + 6.67771666812906e-6*x_20 + 1.37431013219344e-6*x_21 + 5.87129474963125e-6*x_22 + 1.48049611447594e-5*x_23 - 3.88690333553526e-6*x_24 + 1.56029521826816e-6*x_25 + 5.04030531837099e-6*x_26 - 1.80429059028107e-6*x_27 - 1.88327246964206e-6*x_28 - 2.57523086232552e-6*x_29 + 7.5940100320259e-6*x_3 + 3.70134761258372e-6*x_30 - 6.54060188295647e-6*x_31 - 1.95879445949224e-6*x_32 + 4.37505363157501e-6*x_33 - 1.01379594050204e-5*x_34 + 2.54847145125721e-6*x_35 + 8.05488906983961e-6*x_36 - 4.33825114790774e-6*x_37 + 1.74285194488554e-5*x_38 + 3.92335794597725e-7*x_39 + 2.09335955632876e-6*x_4 - 8.40351128938502e-7*x_40 + 1.45516529461967e-5*x_41 - 1.35980254835036e-6*x_42 + 9.54584214041153e-7*x_43 + 8.67074784333941e-6*x_44 + 2.54606020650725e-6*x_45 - 7.20460429298113e-8*x_46 - 3.01505622684327e-6*x_47 + 1.20616997610652e-6*x_48 - 1.5138545712044e-6*x_49 + 1.11798201674703e-5*x_5 + 3.55776982218596e-6*x_50 - 1.29324996084469e-6*x_51 - 6.55024036739712e-8*x_52 - 1.63227071124861e-6*x_53 - 2.66340997881941e-6*x_54 + 1.37158713648415e-5*x_55 + 2.21387862473028e-6*x_56 + 7.80354581157585e-7*x_57 + 1.06599617377183e-6*x_58 - 7.67413430248562e-7*x_59 + 8.52075876679968e-7*x_6 - 1.58669290928646e-6*x_60 + 2.0876880338144e-7*x_61 + 9.02116579278371e-7*x_62 + 1.01802964363502e-5*x_63 + 6.04833590053668e-7*x_64 + 7.62406100431493e-6*x_65 + 1.65906101442938e-6*x_66 - 1.48098664811786e-6*x_67 - 1.4757453338495e-5*x_68 - 3.34767978335872e-7*x_69 + 1.21166069494413e-6*x_7 + 2.4047547771034e-6*x_70 + 9.84980353965386e-7*x_71 + 1.11969619564091e-6*x_72 + 1.67112787812415e-6*x_73 - 3.17692219563534e-8*x_74 - 3.53141757733084e-7*x_75 + 5.48357448728013e-6*x_76 - 3.35780421136408e-7*x_77 + 2.53657287651059e-6*x_78 + 1.66291264815407e-6*x_79 - 2.7103128708629e-6*x_8 + 5.59869047608606e-6*x_80 + 2.98030128509984e-6*x_81 + 3.30318041946271e-6*x_82 + 1.97047631562146e-6*x_83 - 1.05103216075625e-6*x_84 + 1.27114976996582e-6*x_85 - 7.16151268464704e-9*x_86 + 1.3124133567994e-6*x_87 + 2.05208279088117e-6*x_88 + 1.42293885952496e-6*x_89 + 2.9290852343467e-6*x_9 - 1.11990447410379e-6*x_90 + 4.88267070898284e-5*x_91 + 5.48767681212504e-6*x_92 + 2.29567658147327e-6*x_93 + 1.63529993556089e-6*x_94 - 6.72622299965741e-6*x_95 + 7.67285393526869e-6*x_96 + 6.53877886758486e-7*x_97 + 1.72780575374482e-6*x_98 - 9.29202759833536e-6*x_99 - 2.37015436055182e-9*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 1.16868623783428e-8*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 5.89489229224007e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) - 5.484369805739e-10*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 2.80667763110411e-6*std::exp(0.480159848928452*x_1) + 4.38516562368484e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) - 2.51997582603712e-5*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 1.02556364311724e-6*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 6.98113413963065e-7*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 5.89162867931819e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 1.34367766337261e-6*std::sin(1.81255984306335*x_120 + 8.193039894104) - 2.93921292916061e-5*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 4.79745293851553e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 5.0315669239626e-8*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 4.49298707226105e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) - 1.38608075728123e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 0.000122672462161822*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 8.54336739845117e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 5.78662245772943e-8*std::sin(1.68991982936859*x_36 - 6.20679998397827) - 6.17008951235272e-7*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 1.38027920021769e-5*std::sin(0.257119953632355*x_42 + 4.82496023178101) + 3.14066671364127e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 3.64353014155292e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 2.88556319026821e-5*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 1.48913117163693e-8*std::sin(0.434399873018265*x_49 + 5.23328018188477) + 6.59518416317043e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 2.60106463364753e-5*std::sin(1.2753598690033*x_58 + 2.43391990661621) - 1.08291697913291e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) - 6.56113930896195e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) - 1.182744655231e-6*std::sin(1.37127983570099*x_71 - 1.19743990898132) + 4.42493747664313e-7*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 7.9566785052307e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 3.37272194632488e-8*std::sin(1.55535984039307*x_78 - 6.17880010604858) + 5.42351398616477e-8*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 4.37151252858121e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 1.52946419585655e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 4.69917435476292e-8*std::sin(0.532079875469208*x_87 - 7.78791999816895) + 4.93870755280819e-5*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 0.000227669240590073*std::sin(0.278159946203232*x_91 - 7.86392021179199) + 1.91713137217383e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 3.53890929729761e-7*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 2.68116857131155e-9*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 1.7631671294478e-6*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0543517074235818);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.37840339764724e-5*x_1 + 7.38876438904318e-6*x_10 - 1.21176519987208e-6*x_100 + 2.933014567605e-6*x_101 - 2.337378023274e-6*x_102 + 2.73338699773478e-6*x_103 - 1.26735891198451e-6*x_104 - 4.2010311495683e-6*x_105 + 1.42655482704284e-6*x_106 - 8.01513546077782e-6*x_107 + 5.97581400702867e-7*x_108 + 5.52074207075217e-7*x_109 - 3.58860377280597e-6*x_11 + 1.3163144884838e-6*x_110 - 2.38150650079818e-6*x_111 - 1.64834174404692e-7*x_112 - 8.35091653095701e-7*x_113 - 1.64220354280125e-7*x_114 - 3.00120496967998e-7*x_115 - 4.78418708661494e-6*x_116 - 2.8503186162554e-6*x_117 + 4.87061031613756e-7*x_118 + 5.43243717184609e-6*x_119 + 6.13401996896731e-6*x_12 + 1.88972883590016e-5*x_120 + 8.98861694177744e-6*x_13 - 1.24733274708772e-5*x_14 - 4.22613384164684e-7*x_15 + 5.77341335824256e-6*x_16 - 6.29183194910228e-8*x_17 + 1.35618161692616e-7*x_18 - 2.68229646747143e-6*x_19 - 4.90482602710887e-6*x_2 + 7.98194865084898e-6*x_20 - 3.09009274396155e-6*x_21 + 8.61861492657109e-7*x_22 + 6.02131963859233e-6*x_23 + 3.0613328150071e-6*x_24 + 3.96949935291727e-6*x_25 + 1.63661407169851e-6*x_26 - 2.99350730993676e-6*x_27 + 7.11549732271283e-6*x_28 + 3.68262511961335e-6*x_29 + 1.76647568373784e-8*x_3 - 1.10092636358348e-6*x_30 - 2.0420343815358e-6*x_31 + 2.90027256324131e-5*x_32 + 1.05287995706108e-5*x_33 - 5.6349874752766e-6*x_34 - 8.55865181696242e-6*x_35 - 2.42252448716022e-6*x_36 + 9.70503599802376e-6*x_37 - 1.4886431412002e-6*x_38 + 1.10410966229901e-7*x_39 + 4.83816622266758e-6*x_4 - 4.60880288286468e-6*x_40 - 1.51053468150751e-6*x_41 + 1.15397111437316e-6*x_42 - 2.76655164361823e-6*x_43 - 1.35947253934015e-6*x_44 - 1.47638737485291e-6*x_45 + 1.68973363302742e-6*x_46 - 1.047614944545e-5*x_47 - 7.82516486925092e-6*x_48 + 7.32610280283867e-6*x_49 - 3.01431752637854e-7*x_5 - 3.48060426727939e-6*x_50 + 8.2116973529017e-7*x_51 + 1.61661432036602e-5*x_52 + 1.2644245107622e-5*x_53 + 2.66004254877196e-6*x_54 - 1.38811898594049e-6*x_55 - 4.71333195773755e-7*x_56 + 5.02365253385597e-6*x_57 + 7.60592316795298e-7*x_58 - 3.16364603047148e-7*x_59 + 8.08067244583602e-7*x_6 - 2.26620194366405e-6*x_60 - 2.59367732042633e-6*x_61 - 1.51550767937014e-5*x_62 + 2.25091032071837e-5*x_63 - 1.13371558309019e-5*x_64 + 1.59996068108807e-5*x_65 + 5.03257239418233e-7*x_66 - 2.85213039030281e-6*x_67 - 1.74260866885227e-7*x_68 - 3.68761458522001e-6*x_69 + 1.76126906213049e-6*x_7 - 1.56307780833352e-5*x_70 - 8.76885729393867e-7*x_71 - 3.82853868493432e-6*x_72 - 2.05880245272805e-6*x_73 - 1.84259662741327e-7*x_74 + 2.86010438775774e-8*x_75 - 9.94705821323876e-7*x_76 - 6.70168299878257e-6*x_77 - 1.90645701733455e-6*x_78 - 1.5212037501201e-6*x_79 - 2.55194952256147e-5*x_8 + 1.63018738566883e-6*x_80 + 8.12488578167679e-6*x_81 - 6.12547675579808e-6*x_82 - 5.37257638483346e-6*x_83 + 3.38085901708318e-6*x_84 - 2.30064110975607e-6*x_85 + 2.33414083666544e-7*x_86 - 5.25077790831064e-7*x_87 + 6.50778627371187e-6*x_88 + 8.50047739391251e-6*x_89 - 7.95386099496497e-7*x_9 - 1.37678034232695e-6*x_90 - 3.02786232957342e-6*x_91 + 1.21233722983879e-5*x_92 - 8.08644602146237e-5*x_93 + 4.65479380446598e-7*x_94 - 4.07168526573588e-6*x_95 - 8.81531304286305e-7*x_96 - 3.42491520414921e-6*x_97 - 1.37059896871139e-6*x_98 - 3.51565923498509e-6*x_99 + 1.76650719370185e-7*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) + 7.47620922219455e-10*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) + 2.12354156769938e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) + 2.42959847314238e-9*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 1.01277682551892e-6*std::exp(0.480159848928452*x_1) + 0.000187611456822732*std::exp(-0.00251140829355629*x_1 + 0.00260614607612874*x_10 + 0.0022542179631968*x_100 + 0.00112000689395695*x_101 - 0.000912527386191493*x_102 - 0.00171104721118206*x_103 - 3.44259200659255e-5*x_104 - 0.000667788959387572*x_105 - 0.002827675984569*x_106 - 0.00650192930015695*x_107 - 0.00362047986597753*x_108 + 0.00486918148005792*x_109 - 0.011240206221125*x_11 - 0.00293937500700248*x_110 - 0.0112722785219849*x_111 - 0.00891737280925546*x_112 + 0.00165949824921992*x_113 + 0.000257498766320412*x_114 + 0.0275227063663799*x_115 + 0.00187753634485343*x_116 + 0.00465205964401123*x_117 - 0.0204237724942851*x_118 + 0.00314110560963541*x_119 + 0.00018707836254152*x_12 + 0.000288858320147622*x_120 - 0.00028244617105653*x_13 - 0.000936734859627596*x_14 - 0.000359916456052855*x_15 - 0.0151391377461495*x_16 - 0.00739382336499283*x_17 + 0.000637565775937232*x_18 - 0.0288598245161115*x_19 - 0.00512400418823661*x_2 - 0.0024335951311844*x_20 + 0.00493821665280641*x_21 + 0.00160776532436568*x_22 + 0.00536735489721125*x_23 - 0.00184225316476043*x_24 + 0.00916049045001306*x_25 - 0.00246171837692767*x_26 + 0.000737743807968308*x_27 - 0.00654805561612137*x_28 - 0.0018794708017204*x_29 - 0.0152678723128609*x_3 - 0.00247678730208777*x_30 - 4.04509021359233e-5*x_31 + 0.00204885125193634*x_32 + 0.00416097148003745*x_33 + 0.00050668023000459*x_34 + 0.00440099755305379*x_35 - 0.00131364130137178*x_36 - 0.00314726086352134*x_37 - 0.0147955415315619*x_38 + 0.00629106538356401*x_39 + 0.00622827179174869*x_4 - 0.00302025017633547*x_40 - 0.00175768610751468*x_41 - 0.000139369881332811*x_43 + 0.00334885629078795*x_44 - 0.0147330361372563*x_45 + 0.000886484529628508*x_46 - 0.00107586375241839*x_47 + 0.00032586576032498*x_48 - 0.00762760477889253*x_49 + 0.00174221202032203*x_5 + 0.00481002512167624*x_50 - 0.00280520545457522*x_51 + 0.00320951512342006*x_52 - 0.000297992204487662*x_53 - 0.0195414018522463*x_54 - 0.0130119457782552*x_55 + 0.000459028750411576*x_56 - 0.00278058144319354*x_57 + 0.00277934024724134*x_58 + 0.00168966162933202*x_59 + 0.000494486609553115*x_6 + 0.001123490374103*x_60 - 0.0079647007119014*x_61 + 0.00116249159129557*x_62 + 0.00468635911794479*x_63 - 0.00666067794936357*x_64 - 0.00316943481288803*x_65 - 0.00185418880157005*x_66 - 0.000865612092820593*x_67 + 0.00029080116035179*x_68 - 0.00709855953622295*x_69 - 0.000299034093876714*x_7 - 0.00461634792017839*x_70 - 0.00439436236827441*x_71 - 0.00116115752947708*x_72 + 0.000108151238577872*x_73 + 0.012122442257564*x_74 - 0.0024093907389384*x_75 - 0.0157595522589918*x_76 - 0.0202268430733008*x_77 + 9.97048400397993e-5*x_78 + 0.000256309906234854*x_79 - 6.97753427257396e-5*x_8 - 0.00585129858683543*x_80 + 0.00122826981099653*x_81 + 0.000937808436386661*x_82 + 0.000494034383836867*x_83 - 0.00045747021524915*x_84 + 0.00194403945232655*x_85 + 0.00103147816886847*x_86 + 0.00129936336507187*x_87 + 0.00355942607234926*x_88 - 0.00297527883702486*x_89 + 0.0027620223607593*x_9 - 0.00077438260835936*x_90 - 0.0395687823588661*x_91 + 0.00166062441129816*x_92 - 0.005085324580939*x_93 + 0.00140503964307961*x_94 - 0.00782938285808197*x_95 - 0.00349501361889138*x_96 + 0.00158783905782006*x_97 + 0.000585469952858136*x_98 - 0.000560198579927138*x_99 + 0.469334360409512*std::sin(0.257119953632355*x_42 + 4.82496023178101)) - 1.57968645082785e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) + 1.61205513510954e-6*std::sin(1.18727993965149*x_103 + 8.20639991760254) - 3.6944305655042e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) + 5.20313102096183e-5*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 2.10981935029394e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) - 4.84038593125275e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) - 1.06060158349872e-5*std::sin(0.334799855947495*x_19 - 1.57703983783722) + 1.72820642498083e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) - 8.37014445086377e-7*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 1.60895935260704e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) + 1.41562741251517e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 4.42657986189762e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) - 5.25647537652489e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) + 2.56349764620885e-7*std::sin(1.68991982936859*x_36 - 6.20679998397827) + 2.73337513503869e-6*std::sin(1.90951979160309*x_4 - 3.20263981819153) - 1.93235716974077e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) - 1.31252401658608e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) - 1.84592523090594e-6*std::sin(0.956799805164337*x_47 + 0.626479864120483) - 2.47720902876691e-7*std::sin(0.434399873018265*x_49 + 5.23328018188477) - 6.73577166620722e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) + 1.6639285012576e-6*std::sin(1.2753598690033*x_58 + 2.43391990661621) + 8.07112256340461e-6*std::sin(2.0511999130249*x_59 - 9.80607986450195) + 4.03687042954051e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) + 7.27706988003963e-7*std::sin(1.37127983570099*x_71 - 1.19743990898132) - 3.29796405426992e-5*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 2.84932319875025e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) + 5.61061202403824e-7*std::sin(1.55535984039307*x_78 - 6.17880010604858) - 2.4026390937503e-7*std::sin(1.04719984531403*x_82 + 8.62975978851318) - 1.5747681395945e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) - 1.13992976552843e-5*std::sin(1.69791984558105*x_86 + 0.384719848632813) - 7.81720063422782e-7*std::sin(0.532079875469208*x_87 - 7.78791999816895) - 0.000218786784163302*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 8.21534073588677e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) - 1.95799826928226e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) - 2.63759560794138e-5*std::sin(1.01863980293274*x_94 + 6.77767992019653) + 4.4601947222675e-8*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 6.36230819112269e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0712671871993187);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.208289116809e-6*x_1 + 5.45195521113889e-7*x_10 - 3.65307422858382e-7*x_100 + 1.28606327159631e-6*x_101 + 2.4801110565661e-7*x_102 - 2.00318478300102e-7*x_103 - 2.80668959003874e-7*x_104 - 5.78403755325246e-7*x_105 + 1.74791203687329e-6*x_106 - 5.72057522826671e-7*x_107 - 4.24209694937956e-7*x_108 + 2.03182686929665e-6*x_109 + 6.89045218800677e-7*x_11 + 1.65875398038002e-6*x_110 + 4.64356422659398e-7*x_111 - 5.51490710836071e-7*x_112 - 2.12294192586325e-6*x_113 + 1.08336314775548e-6*x_114 + 3.60887131458463e-7*x_115 - 2.17509239968411e-6*x_116 + 2.43325563679883e-6*x_117 - 2.48706249874709e-7*x_118 - 1.12037147176152e-6*x_119 + 3.70314627862446e-7*x_12 + 4.37795034237637e-6*x_120 + 1.07351663360495e-6*x_13 - 2.69430467772829e-6*x_14 + 1.09796356137106e-6*x_15 + 2.90491010037222e-7*x_16 - 1.95756771717094e-7*x_17 + 1.35644673089227e-6*x_18 + 5.74160438805936e-7*x_19 + 3.32126545792402e-6*x_2 - 2.01761686757806e-6*x_20 - 6.92127553479071e-7*x_21 - 9.10965464919138e-7*x_22 - 2.03746063898936e-6*x_23 + 1.83714878403452e-6*x_24 + 1.71985664683913e-6*x_25 - 7.31899643642046e-7*x_26 - 1.46993598559786e-8*x_27 + 3.66930658458809e-7*x_28 - 1.44247545624107e-6*x_29 + 3.21181402894523e-6*x_3 - 3.5446537697938e-6*x_30 - 4.38405074916688e-6*x_31 + 3.20548391807197e-6*x_32 + 7.54003562807222e-6*x_33 + 7.61783986922061e-6*x_34 + 2.02582756432226e-6*x_35 - 3.51418380078786e-6*x_36 - 1.36198841378798e-6*x_37 + 7.45976993055748e-7*x_38 + 2.6189108157705e-7*x_39 + 2.12819160150079e-6*x_4 - 3.75213483301197e-7*x_40 + 4.80857275117943e-6*x_41 + 1.26292198170725e-6*x_42 + 2.73916749811449e-7*x_43 - 2.69215099845491e-8*x_44 - 5.33736107823198e-7*x_45 - 1.33187065655321e-6*x_46 + 7.15583403103161e-8*x_47 - 7.24941934078755e-7*x_48 + 8.01636257641985e-8*x_49 - 1.09048783826431e-6*x_5 - 1.93019135478225e-6*x_50 - 6.45993673288738e-7*x_51 + 1.14657724884876e-6*x_52 - 5.70178965051603e-7*x_53 - 3.53470652797099e-6*x_54 + 1.34930612500041e-6*x_55 - 2.15027267681077e-7*x_56 + 5.62362059022269e-7*x_57 + 8.6255682361978e-8*x_58 + 5.0396032918218e-7*x_59 + 1.04397969649112e-6*x_6 - 2.21498302205239e-8*x_60 - 6.31315102265297e-7*x_61 + 1.45505031292641e-6*x_62 - 1.02916006137345e-6*x_63 - 3.81185729587686e-7*x_64 + 6.7049130868621e-7*x_65 + 1.58489215115072e-6*x_66 + 9.51034490794607e-7*x_67 + 2.34339017248393e-6*x_68 - 3.1957994754248e-7*x_69 - 4.97388059761628e-7*x_7 + 6.36826470082218e-7*x_70 + 7.9226728719654e-7*x_71 - 5.66812866020834e-7*x_72 - 4.2305084172324e-7*x_73 - 1.07283712869889e-6*x_74 + 1.49187466137219e-6*x_75 - 2.60768753253304e-8*x_76 + 8.38624032889777e-7*x_77 - 4.72532027336398e-8*x_78 - 1.57070354449681e-6*x_79 - 4.20232171369928e-6*x_8 - 1.48396802717345e-6*x_80 + 1.98060750161948e-7*x_81 - 1.20371291996523e-6*x_82 + 2.18770042501873e-6*x_83 + 5.02732906459774e-7*x_84 + 2.71463045242443e-7*x_85 + 2.11604898097728e-6*x_86 + 8.98388697399477e-7*x_87 + 9.13300821120013e-7*x_88 + 2.85936480912218e-6*x_89 + 2.84896517294696e-6*x_9 + 7.02069754391133e-8*x_90 - 2.39525548099082e-5*x_91 + 7.4531989283607e-7*x_92 - 6.73441769774593e-6*x_93 - 1.51948365613076e-6*x_94 + 1.05378610129993e-6*x_95 - 4.82790811896682e-7*x_96 - 5.87089491418331e-7*x_97 - 9.68573889081727e-7*x_98 + 1.41567968895344e-6*x_99 + 1.03194781643922e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) + 1.88988620316177e-9*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 4.1261121342917e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) - 1.08323619903817e-9*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 4.42723443442064e-7*std::exp(0.480159848928452*x_1) + 3.06938349231301e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) + 4.07506086043605e-6*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 7.17840188178647e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) + 3.03953457697322e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) + 1.85942965278898e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 9.40503140102606e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) - 4.63629472293733e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 3.35796275860034e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 5.07178066257049e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) - 1.41801085005353e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) - 4.02171027141871e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 1.93502717454705e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) - 2.11337950856509e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 1.14293512990689e-7*std::sin(1.68991982936859*x_36 - 6.20679998397827) - 1.21867498870923e-6*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 5.56788166909626e-6*std::sin(0.257119953632355*x_42 + 4.82496023178101) - 7.76909193562858e-6*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 2.55027796665752e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) - 4.66625334079842e-6*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 1.5010327388016e-6*std::sin(0.434399873018265*x_49 + 5.23328018188477) + 1.91359123569009e-7*std::sin(1.18223989009857*x_57 - 7.60576009750366) + 4.2061898271104e-6*std::sin(1.2753598690033*x_58 + 2.43391990661621) + 4.71494106291447e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) + 1.62303418800822e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) + 2.92576475018881e-7*std::sin(1.37127983570099*x_71 - 1.19743990898132) - 1.92658530722817e-6*std::sin(1.11815989017487*x_75 + 0.799599885940552) - 2.51117046840889e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 3.39967771592832e-6*std::sin(1.55535984039307*x_78 - 6.17880010604858) + 1.07121636284551e-7*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 3.05982704944943e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) - 6.65917487698422e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 4.73673151578872e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) + 9.75460624859186e-5*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 3.5912393016873e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) + 5.56255246357638e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) - 1.5408151395981e-6*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 2.70259724625909e-7*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 2.781207981502e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.060721062371989);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.47165395784075e-6*x_1 - 9.166629770704e-8*x_10 - 6.72872422855961e-7*x_100 - 8.84023613445586e-7*x_101 - 5.84104968920996e-7*x_102 - 2.55607907948886e-6*x_103 - 8.55429259492445e-7*x_104 + 2.44061065426644e-7*x_105 - 4.63881820018924e-7*x_106 + 3.96522824252727e-7*x_107 + 4.85320677442444e-8*x_108 + 5.08938905681339e-7*x_109 + 1.13933474793671e-7*x_11 + 8.67268435609229e-8*x_110 + 2.20327983587772e-7*x_111 - 1.55880061019386e-6*x_112 - 1.8286930777199e-7*x_113 - 5.60982165972794e-8*x_114 - 4.18917748468735e-7*x_115 - 6.03415946878222e-7*x_116 - 1.48233292986111e-7*x_117 - 1.05423699650395e-6*x_118 - 6.03615337356424e-7*x_119 - 1.35875555148282e-6*x_12 - 5.13164871747966e-7*x_120 - 9.12735306385762e-7*x_13 + 1.140240546001e-6*x_14 - 3.32995505718444e-7*x_15 - 2.64302673174914e-7*x_16 - 6.79934420567418e-7*x_17 + 6.43788522802116e-7*x_18 - 1.71864295436941e-8*x_19 - 4.42485334758247e-7*x_2 - 1.02480279554125e-6*x_20 - 7.03737838648906e-7*x_21 - 2.95050702865556e-7*x_22 - 4.38762860139825e-7*x_23 - 2.06721153113913e-7*x_24 + 6.86449264007852e-7*x_25 - 2.62606975203678e-6*x_26 + 2.51987611534207e-7*x_27 - 1.07171717549444e-7*x_28 + 6.35641952761138e-7*x_29 - 7.13547501843766e-7*x_3 - 2.76006381942325e-6*x_30 + 1.13402355577233e-6*x_31 - 7.03547703539585e-7*x_32 - 4.39548882309116e-6*x_33 - 6.55517890050769e-7*x_34 - 7.92181902101564e-7*x_35 - 1.81978419023701e-6*x_36 - 1.84054495793401e-6*x_37 - 6.82515508138342e-7*x_38 + 6.98084148511931e-7*x_39 - 5.70718181479691e-7*x_4 - 2.14201159063577e-7*x_40 + 1.60208679703087e-6*x_41 - 1.88774190583054e-6*x_42 - 1.46172643088424e-7*x_43 - 2.1877312660192e-7*x_44 - 7.30149402944365e-7*x_45 - 4.71910594017037e-7*x_46 + 3.86916000377645e-7*x_47 + 1.21630366762638e-7*x_48 - 6.13710889544619e-9*x_49 - 1.7480303063747e-7*x_5 - 5.58003374509215e-7*x_50 + 7.82534941540052e-8*x_51 - 7.0307268689147e-7*x_52 + 7.40509203239004e-7*x_53 + 2.04442642114884e-6*x_54 - 1.67893571832947e-7*x_55 - 7.8940642898866e-7*x_56 - 4.63003018361698e-7*x_57 + 2.80988228799932e-7*x_58 - 2.05874665964741e-7*x_59 + 7.41624409395498e-8*x_6 + 4.2854338709652e-8*x_60 - 9.92405329118383e-7*x_61 + 5.89190634735587e-7*x_62 - 8.69381810225976e-7*x_63 + 1.47710628927553e-7*x_64 - 3.4745146559626e-7*x_65 + 1.3150911665074e-6*x_66 + 2.3495526789411e-6*x_67 + 1.47901332499705e-6*x_68 + 2.99435680273004e-7*x_69 - 4.2865786156008e-7*x_7 - 3.98894633998958e-7*x_70 + 1.60568861423086e-7*x_71 - 1.54152117068899e-7*x_72 - 2.2133455260224e-6*x_73 - 6.82252245105543e-7*x_74 - 6.72932821197424e-8*x_75 - 3.3747974172931e-7*x_76 - 4.87836602273879e-7*x_77 - 5.68686508345962e-8*x_78 - 1.64199107407201e-6*x_79 + 5.01580487435954e-6*x_8 - 8.63196421549094e-8*x_80 + 1.38378356241194e-7*x_81 - 3.33357369009004e-7*x_82 - 2.33941735405188e-7*x_83 - 5.11662221662928e-7*x_84 - 4.1041041840161e-8*x_85 + 1.00606514268698e-6*x_86 - 1.5171907283125e-7*x_87 - 6.87645891453382e-7*x_88 - 5.81403815022109e-7*x_89 + 2.41168813298921e-6*x_9 + 4.26124636981235e-7*x_90 - 1.13410001288747e-6*x_91 - 9.9907939633175e-7*x_92 + 9.46749508743335e-7*x_93 - 2.53133961224396e-6*x_94 + 1.26399258630144e-7*x_95 + 5.18572386321955e-7*x_96 + 1.54034111258892e-7*x_97 - 3.07721999074144e-7*x_98 + 5.0787667669124e-7*x_99 - 3.10114549296142e-9*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) + 1.01821437633126e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) - 1.11073823095442e-10*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) + 4.99173112188686e-7*std::exp(0.480159848928452*x_1) - 2.08079194019323e-5*std::exp(0.00234100817298011*x_1 - 0.00242931795672223*x_10 - 0.00210126831589361*x_100 - 0.00104401394997166*x_101 + 0.000850612015029003*x_102 + 0.00159495193036092*x_103 + 3.20901067514474e-5*x_104 + 0.000622479194547245*x_105 + 0.00263581696667964*x_106 + 0.00606077063250134*x_107 + 0.00337482876763199*x_108 - 0.00453880544624533*x_109 + 0.0104775534496521*x_11 + 0.00273993716294624*x_110 + 0.0105074496312614*x_111 + 0.00831232527245365*x_112 - 0.00154690058738669*x_113 - 0.000240027365536319*x_114 - 0.0256552790366832*x_115 - 0.00175014470552101*x_116 - 0.00433641541909527*x_117 + 0.0190380108462982*x_118 - 0.00292798025841406*x_119 - 0.000174385016096793*x_12 - 0.000269259160302177*x_120 + 0.00026328207825338*x_13 + 0.000873177001099375*x_14 + 0.000335495971472106*x_15 + 0.0141119408128662*x_16 + 0.00689214930580206*x_17 - 0.000594306666945*x_18 + 0.0269016731514089*x_19 + 0.00477633832532272*x_2 + 0.00226847466676154*x_20 - 0.00460315655316887*x_21 - 0.0014986777634808*x_22 - 0.00500317758521997*x_23 + 0.00171725550419983*x_24 - 0.0085389472779115*x_25 + 0.00229468973832305*x_26 - 0.000687687576906766*x_27 + 0.00610376725831453*x_28 + 0.00175194790866701*x_29 + 0.0142319406844879*x_3 + 0.00230873623050368*x_30 + 3.77062912261553e-5*x_31 - 0.00190983582331473*x_32 - 0.00387864779585928*x_33 - 0.000472301760956816*x_34 - 0.00410238799776165*x_35 + 0.00122451018050946*x_36 + 0.00293371787570661*x_37 + 0.0137916577475365*x_38 - 0.00586421392230921*x_39 - 0.00580568090239858*x_4 + 0.00281532491765162*x_40 + 0.00163842635774637*x_41 + 0.000129913575623886*x_43 - 0.00312163496751419*x_44 + 0.0137333933708121*x_45 - 0.000826336177357317*x_46 + 0.00100286593935629*x_47 - 0.000303755629927825*x_48 + 0.00711006855136411*x_49 - 0.00162400219394938*x_5 - 0.00448366287193331*x_50 + 0.00261487107170047*x_51 - 0.00299174815760049*x_52 + 0.00027777330670599*x_53 + 0.0182155094275084*x_54 + 0.012129079724482*x_55 - 0.000427883454515741*x_56 + 0.00259191780996124*x_57 - 0.00259076082968216*x_58 - 0.00157501736933262*x_59 - 0.000460935482837738*x_6 - 0.00104726107450862*x_60 + 0.00742429238198411*x_61 - 0.00108361604253124*x_62 - 0.0043683876591382*x_63 + 0.00620874811835889*x_64 + 0.00295438731318033*x_65 + 0.00172838130297685*x_66 + 0.000806879944261842*x_67 - 0.00027107017797239*x_68 + 0.00661691925336129*x_69 + 0.00027874450345698*x_7 + 0.00430312675090922*x_70 + 0.00409620301309085*x_71 + 0.00108237249737437*x_72 - 0.000100813131054131*x_73 - 0.0112999293958893*x_74 + 0.00224591255282122*x_75 + 0.0146902599372101*x_76 + 0.0188544431702626*x_77 - 9.29398242483001e-5*x_78 - 0.000238919170113074*x_79 + 6.5041056053112e-5*x_8 + 0.00545428548972884*x_80 - 0.00114493118205638*x_81 - 0.000874177735218849*x_82 - 0.000460513940828625*x_83 + 0.00042643066662678*x_84 - 0.00181213554887476*x_85 - 0.000961491936523111*x_86 - 0.00121120100825852*x_87 - 0.00331791749986166*x_88 + 0.00277340490283518*x_89 - 0.00257461796916154*x_9 + 0.000721840419112356*x_90 + 0.0368840236510514*x_91 - 0.00154795033888907*x_92 + 0.00474028314582694*x_93 - 0.00130970710586956*x_94 + 0.0072981559020839*x_95 + 0.00325787545875926*x_96 - 0.00148010350259301*x_97 - 0.000545745567613121*x_98 + 0.000522188868080955*x_99 - 0.437489824493341*std::sin(0.257119953632355*x_42 + 4.82496023178101)) - 3.66469419161992e-5*std::exp(0.00283827539715731*x_1 - 3.37887824248784e-5*x_10 + 0.0018243479992083*x_100 + 0.000259629985449323*x_101 + 0.00572092534442192*x_102 + 0.000764836230073784*x_104 + 0.000451226927913321*x_105 - 0.00170325135364169*x_106 + 0.000148096747856541*x_107 + 0.000640251496416175*x_108 + 0.000433370152260658*x_109 - 0.00160471886851922*x_11 - 0.00178923219595605*x_110 - 0.00118979829677704*x_111 + 0.000603237875301968*x_112 + 0.00524099602195542*x_113 + 0.000141669522888383*x_114 - 0.000255743142343434*x_115 + 0.0003595414451926*x_116 + 0.00232071456819957*x_117 - 3.1586131415431e-5*x_118 + 0.000957001417058365*x_119 + 3.20946193621079e-5*x_12 - 0.000155229192305964*x_120 + 0.000777485800463708*x_13 - 0.000620993203933745*x_14 + 0.000263133021883852*x_15 - 0.000220573123641475*x_16 - 4.73244599078417e-5*x_17 - 0.000184437747597774*x_18 - 0.00133940677075355*x_19 - 0.00144229711767744*x_2 + 0.0029409342199725*x_20 - 0.000168291472403429*x_21 + 0.00276072503289564*x_22 + 0.00576307189755126*x_23 - 0.00108171551809586*x_24 + 0.000474375489845348*x_25 + 0.00125045844626963*x_26 + 0.00059239022425957*x_27 - 0.000676366527011384*x_28 + 0.000172981659093794*x_29 + 0.00130446112818358*x_3 + 0.00115331090048159*x_30 - 0.00176814274558202*x_31 - 5.55094895871129e-5*x_32 + 0.00144636081233183*x_33 - 0.00116742766299857*x_34 - 0.000338149551446354*x_35 + 0.00363077855797244*x_36 + 0.00041395109588381*x_37 + 0.00573686702263998*x_38 + 0.00119458079474236*x_39 - 0.000221603206015987*x_4 - 0.000397186088133795*x_40 + 0.0018221015099955*x_41 - 0.000736309288669593*x_42 + 0.000768377321401024*x_43 + 0.00234112878658859*x_44 + 0.00119870096209238*x_45 + 0.000151432067455287*x_46 + 0.000451325435318286*x_48 - 0.000220338900807307*x_49 + 0.00379514052624565*x_5 + 0.00131860619285333*x_50 - 0.000355379566691127*x_51 + 0.000240243735698351*x_52 - 0.000642727019112379*x_53 + 0.00055550362169176*x_54 + 0.00456106745984061*x_55 - 0.000321615684909132*x_56 - 0.000331160892139252*x_59 + 6.19257172947386e-5*x_6 - 0.000668236704868647*x_60 - 3.10114233960788e-5*x_61 + 0.000348283322361675*x_62 + 0.0040394843300692*x_63 + 3.25848281469254e-5*x_64 + 0.00372120966925509*x_65 - 0.000103818813837259*x_66 - 1.33123543158072e-5*x_67 - 0.00488348016344502*x_68 + 0.000211680860606704*x_69 - 0.00012797424016185*x_7 - 0.000670890184977952*x_70 + 0.000639329305576277*x_71 - 8.10642530701316e-5*x_72 + 3.51892017265309e-5*x_73 + 0.000343257103726801*x_74 - 1.34211632188491e-5*x_75 + 0.00167557145481767*x_76 - 0.000903304295063858*x_77 + 0.000827546693721889*x_78 + 0.000703864506509322*x_79 + 0.00122012410124146*x_8 + 0.0022517442854993*x_80 + 0.00137647881960906*x_81 + 0.00129050616843484*x_82 - 0.000351560842910574*x_83 - 0.000373291142493033*x_84 + 0.000938652661708959*x_85 - 0.000604028291297324*x_86 + 0.000421134489255272*x_87 + 0.000234937852762916*x_88 - 0.000174973243986812*x_89 + 0.0015806214979139*x_9 - 0.00044553656089881*x_90 + 0.00880026914102106*x_91 + 0.000323142539133428*x_92 + 0.000970566050775149*x_93 + 0.000168277368799178*x_94 - 0.00236855834215575*x_95 + 0.00281133876381874*x_96 + 0.000491033291196557*x_97 + 0.000200774296068692*x_98 - 0.00319084782549247*x_99 - 4.69669921267983e-6*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 0.0101272421073885*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 0.0115964592763454*std::sin(0.956799805164337*x_47 + 0.626479864120483) - 0.0104531206251048*std::sin(1.2753598690033*x_58 + 2.43391990661621)) - 7.57441944530051e-7*std::sin(1.02879977226257*x_100 - 2.18503999710083) - 1.7714380407582e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 9.13422055255263e-7*std::sin(1.35679984092712*x_110 + 4.20128011703491) + 8.7254633581358e-7*std::sin(1.30927979946136*x_118 + 7.02824020385742) - 2.32091079221615e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) + 5.22744774453189e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) + 8.28655607193953e-7*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 4.93604238152823e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) - 6.65408432904303e-8*std::sin(1.08775985240936*x_24 + 2.03655982017517) + 6.31432409209717e-7*std::sin(1.65895986557007*x_28 + 0.5865598320961) - 2.18175375891233e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) - 7.6504803729896e-8*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 1.17195284409408e-8*std::sin(1.68991982936859*x_36 - 6.20679998397827) - 1.24961564455583e-7*std::sin(1.90951979160309*x_4 - 3.20263981819153) - 2.8124283938872e-7*std::sin(0.462319850921631*x_42 - 7.79824018478394) - 6.29340552262351e-7*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 1.46085994401638e-6*std::sin(0.434399873018265*x_49 + 5.23328018188477) - 3.00445194369546e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 1.41690480796683e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) + 5.87541951160428e-9*std::sin(1.52071976661682*x_67 - 4.38895988464355) + 1.05913328422977e-8*std::sin(1.37127983570099*x_71 - 1.19743990898132) + 5.7896545223886e-7*std::sin(1.11815989017487*x_75 + 0.799599885940552) - 1.1783788580154e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 3.30869065636098e-6*std::sin(1.55535984039307*x_78 - 6.17880010604858) + 1.09841322593626e-8*std::sin(1.04719984531403*x_82 + 8.62975978851318) - 7.5508366942904e-7*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 2.00117387988271e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 4.60996030139909e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) + 1.00022636778926e-5*std::sin(0.226879999041557*x_91 + 4.96575975418091) - 4.04914202171037e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) - 8.73353788907434e-6*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 4.63036197134376e-7*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 2.63026645576098e-7*std::sin(1.45119988918304*x_95 - 0.792559862136841) + 3.13582726267363e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0289728126903563);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.34269828839882e-6*x_1 - 5.32837961373958e-7*x_10 + 2.07606649978839e-6*x_100 + 2.62609667905566e-6*x_101 + 6.42648264211176e-6*x_102 + 2.90317202160197e-7*x_103 + 3.15631902369857e-6*x_104 - 6.16392287399588e-7*x_105 - 4.81649520602568e-7*x_106 - 7.60338679121707e-8*x_107 + 1.22967514178523e-6*x_108 + 6.32359106864927e-6*x_109 + 1.1837652863392e-6*x_11 - 7.03810885620897e-7*x_110 - 1.16026467610643e-6*x_111 + 2.2084809202722e-6*x_112 + 4.06373330264264e-6*x_113 + 1.17173715839115e-6*x_114 - 2.33946004254527e-6*x_115 - 7.4193567551892e-7*x_116 + 9.56856508912798e-6*x_117 + 4.21920582155914e-7*x_118 + 3.31505490750901e-8*x_119 + 7.98120034701253e-7*x_12 + 4.54354652524536e-7*x_120 + 1.3437535218558e-6*x_13 + 2.22894702596512e-6*x_14 + 1.30217412748643e-6*x_15 - 4.99209773703796e-7*x_16 + 1.34663221512902e-7*x_17 + 3.03458905071783e-6*x_18 + 3.19200135244579e-6*x_19 + 2.57002976055322e-6*x_2 + 2.23891902009308e-6*x_20 - 1.75592768265272e-7*x_21 + 4.40047651119189e-6*x_22 + 5.28647719940893e-6*x_23 - 1.90372470956806e-6*x_24 + 2.59997590358386e-6*x_25 + 1.87419571362696e-6*x_26 + 4.54189080212968e-6*x_27 - 4.98378441183291e-7*x_28 + 3.49294514271671e-7*x_29 + 2.46509569232724e-6*x_3 + 1.49498170477099e-6*x_30 + 5.68964318977288e-6*x_31 - 5.68037149811449e-7*x_32 + 1.88279015963929e-5*x_33 + 2.7611159703597e-5*x_34 + 8.67924853140805e-7*x_35 + 3.63074913769147e-6*x_36 - 3.72840061546611e-6*x_37 + 1.06837206233677e-5*x_38 + 2.37255345682632e-6*x_39 - 8.58897638917929e-7*x_4 - 7.1272868851728e-7*x_40 + 3.87117656483607e-6*x_41 + 2.0822962524673e-6*x_42 - 1.06620323776512e-6*x_43 + 2.888238837091e-6*x_44 + 2.73613763074008e-6*x_45 - 8.53570926653267e-7*x_46 + 4.75960137525734e-6*x_47 + 1.27879992212909e-6*x_48 + 8.84474694415415e-7*x_49 + 4.43779421966493e-6*x_5 + 7.33152860025333e-7*x_50 - 1.56333062868064e-6*x_51 - 6.04941217206209e-7*x_52 - 6.09595339108226e-6*x_53 - 1.59728021900376e-6*x_54 + 4.83654285555679e-6*x_55 - 2.40633806081871e-6*x_56 - 1.29150937700387e-6*x_57 - 4.21439974246782e-7*x_58 + 9.98661441886957e-7*x_59 + 8.18971186603688e-7*x_6 - 8.40173532488115e-8*x_60 + 6.21547078160055e-7*x_61 + 2.38336957171901e-6*x_62 + 1.59591522821917e-6*x_63 + 2.1504664446536e-6*x_64 + 5.61235305805661e-6*x_65 + 2.1110694991949e-6*x_66 + 1.74933027404342e-8*x_67 - 3.62180827344234e-6*x_68 + 1.17419563833596e-6*x_69 - 3.57587740607049e-7*x_7 + 7.07470110615507e-7*x_70 + 3.35229539081284e-6*x_71 + 7.24865646758943e-7*x_72 - 2.11379912920707e-7*x_73 - 1.36506385692984e-6*x_74 + 2.71049183041469e-6*x_75 + 3.022947831043e-6*x_76 + 2.54928401642174e-7*x_77 + 1.31729595965102e-6*x_78 + 3.22787192843491e-7*x_79 + 4.66267671155401e-7*x_8 + 1.48403446109588e-6*x_80 + 2.42098974690618e-6*x_81 + 1.4221621239836e-6*x_82 + 2.58626967515191e-7*x_83 + 1.07604271029696e-6*x_84 + 4.14642299642372e-6*x_85 + 7.19382834446504e-7*x_86 + 2.10441152816295e-6*x_87 - 1.33801994466462e-6*x_88 - 6.43500962045338e-7*x_89 + 3.76658699969923e-6*x_9 - 1.21239380378632e-6*x_90 - 3.18653140749714e-5*x_91 + 1.02106052932447e-6*x_92 + 6.66916696462612e-6*x_93 + 4.48366505161749e-7*x_94 - 9.55485369224154e-7*x_95 + 3.13642822539109e-6*x_96 + 8.05499096457245e-7*x_97 + 3.77900875817495e-7*x_98 - 1.68295722521019e-6*x_99 - 1.33923293983932e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 5.04314633280653e-9*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) + 2.86610326601858e-9*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) + 5.46760122483595e-10*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) + 2.49663557022893e-8*std::exp(0.480159848928452*x_1) - 2.13207246086926e-7*std::sin(1.02879977226257*x_100 - 2.18503999710083) - 1.08742675616603e-5*std::sin(1.18727993965149*x_103 + 8.20639991760254) - 4.98630197351966e-8*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 3.94462274391845e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) + 1.02162345059316e-5*std::sin(1.30927979946136*x_118 + 7.02824020385742) - 6.53297591974325e-8*std::sin(1.81255984306335*x_120 + 8.193039894104) + 2.61453024248191e-7*std::sin(0.334799855947495*x_19 - 1.57703983783722) + 2.3325270172875e-7*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 1.82529912330473e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) - 7.79095426082584e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) - 6.87769815563124e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) - 1.09121343016613e-6*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 5.7439752239905e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) + 5.76892973271729e-8*std::sin(1.68991982936859*x_36 - 6.20679998397827) + 6.15122432841514e-7*std::sin(1.90951979160309*x_4 - 3.20263981819153) - 3.20301297072889e-5*std::sin(0.257119953632355*x_42 + 4.82496023178101) + 2.11156923828859e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) - 1.77148845489316e-7*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 1.24518600031176e-5*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 5.40211401965013e-7*std::sin(0.434399873018265*x_49 + 5.23328018188477) + 3.27251393663798e-7*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 1.12241841684392e-5*std::sin(1.2753598690033*x_58 + 2.43391990661621) - 6.11891830213298e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) - 4.41126079146027e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) - 7.95196516678618e-7*std::sin(1.37127983570099*x_71 - 1.19743990898132) + 2.50026838930029e-6*std::sin(1.11815989017487*x_75 + 0.799599885940552) - 1.37970836117168e-6*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 1.22352072521558e-6*std::sin(1.55535984039307*x_78 - 6.17880010604858) - 5.40693147326407e-8*std::sin(1.04719984531403*x_82 + 8.62975978851318) - 2.12543431066603e-7*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 8.64209042873925e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 1.7047172301645e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) - 4.92360734620484e-5*std::sin(0.226879999041557*x_91 + 4.96575975418091) - 2.02519561920826e-6*std::sin(0.278159946203232*x_91 - 7.86392021179199) + 9.51275806495265e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 1.99962668293939e-6*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 9.72646238558417e-8*std::sin(1.45119988918304*x_95 - 0.792559862136841) + 1.56839735452843e-8*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0522044019977258);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.04683053254045e-6*x_1 + 7.31246302177145e-7*x_10 + 5.49559336247138e-6*x_100 - 3.4228402330208e-6*x_101 - 3.76017332838243e-7*x_102 - 4.98099510870314e-6*x_103 - 1.46362511757308e-6*x_104 + 1.18044242671362e-8*x_105 + 3.19006819151975e-7*x_106 + 9.20647590993711e-6*x_107 + 1.69951504688777e-6*x_108 - 3.46928097944735e-5*x_109 - 4.39939605269329e-6*x_11 - 7.30964297378838e-7*x_110 + 5.10277501613299e-6*x_111 + 1.4471694312992e-6*x_112 + 4.55956398515786e-6*x_113 + 3.906168600185e-7*x_114 - 1.54489680793866e-6*x_115 + 3.25625239781896e-6*x_116 - 1.02330166119736e-5*x_117 - 1.43396206438533e-6*x_118 - 4.97484967888898e-6*x_119 - 2.37256695555078e-6*x_12 - 1.75983512253298e-6*x_120 - 4.17942195247383e-6*x_13 - 6.10331546519785e-6*x_14 + 9.2321918981896e-7*x_15 + 7.35580117459513e-6*x_16 + 4.31226137750959e-7*x_17 - 4.17179702495391e-6*x_18 - 3.82567835746338e-6*x_19 + 6.83881326617932e-7*x_2 + 2.32582474309252e-7*x_20 + 2.93401058244004e-8*x_21 - 5.65639266621939e-6*x_22 - 1.7244559932389e-6*x_23 + 3.44766250739063e-7*x_24 - 7.45740058028041e-6*x_25 - 9.53006806968211e-6*x_26 - 2.3633030492825e-5*x_27 - 1.27463018371696e-6*x_28 + 1.24844213128091e-6*x_29 + 5.52943982623582e-7*x_3 - 5.53692715338241e-6*x_30 - 1.48806536013757e-5*x_31 - 6.64909404911116e-6*x_32 - 9.9518360656512e-6*x_33 - 9.54347834901131e-5*x_34 - 4.25547212587667e-8*x_35 + 1.70832104716824e-7*x_36 - 6.08752871424974e-6*x_37 + 2.79639372553667e-7*x_38 - 7.62558561216295e-6*x_39 - 8.89285551522383e-7*x_4 + 5.4869034758019e-6*x_40 + 9.68307143316833e-6*x_41 - 2.55774377747659e-5*x_42 + 2.84932246120391e-6*x_43 + 3.23399848530172e-7*x_44 + 2.14793826533849e-6*x_45 + 8.6307582147304e-8*x_46 - 1.37429200070199e-5*x_47 - 2.30392191428179e-7*x_48 - 1.02389163736195e-5*x_49 - 5.84199683294295e-8*x_5 - 9.28016085604425e-7*x_50 + 2.95023749395943e-6*x_51 - 5.03621802754922e-6*x_52 - 2.54797542679059e-6*x_53 + 1.35882163631983e-7*x_54 + 1.43972063999834e-6*x_55 + 4.10502093791613e-6*x_56 + 3.81990684839468e-6*x_57 + 2.35095421851824e-6*x_58 - 5.58562631018658e-8*x_59 + 2.37339558985292e-6*x_6 + 2.1835115023859e-7*x_60 - 2.02577145860312e-6*x_61 - 4.22550104237724e-7*x_62 - 8.24500428116204e-6*x_63 + 1.4965996614264e-6*x_64 - 2.08296707495794e-5*x_65 + 9.7087084873068e-7*x_66 + 1.03753353315574e-5*x_67 - 1.7064440589563e-6*x_68 - 1.05090782161599e-6*x_69 + 9.77102578538486e-7*x_7 + 1.81013363881543e-6*x_70 - 2.62647871406132e-6*x_71 - 1.54681507812356e-7*x_72 - 2.72223652133889e-6*x_73 + 1.53715733534357e-6*x_74 - 2.76408049520652e-6*x_75 - 6.27803684691943e-7*x_76 + 1.83610779310575e-6*x_77 - 2.7454669046245e-6*x_78 + 3.0178762526433e-6*x_79 + 9.21707873494278e-6*x_8 + 9.68536608322219e-7*x_80 - 6.52349496032075e-6*x_81 + 5.34781706194456e-7*x_82 - 3.49387102519523e-6*x_83 + 9.51200444778896e-7*x_84 - 1.33500706493664e-5*x_85 - 1.67224162834635e-6*x_86 - 6.43864873837512e-7*x_87 + 3.3218646646353e-6*x_88 + 1.49002311530296e-6*x_89 - 4.34182274961509e-6*x_9 + 1.23435444283354e-6*x_90 + 0.000176308088947463*x_91 - 9.07719768266814e-6*x_92 - 2.55750494420792e-7*x_93 - 6.11774061041279e-6*x_94 + 3.69561615098309e-7*x_95 + 6.28971335890527e-6*x_96 + 3.45304134007549e-7*x_97 - 2.67686213332938e-7*x_98 - 2.00115955921711e-6*x_99 - 1.48473525233032e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 3.71087032760109e-9*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) - 1.88446596571721e-9*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) + 2.7418541716787e-6*std::exp(0.480159848928452*x_1) + 0.00512652142117746*std::exp(0.000335009496197428*x_1 - 3.98818345415677e-6*x_10 + 0.000215332840751*x_100 + 3.06448453558231e-5*x_101 + 0.0006752566432903*x_102 + 9.0275735880734e-5*x_104 + 5.32595624590748e-5*x_105 - 0.000201039468704335*x_106 + 1.74802688060462e-5*x_107 + 7.55706551481425e-5*x_108 + 5.11518778344253e-5*x_109 - 0.000189409406930548*x_11 - 0.000211188025357863*x_110 - 0.000140435184118865*x_111 + 7.12018350631246e-5*x_112 + 0.000618609257807232*x_113 + 1.67216456644418e-5*x_114 - 3.01860705124776e-5*x_115 + 4.24376713185427e-5*x_116 + 0.000273920359909134*x_117 - 3.72819846266765e-6*x_118 + 0.000112957524456595*x_119 + 3.78821670156346e-6*x_12 - 1.83221309537611e-5*x_120 + 9.17687996643565e-5*x_13 - 7.32975456152821e-5*x_14 + 3.10583184360845e-5*x_15 - 2.60348559198422e-5*x_16 - 5.58583690906818e-6*x_17 - 2.17696975298462e-5*x_18 - 0.0001580938861405*x_19 - 0.000170238318397171*x_2 + 0.00034712660102312*x_20 - 1.98639080057782e-5*x_21 + 0.000325856012188354*x_22 + 0.000680231317539478*x_23 - 0.000127677874778883*x_24 + 5.59918512561064e-5*x_25 + 0.000147595069358024*x_26 + 6.99214568044543e-5*x_27 - 7.98334121085747e-5*x_28 + 2.04175037145613e-5*x_29 + 0.00015396915528338*x_3 + 0.000136128475804819*x_30 - 0.000208698779193814*x_31 - 6.55193860306163e-6*x_32 + 0.000170717967517982*x_33 - 0.000137794716333658*x_34 - 3.99127269266713e-5*x_35 + 0.000428550836444204*x_36 + 4.88597928944111e-5*x_37 + 0.000677138283667312*x_38 + 0.000140999675582778*x_39 - 2.61564393918593e-5*x_4 - 4.68809726552956e-5*x_40 + 0.000215067681415107*x_41 - 8.69086220772449e-5*x_42 + 9.06937006852473e-5*x_43 + 0.000276329906574203*x_44 + 0.000141485990332066*x_45 + 1.78739458042516e-5*x_46 + 5.32711895605682e-5*x_48 - 2.60072099508319e-5*x_49 + 0.000447950934207929*x_5 + 0.000155638736393599*x_50 - 4.19464332866696e-5*x_51 + 2.83566326726088e-5*x_52 - 7.58628479396212e-5*x_53 + 6.55676290698189e-5*x_54 + 0.000538355408842308*x_55 - 3.79611889242711e-5*x_56 - 3.90878361370345e-5*x_59 + 7.30926370758551e-6*x_6 - 7.88738267128302e-5*x_60 - 3.6603640854199e-6*x_61 + 4.11088439392495e-5*x_62 + 0.000476791509262723*x_63 + 3.84607740042226e-6*x_64 + 0.000439224670654132*x_65 - 1.2254021774726e-5*x_66 - 1.57129400374852e-6*x_67 - 0.000576410672087849*x_68 + 2.49852775165917e-5*x_69 - 1.51051535611411e-5*x_7 - 7.91870243100326e-5*x_70 + 7.54618064123991e-5*x_71 - 9.5682380250504e-6*x_72 + 4.15347881808856e-6*x_73 + 4.05155854505441e-5*x_74 - 1.58413701955537e-6*x_75 + 0.000197772333679623*x_76 - 0.000106619504613753*x_77 + 9.76776253711266e-5*x_78 + 8.30790746920145e-5*x_79 + 0.000144014622705264*x_8 + 0.00026577960666047*x_80 + 0.000162469602613443*x_81 + 0.000152322012782845*x_82 - 4.14956987557211e-5*x_83 - 4.40605861245192e-5*x_84 + 0.000110791770107453*x_85 - 7.12951300494588e-5*x_86 + 4.97076686843262e-5*x_87 + 2.77303646329172e-5*x_88 - 2.06525759884895e-5*x_89 + 0.000186565127621268*x_9 - 5.25879126999924e-5*x_90 + 0.00103872010950312*x_91 + 3.81414077518593e-5*x_92 + 0.000114558595695881*x_93 + 1.98622433183558e-5*x_94 - 0.000279567492891823*x_95 + 0.000331830090853941*x_96 + 5.79580176274227e-5*x_97 + 2.3697945535071e-5*x_98 - 0.000376624595179002*x_99 - 5.54364399806521e-7*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 0.00119534639931826*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 0.00136876216583262*std::sin(0.956799805164337*x_47 + 0.626479864120483) - 0.00123381074219037*std::sin(1.2753598690033*x_58 + 2.43391990661621)) + 1.2927332803847e-5*std::exp(0.00189166393868976*x_1 - 0.00148449215987736*x_10 + 0.000558420488551074*x_100 + 6.24114018609995e-5*x_101 - 0.00257504496313805*x_102 + 0.00179453726791559*x_103 - 0.00162975848035896*x_104 + 0.0257239457855353*x_105 - 0.00238782174143585*x_106 - 0.000622483742998097*x_107 - 0.00117941566038091*x_108 - 0.00536360602819718*x_109 - 0.000980895801645345*x_11 - 0.00601705097420042*x_110 - 0.00153344594112644*x_111 + 0.000360378182069189*x_112 + 0.00209841473897205*x_113 - 0.00468804456547496*x_114 + 0.000695853776218877*x_115 - 0.0011890651637979*x_116 + 0.0043672031178052*x_117 - 0.00290183593515969*x_118 - 0.000134251219331258*x_119 - 0.00916259290929161*x_12 + 0.010854164649162*x_120 + 0.0100763938154754*x_13 - 0.00638808567641311*x_14 + 0.000883762775839025*x_15 - 0.00057489451745969*x_16 + 0.000391050374400991*x_17 - 0.00869115661441562*x_18 - 0.00846451221927506*x_19 + 0.00751069702477359*x_2 - 0.00173470407320441*x_20 - 0.00390387810076845*x_21 + 0.00480834829419161*x_22 - 0.00332667870725551*x_23 + 0.0199068278713887*x_24 - 0.00909156156269395*x_25 - 0.000133340840003386*x_26 + 0.00463504953572301*x_27 - 0.00393045086765849*x_28 - 0.000697315667933081*x_29 - 0.000490687797476*x_3 - 0.014518222495322*x_30 - 0.00825642047220056*x_31 + 0.0197441954873888*x_32 + 0.00404636787251516*x_33 - 0.0133704446471652*x_34 + 0.00588040143283065*x_36 + 0.0493318258600159*x_37 - 0.00136291785383175*x_38 + 0.00226102297947631*x_39 - 0.00130032234435798*x_4 - 0.00172446503990644*x_40 - 0.042310126416564*x_41 + 0.0229516584880841*x_43 - 0.0119175115457749*x_44 + 0.00166225709406967*x_45 + 0.00202177243674562*x_46 + 0.00139854031287746*x_47 - 0.000362414588023316*x_48 - 0.00126556557436051*x_49 - 0.00894822969998456*x_5 - 0.00603684541891987*x_50 + 0.00181258107572413*x_51 + 0.00446212106265912*x_52 + 0.000229082361851332*x_53 + 0.00118895740613608*x_54 + 0.00995459251981108*x_55 - 0.00580474446670084*x_56 + 0.00285960936650532*x_57 - 0.00301810319124111*x_58 - 0.00196261953332776*x_59 - 0.000556763526890287*x_6 - 0.00756803391837477*x_60 + 0.00136740788744825*x_61 + 0.0123713758769437*x_62 - 0.00275505047409065*x_63 - 0.00469043638947591*x_64 + 0.00902655997721528*x_65 - 0.0202910160795894*x_66 - 0.000617938843179038*x_68 - 0.00161999737053307*x_69 - 0.00646941855679072*x_7 - 0.00403534639991742*x_70 - 0.0132173998110802*x_72 + 0.00217822417244006*x_73 + 0.00522849556014203*x_74 + 0.00600067520510532*x_75 + 6.80277504841755e-5*x_76 - 0.000508898771471981*x_77 + 0.00092819937527073*x_78 + 0.00298523390065063*x_79 + 0.00100115361549635*x_8 + 0.000161045209796031*x_80 - 0.00114747833381216*x_81 + 0.00250918830022102*x_82 + 0.000856243293057801*x_83 - 0.00371874165502524*x_84 - 0.000491648126565609*x_85 - 0.000619099013188893*x_86 + 0.00111723789470927*x_87 + 0.00194375603226117*x_88 + 0.00561669441972749*x_89 + 0.000360916053321238*x_9 - 8.08850860664158e-5*x_90 - 0.136283838074579*x_91 - 0.0153147776723589*x_92 + 0.00328528909339943*x_93 - 0.00138660642431727*x_94 + 0.00201566360971611*x_95 - 0.00102337761917648*x_96 + 0.000205636734915683*x_97 - 0.0138788203320564*x_98 - 0.00434723647567016*x_99 - 0.0975887106217597*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 0.35875036245368*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 0.00749462238376192*std::sin(1.52071976661682*x_67 - 4.38895988464355) + 0.0135101910658432*std::sin(1.37127983570099*x_71 - 1.19743990898132)) + 4.65360813058422e-5*std::exp(0.0023313241461068*x_1 - 0.00241926861958269*x_10 - 0.00209257601867141*x_100 - 0.00103969518711371*x_101 + 0.000847093296167884*x_102 + 0.00158835410745132*x_103 + 3.19573599034291e-5*x_104 + 0.000619904190616184*x_105 + 0.00262491340699409*x_106 + 0.00603569909864019*x_107 + 0.00336086814465947*x_108 - 0.00452002981170399*x_109 + 0.0104342110511316*x_11 + 0.00272860289020708*x_110 + 0.0104639835614828*x_111 + 0.00827793975332253*x_112 - 0.00154050153802347*x_113 - 0.000239034446551665*x_114 - 0.0255491510810011*x_115 - 0.00174290489809271*x_116 - 0.00431847700950873*x_117 + 0.0189592564827817*x_118 - 0.0029158681095398*x_119 - 0.000173663639212392*x_12 - 0.000268145318422278*x_120 + 0.000262192961713552*x_13 + 0.000869564937868927*x_14 + 0.000334108128387608*x_15 + 0.0140535640777298*x_16 + 0.00686363861546677*x_17 - 0.000591848204048497*x_18 + 0.0267903892487117*x_19 + 0.00475658009071581*x_2 + 0.00225909068857305*x_20 - 0.00458411471799827*x_21 - 0.00149247819702756*x_22 - 0.00498248098674312*x_23 + 0.00171015174922667*x_24 - 0.00850362429362487*x_25 + 0.00228519731649031*x_26 - 0.000684842826063061*x_27 + 0.00607851786070876*x_28 + 0.00174470064194493*x_29 + 0.0141730675469916*x_3 + 0.00229918570267655*x_30 + 3.75503119597258e-5*x_31 - 0.00190193542311534*x_32 - 0.00386260302936905*x_33 - 0.000470347994627331*x_34 - 0.00408541768724604*x_35 + 0.00121944476056281*x_36 + 0.00292158199208392*x_37 + 0.0137346059243963*x_38 - 0.00583995548277452*x_39 - 0.00578166459586638*x_4 + 0.00280367878908432*x_40 + 0.0016316486945748*x_41 + 0.000129376163336279*x_43 - 0.00310872172899457*x_44 + 0.0136765825693806*x_45 - 0.000822917880129535*x_46 + 0.000998717393093553*x_47 - 0.000302499086820846*x_48 + 0.00708065639649973*x_49 - 0.00161728419908288*x_5 - 0.0044651153451695*x_50 + 0.00260405415870509*x_51 - 0.00297937222064702*x_52 + 0.000276624244435351*x_53 + 0.0181401574980094*x_54 + 0.012078905472484*x_55 - 0.000426113432983993*x_56 + 0.00258119584751157*x_57 - 0.00258004365330212*x_58 - 0.00156850200953739*x_59 - 0.0004590287352859*x_6 - 0.0010429288793006*x_60 + 0.0073935803803037*x_61 - 0.001079133458063*x_62 - 0.00435031699028177*x_63 + 0.00618306444739962*x_64 + 0.00294216592648667*x_65 + 0.00172123152401471*x_66 + 0.000803542131453689*x_67 - 0.000269948844472432*x_68 + 0.00658954710464022*x_69 + 0.000277591423645717*x_7 + 0.00428532604624871*x_70 + 0.00407925828794416*x_71 + 0.00107789505706789*x_72 - 0.000100396098306625*x_73 - 0.0112531850823925*x_74 + 0.00223662190712094*x_75 + 0.0146294908746968*x_76 + 0.0187764481694551*x_77 - 9.25553609362924e-5*x_78 - 0.000237930835390185*x_79 + 6.47720013176538e-5*x_8 + 0.00543172279735259*x_80 - 0.00114019495581715*x_81 - 0.000870561532260818*x_82 - 0.00045860893706572*x_83 + 0.000424666654829265*x_84 - 0.00180463930449769*x_85 - 0.000957514541715512*x_86 - 0.00120619064424171*x_87 - 0.00330419230120454*x_88 + 0.00276193218440574*x_89 - 0.00256396757080342*x_9 + 0.000718854388521944*x_90 + 0.0367314458513004*x_91 - 0.00154154694702852*x_92 + 0.00472067406034782*x_93 - 0.00130428925258917*x_94 + 0.00726796568801412*x_95 + 0.00324439863545866*x_96 - 0.00147398077211312*x_97 - 0.000543487986967418*x_98 + 0.000520028734216493*x_99 - 0.435680064379689*std::sin(0.257119953632355*x_42 + 4.82496023178101)) + 2.76048826472531e-7*std::sin(1.02879977226257*x_100 - 2.18503999710083) + 6.45598512006752e-8*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 4.3731902575084e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 5.44916856907646e-5*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 8.45853210487584e-8*std::sin(1.81255984306335*x_120 + 8.193039894104) + 2.87132841405116e-5*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 3.0200256213392e-7*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 6.60003659492797e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 4.15556466098694e-6*std::sin(1.08775985240936*x_24 + 2.03655982017517) - 2.04071470200126e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) - 0.000119839200056678*std::sin(0.352079838514328*x_34 - 4.59624004364014) - 1.98832198854188e-7*std::sin(1.68991982936859*x_36 - 6.20679998397827) - 2.12008382062243e-6*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 2.29362424616431e-7*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 1.95333190951804e-6*std::sin(0.434399873018265*x_49 + 5.23328018188477) + 9.71003256014253e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 6.78371434800281e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) + 2.77191256834428e-6*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 7.35913357492295e-6*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 4.42408669240755e-6*std::sin(1.55535984039307*x_78 - 6.17880010604858) + 1.86355550109401e-7*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 2.75189355883617e-7*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 9.58101905327616e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 6.16402865669463e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) + 0.000169697278403047*std::sin(0.226879999041557*x_91 + 4.96575975418091) - 0.000222410956697314*std::sin(0.278159946203232*x_91 - 7.86392021179199) + 2.82257592590558e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 2.21687813922547e-6*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 3.51695822697926e-7*std::sin(1.45119988918304*x_95 - 0.792559862136841) + 1.72244474950315e-6*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0638965698626662);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.75142962918926e-5*x_1 + 4.06207347161581e-6*x_10 - 1.08556078146895e-7*x_100 + 6.22189661159039e-7*x_101 - 2.04599583076723e-6*x_102 + 1.11528366402835e-6*x_103 + 3.53431403049848e-8*x_104 - 3.7587522808507e-6*x_105 + 9.50151574514715e-7*x_106 - 3.84222370677029e-6*x_107 + 1.06952461538768e-6*x_108 - 2.34615213636797e-6*x_109 - 2.11531478294081e-6*x_11 + 6.63674235535275e-7*x_110 - 1.19393561251834e-6*x_111 + 3.03254417922371e-10*x_112 - 3.02917685081298e-8*x_113 - 7.6194074767718e-7*x_114 - 3.85582224043176e-7*x_115 - 2.81047538933956e-6*x_116 - 2.21479587076249e-6*x_117 - 3.61740708592665e-7*x_118 + 2.29072156313004e-6*x_119 + 3.34162108541636e-6*x_12 + 1.00000598903005e-5*x_120 + 4.35376502642467e-6*x_13 - 4.78223124079272e-6*x_14 - 6.17605067333015e-7*x_15 + 3.78474787168865e-6*x_16 - 2.16690947404092e-7*x_17 + 5.09408043105586e-7*x_18 - 1.54145175664433e-6*x_19 - 3.07649097302502e-6*x_2 + 5.29499722268435e-6*x_20 - 7.18050498210871e-7*x_21 + 5.83004665957544e-7*x_22 + 3.69594547248273e-6*x_23 + 1.14121051248641e-7*x_24 + 2.28304940147922e-6*x_25 - 1.12182524000583e-6*x_26 - 3.71916280815681e-6*x_27 + 4.24765855353947e-6*x_28 + 4.22157700082542e-6*x_29 - 2.82741752563688e-6*x_3 + 5.89500754808799e-7*x_30 - 1.50515440346169e-5*x_31 + 1.41212221127157e-5*x_32 + 6.52847415493768e-6*x_33 - 1.04697403495053e-5*x_34 - 6.00102398978291e-6*x_35 - 6.56714611564505e-7*x_36 + 2.44163478011399e-6*x_37 - 9.89786325141491e-7*x_38 - 1.06198175001492e-6*x_39 + 1.24779105547914e-6*x_4 - 2.20607185320898e-6*x_40 - 1.10088327068721e-6*x_41 - 3.17706698090581e-6*x_42 - 3.05506740741712e-6*x_43 - 1.15359784579944e-6*x_44 - 1.16501745311184e-7*x_45 + 1.60892789253312e-6*x_46 - 7.18621096887849e-6*x_47 - 4.03469392746168e-6*x_48 + 3.27551247273897e-6*x_49 + 3.30659517402105e-7*x_5 - 7.73501492781522e-7*x_50 + 7.89616922895992e-7*x_51 + 8.65060383280715e-6*x_52 + 6.3229036052202e-6*x_53 + 2.11376977109869e-6*x_54 - 3.42579013941826e-6*x_55 - 1.60537671251258e-6*x_56 + 2.43180539379955e-6*x_57 + 3.33445612134924e-7*x_58 + 3.97588494649664e-7*x_59 + 5.51678776531185e-7*x_6 - 3.23750927906646e-7*x_60 - 3.57753451487061e-7*x_61 - 1.03636087461348e-5*x_62 + 1.23839871279719e-5*x_63 - 5.92154782175281e-6*x_64 + 6.62367517779729e-6*x_65 + 1.25817437147174e-6*x_66 + 7.05155536024979e-7*x_67 + 7.28492478886557e-8*x_68 - 2.09695723215326e-6*x_69 + 1.05157302157757e-6*x_7 - 9.39130043111119e-6*x_70 - 6.80454739114635e-7*x_71 - 9.77962480232072e-7*x_72 - 2.45941102354273e-6*x_73 + 1.10950844285701e-6*x_74 - 2.4620301896e-7*x_75 - 1.15074759838013e-6*x_76 - 4.64368624724531e-6*x_77 - 1.31451164276279e-6*x_78 - 3.55692905099788e-7*x_79 - 1.33427263904278e-5*x_8 + 1.32738390936511e-6*x_80 + 4.42392660187006e-6*x_81 - 3.30609866410169e-6*x_82 - 5.43040294161803e-6*x_83 + 2.94006037342408e-6*x_84 - 2.28680607696148e-6*x_85 + 1.38639209946649e-7*x_86 - 4.91501249414789e-7*x_87 + 2.8584451506243e-6*x_88 + 2.80262049076637e-6*x_89 - 8.76053821651904e-7*x_9 - 1.00923914824477e-6*x_90 + 1.96282915704116e-5*x_91 + 6.50337054580022e-6*x_92 - 4.46268788553421e-5*x_93 - 8.07927807004233e-7*x_94 - 2.37085552901543e-6*x_95 + 1.01627690494607e-7*x_96 - 8.30177512091181e-7*x_97 - 3.54398339038241e-7*x_98 - 2.08485267616368e-6*x_99 + 9.59702289572461e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) + 4.94638753850935e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) - 5.08165730260999e-10*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 3.71650465499429e-7*std::exp(0.480159848928452*x_1) - 5.25497747092203e-5*std::exp(-0.0113437964414428*x_1 + 0.000135044354827552*x_10 - 0.00729141096107153*x_100 - 0.00103766875757781*x_101 - 0.0228649456035209*x_102 - 0.00305683744209149*x_104 - 0.00180342838622105*x_105 + 0.00680742138823975*x_106 - 0.000591901463475631*x_107 - 0.00255890695242204*x_108 - 0.00173205982617673*x_109 + 0.00641361448168717*x_11 + 0.00715106287350745*x_110 + 0.0047552924915362*x_111 - 0.00241097381531322*x_112 - 0.020946801738485*x_113 - 0.000566213634945968*x_114 + 0.00102213412797943*x_115 - 0.0014369870417127*x_116 - 0.00927524992349704*x_117 + 0.000126240972073456*x_118 - 0.00382486818585517*x_119 - 0.000128273256807279*x_12 + 0.000620407857902748*x_120 - 0.00310739425265283*x_13 + 0.00248193691986309*x_14 - 0.00105166941878216*x_15 + 0.000881569356359191*x_16 + 0.00018914268870225*x_17 + 0.000737146320248853*x_18 + 0.00535323590337153*x_19 + 0.00576445997009282*x_2 - 0.0117540951707698*x_20 + 0.00067261415424565*x_21 - 0.0110338492294756*x_22 - 0.0230333936406235*x_23 + 0.00432331572091954*x_24 - 0.00189594674252011*x_25 - 0.00499773421817084*x_26 - 0.00236761877463746*x_27 + 0.00270324867343997*x_28 - 0.000691359524459249*x_29 - 0.00521356790067306*x_3 - 0.0046094625285001*x_30 + 0.00706677421274374*x_31 + 0.000221855973199524*x_32 - 0.00578070142608603*x_33 + 0.00466588329745195*x_34 + 0.00135148959900597*x_35 - 0.0145112109018193*x_36 - 0.00165444726509669*x_37 - 0.0229286600523801*x_38 - 0.00477440680421165*x_39 + 0.000885686308782512*x_4 + 0.00158744219735525*x_40 - 0.00728243236922544*x_41 + 0.00294282320065804*x_42 - 0.00307099019810558*x_43 - 0.00935683987003574*x_44 - 0.0047908739658444*x_45 - 0.000605231807188302*x_46 - 0.0018038220928892*x_48 + 0.000880633232910635*x_49 - 0.0151681199222314*x_5 - 0.00527010178544879*x_50 + 0.00142035317222209*x_51 - 0.000960187315446346*x_52 + 0.00256880092732667*x_53 - 0.00222019329529013*x_54 - 0.0182293166025894*x_55 + 0.00128540833833053*x_56 + 0.00132355787375557*x_59 - 0.000247499848741041*x_6 + 0.00267075603809362*x_60 + 0.000123944024148203*x_61 - 0.00139199145959454*x_62 - 0.0161446940683055*x_63 - 0.000130232484821004*x_64 - 0.0148726388729709*x_65 + 0.000414934890441375*x_66 + 5.32057733601636e-5*x_67 + 0.0195179104027142*x_68 - 0.000846029457069912*x_69 + 0.000511477403354979*x_7 + 0.00268136125922597*x_70 - 0.00255522121242005*x_71 + 0.000323991247088351*x_72 - 0.000140641440827918*x_73 - 0.00137190306326721*x_74 + 5.36406522476601e-5*x_75 - 0.00669679254013928*x_76 + 0.00361025574126749*x_77 - 0.00330747370349342*x_78 - 0.00281315044064973*x_79 - 0.00487649628772596*x_8 - 0.00899959490839731*x_80 - 0.00550140255989304*x_81 - 0.00515779381233168*x_82 + 0.00140509079659918*x_83 + 0.00149194075320377*x_84 - 0.00375153331995528*x_85 + 0.00241413288795443*x_86 - 0.00168315728817841*x_87 - 0.000938981178782518*x_88 + 0.000699319334717574*x_89 - 0.00631730400131779*x_9 + 0.00178068557375318*x_90 - 0.0351722253117642*x_91 - 0.00129151074951076*x_92 - 0.00387908224973355*x_93 - 0.00067255778606662*x_94 + 0.0094664681658469*x_95 - 0.0112361382185246*x_96 - 0.00196252333613726*x_97 - 0.000802438955556711*x_98 + 0.012752930263307*x_99 + 1.87713989518727e-5*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) + 0.0404757667612112*std::sin(1.18727993965149*x_103 + 8.20639991760254) - 0.0463478186803497*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 0.0417782124552817*std::sin(1.2753598690033*x_58 + 2.43391990661621)) - 0.00038818878445651*std::exp(-0.000742376714521531*x_1 + 0.000770381369896624*x_10 + 0.000666350799918607*x_100 + 0.000331076010344708*x_101 - 0.000269744702448391*x_102 - 0.000505788569022299*x_103 - 1.01763626004168e-5*x_104 - 0.000197399592466062*x_105 - 0.000835866000977162*x_106 - 0.00192198175194631*x_107 - 0.00107022022456163*x_108 + 0.00143933862082449*x_109 - 0.00332262475456232*x_11 - 0.000868884428726322*x_110 - 0.0033321053831804*x_111 - 0.00263599110717452*x_112 + 0.000490550605081255*x_113 + 7.61170888161719e-5*x_114 + 0.00813576047329239*x_115 + 0.00055500305014654*x_116 + 0.00137515702370673*x_117 - 0.00603730311847151*x_118 + 0.000928516350140826*x_119 + 5.53006934388101e-5*x_12 + 8.53870281561186e-5*x_120 - 8.34915855920874e-5*x_13 - 0.000276900474228898*x_14 - 0.000106391938273164*x_15 - 0.00447515577993113*x_16 - 0.00218562720826377*x_17 + 0.000188465566210827*x_18 - 0.00853101495320781*x_19 - 0.00151466466214105*x_2 - 0.000719375006684382*x_20 + 0.00145974553946967*x_21 + 0.000475258261385321*x_22 + 0.00158659956028908*x_23 - 0.000544573279972363*x_24 + 0.00270785710994712*x_25 - 0.00072768828765512*x_26 + 0.00021807836890694*x_27 - 0.00193561677218037*x_28 - 0.000555574879003267*x_29 - 0.00451320994457084*x_3 - 0.000732142688470959*x_30 - 1.19573579111563e-5*x_31 + 0.000605644038390103*x_32 + 0.00122999049756016*x_33 + 0.000149775568325123*x_34 + 0.00130094262746375*x_35 - 0.000388314682194193*x_36 - 0.000930335854029785*x_37 - 0.00437358813377735*x_38 + 0.00185965000684016*x_39 + 0.00184108811051113*x_4 - 0.000892791271213801*x_40 - 0.000519575108915933*x_41 - 4.11979823721122e-5*x_43 + 0.000989927817367941*x_44 - 0.00435511142913975*x_45 + 0.000262046388183207*x_46 - 0.000318027219963575*x_47 + 9.63264926478978e-5*x_48 - 0.00225473340593476*x_49 + 0.000515000941489725*x_5 + 0.00142185189710412*x_50 - 0.000829223672737208*x_51 + 0.000948738322894428*x_52 - 8.80870204531006e-5*x_53 - 0.00577647280270497*x_54 - 0.00384635408793472*x_55 + 0.000135689707036413*x_56 - 0.000821944771606407*x_57 + 0.000821577871897016*x_58 + 0.000499466953364382*x_59 + 0.000146171112644972*x_6 + 0.000332105733210784*x_60 - 0.00235437955740594*x_61 + 0.000343634561699584*x_62 + 0.00138529600860773*x_63 - 0.00196890813223068*x_64 - 0.000936890512514047*x_65 - 0.000548101475233635*x_66 - 0.000255876459103465*x_67 + 8.59613351420877e-5*x_68 - 0.0020983467004779*x_69 - 8.83950047914192e-5*x_7 - 0.00136460057524833*x_70 - 0.00129898125515746*x_71 - 0.000343240210676564*x_72 + 3.19696965932933e-5*x_73 + 0.00358341528067652*x_74 - 0.000712220145709098*x_75 - 0.00465855140256528*x_76 - 0.00597909043480791*x_77 + 2.94729263101329e-5*x_78 + 7.57656596811299e-5*x_79 - 2.06257141940061e-5*x_8 - 0.00172965416723548*x_80 + 0.000363078719287963*x_81 + 0.000277217825409598*x_82 + 0.000146037433926815*x_83 - 0.000135229001297598*x_84 + 0.000574661485837002*x_85 + 0.000304906763296907*x_86 + 0.000384094099078468*x_87 + 0.00105217261564072*x_88 - 0.000879497664112676*x_89 + 0.000816458674153669*x_9 - 0.00022890886282866*x_90 - 0.0116966017515201*x_91 + 0.000490883500574914*x_92 - 0.0015032309021036*x_93 + 0.000415332192968473*x_94 - 0.00231437936150298*x_95 - 0.0010331321809591*x_96 + 0.000469368021901454*x_97 + 0.000173065949160511*x_98 - 0.000165595686815635*x_99 + 0.138736063501444*std::sin(0.257119953632355*x_42 + 4.82496023178101)) - 3.67958013818972e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) - 8.60547567754744e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) + 2.82674011833396e-5*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 5.2695239315703e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) - 1.12747614721116e-6*std::sin(1.81255984306335*x_120 + 8.193039894104) - 3.89200327539848e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) + 4.02552926418963e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) - 5.75220297126186e-7*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 4.01856671392527e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) + 4.29665281849634e-7*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 1.62438597012893e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 2.77577528765099e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 5.36171580534136e-8*std::sin(1.68991982936859*x_36 - 6.20679998397827) - 5.7170252077813e-7*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 1.02041556260988e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) - 3.05727589155188e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) - 1.70240898700849e-7*std::sin(0.434399873018265*x_49 + 5.23328018188477) - 2.04441310322866e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) + 4.38485324664163e-6*std::sin(2.0511999130249*x_59 - 9.80607986450195) - 2.13174120967264e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) - 3.84278614330302e-7*std::sin(1.37127983570099*x_71 - 1.19743990898132) - 1.79170719773741e-5*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 7.11652245605816e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) + 3.85577325991546e-7*std::sin(1.55535984039307*x_78 - 6.17880010604858) + 5.02527007291915e-8*std::sin(1.04719984531403*x_82 + 8.62975978851318) - 3.66812386449808e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) - 6.19297339874899e-6*std::sin(1.69791984558105*x_86 + 0.384719848632813) - 5.37220414523611e-7*std::sin(0.532079875469208*x_87 - 7.78791999816895) + 4.57606255415541e-5*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 3.01471669947063e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) - 5.94283404513573e-6*std::sin(0.48871985077858*x_92 - 4.95479965209961) - 1.43294437346902e-5*std::sin(1.01863980293274*x_94 + 6.77767992019653) + 3.06517354442861e-8*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 2.33472443415166e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0516769968831042);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.44186455297227e-6*x_1 - 6.30037565539542e-7*x_10 - 9.93869058904734e-8*x_100 + 3.93155983939143e-7*x_101 + 2.92913922368078e-6*x_102 - 6.90253301163433e-7*x_103 - 7.98962919723191e-7*x_104 + 5.99836919745155e-7*x_105 - 1.01793054394115e-6*x_106 + 1.87412350018669e-7*x_107 - 6.75298124904608e-7*x_108 + 3.20378105044175e-6*x_109 - 4.61367320367932e-7*x_11 - 7.46556771116402e-7*x_110 - 4.32140265868306e-7*x_111 - 8.06075062860312e-7*x_112 + 1.43364414810113e-6*x_113 + 1.00221952929421e-6*x_114 + 9.10581648040906e-7*x_115 + 7.03592164783675e-7*x_116 + 9.63354499426975e-7*x_117 - 1.21736457933818e-8*x_118 + 6.43494048669216e-7*x_119 - 5.30374332843197e-7*x_12 - 2.53054458822254e-6*x_120 - 1.03724668114879e-6*x_13 - 6.92352358928634e-7*x_14 + 3.31031168027862e-7*x_15 - 1.75731196935509e-6*x_16 - 2.12496682968675e-7*x_17 - 5.06216253989305e-8*x_18 - 7.55259550480589e-7*x_19 - 6.99706883581647e-7*x_2 - 8.45976185561545e-7*x_20 - 7.02444917490761e-7*x_21 + 2.91542713621873e-7*x_22 + 1.33022231546345e-6*x_23 - 2.25413954699685e-7*x_24 + 5.44616037294748e-7*x_25 + 1.60069173456013e-6*x_26 + 2.28194572596988e-6*x_27 - 1.27340502094181e-6*x_28 - 2.44420193266239e-6*x_29 + 2.94805854021215e-6*x_3 - 6.06624064231397e-7*x_30 + 1.18116883921115e-5*x_31 - 2.40573026489337e-6*x_32 - 4.09617683791394e-6*x_33 + 6.34885284913099e-6*x_34 + 1.96978514976459e-6*x_35 - 7.5462206481828e-8*x_36 - 1.0086509421473e-6*x_37 + 1.39788492198885e-6*x_38 + 1.87443004084687e-6*x_39 + 1.09043960409853e-6*x_4 + 3.77516628909152e-8*x_40 + 3.93944537054836e-6*x_41 + 3.04454932142193e-6*x_42 + 9.08455260405765e-7*x_43 + 2.09023977981167e-6*x_44 - 8.43378229424171e-7*x_45 - 1.03668168975853e-6*x_46 + 2.25451056175664e-6*x_47 + 6.4964101439079e-7*x_48 - 2.80671549147327e-7*x_49 + 1.35330929658135e-6*x_5 + 8.75361903285542e-8*x_50 - 6.56478162319351e-7*x_51 - 1.51772664319097e-6*x_52 - 1.75128404826552e-7*x_53 - 7.60232127368818e-7*x_54 + 3.69935430250146e-6*x_55 + 1.55577253758916e-6*x_56 - 4.0502411629757e-7*x_57 + 2.38281554735025e-7*x_58 - 6.7877849520644e-7*x_59 - 1.72427999359682e-7*x_6 - 4.31097834955776e-7*x_60 - 1.36415132044781e-6*x_61 + 3.10017038134079e-6*x_62 - 5.13428598799558e-7*x_63 + 8.14182612484967e-7*x_64 + 1.18532980426063e-6*x_65 + 2.56241052036691e-7*x_66 - 1.38201997563816e-6*x_67 - 1.484506332983e-6*x_68 + 5.22724929146361e-7*x_69 - 1.81743578835754e-7*x_7 + 1.98609865823479e-6*x_70 + 2.51726159222056e-7*x_71 - 1.09982400935804e-7*x_72 + 9.62502824869066e-7*x_73 - 1.06680391876854e-6*x_74 - 4.33768100638601e-7*x_75 + 6.96002071355146e-7*x_76 + 7.00555185147986e-7*x_77 + 6.61513214352214e-7*x_78 - 6.71788809515587e-7*x_79 + 3.44286343526828e-6*x_8 + 6.34775068037546e-8*x_80 - 2.87374379713853e-7*x_81 + 7.69264097436915e-7*x_82 + 2.91575662013142e-6*x_83 - 1.62179694205366e-6*x_84 + 1.49597096098676e-6*x_85 - 1.06990073716278e-7*x_86 + 1.92294232290456e-7*x_87 + 1.04105937923914e-7*x_88 + 5.77189514130629e-7*x_89 + 1.88087879933968e-6*x_9 + 4.252556751451e-7*x_90 - 9.43872853991412e-6*x_91 - 5.83269871333953e-7*x_92 + 8.06849640762975e-6*x_93 + 4.49167027099853e-7*x_94 - 6.4366028681618e-7*x_95 + 5.10631617706082e-7*x_96 - 4.71290521490802e-7*x_97 + 5.33082433427997e-7*x_98 - 2.32614353890478e-7*x_99 - 1.62839349451156e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 1.28842608718431e-9*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 4.07273048488749e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) + 1.22043718006054e-9*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) + 2.18094935689836e-7*std::exp(0.480159848928452*x_1) - 6.48445986296452e-5*std::exp(0.00144909321960929*x_1 - 0.00113718270959451*x_10 + 0.000427773309571444*x_100 + 4.78097284688567e-5*x_101 - 0.00197259149469064*x_102 + 0.00137469015192722*x_103 - 0.00124846275027303*x_104 + 0.0197056118991386*x_105 - 0.0018291707233934*x_106 - 0.000476848425794036*x_107 - 0.000903481427965887*x_108 - 0.00410874520000605*x_109 - 0.000751406963063439*x_11 - 0.00460931119445912*x_110 - 0.00117468334119793*x_111 + 0.000276064669548703*x_112 + 0.00160747292792333*x_113 - 0.00359123703429128*x_114 + 0.000533052921470146*x_115 - 0.000910873348744286*x_116 + 0.00334545914696214*x_117 - 0.00222292696501423*x_118 - 0.000102842015264061*x_119 - 0.00701892708706557*x_12 + 0.00831474136390094*x_120 + 0.0077189365708542*x_13 - 0.00489353920146367*x_14 + 0.000676999027162537*x_15 - 0.000440393100593975*x_16 + 0.000299560844016855*x_17 - 0.0066577872860628*x_18 - 0.00648416825704641*x_19 + 0.00575350616488339*x_2 - 0.00132885543731951*x_20 - 0.00299053292199623*x_21 + 0.00368339469190237*x_22 - 0.00254837419052433*x_23 + 0.0152494577405431*x_24 - 0.00696451412256951*x_25 - 0.000102144626851506*x_26 + 0.00355064063832692*x_27 - 0.00301088876614965*x_28 - 0.000534172791298781*x_29 - 0.000375887252341445*x_3 - 0.0111215620007654*x_30 - 0.00632476132774206*x_31 + 0.0151248745732462*x_32 + 0.00309968601091373*x_33 - 0.0102423164522492*x_34 + 0.00450463196480757*x_36 + 0.0377902294919307*x_37 - 0.00104405173692744*x_38 + 0.00173203760029877*x_39 - 0.000996100974373254*x_4 - 0.00132101191214363*x_40 - 0.0324113158035469*x_41 + 0.0175819245763639*x_43 - 0.00912930929346756*x_44 + 0.00127335803944765*x_45 + 0.00154876173815012*x_46 + 0.001071340021497*x_47 - 0.000277624641169529*x_48 - 0.000969475843604129*x_49 - 0.00685471595696616*x_5 - 0.00462447456203314*x_50 + 0.00138851245884787*x_51 + 0.00341817023876545*x_52 + 0.000175486612870983*x_53 + 0.000910790801895504*x_54 + 0.00762563171470249*x_55 - 0.00444667558344796*x_56 + 0.0021905796579303*x_57 - 0.00231199251677755*x_58 - 0.00150344815495499*x_59 - 0.000426504008054039*x_6 - 0.00579742860906154*x_60 + 0.00104749128934286*x_61 + 0.00947698823974741*x_62 - 0.00211048319949016*x_63 - 0.00359306927091185*x_64 + 0.00691472020576723*x_65 - 0.0155437618799681*x_66 - 0.000473366843586489*x_68 - 0.00124098533434556*x_69 - 0.00495584356910315*x_7 - 0.00309124310470568*x_70 - 0.0101250777452404*x_72 + 0.00166861027189546*x_73 + 0.00400524496449774*x_74 + 0.00459676667453872*x_75 + 5.21120850039416e-5*x_76 - 0.000389837615511309*x_77 + 0.000711039309700026*x_78 + 0.00228681327370278*x_79 + 0.000766925290655985*x_8 + 0.000123367325872706*x_80 - 0.000879016108076521*x_81 + 0.00192214255302225*x_82 + 0.000655917959278435*x_83 - 0.00284871070783758*x_84 - 0.000376622904348065*x_85 - 0.000474255582046048*x_86 + 0.000855850674531088*x_87 + 0.00148899792892139*x_88 + 0.00430262142961923*x_89 + 0.000276476701288816*x_9 - 6.1961338580859e-5*x_90 - 0.104399085723964*x_91 - 0.0117317563817442*x_92 + 0.00251666802561079*x_93 - 0.00106219816672965*x_94 + 0.00154408212268186*x_95 - 0.000783949801398503*x_96 + 0.000157526287927922*x_97 - 0.0106317533616932*x_98 - 0.00333016386900897*x_99 - 0.0747570094138155*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 0.27481769204951*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 0.00574119232159376*std::sin(1.52071976661682*x_67 - 4.38895988464355) + 0.0103493680186659*std::sin(1.37127983570099*x_71 - 1.19743990898132)) + 3.02967328858102e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) - 2.77816447925046e-6*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 7.08553117927905e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 4.79632618300877e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) + 4.19557654012713e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 9.28335363935966e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) + 2.28393687846454e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 3.31451905545852e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 1.39838545071337e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) - 3.19956877486964e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) + 9.8965789229937e-7*std::sin(1.65895986557007*x_28 + 0.5865598320961) - 9.53235328831531e-6*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 1.28769748294438e-7*std::sin(1.68991982936859*x_36 - 6.20679998397827) + 1.37303043228358e-6*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 1.44413954246287e-5*std::sin(0.257119953632355*x_42 + 4.82496023178101) + 2.51728369993171e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 3.18120875407068e-6*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 4.13862996575399e-7*std::sin(0.434399873018265*x_49 + 5.23328018188477) - 4.70894356188304e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 2.86756138641138e-6*std::sin(1.2753598690033*x_58 + 2.43391990661621) - 7.44008488757493e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) + 3.04011397760122e-6*std::sin(1.11815989017487*x_75 + 0.799599885940552) - 5.66615031104489e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 9.37355175895786e-7*std::sin(1.55535984039307*x_78 - 6.17880010604858) - 1.20689493045626e-7*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 3.02024048236762e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 1.05080478641961e-6*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 1.3060060906217e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) - 0.000109901092238267*std::sin(0.226879999041557*x_91 + 4.96575975418091) - 1.76912046594794e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) - 1.36882658754174e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 2.43137618937368e-6*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 7.45156961577141e-8*std::sin(1.45119988918304*x_95 - 0.792559862136841) + 1.37008189841908e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0725867524368364);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.27210566842359e-7*x_1 - 4.05085549184451e-7*x_10 + 1.19590458914931e-7*x_100 - 1.44467942554695e-6*x_101 + 3.03533518940265e-6*x_102 + 1.86722005859577e-8*x_103 - 1.27533104639133e-6*x_104 - 2.62982569582528e-6*x_105 + 1.87119918028329e-7*x_106 + 4.34807492091642e-7*x_107 - 6.83480353653309e-7*x_108 - 1.4161058055895e-7*x_109 - 1.60184925058767e-6*x_11 + 3.33198987748901e-7*x_110 + 1.77875726470631e-8*x_111 - 1.82727312879094e-6*x_112 + 8.78115712359324e-7*x_113 + 4.8479093125773e-7*x_114 + 2.84015906639328e-6*x_115 - 4.25636092546629e-7*x_116 - 2.8879755902232e-6*x_117 - 2.49853526927236e-7*x_118 - 5.54406568670873e-7*x_119 + 1.48835034483752e-7*x_12 - 9.94708705636657e-7*x_120 - 1.79723549919725e-6*x_13 - 1.50570917260758e-6*x_14 + 8.48197292925038e-8*x_15 - 1.26237002894248e-6*x_16 - 3.87988163317288e-7*x_17 - 3.51769041369581e-7*x_18 - 2.78627436273201e-6*x_19 - 1.12972249355531e-6*x_2 - 9.81446804233733e-7*x_20 + 1.0667119050919e-6*x_21 - 1.50113252127177e-6*x_22 + 5.23826011316669e-7*x_23 - 1.46978891215099e-6*x_24 + 1.08037642363607e-6*x_25 - 2.02832348620934e-7*x_26 - 2.04636649301213e-6*x_27 - 7.88991444939467e-7*x_28 - 1.79260494922985e-6*x_29 + 2.04638242920569e-6*x_3 + 4.85804431092269e-7*x_30 - 2.11470925503836e-5*x_31 - 4.71469271061933e-6*x_32 - 9.18963738711858e-6*x_33 - 1.13194496754053e-5*x_34 + 2.55074279551953e-6*x_35 - 1.72398056897784e-6*x_36 - 5.59042242303246e-6*x_37 - 1.20192305102711e-6*x_38 - 5.27686333879546e-7*x_39 + 1.8170560879453e-6*x_4 + 5.35485900500206e-7*x_40 + 8.33622294841872e-6*x_41 - 1.02652864451781e-7*x_42 - 7.58464580435255e-7*x_43 + 2.15563769070516e-6*x_44 - 1.20401950381861e-6*x_45 - 5.66870474844662e-7*x_46 - 2.05552014920999e-6*x_47 + 3.91149791972685e-7*x_48 - 1.80519726161053e-6*x_49 + 1.39237331733354e-6*x_5 + 1.55029157406744e-6*x_50 - 2.87951531475377e-7*x_51 - 9.78191858506047e-7*x_52 + 1.92873949503726e-6*x_53 - 2.88270119810565e-6*x_54 + 1.07843137472177e-6*x_55 + 1.67827218247578e-6*x_56 + 8.50859924756912e-8*x_57 + 2.34354203871883e-7*x_58 - 3.00438708155749e-7*x_59 + 4.9851654990907e-8*x_6 + 1.02886208804784e-6*x_60 + 2.60602518648738e-7*x_61 + 2.65661793259187e-7*x_62 + 1.2290265252036e-7*x_63 + 3.3185491171301e-7*x_64 - 2.53915083122055e-6*x_65 + 1.88288846395511e-6*x_66 + 8.55585629571457e-7*x_67 - 1.00435222250576e-6*x_68 - 2.56158143781594e-7*x_69 + 3.05749861122724e-10*x_7 + 2.46818282909299e-6*x_70 - 1.3613396718228e-6*x_71 + 1.72333227776158e-6*x_72 + 4.35827259965871e-7*x_73 + 9.11649372580512e-7*x_74 - 1.78189141478946e-6*x_75 - 6.07816143955133e-7*x_76 + 3.68629581056379e-7*x_77 + 3.75649886052557e-7*x_78 - 7.25569948468087e-7*x_79 - 8.34810245433697e-7*x_8 - 9.022079881243e-8*x_80 - 1.19711370374073e-6*x_81 + 1.72952158555341e-7*x_82 + 2.15499362647082e-6*x_83 - 8.04932232987217e-7*x_84 - 9.25771691171098e-7*x_85 + 6.77060153889961e-7*x_86 - 5.90630342867233e-7*x_87 + 6.29493889615109e-7*x_88 + 2.47177630865241e-7*x_89 + 1.5547559061798e-6*x_9 + 5.99463612814163e-7*x_90 + 2.70096107763252e-5*x_91 + 8.68580264291715e-7*x_92 + 3.64320493633228e-6*x_93 - 9.17901909625962e-7*x_94 - 9.06425482433889e-7*x_95 + 1.09875439593846e-8*x_96 + 4.71383074409695e-7*x_97 + 1.1930120443078e-6*x_98 - 8.45632547084308e-8*x_99 - 1.05731204934045e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 4.15233157203672e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) - 3.52342131115185e-9*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 7.25263218734495e-7*std::exp(0.480159848928452*x_1) + 0.000613288935504118*std::exp(0.00291709569583567*x_1 - 3.47271134710391e-5*x_10 + 0.00187501103716962*x_100 + 0.000266840037377148*x_101 + 0.00587979824478091*x_102 + 0.000786076106991586*x_104 + 0.000463757720825618*x_105 - 0.00175055147841211*x_106 + 0.000152209467119456*x_107 + 0.000658031594227449*x_108 + 0.000445405053762352*x_109 - 0.00164928269789186*x_11 - 0.00183892005085253*x_110 - 0.00122283957854021*x_111 + 0.000619990086716344*x_112 + 0.00538654104983973*x_113 + 0.000145603754964265*x_114 - 0.000262845254733458*x_115 + 0.000369526087319193*x_116 + 0.00238516194902664*x_117 - 3.24632937636484e-5*x_118 + 0.000983577815389444*x_119 + 3.29859026697895e-5*x_12 - 0.0001595399830465*x_120 + 0.00079907696215017*x_13 - 0.000638238489525239*x_14 + 0.00027044035485013*x_15 - 0.000226698547377048*x_16 - 4.86386833508748e-5*x_17 - 0.000189559674232441*x_18 - 0.00137660275315482*x_19 - 0.00148235041543429*x_2 + 0.00302260540446848*x_20 - 0.000172965009063454*x_21 + 0.00283739171995483*x_22 + 0.0059231152283446*x_23 - 0.001111755288129*x_24 + 0.000487549129666471*x_25 + 0.00128518429011077*x_26 + 0.000608841191088598*x_27 - 0.000695149556920489*x_28 + 0.00017778544453664*x_29 + 0.00134068665296554*x_3 + 0.00118533890936897*x_30 - 0.0018172449361067*x_31 - 5.70510153154201e-5*x_32 + 0.00148652696088064*x_33 - 0.00119984770129897*x_34 - 0.000347540130200497*x_35 + 0.00373160705779349*x_36 + 0.000425446720673594*x_37 + 0.00589618263121531*x_38 + 0.0012277548888177*x_39 - 0.000227757235643893*x_4 - 0.000408216140442655*x_40 + 0.00187270216185049*x_41 - 0.000756756958444947*x_42 + 0.000789715536160298*x_43 + 0.00240614308026433*x_44 + 0.00123198947523412*x_45 + 0.000155637410177935*x_46 + 0.000463858963829493*x_48 - 0.000226457820059994*x_49 + 0.00390053343847137*x_5 + 0.00135522453301297*x_50 - 0.000365248631412202*x_51 + 0.000246915421970343*x_52 - 0.000660575863402059*x_53 + 0.000570930229491168*x_54 + 0.00468773053835542*x_55 - 0.000330547110087102*x_56 - 0.000340357392399639*x_59 + 6.36454248107646e-5*x_6 - 0.000686793965632821*x_60 - 3.18726258209627e-5*x_61 + 0.000357955320900201*x_62 + 0.00415166278946799*x_63 + 3.34897247927886e-5*x_64 + 0.0038245494853523*x_65 - 0.000106701913174019*x_66 - 1.36820449188879e-5*x_67 - 0.00501909680073755*x_68 + 0.00021755934184014*x_69 - 0.000131528147525031*x_7 - 0.000689521134185102*x_70 + 0.000657083793696006*x_71 - 8.33154471034961e-5*x_72 + 3.61664231029752e-5*x_73 + 0.000352789521710733*x_74 - 1.37938754984892e-5*x_75 + 0.00172210289523319*x_76 - 0.000928389498002829*x_77 + 0.000850528070946515*x_78 + 0.000723411168784492*x_79 + 0.0012540075454558*x_8 + 0.00231427632777684*x_80 + 0.00141470431097423*x_81 + 0.00132634415714594*x_82 - 0.000361323859800894*x_83 - 0.00038365762045171*x_84 + 0.000964719506112161*x_85 - 0.000620802452951234*x_86 + 0.00043282960039921*x_87 + 0.000241462192065639*x_88 - 0.000179832336718115*x_89 + 0.00162451613149589*x_9 - 0.000457909329530544*x_90 + 0.00904465692764668*x_91 + 0.000332116365801442*x_92 + 0.000997519145631903*x_93 + 0.0001729505137952*x_94 - 0.00243433436803147*x_95 + 0.00288941101898897*x_96 + 0.000504669526324372*x_97 + 0.000206349896660136*x_98 - 0.00327945923328412*x_99 - 4.82712885143744e-6*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 0.0104084805835744*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 0.0119184986333044*std::sin(0.956799805164337*x_47 + 0.626479864120483) - 0.0107434089074248*std::sin(1.2753598690033*x_58 + 2.43391990661621)) + 3.08888793300027e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) + 7.22401713777623e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) - 3.11424326058449e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 3.73092857135356e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 9.46479580569643e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) - 7.59511176461861e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 3.37930098030485e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 1.58508146167956e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 2.84522578577726e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) + 2.34810871750201e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 3.16993386670377e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 8.09933307469176e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) - 3.71760286219547e-7*std::sin(1.68991982936859*x_36 - 6.20679998397827) - 3.96396042746587e-6*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 4.17345318036189e-5*std::sin(0.257119953632355*x_42 + 4.82496023178101) + 2.97743320683947e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 2.56648374396142e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 4.69117125905569e-7*std::sin(0.434399873018265*x_49 + 5.23328018188477) - 1.11726602838406e-7*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 4.83082954228352e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) - 6.22012962036136e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) - 1.12127249809765e-6*std::sin(1.37127983570099*x_71 - 1.19743990898132) + 1.97393882419694e-6*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 5.0386405498446e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 1.06249983619598e-6*std::sin(1.55535984039307*x_78 - 6.17880010604858) + 3.4843246238039e-7*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 3.07927076358575e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) + 6.82285065575827e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 1.48036869378826e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) + 0.000317286179770406*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 5.88311690688319e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) - 3.24774214197144e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) + 1.57868681628168e-6*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 8.4464157234678e-8*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 4.55613517312682e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0684403359576569);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.85645914539854e-6*x_1 + 6.89756904045137e-7*x_10 + 4.08250084163019e-6*x_100 + 8.16499595145156e-7*x_101 + 1.1045938994229e-5*x_102 + 3.289320737731e-7*x_103 + 1.17297222538424e-6*x_104 + 1.55260769657723e-6*x_105 - 2.56895299860583e-6*x_106 + 4.94679790182339e-7*x_107 + 9.93880752044281e-7*x_108 - 2.64308914388308e-6*x_109 - 3.80670466060035e-6*x_11 - 2.20164124904332e-6*x_110 - 1.87684881614698e-6*x_111 + 1.47313770456375e-6*x_112 + 9.56776412973113e-6*x_113 + 3.50344761623425e-7*x_114 + 1.20274104759261e-7*x_115 + 3.22542853588478e-7*x_116 + 3.63905925669684e-6*x_117 - 2.71364189129677e-7*x_118 + 1.03179970339228e-6*x_119 + 4.83223768012009e-7*x_12 + 3.30111450423975e-6*x_120 + 2.83345440684507e-6*x_13 - 4.51131480046936e-6*x_14 + 9.42762029798103e-7*x_15 + 7.04211190023529e-7*x_16 - 3.1185813816277e-8*x_17 - 1.1516572893265e-6*x_18 - 3.74965380467447e-6*x_19 - 1.41483526760442e-6*x_2 + 5.08444535935259e-6*x_20 - 3.32662998123783e-7*x_21 + 4.36798944591531e-6*x_22 + 9.96239869941001e-6*x_23 - 3.20737183193553e-7*x_24 + 2.53105006077097e-7*x_25 + 1.95044407336391e-6*x_26 - 1.71045064998665e-6*x_27 - 1.09711432342325e-6*x_28 - 4.73807590585039e-7*x_29 + 3.66714252937559e-6*x_3 + 4.80456417160738e-8*x_30 - 3.22201583800296e-6*x_31 + 3.09608594949779e-6*x_32 + 4.12441954220666e-6*x_33 - 1.19366424806421e-5*x_34 - 4.41184194944154e-8*x_35 + 5.7748200646031e-6*x_36 + 2.81736017251538e-6*x_37 + 1.06194076735066e-5*x_38 + 9.52276184967935e-7*x_39 + 9.09680968281346e-7*x_4 - 8.19035202221034e-7*x_40 + 4.16619777912292e-6*x_41 - 2.99735535725648e-6*x_42 + 2.7459907253579e-6*x_43 + 3.97975225069367e-6*x_44 + 1.77928608807989e-6*x_45 + 2.6878940871127e-7*x_46 - 2.6600438017224e-6*x_47 + 5.73884340982451e-8*x_48 - 1.01607364384102e-6*x_49 + 6.24601001571851e-6*x_5 + 1.27077316658922e-6*x_50 - 4.02429057763129e-7*x_51 + 1.51242476356307e-6*x_52 - 4.56735351859223e-7*x_53 - 4.01832299784458e-7*x_54 + 9.25137083974727e-6*x_55 + 2.70162663417976e-7*x_56 + 1.15073439490283e-6*x_57 + 4.94328663163222e-7*x_58 - 6.63318006759065e-7*x_59 + 6.63938673973267e-7*x_6 - 1.92621261353427e-6*x_60 - 5.90815605140421e-7*x_61 + 5.15939784774611e-7*x_62 + 7.75651069237432e-6*x_63 - 1.02675521711025e-6*x_64 + 6.23874226103878e-6*x_65 - 8.05985131391738e-7*x_66 + 1.62032142550534e-7*x_67 - 9.09567550403141e-6*x_68 - 5.34233222123778e-7*x_69 + 1.61502453670128e-8*x_7 - 1.29768069407069e-6*x_70 + 7.24130371223253e-7*x_71 - 1.19610847706408e-6*x_72 + 1.95005922489933e-7*x_73 + 6.72324016030035e-7*x_74 + 2.97715085417697e-7*x_75 + 2.98756130129955e-6*x_76 - 1.5963856597587e-6*x_77 + 1.24590154230816e-6*x_78 + 1.29768273504222e-6*x_79 - 9.59250978571057e-7*x_8 + 3.83192794316098e-6*x_80 + 2.37290545186862e-6*x_81 + 1.8596450844908e-6*x_82 - 1.51340474217644e-7*x_83 - 5.94091231262842e-7*x_84 + 9.03035898875607e-8*x_85 - 4.57852703477861e-7*x_86 + 9.44583426766596e-7*x_87 + 1.90144275887584e-6*x_88 + 1.73334465065896e-6*x_89 + 2.29887041329903e-6*x_9 - 7.9172367345998e-7*x_90 + 2.3431477867611e-5*x_91 + 1.28618270645537e-6*x_92 - 5.3455775655072e-6*x_93 - 1.46656672432749e-8*x_94 - 4.45921028387892e-6*x_95 + 5.35625495058148e-6*x_96 + 3.08564884571585e-7*x_97 - 5.32706145618594e-7*x_98 - 6.53442799135858e-6*x_99 + 1.32774743946688e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 7.81759175955384e-9*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) - 2.01031798795851e-8*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) + 1.810988293556e-10*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 7.88911019980481e-7*std::exp(0.480159848928452*x_1) + 1.49546028942303e-6*std::sin(1.02879977226257*x_100 - 2.18503999710083) - 1.68566563155646e-5*std::sin(1.18727993965149*x_103 + 8.20639991760254) + 3.49744988940485e-7*std::sin(2.01775979995728*x_107 - 6.80599975585938) + 3.9107929562492e-6*std::sin(1.35679984092712*x_110 + 4.20128011703491) - 6.0427743093876e-6*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 4.5823048883384e-7*std::sin(1.81255984306335*x_120 + 8.193039894104) - 8.26164517145399e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 1.6360614342993e-6*std::sin(1.29959988594055*x_19 + 7.59296035766602) + 1.18081367894327e-6*std::sin(1.31647980213165*x_19 + 3.62504005432129) + 4.60825152609781e-7*std::sin(1.08775985240936*x_24 + 2.03655982017517) - 1.01357437177181e-6*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 3.44812158600233e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) - 5.3566187303739e-6*std::sin(0.522799849510193*x_35 - 5.14815998077393) + 1.91079484086033e-8*std::sin(1.68991982936859*x_36 - 6.20679998397827) + 2.03741911520457e-7*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 9.92812608373799e-6*std::sin(0.257119953632355*x_42 + 4.82496023178101) - 1.96917133017159e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 1.24254249613261e-6*std::sin(1.88767993450165*x_45 + 9.41016006469727) + 1.93021482478614e-5*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 3.49470946880476e-7*std::sin(0.434399873018265*x_49 + 5.23328018188477) + 4.82274182784037e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) - 1.73990766621428e-5*std::sin(1.2753598690033*x_58 + 2.43391990661621) + 6.06644136824982e-7*std::sin(2.0511999130249*x_59 - 9.80607986450195) + 4.11377856948415e-7*std::sin(1.52071976661682*x_67 - 4.38895988464355) + 7.41570844139109e-7*std::sin(1.37127983570099*x_71 - 1.19743990898132) - 2.47882564199155e-6*std::sin(1.11815989017487*x_75 + 0.799599885940552) + 8.16080155021391e-7*std::sin(0.739839851856232*x_76 + 2.37055993080139) - 7.91514108761198e-7*std::sin(1.55535984039307*x_78 - 6.17880010604858) - 1.79089315395977e-8*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 1.49080421407552e-6*std::sin(1.4094398021698*x_82 - 4.78895998001099) - 8.56797432101427e-7*std::sin(1.69791984558105*x_86 + 0.384719848632813) + 1.10280742394925e-6*std::sin(0.532079875469208*x_87 - 7.78791999816895) - 1.63080570425303e-5*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 6.39940871091204e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) + 1.4019062135792e-5*std::sin(0.48871985077858*x_92 - 4.95479965209961) - 1.98247752812962e-6*std::sin(1.01863980293274*x_94 + 6.77767992019653) - 6.29219599461098e-8*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 4.95597343661276e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0446907808804258);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.27915615121127e-5*x_1 + 5.31860073289285e-6*x_10 + 4.09349653084925e-7*x_100 + 5.36467272751955e-6*x_101 - 1.53241596332928e-6*x_102 - 2.87657585739578e-6*x_103 + 5.75053354493159e-7*x_104 - 4.51829414254119e-6*x_105 - 1.95632818956231e-6*x_106 - 2.47280599122159e-6*x_107 - 2.70821780638309e-7*x_108 + 1.28066235583125e-7*x_109 - 1.9101701458176e-6*x_11 + 4.98220659945459e-6*x_110 - 1.72402948805371e-6*x_111 + 2.25793085564321e-6*x_112 - 7.0157987161001e-7*x_113 + 2.97856751644683e-6*x_114 - 4.70516194835528e-7*x_115 + 4.26856087948628e-6*x_116 + 1.1999618721451e-6*x_117 - 1.50652396380954e-6*x_118 + 3.54971385355647e-6*x_119 + 6.46034433644015e-6*x_12 + 2.77488216283181e-6*x_120 + 2.13434110426155e-6*x_13 - 5.57561167397154e-6*x_14 - 5.32324776277646e-7*x_15 + 1.98672834085094e-6*x_16 - 9.52632411769478e-7*x_17 + 2.10120783906235e-6*x_18 + 1.55164465030253e-6*x_19 - 5.51642023145981e-6*x_2 + 2.41485399753771e-6*x_20 - 2.2186929189005e-6*x_21 - 3.48209663864888e-7*x_22 + 3.68710517688427e-6*x_23 - 4.2196483123291e-6*x_24 + 2.44039761160154e-6*x_25 + 3.2762562571226e-6*x_26 - 6.09498840606869e-7*x_27 + 2.91946126777076e-6*x_28 - 1.64116407961078e-6*x_29 - 6.87283826502156e-7*x_3 - 5.49358952674098e-7*x_30 + 0.000122914648836696*x_31 + 1.21411169022228e-5*x_32 + 5.7150529022977e-6*x_33 + 1.62135471462556e-5*x_34 - 5.16723567483289e-6*x_35 - 2.29904439924463e-6*x_36 - 6.54925315110984e-6*x_37 + 8.89970372042769e-7*x_38 + 1.0990146646527e-6*x_39 + 3.06795179891051e-6*x_4 - 2.80101803451237e-6*x_40 + 9.08648461014089e-6*x_41 + 2.19325912987188e-6*x_42 - 6.77889961014888e-6*x_43 + 4.72074301817064e-6*x_44 - 5.74718807361862e-6*x_45 - 3.76644646186141e-7*x_46 - 1.39657696797605e-6*x_47 - 3.66592226949071e-6*x_48 + 5.37410677778488e-6*x_49 + 1.88421401136011e-6*x_5 - 4.17242255349872e-6*x_50 - 2.65184217564123e-7*x_51 + 3.18814553676744e-6*x_52 + 3.10597571120726e-6*x_53 + 5.26944448816442e-6*x_54 - 3.06126127055984e-6*x_55 + 6.99480647060174e-6*x_56 + 9.53077529135657e-7*x_57 + 5.07398685889617e-6*x_58 - 8.39341569056317e-7*x_59 + 4.21163741857714e-7*x_6 - 2.76250974688074e-6*x_60 - 1.00637778468064e-5*x_61 - 6.84921362860413e-6*x_62 + 8.03448851756155e-6*x_63 - 4.12487904986047e-6*x_64 + 5.59368328900714e-6*x_65 + 4.34845514364363e-6*x_66 - 7.98301709470269e-6*x_67 - 8.15016862962411e-7*x_68 - 2.22148995754592e-6*x_69 + 6.21485005817299e-6*x_7 - 5.3084060973329e-6*x_70 + 5.84247580185963e-7*x_71 - 1.93792830825659e-6*x_72 - 1.09655411704167e-6*x_73 - 7.28464061483208e-6*x_74 - 1.03096049311468e-6*x_75 - 2.78885408932278e-7*x_76 - 4.84439684522155e-6*x_77 - 1.70132703282987e-6*x_78 - 2.20614282710302e-6*x_79 + 5.40861599370277e-7*x_8 - 5.71155203501933e-7*x_80 + 5.32239919640354e-6*x_81 - 3.11309877692125e-6*x_82 - 7.83262735018775e-7*x_83 - 1.46286723062115e-8*x_84 + 4.12457774702009e-7*x_85 - 4.96360960901082e-7*x_86 + 5.21904065944292e-7*x_87 + 3.39111777502066e-6*x_88 + 3.03233546847578e-6*x_89 - 5.38309003958086e-6*x_9 - 4.43847636969504e-7*x_90 + 1.94398077442385e-5*x_91 + 1.25494577372138e-5*x_92 - 3.41424720831956e-5*x_93 + 4.99485879475402e-6*x_94 - 3.66010466592592e-6*x_95 + 9.53956963744591e-7*x_96 - 5.92213770360546e-6*x_97 + 4.23807207405805e-6*x_98 - 1.51102756184541e-6*x_99 + 7.71914485320288e-8*std::pow(4.70088005065918 - 8.59376049041748*x_74, 2) - 4.35704295128834e-10*std::pow(-5.60727977752686*x_58 - 0.404159843921661, 2) + 1.88491035517089e-8*std::pow(-6.29856014251709*x_64 - 7.92695999145508, 2) - 6.82248998904128e-7*std::exp(0.480159848928452*x_1) + 0.000385726542753011*std::exp(-0.00465867995737052*x_1 + 5.54601303398501e-5*x_10 - 0.00299444284641757*x_100 - 0.000426150686701007*x_101 - 0.0093901952806852*x_102 - 0.00125538459702827*x_104 - 0.00074063350138646*x_105 + 0.00279567759757281*x_106 - 0.000243082595748824*x_107 - 0.00105089408061596*x_108 - 0.000711323800530918*x_109 + 0.0026339486427118*x_11 + 0.00293680457461279*x_110 + 0.00195290755930882*x_111 - 0.000990140774221812*x_112 - 0.00860245032902602*x_113 - 0.000232533096510429*x_114 + 0.000419770911823282*x_115 - 0.000590143058788584*x_116 - 0.00380916751647054*x_117 + 5.18447496332874e-5*x_118 - 0.00157080011520034*x_119 - 5.26793700538853e-5*x_12 + 0.000254789626023921*x_120 - 0.00127614731092978*x_13 + 0.00101928396227052*x_14 - 0.000431900490135805*x_15 + 0.000362043652026272*x_16 + 7.767728004367e-5*x_17 + 0.00030273187689147*x_18 + 0.00219847146754171*x_19 + 0.00236735331653398*x_2 - 0.00482718178801577*x_20 + 0.00027622975214719*x_21 - 0.00453139057310765*x_22 - 0.009459373663633*x_23 + 0.00177550297225458*x_24 - 0.000778629018531376*x_25 - 0.00205247373351985*x_26 - 0.000972335689293696*x_27 + 0.00111017246119954*x_28 - 0.000283928116707801*x_29 - 0.00214111249356715*x_3 - 0.00189301798622918*x_30 + 0.00290218883582018*x_31 + 9.11119995058808e-5*x_32 - 0.00237402337147588*x_33 + 0.00191618891554304*x_34 + 0.000555030896400942*x_35 - 0.00595947641818612*x_36 - 0.000679449808026711*x_37 - 0.00941636158465826*x_38 - 0.00196075744147302*x_39 + 0.000363734405544195*x_4 + 0.000651932109896226*x_40 - 0.0029907555106923*x_41 + 0.00120856113151893*x_42 - 0.00126119686288871*x_43 - 0.00384267494501308*x_44 - 0.00196752018939867*x_45 - 0.000248557112626807*x_46 - 0.000740795189175327*x_48 + 0.000361659204053327*x_49 - 0.00622925637263144*x_5 - 0.00216432987738363*x_50 + 0.000583311847138283*x_51 - 0.000394330542237969*x_52 + 0.00105495734663319*x_53 - 0.000911790868220216*x_54 - 0.00748643122533351*x_55 + 0.000527892588140954*x_56 + 0.000543559871751432*x_59 - 0.000101643448093773*x_6 + 0.00109682835811804*x_60 + 5.0901437108443e-5*x_61 - 0.000571664234907514*x_62 - 0.00663031667238972*x_63 - 5.34839874786226e-5*x_64 - 0.00610790796435574*x_65 + 0.000170405813229411*x_66 + 2.18505921936189e-5*x_67 + 0.00801563202162969*x_68 - 0.000347448096000509*x_69 + 0.000210053974430688*x_7 + 0.00110118371934017*x_70 - 0.00104938041778147*x_71 + 0.000133057000534646*x_72 - 5.77587463723386e-5*x_73 - 0.000563414315241824*x_74 + 2.20291886244982e-5*x_75 - 0.00275024444827283*x_76 + 0.00148266289417703*x_77 - 0.00135831610973751*x_78 - 0.00115530701230178*x_79 - 0.00200268363727189*x_8 - 0.00369596128074312*x_80 - 0.00225932067588659*x_81 - 0.00211820714359566*x_82 + 0.000577043881754439*x_83 + 0.000612711495698405*x_84 - 0.00154068289018596*x_85 + 0.000991438144857246*x_86 - 0.000691240464690632*x_87 - 0.000385621588021539*x_88 + 0.000287197058345316*x_89 - 0.00259439577283286*x_9 + 0.000731293463845657*x_90 - 0.0144445593643952*x_91 - 0.000530398731547502*x_92 - 0.00159306479300037*x_93 - 0.00027620660281555*x_94 + 0.00388769718664907*x_95 - 0.00461446678694347*x_96 - 0.000805970750544576*x_97 - 0.000329546311815685*x_98 + 0.00523738423217471*x_99 + 7.70905406495223e-6*std::pow(-4.89264011383057*x_57 - 9.15823936462402, 2) + 0.0166226222713914*std::sin(1.18727993965149*x_103 + 8.20639991760254) - 0.0190341615409422*std::sin(0.956799805164337*x_47 + 0.626479864120483) + 0.0171575117752583*std::sin(1.2753598690033*x_58 + 2.43391990661621)) + 3.24117117390919e-8*std::sin(1.02879977226257*x_100 - 2.18503999710083) + 7.58016367529519e-9*std::sin(2.01775979995728*x_107 - 6.80599975585938) + 2.27362346353267e-5*std::sin(1.35679984092712*x_110 + 4.20128011703491) + 6.01930023924182e-7*std::sin(1.30927979946136*x_118 + 7.02824020385742) + 9.93141350471816e-9*std::sin(1.81255984306335*x_120 + 8.193039894104) - 7.14465764170091e-6*std::sin(0.334799855947495*x_19 - 1.57703983783722) - 3.54590168465208e-8*std::sin(1.29959988594055*x_19 + 7.59296035766602) - 9.96668797921771e-8*std::sin(1.31647980213165*x_19 + 3.62504005432129) - 4.59035007652605e-8*std::sin(1.08775985240936*x_24 + 2.03655982017517) - 3.88479586649332e-7*std::sin(1.65895986557007*x_28 + 0.5865598320961) + 2.98193007901957e-5*std::sin(0.352079838514328*x_34 - 4.59624004364014) + 1.88865154282144e-5*std::sin(0.522799849510193*x_35 - 5.14815998077393) + 1.98879086903019e-6*std::sin(1.68991982936859*x_36 - 6.20679998397827) + 2.12058377281468e-5*std::sin(1.90951979160309*x_4 - 3.20263981819153) + 2.02054353367961e-5*std::sin(0.257119953632355*x_42 + 4.82496023178101) + 6.94295909044233e-5*std::sin(0.462319850921631*x_42 - 7.79824018478394) + 2.69301227809664e-8*std::sin(1.88767993450165*x_45 + 9.41016006469727) - 2.94971844201241e-8*std::sin(0.434399873018265*x_49 + 5.23328018188477) + 1.84844526852112e-8*std::sin(1.18223989009857*x_57 - 7.60576009750366) + 3.52685595716796e-6*std::sin(2.0511999130249*x_59 - 9.80607986450195) - 1.45044749928276e-6*std::sin(1.52071976661682*x_67 - 4.38895988464355) - 2.61465112488408e-6*std::sin(1.37127983570099*x_71 - 1.19743990898132) - 1.44111851603716e-5*std::sin(1.11815989017487*x_75 + 0.799599885940552) - 8.12909968311986e-8*std::sin(0.739839851856232*x_76 + 2.37055993080139) + 6.68079502621554e-8*std::sin(1.55535984039307*x_78 - 6.17880010604858) - 1.86399495950084e-6*std::sin(1.04719984531403*x_82 + 8.62975978851318) + 3.23107987472415e-8*std::sin(1.4094398021698*x_82 - 4.78895998001099) - 4.98117585592841e-6*std::sin(1.69791984558105*x_86 + 0.384719848632813) - 9.30827419403154e-8*std::sin(0.532079875469208*x_87 - 7.78791999816895) - 0.00169737295937039*std::sin(0.226879999041557*x_91 + 4.96575975418091) + 5.53419850404184e-5*std::sin(0.278159946203232*x_91 - 7.86392021179199) + 5.37318189508235e-6*std::sin(0.48871985077858*x_92 - 4.95479965209961) - 1.15255588171171e-5*std::sin(1.01863980293274*x_94 + 6.77767992019653) + 5.31094408039832e-9*std::sin(1.45119988918304*x_95 - 0.792559862136841) - 4.28591796804685e-7*std::sin(1.50895988941193*x_96 + 3.21016001701355) + 0.0678757786462669);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
