
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.14873267409773e-5*x_10 - 0.000258190101370332*x_100 + 0.000706935145897665*x_101 + 5.01016081170036e-5*x_102 + 0.00143436704829544*x_103 - 0.000606146738955919*x_104 - 3.648038086463e-5*x_105 + 0.00138747827268198*x_106 - 0.000296404767719075*x_107 - 6.80619098671079e-5*x_108 - 0.000661070878432985*x_109 + 0.0011706448166943*x_11 - 0.000299928779415488*x_113 - 0.000841720334409133*x_114 + 8.82637789652101e-5*x_115 - 0.000137537917688674*x_116 + 0.00013961447611025*x_117 - 0.00156561054502365*x_118 + 1.11506007447881e-5*x_119 - 0.000277123376015924*x_12 - 0.000307778063827347*x_120 - 0.000932285196692785*x_13 + 0.000363060175249933*x_14 - 0.000377563193835348*x_15 + 0.00652915692456113*x_16 + 0.00150338672551175*x_17 - 1.99221415634423e-6*x_18 - 0.000157770733883292*x_19 + 0.000112041361902818*x_2 + 7.33264171446703e-5*x_20 - 0.000253932128400212*x_22 - 0.00145344582838522*x_24 - 0.000373141270864804*x_25 - 0.00222655130451885*x_27 - 4.52952378510397e-5*x_28 - 0.00476069838209165*x_29 - 0.000291865407581859*x_3 - 0.000671928482835722*x_30 - 0.00674844841789634*x_31 - 0.000106037465124545*x_32 + 0.000143463608581677*x_33 - 0.000548400737359144*x_34 - 0.000213236316672556*x_35 + 0.00265671365994919*x_36 - 0.00010628656117037*x_37 + 0.000255255534802128*x_38 - 0.000306319103321411*x_4 - 0.000198185720024331*x_40 - 1.10549811290646e-5*x_42 - 0.000150427500348754*x_43 - 0.000259826502310061*x_44 - 9.49128813179761e-6*x_45 - 1.50185916962288e-5*x_47 + 0.000804726000759205*x_48 + 9.62097261610731e-5*x_49 + 1.62909929177713e-5*x_5 - 0.0017997519929812*x_50 + 0.00165371093471256*x_51 + 0.00314919694235375*x_52 + 0.00147055407587078*x_53 - 4.81775739401594e-5*x_55 - 1.90132555450907e-5*x_56 - 0.00247018398642225*x_57 - 0.00220597560397352*x_59 - 0.00209833576603143*x_6 - 6.64064760124732e-5*x_60 - 0.00272565424900937*x_61 - 0.00061924118117876*x_62 - 0.000459459296828784*x_63 - 4.99020022004257e-5*x_64 + 2.78645175678738e-5*x_65 + 0.000672964678221756*x_66 - 0.000262201411454575*x_68 + 0.000109576587344509*x_69 - 0.00021378900680496*x_70 - 0.00202149659288084*x_71 - 1.6287970626662e-5*x_72 + 0.000289797881854837*x_73 + 0.00159651766985937*x_74 + 0.000338155929519897*x_76 - 7.77254810219618e-5*x_77 + 0.000220030544179074*x_78 - 0.00420729946657594*x_8 - 0.000222017194945822*x_80 - 0.000297612468129526*x_81 + 0.00347857373281689*x_82 - 0.000256950909630102*x_83 + 0.000141948546875327*x_84 - 0.000385133016917785*x_85 + 1.21445349898747e-5*x_86 - 0.00087194616359435*x_87 + 2.89296058210616e-5*x_88 - 0.00229345325606079*x_89 - 0.000105685458302332*x_9 + 0.00252416752248974*x_90 + 0.00313607593552092*x_91 - 0.00017086526956796*x_93 - 7.39807510898921e-6*x_94 - 0.000278529253455275*x_95 - 0.000167541302793852*x_96 - 0.00435097145084912*x_98 - 0.000509519422944472*x_99 - 1.67018409508094e-7*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) + 5.55853694916413e-6*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) + 8.81931351830445e-5*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) + 7.56599834389823e-5*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) + 4.59258072339529e-5*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 7.4067663231424e-6*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) - 1.24631724155242e-6*std::pow(-8.0*x_54 - 9.99971961975098, 2) + 2.63257331843703e-6*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) + 2.93016510925594e-6*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) - 1.64562488951711e-5*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) + 0.000124060551013819*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) + 1.21783455794505e-6*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) + 3.25635369838962e-5*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 6.1046530007236e-6*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) - 1.81675436500638e-6*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) - 2.09978246083569e-6*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) - 1.30438909699122e-6*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) + 3.59646898674782e-6*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) + 0.00163967825938016*std::pow(-0.0163246664127929*x_10 + 0.00522374084485865*x_100 - 0.00201275544878432*x_101 + 0.0342854218283344*x_103 - 0.00706870591681818*x_104 + 0.00330057780730365*x_105 + 0.0758648208525234*x_108 - 0.0395326088566208*x_109 - 0.0182093978133453*x_11 + 0.0849972685698954*x_111 - 0.00409886924826124*x_112 + 0.00327092076098257*x_113 + 0.00181012974898961*x_114 + 0.0116096738846764*x_116 + 0.00130067710786567*x_117 + 0.133107920959042*x_118 + 0.00179425162195673*x_119 + 0.00225284186542786*x_120 + 0.0195325379247119*x_14 - 0.071040273324928*x_16 - 0.047580325329899*x_17 + 0.00614039419148546*x_19 + 0.00512205338097053*x_2 + 0.128030793645428*x_20 + 0.0133720838587933*x_23 + 0.0180454394281358*x_26 + 0.000508197145947839*x_30 - 0.0293911772987965*x_31 + 0.0536541643416879*x_32 + 0.0125796489551242*x_33 - 0.00462119579499704*x_34 - 0.00606906898697678*x_35 + 0.0081185756392783*x_36 + 0.0131738601234502*x_37 - 0.00700554642919391*x_38 + 0.0183586874017733*x_39 + 0.0820097379863436*x_4 + 0.00273454076449738*x_40 + 0.00433837974413636*x_41 + 0.00882275699074078*x_42 - 0.00020570388429046*x_43 + 0.0535956519831997*x_44 + 0.0310720003150368*x_45 + 0.0127175350113005*x_47 + 0.0154968088510722*x_50 + 0.013306204507144*x_52 + 0.00113255984842717*x_53 + 0.00663079520720076*x_54 - 0.00482816146631202*x_55 - 0.00111923661692564*x_56 + 0.00424926754270139*x_57 - 0.0689667077571463*x_59 + 0.137050735955665*x_60 + 0.00087197156240053*x_61 + 0.0771333532534056*x_62 - 0.151200664558188*x_63 + 0.00206303405221013*x_64 - 0.00521148736748078*x_65 - 0.000500702355560794*x_66 + 0.0265339666074166*x_67 + 0.000178015322772901*x_68 + 0.00214561664761352*x_69 - 0.119217737252295*x_70 + 0.00501239075640652*x_71 + 0.0108433789212447*x_72 + 0.00564226394501959*x_73 + 0.00584007716655541*x_74 - 0.0100411761160761*x_75 - 0.0254398716595732*x_76 + 4.84656837656492e-5*x_77 - 0.00464905546086989*x_78 + 0.00282121239796611*x_79 + 0.152793516815079*x_8 + 0.000878952515818095*x_80 + 0.00406930144368839*x_81 + 0.00345133677963625*x_82 + 0.028534209975801*x_83 + 0.0494128875774714*x_86 + 0.00268731307084257*x_87 + 0.00050569937561232*x_88 - 0.000950361025093377*x_89 + 0.042493200134071*x_9 - 0.0410026524228412*x_91 + 0.119107861093686*x_93 + 0.00842408732701903*x_94 + 0.00238342675877478*x_95 - 0.00177125865181372*x_96 + 0.00649629540776214*x_97 + 0.00145366768267924*x_98 + 0.000402979259824661*x_99 + 0.00070834440492587*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) - 0.000843180500608887*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) - 0.00156830820113779*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) + 0.000761357238674994*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) + 0.00296589473437203*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) + 0.000665547395487361*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) + 0.000824872733910242*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 0.00119656068377967*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 0.00282604127119204*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) - 0.000743932866135735*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) - 0.000587244738176923*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) + 0.0359984754407085*std::exp(0.429519861936569*x_29) + 0.11512134905252*std::sin(0.788719892501831*x_1 + 1.20735991001129) + 0.789247005452992*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 2.76162176771038*std::sin(0.174880012869835*x_106 - 1.40583980083466) - 0.272121038638144*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 3.03673594189738*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0180038869948*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 2.62334706132566*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 1.53904928497207*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.0214072055160961*std::sin(1.528639793396*x_22 - 1.98135983943939) - 0.0526996187612849*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 1.31918786433985*std::sin(0.363919854164124*x_28 + 8.3712797164917) + 2.8946904665315*std::sin(0.356959849596024*x_3 - 1.01327979564667) - 0.324531847647567*std::sin(0.476639837026596*x_48 - 7.32263994216919) + 1.09620156396861*std::sin(0.282959938049316*x_51 + 5.09143972396851) + 0.0158588762556704*std::sin(1.12711989879608*x_58 - 7.43103981018066) + 0.0571535267975607*std::sin(1.25287985801697*x_7 + 9.62911987304688) - 0.453457764199548*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.944536079484337*std::sin(0.356719851493835*x_92 + 5.19888019561768) - 2.14245017183194, 2) + 0.000325153171414788*std::exp(0.594239830970764*x_2) - 0.00554048169751028*std::exp(0.448319852352142*x_20) + 0.151506140828133*std::log(-0.0979729319758934*x_100 - 0.000668629851363645*x_101 + 0.000403556647520647*x_104 - 0.0192650835164541*x_105 - 0.0295722654377657*x_106 - 0.00694251026803006*x_107 + 0.0064181295132222*x_108 + 0.0019864057112276*x_11 - 0.00299273989502263*x_112 - 0.181935484578861*x_113 + 0.111834156521436*x_114 - 0.0815295589220768*x_116 - 0.000680797161514239*x_118 - 0.0068989906008612*x_119 - 0.124513609974235*x_13 + 0.025620948807189*x_14 + 0.00318718334898763*x_16 + 0.0304683631377701*x_18 - 0.0178309277209263*x_20 + 0.0627550486450051*x_23 - 0.0925485081192375*x_25 - 0.156064126159366*x_26 - 0.000120987668361347*x_28 + 0.027977939263799*x_3 + 0.198921753167969*x_31 + 0.00788101133566576*x_32 + 0.0199126574370552*x_33 + 0.000554775073159416*x_34 - 0.0283993397503882*x_37 + 0.190632120369543*x_4 - 0.045121295395445*x_40 - 0.00123735166156713*x_42 - 0.00485189983722135*x_44 + 0.00529992310779745*x_45 + 0.00445766732481161*x_46 - 0.123829260371957*x_47 + 0.000213402922436754*x_48 + 0.00808277898424106*x_49 + 0.00464284752995796*x_5 - 0.0577692455134287*x_50 + 0.0418743698191585*x_51 - 0.00411123098104578*x_52 + 0.00256607701887229*x_54 - 0.0293583914445659*x_56 + 0.0132389537812441*x_57 + 0.0485473508301626*x_58 - 0.0213181875368908*x_59 + 0.023208941599065*x_6 + 0.026607349012055*x_60 - 0.00754885710930146*x_61 + 0.000909453634587455*x_62 - 0.0023565543528789*x_64 + 0.019720495782935*x_65 + 0.0017561977184365*x_66 - 0.0341935052748909*x_68 + 0.00129942406252071*x_69 + 0.00503685202918688*x_7 - 0.0363888794306331*x_72 + 0.0552382152105578*x_74 - 0.00651201918054593*x_78 - 0.0980619300161689*x_8 - 0.000320959578909774*x_83 + 0.0466459018416532*x_84 - 0.00478044915860599*x_85 + 0.112452947239274*x_88 - 0.000951603447695821*x_89 - 0.00600819166754452*x_90 + 0.012503638071351*x_93 - 0.0537385066039969*x_94 + 0.00287198442765589*x_95 + 0.00213604149308299*x_96 + 0.127116400158654*x_97 + 0.0858111943685907*x_98 + 0.0642353687429129*x_99 + 0.00238889932246655*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 0.00126450589224046*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 0.00656576905420236*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 0.00492017897138397*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) + 0.000665752739871232*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 0.000478049185856547*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 0.00126291758960517*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) + 0.000194574037362101*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 0.0500873459838968*std::exp(0.641439855098724*x_71) + 0.0247486381278152*std::log(8.06023979187012*x_91 + 9.42432022094727) - 2.30905291320184*std::sin(0.281039953231812*x_1 + 5.1756796836853) + 0.183652384274842*std::sin(0.328399837017059*x_102 - 4.43911981582642) + 0.0880502468101216*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.48102740560374*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.0348366201941093*std::sin(1.31879985332489*x_110 - 0.19039985537529) + 0.110113903584805*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.160909799292025*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 2.39040054991844*std::sin(0.325919836759567*x_12 - 7.46208000183105) - 1.34472855211168*std::sin(0.333279848098755*x_120 - 4.27167987823486) + 0.47755292651901*std::sin(0.346559852361679*x_15 + 1.93543982505798) + 0.149929721723513*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 1.49590173967438*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 1.10641900884278*std::sin(0.298479825258255*x_22 - 1.12871980667114) + 3.11363097519035*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.12183699530696*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 2.43916462340854*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 1.06093965198282*std::sin(0.327759832143784*x_35 - 1.21751987934113) + 0.608918622868352*std::sin(0.364079833030701*x_36 - 7.4255199432373) - 1.51164748634659*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.0246813053501098*std::sin(1.43327987194061*x_39 - 7.78567981719971) - 1.54126267931821*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.499090397981796*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 1.62359326966984*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 1.56251108346748*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.0200297450296445*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 1.66474994443529*std::sin(0.262719959020615*x_73 - 7.51200008392334) + 0.0968691463819029*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.694558259824134*std::sin(0.437359839677811*x_77 - 4.15848016738892) + 1.22450751511303*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 4.24376677463584*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.435755732577817*std::sin(0.426799863576889*x_81 - 4.15999984741211) - 0.51319321920667*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 1.70769115757368*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 0.961376067317332*std::sin(0.283919870853424*x_87 - 1.28575992584229) - 0.53902280433509*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 1.79907431307784*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 0.512867299132436) + 0.083683880635179*std::sin(0.255999982357025*x_1 - 7.38719987869263) + 0.0153140475947141*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.0025125559078903*std::sin(0.431519865989685*x_107 + 5.2052001953125) - 0.00166402318863546*std::sin(0.450319856405258*x_109 - 4.15903997421265) - 0.00139353187707685*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 0.000266565148252699*std::sin(1.160719871521*x_110 - 7.00648021697998) - 0.00106067260426727*std::sin(0.359679847955704*x_111 - 7.42783975601196) + 0.0210418963985309*std::sin(0.41967985033989*x_111 + 2.01015996932983) + 0.0228431175677605*std::sin(0.344239860773087*x_112 - 4.23336029052734) + 0.00180213627947785*std::sin(0.346559852361679*x_112 - 7.43415975570679) - 0.00311967379065675*std::sin(0.345199823379517*x_114 + 1.94695973396301) + 6.81375023401807e-5*std::sin(1.12887978553772*x_117 + 0.991439819335938) + 0.0010521083690036*std::sin(0.407119870185852*x_118 - 1.19191980361938) + 0.0152637252631193*std::sin(0.312799841165543*x_119 - 7.45648002624512) - 0.0389973898981165*std::sin(0.369039833545685*x_12 + 1.95535981655121) + 0.0296061509983402*std::sin(0.257839977741241*x_120 + 5.06311988830566) + 0.00191419086766402*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.169346340834159*std::sin(0.187120005488396*x_18 - 7.60152006149292) - 0.00328052423729293*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 0.0478522277996777*std::sin(0.32847985625267*x_21 + 5.15607976913452) + 0.00746594331701373*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.0107524612907076*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 0.00400423653170777*std::sin(0.343999862670898*x_26 + 5.15880012512207) - 0.0522814388929751*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 0.0350284015454001*std::sin(0.309999942779541*x_28 + 8.33735942840576) - 0.00230647098218547*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.00113941619606017*std::sin(0.258239984512329*x_35 - 4.14152002334595) + 0.00378872961365371*std::sin(0.371439844369888*x_36 + 5.18383979797363) - 0.00247014522976195*std::sin(0.382879853248596*x_37 + 5.18959999084473) - 0.00115716725371381*std::sin(0.33791983127594*x_39 + 5.16007995605469) + 0.00088356065991559*std::sin(1.05911982059479*x_39 + 8.42039966583252) + 0.00096359048247008*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.0220896056884657*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 8.24915353253711e-5*std::sin(1.41703987121582*x_41 + 4.79800033569336) + 0.0249421665240749*std::sin(0.357599824666977*x_42 + 1.97287976741791) + 0.00894003109696921*std::sin(0.530159831047058*x_43 - 4.43088006973267) + 0.00442598092876057*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.0889317456836884*std::sin(0.172400012612343*x_46 + 1.75647985935211) - 4.72459746547317e-5*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.0123741028660363*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.00135249222375679*std::sin(0.3642398416996*x_49 + 1.96791982650757) + 0.00337021060568562*std::sin(0.354879856109619*x_53 + 5.16688013076782) - 0.00925029000877383*std::sin(0.680319845676422*x_54 - 4.14432001113892) - 0.00233582302669162*std::sin(0.377519845962524*x_55 - 4.21208000183105) - 0.00250347583010971*std::sin(0.320719838142395*x_56 + 8.30823993682861) - 0.116391929380398*std::sin(0.152720034122467*x_58 + 4.94431972503662) + 0.00225781522947652*std::sin(0.304079920053482*x_62 + 5.10087966918945) + 0.00565348577092203*std::sin(0.19480000436306*x_64 - 4.4093599319458) + 0.00144323494369748*std::sin(0.467439860105515*x_65 + 2.05879974365234) + 0.0107043384683667*std::sin(0.427359849214554*x_73 + 2.01815986633301) - 0.0144491002394959*std::sin(0.26639997959137*x_75 - 4.31455993652344) + 0.00292184705442083*std::sin(0.419119864702225*x_75 - 7.36639976501465) - 0.00361696967405477*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.019504749191479*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.000450752056149191*std::sin(0.439199864864349*x_79 + 2.22503995895386) - 0.00495739157068617*std::sin(0.234479993581772*x_83 - 4.34055948257446) - 0.00133976074788034*std::sin(0.404559850692749*x_84 - 4.1814398765564) + 0.00012276149763333*std::sin(1.34455978870392*x_86 + 1.38687980175018) + 0.00990959218656438*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 0.0205750866530412*std::sin(0.506479859352112*x_9 - 0.87367981672287) - 0.00479520353115479*std::sin(0.317679852247238*x_92 - 4.21264028549194) - 0.0568857810811802*std::sin(0.409839868545532*x_92 - 7.41232013702393) - 0.00227747605698294*std::sin(0.353039860725403*x_93 - 7.41192007064819) - 0.00191414002663918*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.011694375202254*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 0.00419362796638073*std::sin(0.335919857025146*x_97 - 7.4507999420166) + 0.00234131687336796*std::sin(0.446159869432449*x_98 - 7.38191986083984) + 0.00672031613066792*std::sin(-0.272755219255956*x_1 + 0.0949490561590319*x_10 - 0.00640922745212045*x_100 + 0.00446306569194845*x_101 - 0.107400655017221*x_102 - 0.00551266392757649*x_103 - 0.000278305121174837*x_105 + 0.00247616528769335*x_106 + 0.00113961620607424*x_107 - 0.024202276181794*x_113 + 0.00624270774132611*x_114 + 0.00859163713904576*x_116 + 0.0168709912413276*x_117 + 0.0011551015894299*x_119 + 0.0135352902276196*x_12 + 0.0419300767118672*x_13 - 0.00916887343562966*x_14 - 0.11649721516071*x_17 + 0.0314273224365822*x_20 - 0.0830732133000711*x_22 - 0.160546213283684*x_25 + 0.000497304195217704*x_26 + 0.0150723835817206*x_27 - 0.00596886215406906*x_29 - 0.0324347053610016*x_3 - 0.0415703115474893*x_31 - 0.00102644766041268*x_34 - 0.00326183421418663*x_36 - 0.00815925311223374*x_37 - 0.0244939579846831*x_38 + 0.000154582188102386*x_39 - 0.0519143959030384*x_41 + 0.00132068917733257*x_42 - 0.000349586712314225*x_49 - 0.0413981939829027*x_5 - 0.116998271981835*x_50 - 0.00365075397507399*x_51 + 0.00292897524481737*x_52 - 0.0138507509796552*x_53 + 0.00908327705892833*x_56 + 0.0460001128272338*x_59 - 0.0290183741545158*x_6 + 0.0020719662708526*x_61 + 0.00936864955276067*x_62 - 0.089411830399535*x_63 + 0.00118650020855758*x_66 - 0.00462224564538625*x_67 + 0.0729315212565729*x_68 - 0.016397381031307*x_69 + 0.00360239976863905*x_71 + 0.0867332301117154*x_72 - 7.62998951685347e-5*x_75 + 0.00273049783429338*x_77 - 0.0850449972006211*x_78 - 0.00698114984846174*x_79 - 0.00635799156846406*x_8 + 0.000735332029804482*x_82 - 0.0679447184171249*x_83 + 0.0038456847271778*x_86 + 0.00643429813524908*x_88 + 0.00128940331744028*x_89 - 0.0735935207264739*x_9 + 0.00880704619698974*x_91 + 0.000717060587039499*x_92 - 0.0435115874342898*x_93 + 0.000178372510739886*x_94 + 0.00080137204425843*x_96 - 0.0104405299149026*x_98 + 0.00122480061253238*x_99 - 0.00404852683264711*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.00348528057737368*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 0.000570682892420224*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 0.00065756048624982*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.00499721672715758*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 0.000597624568212413*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 0.00081415904066609*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 0.000196141913429978*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.00275565848021092*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 0.000261627475216755*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.0378852685799316*std::exp(0.69871985912323*x_85) + 0.399382209705642*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.412659431122862*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.266597283460626*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 1.74108673891837*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.0170137128394261*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.514542447187402*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.157340849630526*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.775543309842021*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.107244355862822*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 1.61150029947112*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.296961500662512*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.300953984144442*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.96397753563123*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 2.32649769934483*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.48429125354825*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.812733663911544*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.0406608923071454*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.596574007155922*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.44193733552531*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.463428156538193*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.216145144062313*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.582379823604342*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.2246655262968*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.237992641830356*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.126206767136953*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.78899656114902*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 1.15405023372202*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.517915578782265*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.42329309542982*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 1.10160754685265*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 1.49995478452755*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.463547951665142*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.0115620842357718*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 1.24425916541765*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 1.15973871702153*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.458069633095029*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.431686172257045*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.235489964035626*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.722611839155604*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.607825699816942*std::sin(0.315439850091934*x_97 - 7.45576000213623) - 4.82621877076749) - 0.392448968809279);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000501506839852391*x_1 - 7.33524980401943e-5*x_10 + 7.27325048315535e-5*x_100 + 6.89361915503973e-5*x_101 + 0.000207149736308361*x_102 + 0.000353251889191903*x_103 - 7.07968951167463e-5*x_104 + 4.63980367875175e-6*x_105 + 0.000590900790409575*x_106 - 0.000110038786131801*x_107 - 0.000499966867763053*x_108 - 1.53758771904844e-5*x_109 + 0.000573955623628928*x_11 - 0.000527058830559391*x_111 + 2.92373007947985e-5*x_112 + 0.000159122359377831*x_113 - 0.000497178104095563*x_114 + 3.36209663274033e-5*x_115 - 3.60284085403946e-5*x_116 + 1.59334085599777e-5*x_117 - 0.00144149082803808*x_118 - 4.44226814383087e-6*x_119 - 2.48869321256453e-5*x_12 - 1.39696277186982e-5*x_120 - 0.000152489341952277*x_13 - 0.000136969395808227*x_14 - 0.000144383455226627*x_15 + 0.00300943926659173*x_16 + 0.0011125547295415*x_17 - 3.88971954472342e-5*x_18 - 9.43960310675427e-5*x_19 + 1.23917054489637e-5*x_2 - 0.00082892580736517*x_20 - 2.25184313779654e-5*x_22 - 0.000163034577424289*x_23 - 0.000601663503804903*x_24 + 3.80342392024289e-5*x_25 + 8.64258473110605e-5*x_26 - 0.00101599397164677*x_27 + 1.54457952390706e-7*x_28 - 0.00208019410452282*x_29 + 2.39189043542655e-5*x_3 - 0.000266417521242076*x_30 - 0.00235791529413717*x_31 - 0.000391466436485022*x_32 + 2.10856580548163e-5*x_33 - 1.08707432990648e-5*x_34 - 4.63980395052361e-5*x_35 + 0.00100260663815382*x_36 - 7.23168722679765e-5*x_37 + 0.000191862354622876*x_38 - 0.000114124452211182*x_39 - 0.000831185276763371*x_4 - 3.74534170588609e-5*x_40 + 6.85516208921006e-5*x_41 - 5.5557614166021e-5*x_42 + 1.27554744428639e-6*x_43 - 0.000395705573541788*x_44 - 0.000203180509136185*x_45 - 5.69084582548522e-6*x_46 + 7.92255951045541e-5*x_47 + 0.000304144920516708*x_48 + 2.82380661222296e-5*x_49 + 7.0190362787961e-5*x_5 - 0.00051646428879829*x_50 + 0.000603051893422153*x_51 + 0.00103682135740015*x_52 + 0.000597956646859025*x_53 - 4.43928028700232e-5*x_54 + 1.09531973466484e-5*x_55 + 2.02265744759388e-5*x_56 - 0.0010250761166327*x_57 - 6.19775924669015e-5*x_58 - 0.000497976586858536*x_59 - 0.000783557223609468*x_6 - 0.00090997410163084*x_60 - 0.00116500610793803*x_61 - 0.000740711587596587*x_62 + 0.000905482767747713*x_63 - 2.94494397844717e-5*x_64 + 1.81206367332451e-5*x_65 + 9.93399706839346e-5*x_66 - 0.000156035460572771*x_67 - 9.15479853308062e-5*x_68 + 5.83674268179461e-5*x_69 - 6.4302574093719e-6*x_7 + 0.000655006760090293*x_70 - 0.000834331641808684*x_71 - 0.000195546586868044*x_72 - 3.49870658975824e-5*x_73 + 0.000523197532914745*x_74 + 6.24045328179772e-5*x_75 + 0.000289569530960754*x_76 - 3.63178701874039e-6*x_77 + 0.000280220621807726*x_78 - 4.65800084434985e-6*x_79 - 0.002473040177682*x_8 - 4.50435234332282e-5*x_80 - 0.000142515733036595*x_81 + 0.00135141639280341*x_82 - 0.000152858494056701*x_83 - 3.61136582409196e-6*x_84 - 0.000145444781887595*x_85 - 0.000313474894115549*x_86 - 0.00036027827465833*x_87 - 0.000147127993364665*x_88 - 0.000866262626650801*x_89 - 0.000128181519713323*x_9 + 0.00100494037235824*x_90 + 0.00118398214458896*x_91 - 1.31843779184082e-6*x_92 - 0.000741868322579499*x_93 + 1.31246053844623e-5*x_94 - 4.32683738123163e-5*x_95 - 5.88517842943178e-5*x_96 - 0.000202564971731437*x_97 - 0.0018139883502787*x_98 - 0.000396519587661202*x_99 + 3.47549478192801e-5*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 3.04976947496588e-6*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 4.39236671924947e-6*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 5.22847070357274e-6*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 1.61432147215297e-6*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 9.72490881596578e-6*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) + 2.98159122132554e-5*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) + 7.44390484419349e-6*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 8.38213726834957e-6*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 6.40828085022768e-6*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) - 1.04929751561203e-6*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) - 6.28130767051441e-6*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) - 4.72109354342354e-6*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 1.20903674133359e-6*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 1.83911911119229e-5*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 8.49927983502373e-7*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 9.18823249553486e-6*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) - 1.0988343667261e-6*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) - 4.12698711205007e-6*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 5.11494623074327e-6*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) + 1.80983364596524e-5*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 7.41974283759075e-6*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 6.10297721986983e-7*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) - 1.49696980587766e-6*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 1.75239749767042e-5*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) - 3.60640252586923e-7*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 6.48504070601081e-6*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) + 4.8889496534707e-5*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) + 1.28325637402228e-5*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 5.06674658652878e-6*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) - 1.61229377812311e-6*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 4.81046590684624e-7*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 2.48401409882401e-7*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) + 4.61304690182798e-6*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 3.64144083878607e-6*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) - 0.00158232566900551*std::pow(-0.0246336994353261*x_10 - 0.0612183814390047*x_100 + 0.187806953115659*x_101 + 0.00880411641114017*x_102 + 0.008338416988467*x_103 - 0.109087870365891*x_104 - 0.0125707139779001*x_105 - 0.00955405450056778*x_106 - 0.00479004173632276*x_108 - 0.00196922136370413*x_11 - 0.0182173702742179*x_113 + 0.00101591601392975*x_115 - 0.00164011095069318*x_116 + 0.00384236702913362*x_119 - 0.0954934848244374*x_12 - 0.106056732888902*x_120 - 0.116332227498558*x_13 + 0.125106304036924*x_14 - 0.00385248972415537*x_15 - 0.00949895464236977*x_17 - 0.000686493774148291*x_18 - 0.00511867620729348*x_19 + 0.0252674285493425*x_20 + 0.0657506410101152*x_22 + 0.0252644640287611*x_24 + 0.199596177306045*x_25 + 0.096926194622269*x_27 - 0.0156082109367021*x_28 + 0.188072992678872*x_29 - 0.100573417047629*x_3 - 0.00133417253646093*x_30 - 0.259495596496251*x_31 + 0.00604621035487068*x_32 - 0.0594395828301998*x_33 - 0.15337906164717*x_34 - 0.00244391088598238*x_38 - 0.0362277378520274*x_4 - 0.00380941762423574*x_42 - 0.051835563019795*x_43 - 0.0287096840703455*x_44 - 0.00517523162010641*x_47 + 0.0111114049730518*x_48 + 0.00561368624810206*x_5 + 0.00165497036752324*x_51 + 0.106293944938076*x_52 + 0.00732852749111263*x_57 - 0.000924671534267043*x_59 - 0.0171599191919529*x_6 + 0.0798404848070056*x_61 + 0.0134942857277191*x_63 + 0.143878001312915*x_66 - 0.090351549788585*x_68 + 0.00775698464421658*x_72 + 0.0998609717841659*x_73 - 0.000680854820308713*x_74 + 0.00125921406079372*x_76 - 0.0282603846989988*x_77 + 0.00390122874823576*x_8 - 0.0418835296927428*x_80 - 0.00292182706494199*x_82 - 0.000196419204028052*x_85 + 0.00418486518325619*x_86 - 0.0286800125661891*x_89 - 0.0364179769085144*x_9 - 0.00223145303961664*x_90 + 0.253524332885984*x_91 - 0.0742727051413147*x_95 - 0.000340623661050447*x_96 + 0.095287814557224*x_99 - 5.75525969084847e-5*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) + 0.00191540703434047*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) + 0.0025522853309802*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) - 0.000429466392563659*std::pow(-8.0*x_54 - 9.99971961975098, 2) + 0.000907154076453441*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) + 0.00100970073840956*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) + 0.000419651591827889*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) + 0.00210359225938976*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) - 0.000626032375466219*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) - 0.000723560557904401*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) - 0.000449477276978378*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) + 0.00123930128719213*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) + 0.112043992414164*std::exp(0.594239830970764*x_2) + 0.865797475875461*std::sin(0.431519865989685*x_107 + 5.2052001953125) - 0.573402992544164*std::sin(0.450319856405258*x_109 - 4.15903997421265) - 0.0918552426191948*std::sin(1.160719871521*x_110 - 7.00648021697998) - 0.365495414697435*std::sin(0.359679847955704*x_111 - 7.42783975601196) + 0.620995153602625*std::sin(0.346559852361679*x_112 - 7.43415975570679) - 1.07500322083315*std::sin(0.345199823379517*x_114 + 1.94695973396301) + 0.0234793889972069*std::sin(1.12887978553772*x_117 + 0.991439819335938) + 0.362544279062678*std::sin(0.407119870185852*x_118 - 1.19191980361938) + 0.659607858421325*std::sin(0.355999857187271*x_16 - 4.24599981307983) - 1.13043040963867*std::sin(0.312319934368134*x_21 + 8.32975959777832) + 2.57267703321568*std::sin(0.201519995927811*x_23 + 4.99215984344482) + 1.3798132296574*std::sin(0.343999862670898*x_26 + 5.15880012512207) - 0.39262953848014*std::sin(0.258239984512329*x_35 - 4.14152002334595) + 1.30555205795612*std::sin(0.371439844369888*x_36 + 5.18383979797363) - 0.851183250592598*std::sin(0.382879853248596*x_37 + 5.18959999084473) - 0.398746346015596*std::sin(0.33791983127594*x_39 + 5.16007995605469) + 0.332042047255666*std::sin(0.339839845895767*x_40 + 8.33960056304932) - 0.0284256214325465*std::sin(1.41703987121582*x_41 + 4.79800033569336) + 1.52514143241947*std::sin(0.266319960355759*x_45 - 7.53560018539429) - 0.0162804120986464*std::sin(1.01415979862213*x_46 + 4.18032026290894) + 0.466053053702215*std::sin(0.3642398416996*x_49 + 1.96791982650757) + 1.16133528667284*std::sin(0.354879856109619*x_53 + 5.16688013076782) - 0.804897385268326*std::sin(0.377519845962524*x_55 - 4.21208000183105) - 0.86266858692278*std::sin(0.320719838142395*x_56 + 8.30823993682861) + 0.778016807719645*std::sin(0.304079920053482*x_62 + 5.10087966918945) + 1.94812529145753*std::sin(0.19480000436306*x_64 - 4.4093599319458) + 0.497321937165466*std::sin(0.467439860105515*x_65 + 2.05879974365234) + 1.00683443368065*std::sin(0.419119864702225*x_75 - 7.36639976501465) - 1.24636558505246*std::sin(0.213599994778633*x_78 + 5.01663970947266) - 0.155323903931487*std::sin(0.439199864864349*x_79 + 2.22503995895386) - 1.70825934473645*std::sin(0.234479993581772*x_83 - 4.34055948257446) - 0.461665935531677*std::sin(0.404559850692749*x_84 - 4.1814398765564) + 3.41472994695934*std::sin(0.189920008182526*x_87 + 4.97759962081909) - 1.65237123701216*std::sin(0.317679852247238*x_92 - 4.21264028549194) - 0.784791699683332*std::sin(0.353039860725403*x_93 - 7.41192007064819) - 0.659590339196839*std::sin(0.43495985865593*x_94 + 2.01871991157532) + 1.44507531022538*std::sin(0.335919857025146*x_97 - 7.4507999420166) + 0.806790500788772*std::sin(0.446159869432449*x_98 - 7.38191986083984) + 13.1304722879481, 2) - 0.00218338028114082*std::exp(0.448319852352142*x_20) - 0.000223222636290936*std::exp(0.429519861936569*x_29) + 6.3943615131517e-5*std::exp(0.641439855098724*x_71) + 6.96585068997381e-5*std::exp(0.69871985912323*x_85) - 3.15951536338737e-5*std::log(8.06023979187012*x_91 + 9.42432022094727) + 0.0329779511608707*std::sin(0.255999982357025*x_1 - 7.38719987869263) + 0.00294783418645412*std::sin(0.281039953231812*x_1 + 5.1756796836853) - 0.000713854981753275*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.000234458367625058*std::sin(0.328399837017059*x_102 - 4.43911981582642) - 0.00489403495801145*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 0.000112408652997339*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.000734332088783186*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.00603492464523005*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.0171245166324359*std::sin(0.174880012869835*x_106 - 1.40583980083466) - 0.000758744517528395*std::sin(0.300959944725037*x_108 + 5.11872005462646) - 0.000490184428024109*std::sin(0.434719860553741*x_109 + 5.23311996459961) + 0.000614099842733266*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.00320128395975613*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.000549159836213882*std::sin(0.866479873657227*x_110 - 6.98816013336182) + 3.12826034403018e-5*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 4.44738963587955e-5*std::sin(1.31879985332489*x_110 - 0.19039985537529) + 0.00094607376299816*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.00829214212457477*std::sin(0.41967985033989*x_111 + 2.01015996932983) + 0.00900196321912626*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.000289297900488011*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.00014057604636747*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.00142596821996118*std::sin(0.357119828462601*x_115 + 5.16096019744873) + 0.00168739300460327*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 0.000205424225913804*std::sin(0.68071985244751*x_117 + 8.02408027648926) + 0.000197186980133633*std::sin(0.481039851903915*x_118 + 2.24391984939575) + 0.00601509373656476*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.00305168600514975*std::sin(0.325919836759567*x_12 - 7.46208000183105) + 0.0188304697454829*std::sin(0.340559840202332*x_12 - 4.26471996307373) - 0.0153680016951901*std::sin(0.369039833545685*x_12 + 1.95535981655121) + 0.00296301726072762*std::sin(0.180560007691383*x_120 - 7.61552000045776) + 0.0116671238746807*std::sin(0.257839977741241*x_120 + 5.06311988830566) + 0.00171673709803343*std::sin(0.333279848098755*x_120 - 4.27167987823486) - 0.000609664176418507*std::sin(0.346559852361679*x_15 + 1.93543982505798) - 0.000111640147791333*std::sin(1.99319982528687*x_15 - 8.39608001708984) + 0.000546014203362777*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.0667356164044017*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.0162670901966305*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 0.000191406596503357*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 0.00055335506297913*std::sin(0.598959863185883*x_2 + 5.59223985671997) + 0.00190973115539119*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.00954347745473255*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.00177243657848926*std::sin(0.316159844398499*x_21 - 1.07039988040924) - 0.0188574958443459*std::sin(0.32847985625267*x_21 + 5.15607976913452) - 0.00141250109954684*std::sin(0.298479825258255*x_22 - 1.12871980667114) - 0.000132743756295886*std::sin(1.528639793396*x_22 - 1.98135983943939) - 0.00427766153221578*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.00423730520875299*std::sin(0.250559985637665*x_23 - 7.5303201675415) - 0.00397499242230067*std::sin(0.184880018234253*x_24 + 1.7682398557663) - 0.020602949162324*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 0.000326784612053831*std::sin(1.65511989593506*x_27 - 3.5927197933197) + 0.0138039118960499*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.00818014066528914*std::sin(0.363919854164124*x_28 + 8.3712797164917) + 0.000890451800693939*std::sin(0.482479840517044*x_28 + 2.26735997200012) - 0.000155542238935827*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.0179496611807815*std::sin(0.356959849596024*x_3 - 1.01327979564667) - 0.000908928778483327*std::sin(0.772399842739105*x_3 + 7.61152029037476) + 0.00311394027489083*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 0.00149434900839586*std::sin(0.301119923591614*x_30 - 4.27631998062134) - 7.4761962987037e-5*std::sin(1.10583996772766*x_32 + 3.84191989898682) + 0.00109690273162504*std::sin(0.273119956254959*x_33 - 4.38567972183228) + 0.000812576922108685*std::sin(0.271199941635132*x_35 + 8.26056003570557) + 0.00135444023737984*std::sin(0.327759832143784*x_35 - 1.21751987934113) - 0.000777371156372019*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.00192983283866843*std::sin(0.323279827833176*x_38 + 5.11079978942871) + 0.000348191552174673*std::sin(1.05911982059479*x_39 + 8.42039966583252) + 3.15091937743771e-5*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 0.000852091450048443*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.00196764084115336*std::sin(0.278159946203232*x_41 + 5.10127973556519) + 0.00870502099123352*std::sin(0.349519848823547*x_41 - 1.24535989761353) + 0.00982915160284126*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.000397419592716973*std::sin(0.389599829912186*x_43 - 4.21072006225586) + 0.000637159819461066*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.00352306688761011*std::sin(0.530159831047058*x_43 - 4.43088006973267) + 0.00107080431210934*std::sin(0.397519826889038*x_45 + 5.20032024383545) + 0.0350460177461556*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.000413085763947016*std::sin(0.479679852724075*x_46 + 5.28007984161377) - 0.00043758993150727*std::sin(0.309039950370789*x_47 + 8.0740795135498) - 0.00487635799007378*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.00201238673875442*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.000232052596931041*std::sin(0.636399865150452*x_48 - 7.38199996948242) - 0.0067974268359878*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.00207274753985303*std::sin(0.241439983248711*x_53 + 5.06199979782104) - 0.00145070430958439*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.00364533300580464*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 0.00212191754688927*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.0458674637635375*std::sin(0.152720034122467*x_58 + 4.94431972503662) + 0.000952275838878359*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 9.83391691749045e-5*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.00199476744869047*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.000778296317113317*std::sin(0.29479992389679*x_64 + 8.33711910247803) - 0.00202549275165723*std::sin(0.212399989366531*x_65 + 5.01623964309692) - 2.55708159855341e-5*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 0.000354402812032672*std::sin(1.25287985801697*x_7 + 9.62911987304688) - 0.00275792186841337*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.00212528988402397*std::sin(0.262719959020615*x_73 - 7.51200008392334) + 0.00421834107763436*std::sin(0.427359849214554*x_73 + 2.01815986633301) - 0.000852311713754889*std::sin(0.39743983745575*x_74 - 4.18959999084473) - 0.00569406818134947*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.00012366723156692*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 2.12588574583708e-5*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.000886702323315143*std::sin(0.437359839677811*x_77 - 4.15848016738892) + 0.00768638668952009*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.00156325785952427*std::sin(0.307599931955338*x_79 + 5.1352801322937) + 0.0054177713754783*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.00228778200361551*std::sin(0.246719971299171*x_80 - 7.53208017349243) - 0.00213237679049558*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.000556304118494649*std::sin(0.426799863576889*x_81 - 4.15999984741211) + 0.000655164074926346*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 0.000842238893732246*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.00281184234421081*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.00218011044503122*std::sin(0.286079943180084*x_86 + 5.12367963790894) + 4.83775685670751e-5*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.000793728415709788*std::sin(0.268799960613251*x_87 - 4.28639984130859) + 0.00122733317243351*std::sin(0.283919870853424*x_87 - 1.28575992584229) + 0.000688139211021388*std::sin(0.467759847640991*x_9 - 4.13375997543335) + 0.00810818281399628*std::sin(0.506479859352112*x_9 - 0.87367981672287) + 0.000432988332918514*std::sin(0.620159804821014*x_90 + 2.2008798122406) - 0.00585696563960513*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.00229677402962084*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 0.0224174177392835*std::sin(0.409839868545532*x_92 - 7.41232013702393) - 0.0013286447125867*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.00460849247608515*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 0.00111759088140568*std::sin(0.315439850091934*x_97 - 7.45576000213623) + 0.0394984991424894);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00777425611860537*x_1 - 0.00272315062629101*x_10 + 0.000126344469010051*x_100 + 1.09643727766313e-5*x_101 + 0.00306768061021314*x_102 + 0.00016059947720008*x_103 - 7.96181720834812e-5*x_104 - 3.71329414774504e-6*x_105 - 8.08977511219376e-5*x_106 - 3.32557658472977e-5*x_107 - 8.68696404703982e-6*x_108 + 3.06408388600831e-6*x_109 + 1.84781057948071e-7*x_11 - 6.58794773510423e-6*x_111 - 1.58041233904779e-8*x_112 + 0.000655907195642863*x_113 - 0.000165611905991759*x_114 + 7.46991042674749e-7*x_115 - 0.000256075831292254*x_116 - 0.000480969362919707*x_117 - 1.03927617039183e-5*x_118 - 3.10061125438336e-5*x_119 - 0.000456007346035279*x_12 - 7.81568754263291e-5*x_120 - 0.00129453275505821*x_13 + 0.000354667866455462*x_14 - 2.83269017958366e-6*x_15 + 5.86133856999908e-6*x_16 + 0.00331718681174274*x_17 + 2.89049489928178e-6*x_18 - 4.23963032938362e-6*x_19 - 3.96998874646182e-7*x_2 - 0.000889094615688282*x_20 + 0.0024161553068795*x_22 + 5.95671724284916e-6*x_23 + 1.8576661917614e-5*x_24 + 0.00471244565449002*x_25 - 3.29642932774644e-5*x_26 - 0.000358334716859628*x_27 - 1.14900154557868e-5*x_28 + 0.000308416447828553*x_29 + 0.000853643490592978*x_3 - 1.02039052518104e-6*x_30 + 0.0010185064964146*x_31 + 1.16531965528009e-6*x_32 - 4.24612609899637e-5*x_33 - 8.31012972252352e-5*x_34 + 4.70399931193862e-7*x_35 + 9.23417807957273e-5*x_36 + 0.000228374843152364*x_37 + 0.000696889576217516*x_38 - 5.82894812954179e-6*x_39 - 1.17509804893389e-5*x_4 - 5.24007464813321e-6*x_40 + 0.00147936341949792*x_41 - 4.12659248409657e-5*x_42 - 3.8098133439057e-5*x_43 - 2.58046455614906e-5*x_44 - 1.81772004617208e-6*x_45 + 4.96743613282691e-7*x_46 - 1.85900039003675e-5*x_47 + 8.19386552293258e-6*x_48 + 1.08648707102514e-5*x_49 + 0.00118460474249906*x_5 + 0.00332712621773899*x_50 + 0.000109939473873781*x_51 - 6.81644938297661e-6*x_52 + 0.000394695811131301*x_53 - 2.27985289761674e-7*x_54 + 3.7421997120474e-7*x_55 - 0.000262082611096583*x_56 + 6.53452155712922e-6*x_57 + 5.40991166668019e-6*x_58 - 0.00130883678349831*x_59 + 0.000817070400630315*x_6 - 7.65748473638169e-6*x_60 - 1.25963420324603e-6*x_61 - 0.000272908755453052*x_62 + 0.0025701186577878*x_63 - 4.22505605133742e-7*x_64 + 2.60149943450452e-6*x_65 + 7.2207864321218e-5*x_66 + 0.00012968982373031*x_67 - 0.00214900278728922*x_68 + 0.00046734788807707*x_69 + 5.61285509715395e-7*x_7 + 9.240299545269e-6*x_70 - 0.00010306656531124*x_71 - 0.00247132179372577*x_72 + 7.29892735331206e-5*x_73 + 5.20223753061591e-6*x_74 + 2.95302093356205e-6*x_75 + 2.89767264190136e-6*x_76 - 9.86098033428916e-5*x_77 + 0.0024236454388711*x_78 + 0.000198762849784582*x_79 + 0.000161318068708754*x_8 - 3.08645901962163e-5*x_80 - 3.15402432107075e-7*x_81 - 2.33748275731705e-5*x_82 + 0.00193435952292398*x_83 + 5.19802222491599e-6*x_84 - 6.77137777265988e-7*x_85 - 0.000110365140910528*x_86 - 2.0828761154854e-7*x_87 - 0.000170902687757124*x_88 - 5.78719134192019e-5*x_89 + 0.00206754168441075*x_9 - 2.31028855206437e-6*x_90 - 6.14329938271816e-5*x_91 - 2.04381520962623e-5*x_92 + 0.00123235864331554*x_93 - 1.17254197575859e-5*x_94 - 5.44765348622301e-5*x_95 - 2.27163938372825e-5*x_96 + 1.36618012807343e-5*x_97 + 0.000307032902671245*x_98 + 4.22807822192261e-5*x_99 - 4.23177445613938e-8*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) + 1.40837616309834e-6*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) + 2.66208847530083e-7*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 5.4902186818718e-8*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 6.53530303118211e-8*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) - 1.40911194164837e-7*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 1.21556052746976e-7*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) + 0.000115393885352233*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) + 7.31661563394482e-7*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 9.93398547152171e-5*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) - 1.62659947636711e-5*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 5.48283957090961e-7*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) - 5.90110927154034e-8*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 1.87422394611764e-5*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 2.29879851748368e-7*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) + 7.41886725632815e-8*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 0.000142434094654831*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) - 1.70339048643257e-5*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) - 5.15850865619278e-8*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 6.39340363584098e-8*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) + 9.27427360814397e-8*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) + 1.8766652503267e-6*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) - 3.15781564594054e-7*std::pow(-8.0*x_54 - 9.99971961975098, 2) + 5.3271781540868e-8*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) - 2.32057187418166e-5*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 2.19040123348797e-7*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) - 5.59057118964617e-6*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) + 6.67019674997922e-7*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) + 7.42421024014074e-7*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) + 3.08564857568344e-7*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) + 7.85436658517717e-5*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 1.54674653579459e-6*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) - 4.60314209526772e-7*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 1.4073420042965e-7*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 5.32025529843364e-7*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) - 7.45708553459595e-6*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) + 2.16825086592428e-8*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 3.3049533148899e-7*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) + 5.76605686628425e-8*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 9.11243594957077e-7*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) + 4.55160231371809e-8*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) + 8.23846238973509e-5*std::exp(0.594239830970764*x_2) - 2.7901611279638e-6*std::exp(0.429519861936569*x_29) - 5.58152222021922e-6*std::exp(0.641439855098724*x_71) + 0.00107983187953647*std::exp(0.69871985912323*x_85) + 2.75788367135636e-6*std::log(8.06023979187012*x_91 + 9.42432022094727) - 0.000257311101028222*std::sin(0.281039953231812*x_1 + 5.1756796836853) - 8.9227976794223e-6*std::sin(0.788719892501831*x_1 + 1.20735991001129) + 2.04654457825701e-5*std::sin(0.328399837017059*x_102 - 4.43911981582642) - 6.11727660134884e-5*std::sin(0.328959852457047*x_102 - 4.24408006668091) + 9.81194749716794e-6*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.0113834653501261*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.000214047112053268*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.000636610655193491*std::sin(0.431519865989685*x_107 + 5.2052001953125) - 0.0117619018109296*std::sin(0.300959944725037*x_108 + 5.11872005462646) - 0.00759873841388313*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.000421616446045122*std::sin(0.450319856405258*x_109 - 4.15903997421265) - 5.36036617666839e-5*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.0496256470178004*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 6.75400746896772e-5*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.000484936499117844*std::sin(1.23231983184814*x_110 + 8.60128021240234) + 3.882045771666e-6*std::sin(1.31879985332489*x_110 - 0.19039985537529) - 0.00026874446034331*std::sin(0.359679847955704*x_111 - 7.42783975601196) + 0.0146658413329024*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.000456610399801876*std::sin(0.346559852361679*x_112 - 7.43415975570679) - 0.00448463668736917*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.000790437167835018*std::sin(0.345199823379517*x_114 + 1.94695973396301) + 1.22706281904269e-5*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.0221050667269721*std::sin(0.357119828462601*x_115 + 5.16096019744873) + 2.10914916483013e-5*std::sin(0.49839985370636*x_115 + 8.25191974639893) + 1.79311081982303e-5*std::sin(0.68071985244751*x_117 + 8.02408027648926) + 1.7264117336379e-5*std::sin(1.12887978553772*x_117 + 0.991439819335938) + 0.000266574525176766*std::sin(0.407119870185852*x_118 - 1.19191980361938) + 0.00305675210185452*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.00026637613797472*std::sin(0.325919836759567*x_12 - 7.46208000183105) + 0.000235370594927778*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0459320855434892*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.000149850868444649*std::sin(0.333279848098755*x_120 - 4.27167987823486) + 5.32164804969608e-5*std::sin(0.346559852361679*x_15 + 1.93543982505798) - 1.39544091882118e-6*std::sin(1.99319982528687*x_15 - 8.39608001708984) + 0.000485001865471801*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.0084642001345144*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.000203329749553551*std::sin(0.231519997119904*x_18 - 7.55200004577637) + 1.6707534744207e-5*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 0.00857799663389028*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.000166696969768402*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.000119288259749286*std::sin(0.302399933338165*x_21 - 4.28687953948975) - 0.000831192124928574*std::sin(0.312319934368134*x_21 + 8.32975959777832) + 0.027475948123092*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 0.000123294659787211*std::sin(0.298479825258255*x_22 - 1.12871980667114) - 1.65922450765231e-6*std::sin(1.528639793396*x_22 - 1.98135983943939) - 0.0663114312657022*std::sin(0.165360018610954*x_23 - 7.6396803855896) + 0.00189165902806613*std::sin(0.201519995927811*x_23 + 4.99215984344482) + 0.000346969880959057*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.00101456036619723*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 4.08462930516134e-6*std::sin(1.65511989593506*x_27 - 3.5927197933197) + 0.000102247293934018*std::sin(0.363919854164124*x_28 + 8.3712797164917) + 0.0138036010872864*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 1.35770000025391e-5*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.000224360968577857*std::sin(0.356959849596024*x_3 - 1.01327979564667) - 0.000271810200298983*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 0.0231650916770602*std::sin(0.301119923591614*x_30 - 4.27631998062134) - 0.00115894460853613*std::sin(1.10583996772766*x_32 + 3.84191989898682) + 0.0170039610533744*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.00028869586098922*std::sin(0.258239984512329*x_35 - 4.14152002334595) + 0.0125964006999392*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.000118226632406468*std::sin(0.327759832143784*x_35 - 1.21751987934113) + 6.78553186854357e-5*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.000959957003991322*std::sin(0.371439844369888*x_36 + 5.18383979797363) - 0.000625864988000293*std::sin(0.382879853248596*x_37 + 5.18959999084473) - 0.000168451609252657*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.000293193477304054*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 2.75038039108607e-6*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 0.0132089468033979*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.000244146594492524*std::sin(0.339839845895767*x_40 + 8.33960056304932) - 0.000171751801234886*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 2.09010236096583e-5*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.00616071697295885*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 5.56165253221652e-5*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.00112141847673273*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.0165993887096241*std::sin(0.397519826889038*x_45 + 5.20032024383545) + 0.00640357074455672*std::sin(0.479679852724075*x_46 + 5.28007984161377) - 1.19707946739615e-5*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.00678342932164552*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 2.51537359570661e-5*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.00359723173877427*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.000342683304282319*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 8.4964125695711e-5*std::sin(0.282959938049316*x_51 + 5.09143972396851) + 0.000180926374381547*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.000853916115891359*std::sin(0.354879856109619*x_53 + 5.16688013076782) - 0.0224885205122887*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.000591831538063877*std::sin(0.377519845962524*x_55 - 4.21208000183105) - 0.000634310020112314*std::sin(0.320719838142395*x_56 + 8.30823993682861) + 0.0328935303792375*std::sin(0.311919927597046*x_57 - 7.47584009170532) + 0.0147619846404869*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 1.22918594523926e-6*std::sin(1.12711989879608*x_58 - 7.43103981018066) + 0.000572066566968366*std::sin(0.304079920053482*x_62 + 5.10087966918945) + 0.000174119633619966*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.0014324335110122*std::sin(0.19480000436306*x_64 - 4.4093599319458) + 0.0120649897959261*std::sin(0.29479992389679*x_64 + 8.33711910247803) - 0.0313987729906072*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.000365674944871917*std::sin(0.467439860105515*x_65 + 2.05879974365234) + 2.23203016155476e-6*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 4.42984173202676e-6*std::sin(1.25287985801697*x_7 + 9.62911987304688) - 0.0427527388588735*std::sin(0.160320028662682*x_70 - 4.45192003250122) - 0.000185512700332767*std::sin(0.262719959020615*x_73 - 7.51200008392334) - 0.0132123612861755*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.000740313464010382*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 1.07946884060914e-5*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.000329550445850237*std::sin(1.73087990283966*x_76 - 7.99607992172241) - 7.73986380051274e-5*std::sin(0.437359839677811*x_77 - 4.15848016738892) - 0.000916437889713826*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.000136453944008656*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 0.000114207831512849*std::sin(0.439199864864349*x_79 + 2.22503995895386) - 0.000472907439688926*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.0354647271508361*std::sin(0.246719971299171*x_80 - 7.53208017349243) - 0.0330556674273109*std::sin(0.258799970149994*x_81 + 5.05815982818604) - 4.85587777949533e-5*std::sin(0.426799863576889*x_81 - 4.15999984741211) - 5.71880841358369e-5*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 0.00125606291424382*std::sin(0.234479993581772*x_83 - 4.34055948257446) - 0.0130562144971992*std::sin(0.358319848775864*x_84 - 7.4423999786377) - 0.000339457508122388*std::sin(0.404559850692749*x_84 - 4.1814398765564) + 3.5146494715501e-5*std::sin(0.349279850721359*x_85 + 1.96199989318848) - 0.000190297887700693*std::sin(0.286079943180084*x_86 + 5.12367963790894) + 0.00251081058725022*std::sin(0.189920008182526*x_87 + 4.97759962081909) - 0.0123042150215917*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.000107131687181905*std::sin(0.283919870853424*x_87 - 1.28575992584229) - 6.00664239740003e-5*std::sin(0.467759847640991*x_9 - 4.13375997543335) + 0.00671209628460353*std::sin(0.620159804821014*x_90 + 2.2008798122406) - 0.00121496904891474*std::sin(0.317679852247238*x_92 - 4.21264028549194) - 7.32088740057112e-5*std::sin(0.356719851493835*x_92 + 5.19888019561768) - 0.000200481240461373*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 0.000577048064988451*std::sin(0.353039860725403*x_93 - 7.41192007064819) - 0.000484988983793014*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.0205963776871319*std::sin(0.355119854211807*x_95 - 7.42967987060547) + 0.0173246645059177*std::sin(0.315439850091934*x_97 - 7.45576000213623) + 0.00106254680301106*std::sin(0.335919857025146*x_97 - 7.4507999420166) + 0.000593223523540168*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 0.00992569699883461*std::sin(0.00176231456048478*x_100 - 0.00354322468999635*x_101 - 0.000537269944925595*x_102 - 0.0308587108410745*x_103 + 0.00633670716296487*x_104 - 0.0309689008220481*x_106 + 0.00648622256683958*x_107 + 0.00118520778085145*x_108 + 0.0144662074195662*x_109 - 0.0257422636858541*x_11 + 0.00540644928092715*x_113 + 0.0184193576575216*x_114 - 0.00186695991895441*x_115 + 0.00290558607216962*x_116 - 0.00305518218405334*x_117 + 0.034260239894788*x_118 + 0.0130135408201092*x_13 + 0.00801756027007928*x_15 - 0.142877475664167*x_16 - 0.0335018252341312*x_17 + 0.00312743523570057*x_19 - 0.00245180000168645*x_2 + 0.00973227099528595*x_22 + 0.0334101535144123*x_24 + 0.0208407482440032*x_25 + 0.054878871838324*x_27 + 0.116121839877091*x_29 + 0.0146190780000723*x_30 + 0.131197031170469*x_31 + 0.0027043797506447*x_32 - 0.00691410742921701*x_33 + 0.00226035180014892*x_34 + 0.00466624818458436*x_35 - 0.0581368384435891*x_36 + 0.00232586775482782*x_37 - 0.00574095421794249*x_38 + 0.00440254512697121*x_4 + 0.00433689612869354*x_40 + 0.00386257998711485*x_44 + 0.000207697763239725*x_45 - 0.016904184240606*x_48 - 0.00210535647512544*x_49 + 0.0393839548581522*x_50 - 0.0360830413930306*x_51 - 0.0621636768066004*x_52 - 0.0321801201312361*x_53 + 0.00105426936857647*x_55 + 0.00041606688088951*x_56 + 0.0545204076306706*x_57 + 0.0482146210567029*x_59 + 0.044828124524758*x_6 + 0.00145317225026767*x_60 + 0.064715713174119*x_61 + 0.0135508485730055*x_62 + 0.0109112941812345*x_63 + 0.00109200501494514*x_64 - 0.000609758959188326*x_65 - 0.00558954555258771*x_66 - 0.00239786336468393*x_69 + 0.00467834269722278*x_70 + 0.0442363897194802*x_71 + 0.000849034721408094*x_72 - 0.034979817700588*x_74 - 0.0073198967726694*x_76 - 9.38022043294981e-5*x_77 - 0.0048149261971418*x_78 + 0.0923160386205288*x_8 + 0.002198597769942*x_80 + 0.00651265066283994*x_81 - 0.0763071440382351*x_82 + 0.00562285418496481*x_83 - 0.00310625863125609*x_84 + 0.00841538840772728*x_85 + 0.0190807891752103*x_87 - 0.000633066274777967*x_88 + 0.0483662981764533*x_89 - 0.0553780404685192*x_90 - 0.0525267237651329*x_91 + 0.00373904298466353*x_93 + 0.000161892003601573*x_94 + 0.00137838470711872*x_95 + 0.00364467343903395*x_96 + 0.0952122647329337*x_98 + 0.0172010354652863*x_99 - 0.00192992949494915*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 0.00165566666071226*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 0.00100499398027065*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 0.000360111929948954*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 0.00271481579676559*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 0.000712587554061363*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 0.121242305561066*std::exp(0.448319852352142*x_20) - 1.83125352278763*std::sin(0.255999982357025*x_1 - 7.38719987869263) - 0.335117150317341*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.0304946441255388*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 0.460459608391341*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.499875713218639*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.334015947238465*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.85337949302064*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.64787110612437*std::sin(0.257839977741241*x_120 + 5.06311988830566) - 3.70580428237672*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 1.04714982223899*std::sin(0.32847985625267*x_21 + 5.15607976913452) + 0.235296002859701*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 1.14407420428493*std::sin(0.347119837999344*x_26 + 5.14224004745483) - 0.766526160602883*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.050472481429823*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.0193349490820196*std::sin(1.05911982059479*x_39 + 8.42039966583252) - 0.483386620301969*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.545809180531322*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.195634611061209*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 1.94609250114588*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.270782369230135*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.202424003724479*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 2.54700342627636*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 0.234242931619823*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.316189515995811*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.426822231436649*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.00268638862463576*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.450244415400633*std::sin(0.506479859352112*x_9 - 0.87367981672287) + 1.24483097832876*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.255907895563407*std::sin(0.263759940862656*x_97 + 8.28248023986816) - 0.961911883232965) + 0.0352533701913327);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.37973947039928e-6*x_10 + 0.000215278689680422*x_100 - 1.21816522842627e-6*x_101 - 4.32277938264207e-7*x_102 - 2.77261344751012e-5*x_103 + 4.81311633599696e-6*x_104 + 4.18607506415848e-5*x_105 + 3.97682166385993e-5*x_106 + 2.04044834618758e-5*x_107 - 1.94971706566643e-5*x_108 + 1.49805002261948e-5*x_109 - 2.35177259495352e-5*x_11 - 7.18385805605864e-6*x_111 + 6.89263652493427e-6*x_112 + 0.000402032241158679*x_113 - 0.000229954880614841*x_114 - 1.50212308023165e-6*x_115 + 0.000179691206106328*x_116 - 2.56807732363362e-6*x_117 + 1.78042281228869e-5*x_118 + 1.49389419166502e-5*x_119 - 1.90407250212653e-7*x_120 + 0.000282826801876709*x_13 - 5.7693153809307e-5*x_14 + 6.4507878324347e-6*x_15 - 0.000115923993964844*x_16 - 2.29335518209111e-5*x_17 - 6.66453390237534e-5*x_18 + 1.99730123543044e-6*x_19 - 2.4055843715487e-6*x_2 + 2.81816979536705e-5*x_20 + 7.83041389194658e-6*x_22 - 0.000138398198311774*x_23 + 2.68812212830943e-5*x_24 + 0.00021920518677748*x_25 + 0.000339843558551155*x_26 + 4.41545740583379e-5*x_27 + 2.64643825438714e-7*x_28 + 9.34295878703336e-5*x_29 - 6.11978805356437e-5*x_3 + 1.17193006100059e-5*x_30 - 0.000327070953985647*x_31 - 1.95975080509705e-5*x_32 - 5.01823743292623e-5*x_33 + 9.95722790003577e-7*x_34 + 4.26733091226929e-6*x_35 - 4.74620480304825e-5*x_36 + 6.2877550741625e-5*x_37 - 4.02697105726118e-6*x_38 - 1.55165226611297e-6*x_39 - 0.000420370597238124*x_4 + 0.000101954876349354*x_40 - 3.66674186118426e-7*x_41 + 1.96084808613679e-6*x_42 + 1.73858234645198e-8*x_43 + 9.19079060945867e-6*x_44 - 1.40519051810624e-5*x_45 - 9.75053201164255e-6*x_46 + 0.000269784546317854*x_47 - 1.40675984553945e-5*x_48 - 1.93738961692422e-5*x_49 - 1.01555881512409e-5*x_5 + 0.000156740117701674*x_50 - 0.000120626184156203*x_51 - 4.21476725652536e-5*x_52 - 2.59872805577663e-5*x_53 - 6.17336544577832e-6*x_54 + 1.25631646918081e-6*x_55 + 6.46467856497057e-5*x_56 + 1.45486334147524e-5*x_57 - 0.000106190629281638*x_58 + 9.12522040530196e-5*x_59 - 1.46984366482775e-5*x_6 - 6.86140558163217e-5*x_60 + 6.8507508517671e-5*x_61 + 2.39425966844379e-6*x_62 + 2.15583177522852e-5*x_63 + 5.85888045459579e-6*x_64 - 4.31859958612849e-5*x_65 - 8.29637134386968e-6*x_66 - 2.24261618024975e-6*x_67 + 7.47785276703407e-5*x_68 - 4.952934146404e-6*x_69 - 1.10174186115535e-5*x_7 + 1.38402395112697e-5*x_70 + 3.51681796059682e-5*x_71 + 7.93623014191583e-5*x_72 - 4.76876774722551e-7*x_73 - 0.000149463712760171*x_74 + 8.48667082454055e-7*x_75 - 3.739315360667e-6*x_76 - 7.95678583303215e-8*x_77 + 1.07630703951704e-5*x_78 - 2.38445184815735e-7*x_79 + 0.000275858888052606*x_8 + 1.69466513823867e-6*x_80 + 4.8960320187592e-6*x_81 - 6.16870870683649e-5*x_82 + 2.81443012204472e-6*x_83 - 0.000104530713067778*x_84 + 1.72274460693355e-5*x_85 - 4.17631268003198e-6*x_86 + 1.51249388365015e-5*x_87 - 0.000246527396002414*x_88 + 4.10764964236947e-5*x_89 - 3.59146974069915e-6*x_9 - 3.14141063465163e-5*x_90 - 3.8796586535502e-5*x_91 - 3.44084550919734e-5*x_93 + 0.000116963828641482*x_94 - 5.3744895829638e-6*x_95 - 1.59015139727309e-6*x_96 - 0.000278598638736136*x_97 - 0.000111216893987818*x_98 - 0.000126700412150183*x_99 - 1.55278729240557e-6*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 5.22538754443407e-6*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 5.9868343364543e-8*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 7.12645139535237e-8*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 2.76593210816205e-6*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 1.3255135952824e-7*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 1.33212024477676e-6*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 1.43617135777977e-5*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) - 1.07622124011951e-5*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) - 6.43489187902106e-8*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 2.50673546802501e-7*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 1.45624222916355e-6*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) - 5.6251196058483e-8*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 6.97171654386906e-8*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 8.08600462137329e-7*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 1.01131745200318e-7*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 1.0456666121963e-6*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 2.38853314869906e-7*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) + 2.8973971853988e-7*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 2.18429299177614e-6*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 5.73335399852004e-7*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) - 2.76245791536992e-6*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 4.25603851003815e-7*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) + 6.28762335952154e-8*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 4.96331577968439e-8*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) + 9.75494244063747e-5*std::exp(0.448319852352142*x_20) - 3.04254409761301e-6*std::exp(0.429519861936569*x_29) + 0.000109559156125416*std::exp(0.641439855098724*x_71) - 5.41342300190646e-5*std::log(8.06023979187012*x_91 + 9.42432022094727) - 0.00147339434253917*std::sin(0.255999982357025*x_1 - 7.38719987869263) + 0.00505073454482217*std::sin(0.281039953231812*x_1 + 5.1756796836853) - 9.72990596909844e-6*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.000401714242316636*std::sin(0.328399837017059*x_102 - 4.43911981582642) - 6.67061254289741e-5*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 0.000192597761922802*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.000269629358917924*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.000233408662625893*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.00105218105682995*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 2.45354537606122e-5*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 7.62002984138012e-5*std::sin(1.31879985332489*x_110 - 0.19039985537529) - 0.000370477693847026*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.000402191197812914*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.000240858965821533*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 2.29993145489861e-5*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 0.000351967976670438*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 0.00026874335030895*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.0052286712722809*std::sin(0.325919836759567*x_12 - 7.46208000183105) + 0.00025666095307972*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.000686614115090699*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.000521265685269588*std::sin(0.257839977741241*x_120 + 5.06311988830566) + 0.00294140810404436*std::sin(0.333279848098755*x_120 - 4.27167987823486) - 0.00104458111339073*std::sin(0.346559852361679*x_15 + 1.93543982505798) - 1.5216649994065e-6*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 0.00298162487949763*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.000221721865154346*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 0.000327950572494451*std::sin(0.676799833774567*x_19 + 5.45519971847534) + 0.00327207858643495*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.000130078434172576*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.000842518310369821*std::sin(0.32847985625267*x_21 + 5.15607976913452) - 0.00242013887038267*std::sin(0.298479825258255*x_22 - 1.12871980667114) - 1.8093090330079e-6*std::sin(1.528639793396*x_22 - 1.98135983943939) + 0.000189315021170757*std::sin(0.250559985637665*x_23 - 7.5303201675415) - 0.00681063800500598*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.000920501961668526*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 4.45410290423809e-6*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 0.000616733453007278*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.000111496034239025*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.000266501610905445*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.000244655455141928*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 4.06092699166038e-5*std::sin(0.772399842739105*x_3 + 7.61152029037476) + 0.00533533595246841*std::sin(0.292639940977097*x_30 - 4.29711961746216) + 0.0023206590544566*std::sin(0.327759832143784*x_35 - 1.21751987934113) - 0.00133192544264484*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.00330652023400251*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 1.55565596113446e-5*std::sin(1.05911982059479*x_39 + 8.42039966583252) + 5.39869488613175e-5*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 0.00337129938104506*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.000388924363966751*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.000439148456886846*std::sin(0.357599824666977*x_42 + 1.97287976741791) + 0.00109169135954545*std::sin(0.513519823551178*x_43 - 4.23767995834351) - 0.000157404163626482*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 0.00156579176261809*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.000217866726763043*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 2.74290076304441e-5*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 9.26495235538561e-5*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.00355138618391004*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.000162866789426165*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 0.00204927411306265*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 1.34037149506339e-6*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.00341777733234946*std::sin(0.237039983272552*x_63 - 4.33999967575073) - 4.38123026834087e-5*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 4.83054139062348e-6*std::sin(1.25287985801697*x_7 + 9.62911987304688) + 0.00364141072938466*std::sin(0.262719959020615*x_73 - 7.51200008392334) - 0.00018846773859201*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.000254400517591497*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.000211887887523583*std::sin(0.959439814090729*x_76 + 5.5699200630188) + 0.0015192503282313*std::sin(0.437359839677811*x_77 - 4.15848016738892) - 0.000343413652584483*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.00267844117889867*std::sin(0.307599931955338*x_79 + 5.1352801322937) + 0.00928265408136544*std::sin(0.154000028967857*x_80 - 7.65791988372803) + 0.00095315552062565*std::sin(0.426799863576889*x_81 - 4.15999984741211) + 0.00112253933445875*std::sin(0.464319854974747*x_82 + 5.2532000541687) + 3.83256576033203e-5*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.00373533870624245*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 2.1614209895824e-6*std::sin(1.34455978870392*x_86 + 1.38687980175018) + 0.00210287745508259*std::sin(0.283919870853424*x_87 - 1.28575992584229) + 0.0011790379868459*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.00036225872942011*std::sin(0.506479859352112*x_9 - 0.87367981672287) - 7.98309550178284e-5*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.00393522674591484*std::sin(0.380959838628769*x_92 + 1.97975981235504) + 0.00100156908809387*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.000205898987137651*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 0.475781947374344*std::sin(-0.0396244991344922*x_1 + 0.0137937187924673*x_10 - 0.000931100157577517*x_100 + 0.000648371617343238*x_101 - 0.0156026241161684*x_102 - 0.000800851941982524*x_103 - 4.04307608235668e-5*x_105 + 0.000359724772881399*x_106 + 0.000165557680232203*x_107 - 0.00351598431089344*x_113 + 0.000906909015958869*x_114 + 0.00124814960208156*x_116 + 0.00245093230356366*x_117 + 0.000167807318428119*x_119 + 0.00196633852643575*x_12 + 0.00609138953568273*x_13 - 0.00133200757259732*x_14 - 0.0169241263793177*x_17 + 0.00456560249913739*x_20 - 0.0120684563891669*x_22 - 0.0233233421038063*x_25 + 7.22458389860968e-5*x_26 + 0.00218963967698881*x_27 - 0.000867126113674353*x_29 - 0.00471194999681553*x_3 - 0.00603912467166508*x_31 - 0.000149117126127131*x_34 - 0.000473862781982578*x_36 - 0.00118533503690874*x_37 - 0.00355835836840058*x_38 + 2.24569186810791e-5*x_39 - 0.00754186094454622*x_41 + 0.000191863045946113*x_42 - 5.07861899666382e-5*x_49 - 0.00601412030215166*x_5 - 0.0169969173808214*x_50 - 0.000530363078368132*x_51 + 0.000425506713931308*x_52 - 0.00201216706944254*x_53 + 0.00131957256378697*x_56 + 0.00668266380339657*x_59 - 0.00421564267296739*x_6 + 0.0003010047834467*x_61 + 0.00136103003677581*x_62 - 0.0129892986317342*x_63 + 0.00017236875105567*x_66 - 0.000671496476124787*x_67 + 0.0105951226480341*x_68 - 0.00238212860694425*x_69 + 0.000523338423748297*x_71 + 0.0126001651255967*x_72 - 1.10844629786179e-5*x_75 + 0.000396672919282107*x_77 - 0.0123549071844033*x_78 - 0.00101418615153445*x_79 - 0.000923656867461436*x_8 + 0.000106825319266245*x_82 - 0.00987066514604889*x_83 + 0.000558681632414847*x_86 + 0.000934742299658764*x_88 + 0.000187317994410141*x_89 - 0.0106912945837854*x_9 + 0.00127944314085727*x_91 + 0.00010417093644636*x_92 - 0.00632114341692017*x_93 + 2.59130564639982e-5*x_94 + 0.000116419278651186*x_96 - 0.001516747396091*x_98 + 0.00017793284008865*x_99 - 0.000588149507876709*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.000506323939825363*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 8.29059250945239e-5*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 9.5527062651115e-5*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.000725970378936396*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 8.68198755297218e-5*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 0.00011827690883502*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 2.84945054402441e-5*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.000400328130702451*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 3.80079167451508e-5*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.00550378026184269*std::exp(0.69871985912323*x_85) + 0.0580202280491*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.0599490756436216*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.0387299053582195*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.252936278057456*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.00247166617569911*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.0747501250713154*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.0228576830794005*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.11266701071175*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.0155799177653051*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.234110615356201*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.0431410653041877*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.0437210731174416*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.140041782263551*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 0.337981822403108*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.0703553846170655*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.118069837307183*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.00590700884268042*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.0866672553313359*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.0642024215587584*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.0673244993725119*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.031400473645143*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.0846051961143255*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.0326382716949729*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.0345743676544388*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.0183346809964886*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.114621431038607*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.167654582786797*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.0752401565740151*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.0614938806276544*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.160035974401834*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.217905846947387*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.0673419026028408*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.00167968113696604*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.180759680264483*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.168480976878147*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.0665460401807318*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.0627131843916056*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.0342107912785889*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.10497739428526*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.0883018443497399*std::sin(0.315439850091934*x_97 - 7.45576000213623) - 0.894649431508553) + 0.0222810320556164*std::sin(0.0137741758061826*x_10 + 0.0342308612932718*x_100 - 0.105014108685959*x_101 - 0.00492290845650389*x_102 - 0.00466250803481411*x_103 + 0.0609975577840748*x_104 + 0.0070290386060538*x_105 + 0.00534224372990237*x_106 + 0.00267839904307854*x_108 + 0.00110110953233656*x_11 + 0.0101864221223531*x_113 - 0.000568059451115866*x_115 + 0.000917084201494155*x_116 - 0.00214849739114978*x_119 + 0.0533961231349016*x_12 + 0.0593026673917336*x_120 + 0.0650483114684781*x_13 - 0.0699544228340752*x_14 + 0.00215415759583109*x_15 + 0.0053114341011778*x_17 + 0.000383859759261659*x_18 + 0.0028621582462387*x_19 - 0.0141285316857319*x_20 - 0.0367651188982096*x_22 - 0.0141268740448332*x_24 - 0.111606169575684*x_25 - 0.0541972369378196*x_27 + 0.00872748496532388*x_28 - 0.105162867329569*x_29 + 0.0562366173006051*x_3 + 0.000746015722130616*x_30 + 0.145099520129071*x_31 - 0.00338079810577375*x_32 + 0.0332362285209674*x_33 + 0.0857634138819501*x_34 + 0.0013665368568186*x_38 + 0.0202570966469825*x_4 + 0.00213007340668232*x_42 + 0.0289843659058049*x_43 + 0.0160533027839821*x_44 + 0.0028937817626708*x_47 - 0.00621305159439525*x_48 - 0.00313894798891718*x_5 - 0.000925392990855329*x_51 - 0.0594353068467713*x_52 - 0.00409781836983314*x_57 + 0.000517039201091406*x_59 + 0.00959513792844637*x_6 - 0.044643593913688*x_61 - 0.00754546285183263*x_63 - 0.0804508023624029*x_66 + 0.0505209594854567*x_68 - 0.00433739440946797*x_72 - 0.0558382465103391*x_73 + 0.000380706682649955*x_74 - 0.000704101951740007*x_76 + 0.0158020726126152*x_77 - 0.00218141050147231*x_8 + 0.0234195883929632*x_80 + 0.00163376839818296*x_82 + 0.00010982973365799*x_85 - 0.00234000860937192*x_86 + 0.0160367116700182*x_89 + 0.0203634706902371*x_9 + 0.00124773895823549*x_90 - 0.141760629234148*x_91 + 0.0415303150427388*x_95 + 0.000190463076947593*x_96 - 0.0532811205780936*x_99 + 3.21811017464553e-5*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) - 0.00107101871972869*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 0.00142713549577726*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) + 0.00024014036582486*std::pow(-8.0*x_54 - 9.99971961975098, 2) - 0.000507244141919095*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) - 0.000564584118556755*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) - 0.000234652323267871*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) - 0.00117624434289424*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) + 0.000350052172337047*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 0.000404586016694769*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) + 0.000251329649054088*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) - 0.000692967528138827*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) - 0.0626505025601671*std::exp(0.594239830970764*x_2) - 0.484119191133576*std::sin(0.431519865989685*x_107 + 5.2052001953125) + 0.32062393420974*std::sin(0.450319856405258*x_109 - 4.15903997421265) + 0.0513617641506956*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.204370363112268*std::sin(0.359679847955704*x_111 - 7.42783975601196) - 0.347235560089826*std::sin(0.346559852361679*x_112 - 7.43415975570679) + 0.601098645164676*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 0.013128731748894*std::sin(1.12887978553772*x_117 + 0.991439819335938) - 0.202720206538435*std::sin(0.407119870185852*x_118 - 1.19191980361938) - 0.368826234520249*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.632091304024303*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 1.43853771704396*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.771536165523813*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 0.219542675834154*std::sin(0.258239984512329*x_35 - 4.14152002334595) - 0.730012299517732*std::sin(0.371439844369888*x_36 + 5.18383979797363) + 0.475947503042399*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.222962949049192*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 0.185664583021806*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.0158944663605985*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.852797862318354*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.00910335286961694*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.26059815796472*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 0.649372070587795*std::sin(0.354879856109619*x_53 + 5.16688013076782) + 0.450066305295724*std::sin(0.377519845962524*x_55 - 4.21208000183105) + 0.482369642040254*std::sin(0.320719838142395*x_56 + 8.30823993682861) - 0.43503576544931*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 1.08931345563653*std::sin(0.19480000436306*x_64 - 4.4093599319458) - 0.278082462310344*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 0.562981396019943*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 0.696917599906605*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.0868508916117898*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 0.955190047630886*std::sin(0.234479993581772*x_83 - 4.34055948257446) + 0.258145057604292*std::sin(0.404559850692749*x_84 - 4.1814398765564) - 1.90937990225713*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 0.923939661415439*std::sin(0.317679852247238*x_92 - 4.21264028549194) + 0.438824013057864*std::sin(0.353039860725403*x_93 - 7.41192007064819) + 0.368816438473225*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.808028101036001*std::sin(0.335919857025146*x_97 - 7.4507999420166) - 0.451124859495774*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 8.18698581570267) + 0.527031472224596);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000138548894960168*x_10 + 2.08702023929876e-5*x_100 - 0.000114014700785082*x_101 - 1.98786576546433e-5*x_102 - 0.0014327367522467*x_103 + 0.000294447004752297*x_104 - 2.801229724202e-5*x_105 - 0.00114583029107901*x_106 + 0.000239986247315364*x_107 - 0.000600019519031013*x_108 + 0.000870757546316606*x_109 - 0.000797903152426189*x_11 - 0.000721379373839032*x_111 + 3.47874676622964e-5*x_112 + 0.000172274704315595*x_113 + 0.000666142177227694*x_114 - 6.90763692150601e-5*x_115 + 8.97256409421393e-6*x_116 - 0.000124078824750704*x_117 + 0.000137909056025222*x_118 - 1.52279730082438e-5*x_119 - 1.91200691690969e-5*x_120 + 0.000481493009763466*x_13 - 0.00016577438563251*x_14 + 0.000296644800885796*x_15 - 0.00468345364554199*x_16 - 0.000835728486577978*x_17 + 6.3599109679929e-5*x_19 - 0.000134186415071339*x_2 - 0.00108660872644519*x_20 + 0.000360088043533305*x_22 - 0.000113490064366562*x_23 + 0.0012361551398414*x_24 + 0.000771094872367226*x_25 - 0.000153153248502498*x_26 + 0.0020304845190962*x_27 + 0.00429643668503302*x_29 + 0.000536583784003872*x_30 + 0.0051036550291716*x_31 - 0.000355307273985347*x_32 - 0.000362582323063306*x_33 + 0.000122852126460827*x_34 + 0.000224157042049651*x_35 - 0.00221993035364757*x_36 - 2.57520448934846e-5*x_37 - 0.000152955081314775*x_38 - 0.000155811811899664*x_39 - 0.000533132473150038*x_4 + 0.000137254199941855*x_40 - 3.68202145310995e-5*x_41 - 7.48795228434993e-5*x_42 + 1.7458271511829e-6*x_43 - 0.000311957977696905*x_44 - 0.000256026139143163*x_45 - 0.000107934850114434*x_47 - 0.000625444424397423*x_48 - 7.78968952298293e-5*x_49 + 0.00132565932268815*x_50 - 0.00133505034808845*x_51 - 0.00241294876475816*x_52 - 0.00120025679698266*x_53 - 5.62761483410717e-5*x_54 + 7.99843540285711e-5*x_55 + 2.48932794574405e-5*x_56 + 0.00198115765243659*x_57 + 0.00236923791653345*x_59 + 0.00165861304758224*x_6 - 0.00110939529875751*x_60 + 0.0023870411007792*x_61 - 0.000153264559227447*x_62 + 0.0016869646570362*x_63 + 2.28943608142726e-5*x_64 + 2.16696499248508e-5*x_65 - 0.000202560243655586*x_66 - 0.000225196133226138*x_67 - 1.51083186832137e-6*x_68 - 0.000106929509527659*x_69 + 0.00118490733703992*x_70 + 0.00159417861767326*x_71 - 6.06149580676818e-5*x_72 - 4.78863956474759e-5*x_73 - 0.00134379700376022*x_74 + 8.52203542666304e-5*x_75 - 5.4921228248739e-5*x_76 - 3.88195645791531e-6*x_77 - 0.000138692362175748*x_78 - 2.39438804017348e-5*x_79 + 0.0021188645149153*x_8 + 7.38870176816722e-5*x_80 + 0.0002064275475431*x_81 - 0.00285260921867012*x_82 - 3.4130228521808e-5*x_83 - 0.000114929659663118*x_84 + 0.000311364197398445*x_85 - 0.000419371569227577*x_86 + 0.000683170003915206*x_87 - 2.77149785175699e-5*x_88 + 0.00179758909596349*x_89 - 0.000360643566797979*x_9 - 0.00204895345153008*x_90 - 0.00159546333058608*x_91 - 0.000872536713000379*x_93 - 6.55060733655255e-5*x_94 + 3.07710319810165e-5*x_95 + 0.00014988350616622*x_96 - 5.51346365874237e-5*x_97 + 0.00351045785283334*x_98 + 0.00063300761641042*x_99 - 7.14062048138685e-5*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 6.01178192999944e-6*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 7.15614785976727e-6*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 1.33103711114324e-5*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 6.12586485608524e-5*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 6.46170656238839e-6*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 2.51718122517594e-5*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 5.6485599066288e-6*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 7.00076821640145e-6*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 3.71841594108604e-5*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 1.01553168866312e-5*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) + 2.39848634780463e-5*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) + 1.33239200152905e-5*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 0.000100446515441683*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 2.63653014093449e-5*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 6.31382436377901e-6*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 4.98399829363901e-6*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) - 0.0018416327657178*std::pow(-0.0797414285960718*x_100 - 0.000544206430025337*x_101 + 0.000328459942391597*x_104 - 0.0156800990910702*x_105 - 0.0240692469365916*x_106 - 0.00565059834028271*x_107 + 0.00522379810399955*x_108 + 0.00161676113994077*x_11 - 0.0024358294666968*x_112 - 0.148079629342997*x_113 + 0.0910232574141013*x_114 - 0.066357955918413*x_116 - 0.000554109560145181*x_118 - 0.00561517712380912*x_119 - 0.101343227550265*x_13 + 0.0208532195440958*x_14 + 0.00259408949308999*x_16 + 0.0247985923723043*x_18 - 0.014512821255669*x_20 + 0.0510771406922881*x_23 - 0.0753264202982004*x_25 - 0.127022598196893*x_26 - 9.84734183520749e-5*x_28 + 0.0227716043714851*x_3 + 0.161904971674748*x_31 + 0.00641445642192737*x_32 + 0.0162071678284128*x_33 + 0.000451538562652255*x_34 - 0.0231145876438441*x_37 + 0.155157932992207*x_4 - 0.0367248022731773*x_40 - 0.00100709642121728*x_42 - 0.00394902363971587*x_44 + 0.00431367553814853*x_45 + 0.00362815273073556*x_46 - 0.100786226612922*x_47 + 0.000173691381471268*x_48 + 0.00657867770445287*x_49 + 0.00377887327985332*x_5 - 0.0470191314402174*x_50 + 0.0340820878134129*x_51 - 0.0033461837377459*x_52 + 0.00208856306783565*x_54 - 0.0238951721445716*x_56 + 0.0107753546448271*x_57 + 0.039513312827102*x_58 - 0.0173511468421597*x_59 + 0.0188900558755108*x_6 + 0.0216560633491871*x_60 - 0.00614411182786103*x_61 + 0.000740216002535655*x_62 - 0.00191802987695716*x_64 + 0.0160507649882416*x_65 + 0.00142939189570999*x_66 - 0.0278305334375215*x_68 + 0.00105761794617934*x_69 + 0.00409955860597508*x_7 - 0.0296173766803557*x_72 + 0.044959093344996*x_74 - 0.00530021611101241*x_78 - 0.0798138652449572*x_8 - 0.000261233126616609*x_83 + 0.0379656990557431*x_84 - 0.00389086901402447*x_85 + 0.0915268991327605*x_88 - 0.000774522277182468*x_89 - 0.00489014442240944*x_90 + 0.0101768717374212*x_93 - 0.0437384612341349*x_94 + 0.00233754503971875*x_95 + 0.00173855162608418*x_96 + 0.103461671935419*x_97 + 0.0698428340408377*x_98 + 0.0522819922467531*x_99 + 0.00194435586343933*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 0.00102919759857973*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 0.00534396382403662*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 0.00400459690461286*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) + 0.000541864712001714*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 0.000389090376807032*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 0.00102790485865017*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) + 0.000158366309898504*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 0.0407667346765165*std::exp(0.641439855098724*x_71) + 0.0201432346702126*std::log(8.06023979187012*x_91 + 9.42432022094727) - 1.87936784466082*std::sin(0.281039953231812*x_1 + 5.1756796836853) + 0.149477036073127*std::sin(0.328399837017059*x_102 - 4.43911981582642) + 0.071665227601879*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.391514388138781*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.0283539729363265*std::sin(1.31879985332489*x_110 - 0.19039985537529) + 0.089623121438307*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.130966553841732*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 1.94557773175792*std::sin(0.325919836759567*x_12 - 7.46208000183105) - 1.09449185256288*std::sin(0.333279848098755*x_120 - 4.27167987823486) + 0.388686464953715*std::sin(0.346559852361679*x_15 + 1.93543982505798) + 0.122029727580125*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 1.21753365297197*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.900528652267766*std::sin(0.298479825258255*x_22 - 1.12871980667114) + 2.53422427067662*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.0991646964696375*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 1.98526743794352*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 0.863512419166405*std::sin(0.327759832143784*x_35 - 1.21751987934113) + 0.49560669367558*std::sin(0.364079833030701*x_36 - 7.4255199432373) - 1.23034931857094*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.0200884316569998*std::sin(1.43327987194061*x_39 - 7.78567981719971) - 1.25445350477909*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.406216089801649*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 1.3214634304738*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 1.27174785402514*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.0163024669249657*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 1.35496137705835*std::sin(0.262719959020615*x_73 - 7.51200008392334) + 0.0788430433139999*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.56530989493308*std::sin(0.437359839677811*x_77 - 4.15848016738892) + 0.996642405330533*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 3.45405632365143*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.354667191579331*std::sin(0.426799863576889*x_81 - 4.15999984741211) - 0.417694557262266*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 1.38991178236159*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 0.782476337901372*std::sin(0.283919870853424*x_87 - 1.28575992584229) - 0.438717588589846*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 1.46428970718792*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 11.3850765163344, 2) + 0.00448589076733457*std::exp(0.448319852352142*x_20) - 0.000305522261003287*std::exp(0.429519861936569*x_29) - 0.0677552545087856*std::sin(0.255999982357025*x_1 - 7.38719987869263) - 0.000977045122652629*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.0066984094921806*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 0.0123991285354341*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.0234381294256878*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.00112828308487592*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 0.017036722425019*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.0184950940710449*std::sin(0.344239860773087*x_112 - 4.23336029052734) + 0.00230951544401438*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 0.0123583846985231*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.0257730478771679*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0315745165935155*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.0239708326226307*std::sin(0.257839977741241*x_120 + 5.06311988830566) - 0.000152800589307143*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 0.137112480160564*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.0222645797012333*std::sin(0.231519997119904*x_18 - 7.55200004577637) + 0.0130620480890816*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.0387438996467449*std::sin(0.32847985625267*x_21 + 5.15607976913452) - 0.000181684856121535*std::sin(1.528639793396*x_22 - 1.98135983943939) + 0.00870580744843585*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 0.0423300421944095*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 0.000447266348945197*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 0.0283609966905241*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.0111960646684897*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.0245674953011832*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.00186745078298162*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.000715381229122458*std::sin(1.05911982059479*x_39 + 8.42039966583252) - 0.0178850077704396*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.0201946041222278*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.00723836033527547*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 0.0720042261063103*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.0100187811875174*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.00275433063892295*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.00930356011577907*std::sin(0.282959938049316*x_51 + 5.09143972396851) + 0.00748956368977316*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 0.0942375609027657*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 0.000134595692492149*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.000485067062361101*std::sin(1.25287985801697*x_7 + 9.62911987304688) - 0.0086668444599769*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.0116988177020372*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.0157921601575817*std::sin(0.292479932308197*x_79 + 5.12367963790894) + 0.00384853635304437*std::sin(0.349279850721359*x_85 + 1.96199989318848) - 9.93947275495892e-5*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.0166587665645501*std::sin(0.506479859352112*x_9 - 0.87367981672287) - 0.00801636166727497*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.0460579808898842*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.00946843480650994*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 0.159485399723053*std::sin(-0.0586233494104023*x_1 + 0.020407425055267*x_10 - 0.0013775369043399*x_100 + 0.000959247856794073*x_101 - 0.0230836503996363*x_102 - 0.00118483827546915*x_103 - 5.98161912569178e-5*x_105 + 0.000532202842000013*x_106 + 0.000244938004210118*x_107 - 0.00520180144307683*x_113 + 0.00134174678008033*x_114 + 0.00184660277953112*x_116 + 0.00362608648567075*x_117 + 0.00024826628163663*x_119 + 0.00290914340905915*x_12 + 0.00901204216949587*x_13 - 0.00197066832518526*x_14 - 0.0250387764103472*x_17 + 0.00675468249245208*x_20 - 0.0178549470958606*x_22 - 0.0345062389035875*x_25 + 0.000106885718553926*x_26 + 0.00323951127890112*x_27 - 0.00128288907759508*x_29 - 0.00697119956343394*x_3 - 0.00893471775020683*x_31 - 0.000220614659591151*x_34 - 0.000701066866396516*x_36 - 0.00175367036946607*x_37 - 0.00526449268797425*x_38 + 3.32243894377937e-5*x_39 - 0.0111579744606017*x_41 + 0.000283856064483405*x_42 - 7.51367619697093e-5*x_49 - 0.00889772447779228*x_5 - 0.0251464686817524*x_50 - 0.00078465749061007*x_51 + 0.000629525402519308*x_52 - 0.00297694546961109*x_53 + 0.00195227107393077*x_56 + 0.00988681607833238*x_59 - 0.00623692661875551*x_6 + 0.000445328243375523*x_61 + 0.00201360625741025*x_62 - 0.0192173076989474*x_63 + 0.000255014794919519*x_66 - 0.000993460445117667*x_67 + 0.0156751906171376*x_68 - 0.00352429332144787*x_69 + 0.000774264708587306*x_71 + 0.0186415954503166*x_72 - 1.63991560881723e-5*x_75 + 0.000586866601639311*x_77 - 0.0182787431166263*x_78 - 0.00150046033204849*x_79 - 0.00136652476269094*x_8 + 0.000158045102247653*x_82 - 0.0146033758005587*x_83 + 0.000826554007283837*x_86 + 0.00138292535271136*x_88 + 0.000277131786571974*x_89 - 0.0158174743334286*x_9 + 0.00189290070374487*x_91 + 0.000154118016355894*x_92 - 0.0093519566757326*x_93 + 3.83376495996665e-5*x_94 + 0.000172239099535634*x_96 - 0.00224398577926655*x_98 + 0.00026324671059431*x_99 - 0.000870150913170761*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.000749092250692852*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 0.000122657020812112*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 0.000141329644393434*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.00107405307614208*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 0.000128447602117854*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 0.000174987411961555*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 4.2156831889036e-5*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.000592274385736124*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 5.62316605226916e-5*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.00814269051762524*std::exp(0.69871985912323*x_85) + 0.085839321028359*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.0886929976416395*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.0572998226864732*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.374212220495211*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.0036567616754492*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.110590740482382*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.0338173092693934*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.166687723005968*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.0230500569821908*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.346360173743221*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.0638260116974672*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.0646841171988575*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.207187939608434*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 0.500034748751048*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.104088843654789*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.174681055369182*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.00873925603903353*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.128221804759844*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.0949857051633183*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.0996047328497229*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.0464561313924337*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.125171045239239*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.0482874193370055*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.0511518197055401*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.0271256529132955*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.169579233768722*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.248040313483992*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.111315728523426*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.0909784938454528*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.236768793310153*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.322385667533814*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.0996304804471619*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.00248504173784514*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.267428942369474*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.24926294066228*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.098453024028204*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.0927824200061069*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.0506139185235852*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.155311148400646*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.130640133956714*std::sin(0.315439850091934*x_97 - 7.45576000213623) + 5.64178265733499) + 0.00994679424911737*std::sin(0.0158197323150336*x_10 + 0.0393143713418803*x_100 - 0.120609400670495*x_101 - 0.00565399302935793*x_102 - 0.00535492141710182*x_103 + 0.0700560998779857*x_104 + 0.00807289748181499*x_105 + 0.00613560237344935*x_106 + 0.00307615907409329*x_108 + 0.00126463160454781*x_11 + 0.0116991734018112*x_113 - 0.00065242004909247*x_115 + 0.00105327729093395*x_116 - 0.00246756351057185*x_119 + 0.0613258017423857*x_12 + 0.0681095070155565*x_120 + 0.0747084173642075*x_13 - 0.0803431188231982*x_14 + 0.00247406429320789*x_15 + 0.00610021731041498*x_17 + 0.000440865480699544*x_18 + 0.00328720773829814*x_19 - 0.016226712394104*x_20 - 0.0422249830177862*x_22 - 0.0162248085825322*x_24 - 0.128180426345444*x_25 - 0.0622458862610073*x_27 + 0.0100235743958584*x_28 - 0.120780250959803*x_29 + 0.0645881281404323*x_3 + 0.00085680400722166*x_30 + 0.166647761708648*x_31 - 0.00388286905852526*x_32 + 0.0381720290027799*x_33 + 0.0984998499457884*x_34 + 0.00156947664801798*x_38 + 0.0232654099195677*x_4 + 0.00244640344215449*x_42 + 0.0332887365750778*x_43 + 0.0184373247726946*x_44 + 0.00332352755676535*x_47 - 0.00713573098426033*x_48 - 0.0036051025944648*x_5 - 0.00106281999065009*x_51 - 0.0682618443098261*x_52 - 0.00470637158974625*x_57 + 0.000593822953383065*x_59 + 0.0110200795815105*x_6 - 0.0512734638524511*x_61 - 0.00866601415494089*x_63 - 0.092398280362563*x_66 + 0.058023657212205*x_68 - 0.0049815262610274*x_72 - 0.064130596644333*x_73 + 0.000437244151288054*x_74 - 0.000808665763799821*x_76 + 0.0181487852537857*x_77 - 0.0025053644361796*x_8 + 0.0268975526752498*x_80 + 0.00187639384654978*x_82 + 0.000126140177906033*x_85 - 0.00268751541551561*x_86 + 0.018418269768213*x_89 + 0.0233875812141144*x_9 + 0.00143303647318518*x_90 - 0.162813023359869*x_91 + 0.0476978424103057*x_95 + 0.000218748107734777*x_96 - 0.0611937205427665*x_99 + 3.69602089007224e-5*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) - 0.00123007210659334*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 0.00163907458697786*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) + 0.00027580280365511*std::pow(-8.0*x_54 - 9.99971961975098, 2) - 0.000582573262926354*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) - 0.000648428606586982*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) - 0.000269499750361271*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) - 0.00135092443304719*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) + 0.000402037242778801*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 0.0004646697248952*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) + 0.000288653769692877*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) - 0.000795877804408901*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) - 0.0719545179218134*std::exp(0.594239830970764*x_2) - 0.556014103498388*std::sin(0.431519865989685*x_107 + 5.2052001953125) + 0.368238716011914*std::sin(0.450319856405258*x_109 - 4.15903997421265) + 0.0589893269495798*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.234720718179823*std::sin(0.359679847955704*x_111 - 7.42783975601196) - 0.398802344922606*std::sin(0.346559852361679*x_112 - 7.43415975570679) + 0.69036578269651*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 0.0150784355322489*std::sin(1.12887978553772*x_117 + 0.991439819335938) - 0.232825502404792*std::sin(0.407119870185852*x_118 - 1.19191980361938) - 0.423599377775709*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.725961057055532*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 1.65217011376465*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.886114405805372*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 0.252146220020192*std::sin(0.258239984512329*x_35 - 4.14152002334595) - 0.838423970156462*std::sin(0.371439844369888*x_36 + 5.18383979797363) + 0.546628865500601*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.256074426503654*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 0.213237005619527*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.0182549000864439*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.979444003804119*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.0104552611780948*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.299298713680008*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 0.745808132124104*std::sin(0.354879856109619*x_53 + 5.16688013076782) + 0.516904138148053*std::sin(0.377519845962524*x_55 - 4.21208000183105) + 0.554004734755182*std::sin(0.320719838142395*x_56 + 8.30823993682861) - 0.499641463395928*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 1.25108373218231*std::sin(0.19480000436306*x_64 - 4.4093599319458) - 0.31937955324198*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 0.646587869118228*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 0.800414488045782*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.0997488253347116*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 1.09704210808187*std::sin(0.234479993581772*x_83 - 4.34055948257446) + 0.296481311637958*std::sin(0.404559850692749*x_84 - 4.1814398765564) - 2.19293548786091*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 1.06115083214448*std::sin(0.317679852247238*x_92 - 4.21264028549194) + 0.50399229091212*std::sin(0.353039860725403*x_93 - 7.41192007064819) + 0.423588126950698*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.928025635891544*std::sin(0.335919857025146*x_97 - 7.4507999420166) - 0.518119894671084*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 9.3602318523546) + 0.268432086313218);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000352884388515642*x_10 + 0.00049023075281443*x_100 - 0.00253511106465697*x_101 - 0.000119466960911982*x_102 - 0.000207185019410272*x_103 + 0.00149022702381836*x_104 + 0.000100071382052458*x_105 - 2.18396484642753e-5*x_106 - 1.27848278894548e-5*x_107 - 9.86764060634319e-6*x_108 + 7.47733595543315e-5*x_109 + 1.45387277270643e-5*x_11 - 0.000109774215669739*x_111 - 4.80154060572673e-6*x_112 - 0.000363696528909673*x_113 + 0.000405104057464218*x_114 - 1.67445951455712e-5*x_115 - 0.000263158106980288*x_116 - 6.68870119055617e-6*x_117 - 0.00011803719389125*x_118 - 7.7343620296878e-5*x_119 + 0.0012862394945779*x_12 + 0.00142561050657064*x_120 + 0.00116824524778689*x_13 - 0.00162390687828897*x_14 + 6.50352392792852e-5*x_15 - 0.000131743165029058*x_16 + 0.000134470135710942*x_17 + 0.000112023879953278*x_18 + 6.61424660523144e-5*x_19 - 1.06347938939026e-5*x_2 - 0.000565837189965479*x_20 - 0.000869665628783712*x_22 + 0.000194418008380732*x_23 - 0.000285522180032522*x_24 - 0.00296646077554519*x_25 - 0.000549748117967627*x_26 - 0.00121556508287155*x_27 + 0.000209825041923364*x_28 - 0.00234285145772322*x_29 + 0.00144903952622123*x_3 + 4.12816676613021e-5*x_30 + 0.00441931248532902*x_31 - 0.000119714986025287*x_32 + 0.000840203380158656*x_33 + 0.00207746866372384*x_34 + 1.5488383872777e-5*x_35 - 0.000105798641507855*x_36 - 0.000108998795805652*x_37 + 3.2553575142121e-5*x_38 - 2.3710297332653e-5*x_39 + 0.00103231640264605*x_4 - 0.000148626605583398*x_40 - 5.60302985852335e-6*x_41 + 3.57420467896067e-5*x_42 + 0.000698459355471618*x_43 + 0.000307449078978204*x_44 - 2.19111295832984e-5*x_45 + 1.50367996747339e-5*x_46 - 0.000364423805304355*x_47 - 0.000176657912339858*x_48 + 2.38135216599922e-5*x_49 - 5.99515014058364e-5*x_5 - 0.000150315207325619*x_50 + 5.98040312966244e-5*x_51 - 0.00156468369758879*x_52 - 5.42209768170471e-5*x_53 + 9.23129836828129e-8*x_54 + 7.96402509522828e-6*x_55 - 9.69053929912009e-5*x_56 + 2.98439026628733e-5*x_57 + 0.000163762061181412*x_58 + 0.000108660339509396*x_59 + 0.000382917427487572*x_6 - 8.48659075024041e-5*x_60 - 0.000995894009336891*x_61 - 7.43339568415432e-5*x_62 + 3.14049385670093e-5*x_63 - 8.82334015788777e-6*x_64 + 7.22530152362381e-5*x_65 - 0.00194054281127498*x_66 - 3.4268693829155e-5*x_67 + 0.00110140779432581*x_68 - 2.31901549334181e-6*x_69 + 1.69905310189025e-5*x_7 + 0.000161640041399562*x_70 + 6.60506219636968e-5*x_71 - 0.000239842752366847*x_72 - 0.00135235390289235*x_73 + 0.000130611919114086*x_74 + 1.29682076976103e-5*x_75 + 3.89407967242054e-6*x_76 + 0.000380433913248179*x_77 - 2.38562780892682e-5*x_78 - 3.64360388792732e-6*x_79 - 0.000429318098272685*x_8 + 0.000566615178189719*x_80 + 5.4217669504593e-6*x_81 - 9.02052773989788e-5*x_82 - 2.87162001569597e-5*x_83 + 0.000152255398563777*x_84 + 3.16785117185825e-7*x_85 - 0.000120184489137197*x_86 + 2.7811667980435e-5*x_87 + 0.000377640228517836*x_88 + 0.000463614820606527*x_89 + 0.000435648036975239*x_9 - 8.10012908237588e-5*x_90 - 0.0034479802870706*x_91 - 0.000105520280344718*x_93 - 0.000191887412546763*x_94 + 0.00100927794394743*x_95 + 2.00562945069082e-5*x_96 + 0.000420404653366924*x_97 + 0.000443682130269477*x_98 - 0.00103910757070595*x_99 + 7.75198677640795e-7*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) - 2.5799374483929e-5*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 3.1640573697188e-6*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) + 8.0583403689855e-6*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 9.14828826656273e-7*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 1.08897003021038e-6*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) - 4.26548694724409e-6*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 2.02547453118154e-6*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 2.71441226911886e-6*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) + 2.21479412402719e-5*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 1.65969643236366e-5*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) - 9.83295053196891e-7*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 3.83046153956074e-6*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) + 2.2457464527755e-6*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) - 8.59556366456454e-7*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 1.06532549711158e-6*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 1.64765532529578e-6*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 1.54536154835548e-6*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 3.4377740012044e-5*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) + 5.78465260457135e-6*std::pow(-8.0*x_54 - 9.99971961975098, 2) + 1.61257656047679e-6*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 3.64984039152166e-6*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) - 1.22188168433368e-5*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) - 1.36000583687412e-5*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) + 5.9039193341551e-7*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 4.45085323151222e-6*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 5.65245317378328e-6*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) - 1.16826438887974e-6*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) - 2.83341156675755e-5*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) + 8.4322775285609e-6*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 4.26012921486762e-6*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) + 9.74592316959092e-6*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) + 6.56345709208288e-7*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) + 6.05418711682593e-6*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) + 9.6079142618373e-7*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) - 1.6692638918753e-5*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) + 7.58428260392184e-7*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) - 0.00150916482352946*std::exp(0.594239830970764*x_2) + 0.000198772862654392*std::exp(0.448319852352142*x_20) - 4.64921340802917e-5*std::exp(0.429519861936569*x_29) - 0.000168956840634304*std::exp(0.641439855098724*x_71) + 8.34831957241595e-5*std::log(8.06023979187012*x_91 + 9.42432022094727) - 0.00300228128528207*std::sin(0.255999982357025*x_1 - 7.38719987869263) - 0.00778899894591035*std::sin(0.281039953231812*x_1 + 5.1756796836853) - 0.000148679551845724*std::sin(0.788719892501831*x_1 + 1.20735991001129) + 0.000619504308174173*std::sin(0.328399837017059*x_102 - 4.43911981582642) - 0.00101931476682744*std::sin(0.328959852457047*x_102 - 4.24408006668091) + 0.000297014969068071*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.000549413795662355*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.00356664241836893*std::sin(0.174880012869835*x_106 - 1.40583980083466) - 0.0116617684423628*std::sin(0.431519865989685*x_107 + 5.2052001953125) + 0.00772339156619326*std::sin(0.450319856405258*x_109 - 4.15903997421265) - 0.00162262282244808*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 4.99949887987515e-5*std::sin(0.866479873657227*x_110 - 6.98816013336182) + 0.00123723457216014*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.000117512420966889*std::sin(1.31879985332489*x_110 - 0.19039985537529) + 0.0049230022166985*std::sin(0.359679847955704*x_111 - 7.42783975601196) - 0.000754908726563008*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.00081953016340348*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.00836442919612421*std::sin(0.346559852361679*x_112 - 7.43415975570679) + 0.0144796433178257*std::sin(0.345199823379517*x_114 + 1.94695973396301) + 0.000371441067482004*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.000351445100370168*std::sin(0.49839985370636*x_115 + 8.25191974639893) + 0.000542788019237856*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 0.000316253171536128*std::sin(1.12887978553772*x_117 + 0.991439819335938) - 0.00488325220428396*std::sin(0.407119870185852*x_118 - 1.19191980361938) - 0.000547608408612519*std::sin(0.312799841165543*x_119 - 7.45648002624512) - 0.00806340437551971*std::sin(0.325919836759567*x_12 - 7.46208000183105) + 0.00392195316186854*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0013990882470709*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.00106216385278608*std::sin(0.257839977741241*x_120 + 5.06311988830566) - 0.00453609755543001*std::sin(0.333279848098755*x_120 - 4.27167987823486) + 0.00161090255663095*std::sin(0.346559852361679*x_15 + 1.93543982505798) - 2.32520715914015e-5*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 0.00888451898048592*std::sin(0.355999857187271*x_16 - 4.24599981307983) - 0.00607554699851792*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.00338806023925027*std::sin(0.231519997119904*x_18 - 7.55200004577637) + 0.000505749538171366*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 0.00504604160731536*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.00198768655719744*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.0152262140335782*std::sin(0.312319934368134*x_21 + 8.32975959777832) + 0.00171676847311061*std::sin(0.32847985625267*x_21 + 5.15607976913452) + 0.00373222131218362*std::sin(0.298479825258255*x_22 - 1.12871980667114) - 2.76474672039364e-5*std::sin(1.528639793396*x_22 - 1.98135983943939) - 0.0346524039100593*std::sin(0.201519995927811*x_23 + 4.99215984344482) + 0.000385760233139101*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 0.0105030370872196*std::sin(0.184880018234253*x_24 + 1.7682398557663) - 0.0185852498145744*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 0.00187567288185741*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 6.80617084872218e-5*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 0.00125669500045736*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.00170373490307941*std::sin(0.363919854164124*x_28 + 8.3712797164917) + 0.000410985916603743*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.00373850102381658*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 8.27480108749952e-5*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.00822789749511914*std::sin(0.292639940977097*x_30 - 4.29711961746216) + 0.00528848245573518*std::sin(0.258239984512329*x_35 - 4.14152002334595) - 0.00357880834333498*std::sin(0.327759832143784*x_35 - 1.21751987934113) + 0.00205403110710447*std::sin(0.364079833030701*x_36 - 7.4255199432373) - 0.0175849967383418*std::sin(0.371439844369888*x_36 + 5.18383979797363) + 0.0114649236651926*std::sin(0.382879853248596*x_37 + 5.18959999084473) - 0.0050991558532173*std::sin(0.323279827833176*x_38 + 5.11079978942871) + 0.00537087215433399*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 3.16990275013718e-5*std::sin(1.05911982059479*x_39 + 8.42039966583252) - 8.32560658339892e-5*std::sin(1.43327987194061*x_39 - 7.78567981719971) - 0.00447240558689346*std::sin(0.339839845895767*x_40 + 8.33960056304932) - 0.00519905512599707*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.000792496825605644*std::sin(0.349519848823547*x_41 - 1.24535989761353) + 0.000382875931396577*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.000894836606539249*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.00168355370358478*std::sin(0.513519823551178*x_43 - 4.23767995834351) - 0.000320736656194063*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 0.0205427328241459*std::sin(0.266319960355759*x_45 - 7.53560018539429) - 0.00319055609882128*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.000219287306016547*std::sin(1.01415979862213*x_46 + 4.18032026290894) + 0.000443938990100308*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.000419133810236118*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.00627745280573341*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 0.0014157474578332*std::sin(0.282959938049316*x_51 + 5.09143972396851) + 0.00547677629808395*std::sin(0.241439983248711*x_53 + 5.06199979782104) - 0.0156424840386943*std::sin(0.354879856109619*x_53 + 5.16688013076782) + 0.00033186764722164*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 0.0108414810488691*std::sin(0.377519845962524*x_55 - 4.21208000183105) + 0.0116196242002453*std::sin(0.320719838142395*x_56 + 8.30823993682861) + 0.0041757302443948*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 2.04817840815447e-5*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.0104794159242824*std::sin(0.304079920053482*x_62 + 5.10087966918945) + 0.00527073117836241*std::sin(0.237039983272552*x_63 - 4.33999967575073) - 0.0262400696221898*std::sin(0.19480000436306*x_64 - 4.4093599319458) - 0.00669862575733038*std::sin(0.467439860105515*x_65 + 2.05879974365234) + 6.75652177699216e-5*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 7.38139434657525e-5*std::sin(1.25287985801697*x_7 + 9.62911987304688) - 0.0056156078053796*std::sin(0.262719959020615*x_73 - 7.51200008392334) - 0.000384033756692114*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.000518382547617743*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.0135614509773302*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 0.000326763269367281*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.00234291450088161*std::sin(0.437359839677811*x_77 - 4.15848016738892) + 0.0167877907390696*std::sin(0.213599994778633*x_78 + 5.01663970947266) - 0.000699761328313464*std::sin(0.292479932308197*x_79 + 5.12367963790894) + 0.00413056266053657*std::sin(0.307599931955338*x_79 + 5.1352801322937) + 0.00209211905980812*std::sin(0.439199864864349*x_79 + 2.22503995895386) - 0.0143152609216273*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.00146991042185196*std::sin(0.426799863576889*x_81 - 4.15999984741211) - 0.00173112596103582*std::sin(0.464319854974747*x_82 + 5.2532000541687) + 0.0230092203695503*std::sin(0.234479993581772*x_83 - 4.34055948257446) + 0.00621836097691703*std::sin(0.404559850692749*x_84 - 4.1814398765564) + 0.000585642000524114*std::sin(0.349279850721359*x_85 + 1.96199989318848) - 0.00576045899608153*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 4.40424779659189e-6*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.0459943474591162*std::sin(0.189920008182526*x_87 + 4.97759962081909) - 0.00324295607612331*std::sin(0.283919870853424*x_87 - 1.28575992584229) - 0.00181825545477254*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.000738161246020356*std::sin(0.506479859352112*x_9 - 0.87367981672287) + 0.022256441354685*std::sin(0.317679852247238*x_92 - 4.21264028549194) - 0.00121987105046676*std::sin(0.356719851493835*x_92 + 5.19888019561768) - 0.00606871667949204*std::sin(0.380959838628769*x_92 + 1.97975981235504) + 0.00204086037409318*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.0105706696221783*std::sin(0.353039860725403*x_93 - 7.41192007064819) + 0.00888428300712618*std::sin(0.43495985865593*x_94 + 2.01871991157532) + 0.000419552768661095*std::sin(0.263759940862656*x_97 + 8.28248023986816) - 0.0194642905750952*std::sin(0.335919857025146*x_97 - 7.4507999420166) - 0.0108669801701408*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 0.765260636806488*std::sin(-0.0319129854041746*x_1 + 0.011109257053299*x_10 - 0.000749894292360416*x_100 + 0.000522188908698264*x_101 - 0.0125661226403407*x_102 - 0.000644994306392276*x_103 - 3.25623366408438e-5*x_105 + 0.000289717010365718*x_106 + 0.00013333770642416*x_107 - 0.00283172174906248*x_113 + 0.000730411104780785*x_114 + 0.00100524122458326*x_116 + 0.00197394461857465*x_117 + 0.000135149531746349*x_119 + 0.00158365995948164*x_12 + 0.00490591501695901*x_13 - 0.00107277919345473*x_14 - 0.01363044101298*x_17 + 0.00367706870998413*x_20 - 0.00971975623694747*x_22 - 0.0187842746884699*x_25 + 5.81857299255726e-5*x_26 + 0.0017635034026542*x_27 - 0.000698370543822973*x_29 - 0.00379493481957173*x_3 - 0.00486382166867755*x_31 - 0.000120096727366964*x_34 - 0.000381642074355657*x_36 - 0.00095465130306208*x_37 - 0.00286584918810345*x_38 + 1.80864700815403e-5*x_39 - 0.00607410323160674*x_41 + 0.000154523658812608*x_42 - 4.09024460760475e-5*x_49 - 0.00484368351938224*x_5 - 0.0136890658087322*x_50 - 0.000427146577207888*x_51 + 0.000342696812519398*x_52 - 0.00162056959003889*x_53 + 0.00106276422132048*x_56 + 0.00538211856495517*x_59 - 0.00339521624323865*x_6 + 0.000242424799569504*x_61 + 0.00109615345675021*x_62 - 0.0104613889563127*x_63 + 0.000138823242103446*x_66 - 0.00054081332785532*x_67 + 0.00853315503811184*x_68 - 0.00191853113918869*x_69 + 0.000421489024298733*x_71 + 0.0101479865872508*x_72 - 8.92726250113848e-6*x_75 + 0.000319474500871654*x_77 - 0.00995045946972187*x_78 - 0.000816810522731914*x_79 - 0.000743899576615813*x_8 + 8.60355317796915e-5*x_82 - 0.00794968768352583*x_83 + 0.00044995392169678*x_86 + 0.000752827619711362*x_88 + 0.00015086314154433*x_89 - 0.00861061049241315*x_9 + 0.00103044457776141*x_91 + 8.38977311250872e-5*x_92 - 0.00509095539396406*x_93 + 2.08699923223326e-5*x_94 + 9.37623647367635e-5*x_96 - 0.00122156591428401*x_98 + 0.000143304477096331*x_99 - 0.000473686912650546*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.00040778581065686*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 6.67712055736256e-5*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 7.69360830465363e-5*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.00058468580330125*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 6.99234433517533e-5*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 9.52584726053281e-5*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 2.29490531382419e-5*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.000322418354074963*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 3.06110138632702e-5*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.00443266320080946*std::exp(0.69871985912323*x_85) + 0.0467286333284156*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.0482820986459687*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.0311924928112473*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.203711136447082*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.00199064337245883*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.0602026448905846*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.0184092397991015*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.0907403436488163*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.0125478352812697*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.18854922621145*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.0347451757737083*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.0352123054859566*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.112787579678477*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 0.272205559712368*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.056663185943846*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.0950917002601925*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.00475741753451456*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.069800525301813*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.0517076805226746*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.0542221558063327*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.0252894769400208*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.0681397733142197*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.0262863811775599*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.0278456842210079*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.0147664808341214*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.0923144048666735*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.135026520720376*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.0605973090134082*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.0495262617265013*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.128890606235648*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.175498145465842*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.0542361721105789*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.00135279033876806*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.145581172354108*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.135692086296002*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.0535951962896786*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.0505082709397953*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.0275528651865914*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.0845472403379244*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.0711169991153771*std::sin(0.315439850091934*x_97 - 7.45576000213623) + 5.18585731815496) - 0.897447684446095);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0052347968798686*x_1 - 0.00200714607970168*x_10 - 0.00032307984075275*x_100 + 0.00131971995232259*x_101 + 0.00212714559367439*x_102 + 0.000169294083589148*x_103 - 0.000816579813945212*x_104 - 8.62910766491562e-5*x_105 - 0.000115441713095069*x_106 - 2.10326587579751e-5*x_107 - 3.41922104905218e-5*x_108 - 1.26494485513882e-6*x_109 - 1.55584537139347e-5*x_11 + 2.71970053806189e-6*x_111 + 2.30597471020711e-7*x_112 + 0.000350272767255963*x_113 - 0.000133272018030618*x_114 + 7.60210249971711e-6*x_115 - 0.0001669396695714*x_116 - 0.000323751314124576*x_117 + 4.34141356699849e-6*x_118 + 7.4747360814032e-6*x_119 - 0.000974351221949615*x_12 - 0.000793550756679168*x_120 - 0.00166019779717611*x_13 + 0.00110967053273249*x_14 - 2.88281918589397e-5*x_15 - 2.65836615990841e-6*x_16 + 0.00216324501517959*x_17 - 8.81993522745886e-6*x_18 - 3.81065917160689e-5*x_19 + 1.6389292939163e-7*x_2 - 0.000407833998912379*x_20 + 0.00208637732172162*x_22 - 7.15771921802883e-6*x_23 + 0.000189054058124474*x_24 + 0.0045860149467405*x_25 + 9.89744375330437e-6*x_26 + 0.00043602546217863*x_27 - 0.00011678166349977*x_28 + 0.00152190687853505*x_29 - 0.000133476815528197*x_3 - 9.96735594665188e-6*x_30 - 0.00116896224323196*x_31 + 4.60079823518283e-5*x_32 - 0.000446791021152931*x_33 - 0.00112825101245819*x_34 - 1.94195066113709e-7*x_35 + 6.28618377070221e-5*x_36 + 0.000160449075591932*x_37 + 0.000451583157820702*x_38 - 2.37935376898041e-6*x_39 - 0.000291511049677528*x_4 + 5.54158973282533e-6*x_40 + 0.000996494884995073*x_41 - 5.34210584328203e-5*x_42 - 0.000387892251499397*x_43 - 0.000212533243337751*x_44 + 3.53591862698843e-7*x_45 - 5.38825938872238e-7*x_46 - 2.33513320570481e-5*x_47 + 8.31208805328402e-5*x_48 + 5.73235336378073e-6*x_49 + 0.000835972106413659*x_5 + 0.00225294338609208*x_50 + 7.73888567337129e-5*x_51 + 0.000740106877683965*x_52 + 0.000265863848951351*x_53 - 9.80087650254679e-8*x_54 - 1.54489121341357e-7*x_55 - 0.000170815956216359*x_56 + 5.33750840037481e-5*x_57 - 5.86821985239282e-6*x_58 - 0.000889396660757677*x_59 + 0.00042571587654444*x_6 + 1.16908607861139e-6*x_60 + 0.000558621184588262*x_61 - 0.000177447682271284*x_62 + 0.00181215738703742*x_63 + 3.50863305337894e-7*x_64 - 2.55049341528555e-6*x_65 + 0.00105363954593377*x_66 + 8.95604930503512e-5*x_67 - 0.00207168483614817*x_68 + 0.000314614853643266*x_69 - 6.08835591763648e-7*x_7 - 3.81467016066477e-6*x_70 - 6.89779119439832e-5*x_71 - 0.00160181813213136*x_72 + 0.000747440481923432*x_73 - 1.15849569011163e-5*x_74 + 1.14307702235734e-6*x_75 + 8.6086900708502e-6*x_76 - 0.000263875492874849*x_77 + 0.0016328465186567*x_78 + 0.000134074514275411*x_79 + 0.000167959681038554*x_8 - 0.000313386450744534*x_80 + 1.30207493865929e-7*x_81 - 3.58663108139217e-5*x_82 + 0.00130496646330828*x_83 - 5.63837990207877e-6*x_84 - 8.91962893360403e-7*x_85 - 4.09110435600519e-5*x_86 + 8.59873138005743e-8*x_87 - 0.000137065611755424*x_88 - 0.000239274601334201*x_89 + 0.00114127193626337*x_9 - 1.59717221660622e-5*x_90 + 0.00172678396878952*x_91 - 1.37620337163508e-5*x_92 + 0.000837386704642054*x_93 + 3.34188017281035e-6*x_94 - 0.000556053760409779*x_95 - 1.82439238459184e-5*x_96 - 1.51574836398629e-5*x_97 + 0.000190051644712405*x_98 + 0.000681780634162347*x_99 - 4.30666250776767e-7*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) + 1.43329964328551e-5*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 2.88761100034241e-7*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) + 2.26652537384283e-8*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) - 2.69796724032788e-8*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 1.52848681821436e-7*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) - 5.01819497290532e-8*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) + 7.77004952991112e-5*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 7.93645289624297e-7*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 6.68905106258714e-5*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) - 1.09527107594314e-5*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) - 5.94732594538658e-7*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) + 2.43615321588709e-8*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 1.2620090611411e-5*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) + 9.49012320116309e-8*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 8.04736690692911e-8*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 9.59080255282062e-5*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) - 1.14697831760843e-5*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 2.12958562088873e-8*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) + 2.63938695442132e-8*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 3.82869566311204e-8*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) + 1.90987585869255e-5*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) - 3.21369827002102e-6*std::pow(-8.0*x_54 - 9.99971961975098, 2) - 5.77847745529437e-8*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) - 1.56255752590978e-5*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) - 9.04262701045002e-8*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) - 3.76441220533046e-6*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) + 6.78823660388934e-6*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) + 7.55559357484477e-6*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) + 3.14025408744632e-6*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) + 5.28873927822248e-5*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 1.57411870215861e-5*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) - 4.68460209424821e-6*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) - 1.52656693815981e-7*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 5.414405768312e-6*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) - 5.02123000501544e-6*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 2.35193725153607e-8*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 3.36343977654796e-6*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) - 2.3803995708962e-8*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 9.27369515204572e-6*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) - 1.87903665290189e-8*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) + 0.000838425522514604*std::exp(0.594239830970764*x_2) + 1.15186140299312e-6*std::exp(0.429519861936569*x_29) + 6.05436863248479e-6*std::exp(0.641439855098724*x_71) + 0.000727105007545623*std::exp(0.69871985912323*x_85) - 2.99152161957104e-6*std::log(8.06023979187012*x_91 + 9.42432022094727) + 0.0002791095685711*std::sin(0.281039953231812*x_1 + 5.1756796836853) + 3.6835959581817e-6*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 2.21992044655774e-5*std::sin(0.328399837017059*x_102 - 4.43911981582642) + 2.52539351147397e-5*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 1.06431802663518e-5*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.00766505862269205*std::sin(0.308319926261902*x_104 - 4.26287984848022) - 8.83650067106456e-5*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.00647876504096209*std::sin(0.431519865989685*x_107 + 5.2052001953125) - 0.00791987888768196*std::sin(0.300959944725037*x_108 + 5.11872005462646) - 0.00511661199902285*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.00429077626811255*std::sin(0.450319856405258*x_109 - 4.15903997421265) + 5.81447704733475e-5*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.0334154391374546*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.000687353048827706*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.000326532086644437*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 4.21091867460517e-6*std::sin(1.31879985332489*x_110 - 0.19039985537529) - 0.00273500325578946*std::sin(0.359679847955704*x_111 - 7.42783975601196) + 0.00987524713347077*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.00464690854832925*std::sin(0.346559852361679*x_112 - 7.43415975570679) - 0.00301973099165091*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.00804425224156845*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 1.33101515116939e-5*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.0148844510093654*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 8.70719433288056e-6*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 1.94501669504762e-5*std::sin(0.68071985244751*x_117 + 8.02408027648926) + 0.000175696336449167*std::sin(1.12887978553772*x_117 + 0.991439819335938) + 0.00271291989921434*std::sin(0.407119870185852*x_118 - 1.19191980361938) + 0.00205826462637693*std::sin(0.481039851903915*x_118 + 2.24391984939575) + 0.000288942562721401*std::sin(0.325919836759567*x_12 - 7.46208000183105) - 9.71679739136392e-5*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0309283787954299*std::sin(0.180560007691383*x_120 - 7.61552000045776) + 0.00016254569303251*std::sin(0.333279848098755*x_120 - 4.27167987823486) - 5.77247886042427e-5*std::sin(0.346559852361679*x_15 + 1.93543982505798) + 5.76079466679542e-7*std::sin(1.99319982528687*x_15 - 8.39608001708984) + 0.00493584753127492*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.0056993708180903*std::sin(0.39183983206749*x_16 + 1.99935972690582) - 8.39405610821884e-5*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 1.81229367707334e-5*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 0.00577599571322942*std::sin(0.598959863185883*x_2 + 5.59223985671997) + 0.00018081893524316*std::sin(0.299679934978485*x_21 - 4.28143978118896) - 4.92457374086115e-5*std::sin(0.302399933338165*x_21 - 4.28687953948975) - 0.00845901405730241*std::sin(0.312319934368134*x_21 + 8.32975959777832) + 0.0185009350492038*std::sin(0.316159844398499*x_21 - 1.07039988040924) - 0.000133739738249982*std::sin(0.298479825258255*x_22 - 1.12871980667114) + 6.84977168562203e-7*std::sin(1.528639793396*x_22 - 1.98135983943939) - 0.0446508152282987*std::sin(0.165360018610954*x_23 - 7.6396803855896) + 0.0192513497543176*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.000376363916654441*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.0103251464279474*std::sin(0.343999862670898*x_26 + 5.15880012512207) - 1.68625632225889e-6*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 4.22107204715582e-5*std::sin(0.363919854164124*x_28 + 8.3712797164917) + 0.00929465749523572*std::sin(0.482479840517044*x_28 + 2.26735997200012) - 1.4727194427507e-5*std::sin(0.638239860534668*x_29 + 8.61336040496826) + 9.26228730853208e-5*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.000294836979187899*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 0.0155982190170883*std::sin(0.301119923591614*x_30 - 4.27631998062134) - 0.000780375579109914*std::sin(1.10583996772766*x_32 + 3.84191989898682) + 0.0114496205051165*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.00293804798331395*std::sin(0.258239984512329*x_35 - 4.14152002334595) + 0.00848178887801363*std::sin(0.271199941635132*x_35 + 8.26056003570557) + 0.000128242365885971*std::sin(0.327759832143784*x_35 - 1.21751987934113) - 7.36037763153839e-5*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.00976944986319053*std::sin(0.371439844369888*x_36 + 5.18383979797363) - 0.00636940675048242*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.000182722221449978*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.00298382007196891*std::sin(0.33791983127594*x_39 + 5.16007995605469) + 2.98338268848435e-6*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 0.00889424691673033*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.00248467160950574*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.000186301993782695*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.000212709008210709*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.00414831998017373*std::sin(0.389599829912186*x_43 - 4.21072006225586) + 6.03281565624741e-5*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.0114126377937182*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.0111772016382263*std::sin(0.397519826889038*x_45 + 5.20032024383545) + 0.00431184561483637*std::sin(0.479679852724075*x_46 + 5.28007984161377) - 0.000121826371289097*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.0045676234621055*std::sin(0.309039950370789*x_47 + 8.0740795135498) - 1.03842094636194e-5*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.0024221966957371*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.00348747636219012*std::sin(0.3642398416996*x_49 + 1.96791982650757) + 3.50757151789892e-5*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.000196253803644593*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.00869027534242194*std::sin(0.354879856109619*x_53 + 5.16688013076782) - 0.0151426496907988*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.00602304948506033*std::sin(0.377519845962524*x_55 - 4.21208000183105) - 0.00645535155578972*std::sin(0.320719838142395*x_56 + 8.30823993682861) + 0.0221488651222858*std::sin(0.311919927597046*x_57 - 7.47584009170532) + 0.00993998524846025*std::sin(0.478079855442047*x_58 - 1.11911988258362) + 5.07444474526092e-7*std::sin(1.12711989879608*x_58 - 7.43103981018066) + 0.00582190204474564*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 0.000188870420379167*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.0145778272464317*std::sin(0.19480000436306*x_64 - 4.4093599319458) + 0.00812396324173202*std::sin(0.29479992389679*x_64 + 8.33711910247803) - 0.0211423699419384*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.00372146150848173*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 2.42111969883842e-6*std::sin(1.12663984298706*x_67 + 2.37519979476929) + 1.82877026754851e-6*std::sin(1.25287985801697*x_7 + 9.62911987304688) - 0.0287875650827434*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.000201228666572995*std::sin(0.262719959020615*x_73 - 7.51200008392334) - 0.0088965460593773*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.00753414500818592*std::sin(0.419119864702225*x_75 - 7.36639976501465) - 1.17091754372197e-5*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.00022190285724798*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 8.39555711948566e-5*std::sin(0.437359839677811*x_77 - 4.15848016738892) - 0.00932655731356932*std::sin(0.213599994778633*x_78 + 5.01663970947266) - 0.000148013829523444*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 0.00116228922681893*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 0.000512970450704193*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.0238801809719503*std::sin(0.246719971299171*x_80 - 7.53208017349243) - 0.0222580401353568*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 5.26725021444092e-5*std::sin(0.426799863576889*x_81 - 4.15999984741211) + 6.20328521652491e-5*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 0.0127829096664718*std::sin(0.234479993581772*x_83 - 4.34055948257446) - 0.00879140458844236*std::sin(0.358319848775864*x_84 - 7.4423999786377) - 0.00345464754410525*std::sin(0.404559850692749*x_84 - 4.1814398765564) - 1.45095171413386e-5*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.000206419237739403*std::sin(0.286079943180084*x_86 + 5.12367963790894) + 0.0255524341674897*std::sin(0.189920008182526*x_87 + 4.97759962081909) - 0.00828504559428061*std::sin(0.268799960613251*x_87 - 4.28639984130859) + 0.000116207496956596*std::sin(0.283919870853424*x_87 - 1.28575992584229) + 6.51550345632121e-5*std::sin(0.467759847640991*x_9 - 4.13375997543335) + 0.00451959134764438*std::sin(0.620159804821014*x_90 + 2.2008798122406) - 0.0123646987931223*std::sin(0.317679852247238*x_92 - 4.21264028549194) + 3.02227980594457e-5*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.000217465287382355*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 0.0058725985810993*std::sin(0.353039860725403*x_93 - 7.41192007064819) - 0.00493571643486692*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.0138685749489476*std::sin(0.355119854211807*x_95 - 7.42967987060547) + 0.0116655662376888*std::sin(0.315439850091934*x_97 - 7.45576000213623) + 0.0108135027674674*std::sin(0.335919857025146*x_97 - 7.4507999420166) + 0.00603721567402959*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 0.202270045876503*std::sin(0.000447146965588757*x_100 - 0.000899012131009804*x_101 - 0.000136319945917846*x_102 - 0.00782969126168466*x_103 + 0.00160779434232493*x_104 - 0.00785764944618555*x_106 + 0.00164573045239881*x_107 + 0.00030071933506248*x_108 + 0.00367046888011708*x_109 - 0.00653150995435737*x_11 + 0.00137176270614883*x_113 + 0.00467349023229383*x_114 - 0.000473698329092087*x_115 + 0.000737225932622496*x_116 - 0.000775182520505583*x_117 + 0.00869275136958706*x_118 + 0.00330188799420493*x_13 + 0.00203427232945561*x_15 - 0.0362518877882048*x_16 - 0.00850032101590639*x_17 + 0.000793515077883818*x_19 - 0.00062208810819961*x_2 + 0.00246934091189287*x_22 + 0.00847706141616083*x_24 + 0.0052878626477113*x_25 + 0.0139242570921565*x_27 + 0.0294632578677336*x_29 + 0.00370925628943308*x_30 + 0.0332882424610912*x_31 + 0.000686174435832733*x_32 - 0.00175429643836036*x_33 + 0.000573512510911586*x_34 + 0.00118395362735185*x_35 - 0.0147508915161114*x_36 + 0.000590135684202658*x_37 - 0.00145663567429801*x_38 + 0.00111704501485321*x_4 + 0.00110038808479543*x_40 + 0.000980041224937255*x_44 + 5.26985514814494e-5*x_45 - 0.00428904967275593*x_48 - 0.000534185996327477*x_49 + 0.00999277671680986*x_50 - 0.00915524551057946*x_51 - 0.015772609542683*x_52 - 0.00816496861094176*x_53 + 0.000267496711224167*x_55 + 0.000105567443771528*x_56 + 0.0138333050077112*x_57 + 0.0122333560568131*x_59 + 0.0113741101070892*x_6 + 0.000368709183226762*x_60 + 0.016420130333463*x_61 + 0.00343821753302961*x_62 + 0.0027684910476159*x_63 + 0.000277071267405351*x_64 - 0.000154712373406605*x_65 - 0.00141821919247617*x_66 - 0.000608402921621395*x_69 + 0.0011870223329892*x_70 + 0.0112239709500136*x_71 + 0.000215423119044475*x_72 - 0.00887532776064859*x_74 - 0.0018572561923461*x_76 - 2.38001614308479e-5*x_77 - 0.00122167726855387*x_78 + 0.0234230809129721*x_8 + 0.000557843839813329*x_80 + 0.00165243597659853*x_81 - 0.0193611904903374*x_82 + 0.00142667049522841*x_83 - 0.000788141999415795*x_84 + 0.00213521210976714*x_85 + 0.00484131333420244*x_87 - 0.000160626071037895*x_88 + 0.0122718406527907*x_89 - 0.0140509097019195*x_90 - 0.0133274533789456*x_91 + 0.000948696539361459*x_93 + 4.10763888505888e-5*x_94 + 0.000349733556665695*x_95 + 0.000924752428066909*x_96 + 0.0241579319701321*x_98 + 0.00436436887360881*x_99 - 0.000489675417099981*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 0.000420087503084754*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 0.000254994209767732*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 9.13701562476402e-5*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 0.000688822343567444*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 0.000180802774748228*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 0.0307624587847145*std::exp(0.448319852352142*x_20) - 0.464638648683106*std::sin(0.255999982357025*x_1 - 7.38719987869263) - 0.0850283032558785*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.00773731766915253*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 0.116831081853933*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.126832015889232*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.0847488981903712*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.216525505352962*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.164382457985511*std::sin(0.257839977741241*x_120 + 5.06311988830566) - 0.940262979768349*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.265690289367051*std::sin(0.32847985625267*x_21 + 5.15607976913452) + 0.0597009728302629*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 0.290282631900659*std::sin(0.347119837999344*x_26 + 5.14224004745483) - 0.194488461051865*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.0128062364251658*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.00490580059070722*std::sin(1.05911982059479*x_39 + 8.42039966583252) - 0.122648286135009*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.138486581418206*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.049637802842696*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 0.493776409815872*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.0687048257167451*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.0513604557649625*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 0.646243797185875*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 0.0594337801167608*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.0802258494588006*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.108296367692848*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.000681609599575458*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.114239210543829*std::sin(0.506479859352112*x_9 - 0.87367981672287) + 0.315847356148197*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.0649307686250431*std::sin(0.263759940862656*x_97 + 8.28248023986816) - 6.66962679018133) + 0.0116805791427178);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000212902042687743*x_1 + 0.00018021628421749*x_10 + 4.40359146699828e-5*x_100 - 0.000212639226913789*x_101 - 9.44065374443789e-5*x_102 - 0.000175021311485747*x_103 + 0.000164147822154455*x_104 - 5.90324184129329e-7*x_105 + 1.34072695046812e-5*x_106 + 8.89539781548885e-7*x_107 - 0.00034984343955437*x_108 + 0.000185298660380009*x_109 + 8.77167873897541e-5*x_11 - 0.000398402242034772*x_111 + 1.92123667711958e-5*x_112 - 1.23437643500594e-5*x_113 - 3.61169181239942e-6*x_114 - 1.22012070416981e-6*x_115 - 4.57412015799641e-5*x_116 + 7.07225473895789e-6*x_117 - 0.000623908215345312*x_118 - 1.21231572853329e-5*x_119 + 0.000125253316466555*x_12 + 0.000116815116737546*x_120 + 0.000172444619052397*x_13 - 0.000248963832249278*x_14 + 4.62686128635869e-6*x_15 + 0.000332982513951498*x_16 + 0.000143495337974271*x_17 + 8.24482787589882e-7*x_18 - 2.26339174205369e-5*x_19 - 2.40082720907952e-5*x_2 - 0.000605925905427499*x_20 - 0.000143810577482404*x_22 - 6.26781104811544e-5*x_23 - 3.03427598527612e-5*x_24 - 0.000365032190443088*x_25 - 8.41950539362366e-5*x_26 - 0.000104643978930597*x_27 + 1.87455469328164e-5*x_28 - 0.000230535755677385*x_29 + 9.54719646164926e-5*x_3 - 7.7969133415761e-7*x_30 + 0.000416970856354781*x_31 - 0.000258751252910149*x_32 + 1.24234837410439e-5*x_33 + 0.000205068523818024*x_34 + 2.84471575635037e-5*x_35 - 4.0599738611877e-5*x_36 - 6.81177825400502e-5*x_37 + 1.66527741679424e-5*x_38 - 8.59308364368162e-5*x_39 - 0.000340889269824672*x_4 - 1.28174374287728e-5*x_40 - 6.085735335119e-5*x_41 - 3.57483329080726e-5*x_42 + 6.32189780762233e-5*x_43 - 0.000216734971876025*x_44 - 0.000145641792945807*x_45 - 5.33946041182529e-5*x_47 - 1.33448583092946e-5*x_48 - 2.72873697343798e-7*x_49 - 3.9055876984053e-5*x_5 - 0.000163961466875785*x_50 - 4.83726407198546e-6*x_51 - 0.00018774268585371*x_52 - 1.6119928892966e-5*x_53 - 3.10801008252383e-5*x_54 + 2.26307313805363e-5*x_55 + 1.23361763232142e-5*x_56 - 2.87189207521038e-5*x_57 + 0.000360279645372366*x_59 - 2.04144940903781e-6*x_6 - 0.000642389119038012*x_60 - 9.83587007239999e-5*x_61 - 0.000354229415508238*x_62 + 0.000622715086780784*x_63 - 9.66992711205439e-6*x_64 + 2.44274702760933e-5*x_65 - 0.000169525223010851*x_66 - 0.000127978902726236*x_67 + 0.000164605796395943*x_68 - 2.28561647009336e-5*x_69 + 0.000558801648697326*x_70 - 2.06823653240259e-5*x_71 + 7.55890762238935e-6*x_72 - 0.000146380196447484*x_73 - 2.65561085267173e-5*x_74 + 4.70058036786971e-5*x_75 + 0.000117730354763623*x_76 + 3.5845026598171e-5*x_77 - 4.45915750417919e-5*x_78 - 1.86728999943758e-5*x_79 - 0.000725827441776554*x_8 + 4.61824911385186e-5*x_80 - 1.90737754984164e-5*x_81 - 1.20941276735686e-5*x_82 - 0.000186781557547662*x_83 + 2.35900541230914e-7*x_85 - 0.000233634111873978*x_86 - 1.25960700912715e-5*x_87 + 2.65202891989127e-6*x_88 + 3.99058763533168e-5*x_89 - 0.000212881680139036*x_9 + 2.67998733821237e-6*x_90 - 0.000105420577553229*x_91 + 5.59709413180177e-7*x_92 - 0.000592250074409247*x_93 - 3.93464532924462e-5*x_94 + 7.80302429142405e-5*x_95 + 9.3369175231519e-6*x_96 - 3.04496685472233e-5*x_97 - 1.4963152022205e-5*x_98 - 0.000115374015285287*x_99 + 6.9120984514412e-8*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) - 2.30041435263063e-6*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 3.32017726926352e-6*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 3.95218584708217e-6*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 7.35103038071175e-6*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 3.16012149977544e-6*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 2.72047353039449e-6*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 4.45452717108959e-7*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) - 3.56866092265174e-6*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) + 5.13265964608211e-7*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 1.39018480439906e-5*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 3.90063167945035e-6*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 4.66482334159862e-7*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) - 3.11957759353789e-6*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 3.86637302718677e-6*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) + 5.60856210051584e-6*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 3.0653086796338e-6*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) + 5.15791492728918e-7*std::pow(-8.0*x_54 - 9.99971961975098, 2) + 6.35500663574265e-7*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 1.32463218815067e-5*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) + 1.53100696440708e-7*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 1.08949702079351e-6*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) - 1.21265612418453e-6*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) - 5.04003863219377e-7*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) - 2.15095909433783e-6*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) - 2.52642583995164e-6*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) + 7.51868316193074e-7*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 8.69000198160932e-7*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) + 2.04216161468257e-7*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) + 5.39824674653774e-7*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) + 3.48698877950539e-6*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) - 1.48840764243723e-6*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) + 2.75255457321453e-6*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) - 0.000134565449355954*std::exp(0.594239830970764*x_2) - 0.000168733343632311*std::exp(0.429519861936569*x_29) - 2.95717570151138e-5*std::exp(0.69871985912323*x_85) + 0.116317451000214*std::log(-0.00362589906499111*x_100 + 0.00729005784698112*x_101 + 0.00110541366146215*x_102 + 0.0634906918970833*x_103 - 0.013037547945468*x_104 + 0.0637174038348623*x_106 - 0.0133451705318478*x_107 - 0.00243852254345973*x_108 - 0.02976370344585*x_109 + 0.0529637851959964*x_11 - 0.0111235756840385*x_113 - 0.0378971684202465*x_114 + 0.00384120314063031*x_115 - 0.00597813923720456*x_116 + 0.00628592787742116*x_117 - 0.0704892160493248*x_118 - 0.0267748939660792*x_13 - 0.0164958429888892*x_15 + 0.293965286921583*x_16 + 0.0689288050587952*x_17 - 0.00643458594237998*x_19 + 0.00504449065620533*x_2 - 0.0200237988684269*x_22 - 0.0687401937800439*x_24 - 0.0428790927942281*x_25 - 0.112911312513703*x_27 - 0.238916524936143*x_29 - 0.0300782291879338*x_30 - 0.269933190882651*x_31 - 0.00556416443982968*x_32 + 0.0142255283052021*x_33 - 0.00465059284107397*x_34 - 0.00960063844949829*x_35 + 0.119614462072061*x_36 - 0.00478538957040864*x_37 + 0.0118118076067352*x_38 - 0.00905807885686133*x_4 - 0.00892300839508909*x_40 - 0.00794711992839717*x_44 - 0.000427330706116678*x_45 + 0.0347797534031554*x_48 + 0.00433169551327454*x_49 - 0.0810310760052641*x_50 + 0.0742395648215237*x_51 + 0.127899537723537*x_52 + 0.066209444165889*x_53 - 0.0021691214516883*x_55 - 0.000856042699877623*x_56 - 0.112173785250122*x_57 - 0.0991998553086398*x_59 - 0.0922322600313262*x_6 - 0.00298984983819639*x_60 - 0.133150261111003*x_61 - 0.0278803854160865*x_62 - 0.0224495968294661*x_63 - 0.00224676119203486*x_64 + 0.0012545572110479*x_65 + 0.0115002897026952*x_66 + 0.00493351795810631*x_69 - 0.00962552247590905*x_70 - 0.0910147868711493*x_71 - 0.00174685851863571*x_72 + 0.0719697216024997*x_74 + 0.0150604253400439*x_76 + 0.000192994674502872*x_77 + 0.00990653813324626*x_78 - 0.189936941805542*x_8 - 0.00452353613655174*x_80 - 0.0133995453924577*x_81 + 0.156999214796403*x_82 - 0.0115688210203727*x_83 + 0.0063910158374869*x_84 - 0.0173143601280362*x_85 - 0.0392580400689965*x_87 + 0.00130251117777941*x_88 - 0.0995119255479802*x_89 + 0.113938334085266*x_90 + 0.108071852129877*x_91 - 0.0076929469721476*x_93 - 0.000333086996867918*x_94 - 0.00283597714778285*x_95 - 0.0074987850132475*x_96 - 0.195895823260896*x_98 - 0.035390514161844*x_99 + 0.00397076078705833*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) + 0.00340647483237166*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) + 0.00206773910577157*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) - 0.000740917393166673*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) + 0.00558563623080299*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) + 0.00146612336068122*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) - 0.24945169961616*std::exp(0.448319852352142*x_20) + 3.76773850986672*std::sin(0.255999982357025*x_1 - 7.38719987869263) + 0.689491529630146*std::sin(0.423519849777222*x_105 + 2.02759981155396) - 0.0627416376742707*std::sin(0.866479873657227*x_110 - 6.98816013336182) + 0.947379146134423*std::sin(0.41967985033989*x_111 + 2.01015996932983) + 1.02847636954928*std::sin(0.344239860773087*x_112 - 4.23336029052734) + 0.687225843751136*std::sin(0.312799841165543*x_119 - 7.45648002624512) - 1.75579773055665*std::sin(0.369039833545685*x_12 + 1.95535981655121) + 1.33297158782193*std::sin(0.257839977741241*x_120 + 5.06311988830566) + 7.62455953312531*std::sin(0.187120005488396*x_18 - 7.60152006149292) - 2.15447324019016*std::sin(0.32847985625267*x_21 + 5.15607976913452) - 0.484113095298063*std::sin(0.250559985637665*x_23 - 7.5303201675415) - 2.35389168347791*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 1.57710011103617*std::sin(0.309999942779541*x_28 + 8.33735942840576) - 0.103845322127869*std::sin(0.772399842739105*x_3 + 7.61152029037476) + 0.0397809649707828*std::sin(1.05911982059479*x_39 + 8.42039966583252) + 0.994550651672526*std::sin(0.349519848823547*x_41 - 1.24535989761353) + 1.12298283276266*std::sin(0.357599824666977*x_42 + 1.97287976741791) + 0.402511202728533*std::sin(0.530159831047058*x_43 - 4.43088006973267) + 4.00401559319238*std::sin(0.172400012612343*x_46 + 1.75647985935211) - 0.557125022639283*std::sin(0.468639850616455*x_47 + 5.26352024078369) - 0.416480134871293*std::sin(0.680319845676422*x_54 - 4.14432001113892) - 5.2403682911887*std::sin(0.152720034122467*x_58 + 4.94431972503662) + 0.481946438953244*std::sin(0.427359849214554*x_73 + 2.01815986633301) - 0.650548600185104*std::sin(0.26639997959137*x_75 - 4.31455993652344) + 0.878171448267352*std::sin(0.292479932308197*x_79 + 5.12367963790894) + 0.00552714834268297*std::sin(1.34455978870392*x_86 + 1.38687980175018) + 0.926361752563366*std::sin(0.506479859352112*x_9 - 0.87367981672287) - 2.56119513598787*std::sin(0.409839868545532*x_92 - 7.41232013702393) - 0.526521326017956*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 5.78479746872304) - 0.000539600911185472*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.00369938683656796*std::sin(0.328959852457047*x_102 - 4.24408006668091) + 0.000311742112548481*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.0129443724771355*std::sin(0.174880012869835*x_106 - 1.40583980083466) - 0.00103982751669338*std::sin(0.431519865989685*x_107 + 5.2052001953125) + 0.000322105791632806*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.000208095399159007*std::sin(0.434719860553741*x_109 + 5.23311996459961) + 0.000688660138676029*std::sin(0.450319856405258*x_109 - 4.15903997421265) - 0.00135902412508709*std::sin(0.286399960517883*x_11 + 8.30607986450195) + 0.000110318650133977*std::sin(1.160719871521*x_110 - 7.00648021697998) - 1.32802379624397e-5*std::sin(1.23231983184814*x_110 + 8.60128021240234) + 0.00043896199748487*std::sin(0.359679847955704*x_111 - 7.42783975601196) - 0.000401631684096018*std::sin(0.375999838113785*x_111 - 7.40831995010376) - 0.000745818585109995*std::sin(0.346559852361679*x_112 - 7.43415975570679) + 0.000122814105541016*std::sin(0.421679854393005*x_112 + 8.21263980865479) + 0.00129108476370416*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 0.000605358736337267*std::sin(0.357119828462601*x_115 + 5.16096019744873) + 0.00127549548029436*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 2.81988749502377e-5*std::sin(1.12887978553772*x_117 + 0.991439819335938) - 0.000435417667403045*std::sin(0.407119870185852*x_118 - 1.19191980361938) - 8.37107443524287e-5*std::sin(0.481039851903915*x_118 + 2.24391984939575) + 0.0142338974895953*std::sin(0.340559840202332*x_12 - 4.26471996307373) - 0.00125787402523488*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 8.43884640618852e-5*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 0.000792192655355285*std::sin(0.355999857187271*x_16 - 4.24599981307983) - 0.000231796518002967*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.012296246320057*std::sin(0.231519997119904*x_18 - 7.55200004577637) + 0.000234912894257906*std::sin(0.598959863185883*x_2 + 5.59223985671997) + 0.00721388694073936*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.00135765312143084*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 0.000752443113649068*std::sin(0.316159844398499*x_21 - 1.07039988040924) - 0.000100340620549453*std::sin(1.528639793396*x_22 - 1.98135983943939) + 0.00181597299531064*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.00308979922584986*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.0016571632559272*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 0.000247015540877157*std::sin(1.65511989593506*x_27 - 3.5927197933197) + 0.00618334461401984*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.000378018787018972*std::sin(0.482479840517044*x_28 + 2.26735997200012) - 0.0135680968490709*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.000634388070299349*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 3.1738300199396e-5*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.000465662307340558*std::sin(0.273119956254959*x_33 - 4.38567972183228) + 0.000471550228955621*std::sin(0.258239984512329*x_35 - 4.14152002334595) - 0.000344958977247005*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.00156797518145424*std::sin(0.371439844369888*x_36 + 5.18383979797363) + 0.001022275751982*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.00047889654835122*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 0.000361733870520031*std::sin(0.293439924716949*x_40 + 8.06552028656006) - 0.000398784319723876*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 3.41393272309824e-5*std::sin(1.41703987121582*x_41 + 4.79800033569336) + 0.000168714434918731*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.00183170322444674*std::sin(0.266319960355759*x_45 - 7.53560018539429) - 0.000454582883523629*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.000175365111621273*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 1.95528642147664e-5*std::sin(1.01415979862213*x_46 + 4.18032026290894) + 0.00018576773609889*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.00152115730175677*std::sin(0.476639837026596*x_48 - 7.32263994216919) + 9.85120599993318e-5*std::sin(0.636399865150452*x_48 - 7.38199996948242) - 0.000559732273403219*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 0.00513815523904728*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.00139477004823599*std::sin(0.354879856109619*x_53 + 5.16688013076782) + 0.000615859817459985*std::sin(0.324719846248627*x_54 + 1.93063986301422) + 0.000966686173888718*std::sin(0.377519845962524*x_55 - 4.21208000183105) + 0.0010360697039019*std::sin(0.320719838142395*x_56 + 8.30823993682861) - 0.000900806418274689*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.000404264618522571*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 7.43342928863118e-5*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.000934402452835517*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 0.00233970915886019*std::sin(0.19480000436306*x_64 - 4.4093599319458) - 0.000330406013562135*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.000859871710631038*std::sin(0.212399989366531*x_65 + 5.01623964309692) - 0.000597286373925967*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 0.000267892058173825*std::sin(1.25287985801697*x_7 + 9.62911987304688) + 0.00117080596454323*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.000361827377904788*std::sin(0.39743983745575*x_74 - 4.18959999084473) - 0.00120921367648585*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 9.02491016757991e-6*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.00149689190290919*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.000186544860441972*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 0.000971219977652468*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.000905246625569582*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.00205162884138631*std::sin(0.234479993581772*x_83 - 4.34055948257446) + 0.000357551216967326*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.000554463320420771*std::sin(0.404559850692749*x_84 - 4.1814398765564) + 0.00212546347623648*std::sin(0.349279850721359*x_85 + 1.96199989318848) - 0.0041011093932041*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 0.000336957320649222*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.000183814243820572*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.00198450691751043*std::sin(0.317679852247238*x_92 - 4.21264028549194) - 0.00442726334717272*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.000942539135238458*std::sin(0.353039860725403*x_93 - 7.41192007064819) + 0.0007921716146706*std::sin(0.43495985865593*x_94 + 2.01871991157532) + 0.000564042503187465*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.000474444938000241*std::sin(0.315439850091934*x_97 - 7.45576000213623) - 0.00173554337259666*std::sin(0.335919857025146*x_97 - 7.4507999420166) - 0.000968959816010911*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 0.102613195776939*std::sin(-0.0221072064890964*x_100 - 0.000150873694302697*x_101 + 9.10609691560685e-5*x_104 - 0.00434709027012411*x_105 - 0.00667286530267272*x_106 - 0.00156655011698309*x_107 + 0.00144822566356877*x_108 + 0.000448224630452359*x_11 - 0.000675299978199091*x_112 - 0.0410530260160872*x_113 + 0.0252349372514608*x_114 - 0.0183968240789077*x_116 - 0.000153619199948913*x_118 - 0.00155673007537532*x_119 - 0.0280960060180757*x_13 + 0.00578126625695412*x_14 + 0.000719175378277095*x_16 + 0.00687506622173144*x_18 - 0.00402347865955121*x_20 + 0.014160429729405*x_23 - 0.0208832065958097*x_25 - 0.0352152558157023*x_26 - 2.73003911708666e-5*x_28 + 0.00631311187661904*x_3 + 0.044885910667034*x_31 + 0.00177831918905256*x_32 + 0.0044932127765242*x_33 + 0.000125182811721471*x_34 - 0.00640819923782943*x_37 + 0.0430153876532012*x_4 - 0.0101814427132594*x_40 - 0.000279203532345257*x_42 - 0.00109481210169619*x_44 + 0.00119590678932872*x_45 + 0.00100585508692907*x_46 - 0.0279415852238505*x_47 + 4.81535295161601e-5*x_48 + 0.00182384726481711*x_49 + 0.00104764027137033*x_5 - 0.013035402876367*x_50 + 0.00944878673653148*x_51 - 0.000927683089495704*x_52 + 0.000579025179496443*x_54 - 0.00662460547789296*x_56 + 0.00298731781359345*x_57 + 0.0109545186375058*x_58 - 0.0048103651115319*x_59 + 0.0052370063238503*x_6 + 0.0060038435808136*x_60 - 0.00170336989519792*x_61 + 0.000205214633129802*x_62 - 0.000531747214574443*x_64 + 0.00444985225560024*x_65 + 0.000396279102953748*x_66 - 0.00771562988320098*x_68 + 0.000293209925309923*x_69 + 0.00113654583586063*x_7 - 0.00821100742068*x_72 + 0.0124642858503961*x_74 - 0.00146941149746042*x_78 - 0.0221272885465975*x_8 - 7.24232657174909e-5*x_83 + 0.0105254641571539*x_84 - 0.00107868953728907*x_85 + 0.0253745649414451*x_88 - 0.000214725572560428*x_89 - 0.0013557248021643*x_90 + 0.00282139671778219*x_93 - 0.0121258825060226*x_94 + 0.000648051982268739*x_95 + 0.000481989355677163*x_96 + 0.0286833153788785*x_97 + 0.019362958265342*x_98 + 0.0144944581331121*x_99 + 0.000539045729655463*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 0.000285330777620468*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 0.00148153994489708*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 0.00111021901958042*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) + 0.000150224485418446*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 0.000107869917236686*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 0.000284972383382209*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) + 4.39048657075967e-5*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 0.0113020124826852*std::exp(0.641439855098724*x_71) + 0.00558443278547749*std::log(8.06023979187012*x_91 + 9.42432022094727) - 0.521028701672037*std::sin(0.281039953231812*x_1 + 5.1756796836853) + 0.0414404376749467*std::sin(0.328399837017059*x_102 - 4.43911981582642) + 0.0198681916360961*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.108541940800677*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.0078607462334892*std::sin(1.31879985332489*x_110 - 0.19039985537529) + 0.0248467689470466*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.0363086628860216*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 0.539384475721306*std::sin(0.325919836759567*x_12 - 7.46208000183105) - 0.303432705072368*std::sin(0.333279848098755*x_120 - 4.27167987823486) + 0.107757938270396*std::sin(0.346559852361679*x_15 + 1.93543982505798) + 0.0338310515991296*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 0.337544339843959*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.249659094595302*std::sin(0.298479825258255*x_22 - 1.12871980667114) + 0.702578574624226*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.027492038453282*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.55038789697403*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 0.239396856721868*std::sin(0.327759832143784*x_35 - 1.21751987934113) + 0.137400090609916*std::sin(0.364079833030701*x_36 - 7.4255199432373) - 0.341097305606922*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.00556923940920306*std::sin(1.43327987194061*x_39 - 7.78567981719971) - 0.347779857338651*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.112617783936727*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.366357431006861*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.352574476103428*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.00451963313094739*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 0.375644272679295*std::sin(0.262719959020615*x_73 - 7.51200008392334) + 0.0218581416141976*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.15672433762029*std::sin(0.437359839677811*x_77 - 4.15848016738892) + 0.276305301251114*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 0.957589269672212*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.0983265659669712*std::sin(0.426799863576889*x_81 - 4.15999984741211) - 0.115800030038884*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 0.385333788411828*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 0.216930725714008*std::sin(0.283919870853424*x_87 - 1.28575992584229) - 0.121628374260553*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.405954037776752*std::sin(0.380959838628769*x_92 + 1.97975981235504) + 4.17946835503474) - 0.207350486975457);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000161165761857374*x_1 - 0.000213032213911106*x_10 + 8.23338448169955e-5*x_100 - 3.05460496040418e-5*x_101 - 6.34609612129485e-5*x_102 + 0.000561987504904529*x_103 - 0.00011653785393236*x_104 + 5.42503599561251e-5*x_105 + 1.46311797869352e-6*x_106 + 6.73377083591607e-7*x_107 + 0.00125074143911983*x_108 - 0.000651752308090328*x_109 - 0.000300208293786691*x_11 + 0.00140130306534336*x_111 - 6.7575795536381e-5*x_112 + 3.96252107278533e-5*x_113 + 3.35313051046062e-5*x_114 + 0.000196478918634858*x_116 + 3.14122868342222e-5*x_117 + 0.00219447684378238*x_118 + 3.02633635174311e-5*x_119 + 7.99774012554429e-6*x_12 + 3.71413607151611e-5*x_120 + 2.47756680016625e-5*x_13 + 0.000316604465449213*x_14 - 0.00117120178622199*x_16 - 0.00085326651078486*x_17 + 0.000101233290760037*x_19 + 8.44444677384433e-5*x_2 + 0.00212934284180144*x_20 - 4.90863483674796e-5*x_22 + 0.000220458167852142*x_23 - 9.48636394484558e-5*x_25 + 0.000297799049752894*x_26 + 8.90597873646937e-6*x_27 - 3.52688472508921e-6*x_29 - 1.9165037480804e-5*x_3 + 8.37836592160423e-6*x_30 - 0.000509119211800506*x_31 + 0.000884566601085735*x_32 + 0.000207393730861634*x_33 - 7.67936130799759e-5*x_34 - 0.000100057391470613*x_35 + 0.000131919122238693*x_36 + 0.000212369018305064*x_37 - 0.000129969582385389*x_38 + 0.000302760888465772*x_39 + 0.00135204929713438*x_4 + 4.50828646622387e-5*x_40 + 4.08492646143066e-5*x_41 + 0.000146236295686853*x_42 - 3.39132643271024e-6*x_43 + 0.000883601940118511*x_44 + 0.000512266923636562*x_45 + 0.000209666982184165*x_47 - 2.06563998954922e-7*x_49 - 2.44613888268545e-5*x_5 + 0.000186355329693449*x_50 - 2.15715962228572e-6*x_51 + 0.000221102725922084*x_52 + 1.0487749516152e-5*x_53 + 0.000109318261702418*x_54 - 7.95992339112887e-5*x_55 - 1.30851045004218e-5*x_56 + 7.00553292269029e-5*x_57 - 0.00110983548160357*x_59 - 1.71463937197336e-5*x_6 + 0.00225947985898287*x_60 + 1.55999986242366e-5*x_61 + 0.0012771907859073*x_62 - 0.00254559363801823*x_63 + 3.40121040347609e-5*x_64 - 8.59189165242844e-5*x_65 - 7.55372351800399e-6*x_66 + 0.000434719670807214*x_67 + 4.60286598991335e-5*x_68 + 2.56847037194785e-5*x_69 - 0.00196547704962499*x_70 + 8.47651086199846e-5*x_71 + 0.000230017786108415*x_72 + 9.30208922552674e-5*x_73 + 9.62821296852167e-5*x_74 - 0.000165588414022051*x_75 - 0.000419413126307542*x_76 + 2.4124251259035e-6*x_77 - 0.000126897849210559*x_78 + 4.23867461937677e-5*x_79 + 0.00251526558639279*x_8 + 1.44908051215118e-5*x_80 + 6.70883274579292e-5*x_81 + 5.73347784506229e-5*x_82 + 0.000430280560115693*x_83 + 0.000816915351832331*x_86 + 4.43042477372353e-5*x_87 + 1.21390883674534e-5*x_88 - 1.49061944319841e-5*x_89 + 0.000657076960693135*x_9 - 0.000670784192639804*x_91 + 4.23697174790519e-7*x_92 + 0.00193795543005487*x_93 + 0.000138988676194082*x_94 + 3.92942417949114e-5*x_95 - 2.87282488329094e-5*x_96 + 0.000107100837726182*x_97 + 1.77967105888627e-5*x_98 + 7.36740758740922e-6*x_99 + 1.16780833389393e-5*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) - 1.39010516457874e-5*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) - 2.58558319182965e-5*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 2.39219587864714e-6*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 2.05938460525673e-6*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 3.37205437852926e-7*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 1.25520766764322e-5*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) + 3.88539720790123e-7*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) + 4.88970699022355e-5*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 2.95275831273091e-6*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 3.53124750842086e-7*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 1.09725126597545e-5*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) + 1.35992215984689e-5*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 1.97270357302243e-5*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) + 4.81070765281623e-7*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) - 4.65913830260526e-5*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) + 1.15896447357956e-7*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 1.62826507809247e-6*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 1.54590594017419e-7*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 1.22648106611617e-5*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) - 9.68157995615334e-6*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) + 0.00110559759195894*std::pow(-0.0043229292750161*x_100 + 0.00869147318179767*x_101 + 0.00131791453443263*x_102 + 0.0756959214179342*x_103 - 0.0155438407627124*x_104 + 0.0759662156691679*x_106 - 0.015910599643884*x_107 - 0.00290729562570838*x_108 - 0.0354853741521009*x_109 + 0.0631453588297826*x_11 - 0.013261933138645*x_113 - 0.0451823881105474*x_114 + 0.00457962265641701*x_115 - 0.00712735590688522*x_116 + 0.00749431276350499*x_117 - 0.0840398174827042*x_118 - 0.0319220063456728*x_13 - 0.0196669464026884*x_15 + 0.350476150023479*x_16 + 0.0821794385170713*x_17 - 0.00767154833720934*x_19 + 0.00601422597385751*x_2 - 0.0238731042353406*x_22 - 0.0819545692628814*x_24 - 0.0511220202779569*x_25 - 0.134616990047728*x_27 - 0.284845005726628*x_29 - 0.0358603632275907*x_30 - 0.321824207527404*x_31 - 0.0066338000360201*x_32 + 0.0169601943299762*x_33 - 0.00554460661438964*x_34 - 0.0114462317533605*x_35 + 0.142608729735251*x_36 - 0.00570531619757786*x_37 + 0.0140824683695763*x_38 - 0.0107993723939544*x_4 - 0.010638336456958*x_40 - 0.00947484658970124*x_44 - 0.000509479272995045*x_45 + 0.0414656920861391*x_48 + 0.00516440557476916*x_49 - 0.0966082078873504*x_50 + 0.0885111202432786*x_51 + 0.152486499479394*x_52 + 0.0789373171555637*x_53 - 0.00258610580617245*x_55 - 0.00102060536756113*x_56 - 0.133737683111239*x_57 - 0.118269690056066*x_59 - 0.109962668525439*x_6 - 0.00356460815973458*x_60 - 0.158746603646619*x_61 - 0.0332400136224497*x_62 - 0.0267652291492139*x_63 - 0.00267867073984349*x_64 + 0.00149572892063801*x_65 + 0.0137110653484418*x_66 + 0.00588192027070882*x_69 - 0.0114758993983564*x_70 - 0.108511152564476*x_71 - 0.00208266851728816*x_72 + 0.0858049302679547*x_74 + 0.0179555890634892*x_76 + 0.000230095298676692*x_77 + 0.0118109365270979*x_78 - 0.226449758093368*x_8 - 0.00539312497143124*x_80 - 0.0159754273383516*x_81 + 0.187180197140864*x_82 - 0.0137927708879876*x_83 + 0.00761960246707291*x_84 - 0.0206428124263968*x_85 - 0.0468048689861796*x_87 + 0.00155290139094705*x_88 - 0.118641751591516*x_89 + 0.135841442669879*x_90 + 0.12884720865185*x_91 - 0.00917181230943196*x_93 - 0.00039711848125895*x_94 - 0.00338115551913666*x_95 - 0.00894032533167026*x_96 - 0.233554154169479*x_98 - 0.0421938633662662*x_99 + 0.00473408601364431*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) + 0.0040613236920044*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) + 0.00246523407111374*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) - 0.000883348772781317*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) + 0.00665939948932032*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) + 0.001747965810154*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) - 0.297405425701187*std::exp(0.448319852352142*x_20) + 4.49203544085645*std::sin(0.255999982357025*x_1 - 7.38719987869263) + 0.822036980315417*std::sin(0.423519849777222*x_105 + 2.02759981155396) - 0.0748028716197102*std::sin(0.866479873657227*x_110 - 6.98816013336182) + 1.12950001419146*std::sin(0.41967985033989*x_111 + 2.01015996932983) + 1.22618708543608*std::sin(0.344239860773087*x_112 - 4.23336029052734) + 0.819335746872675*std::sin(0.312799841165543*x_119 - 7.45648002624512) - 2.09332617218035*std::sin(0.369039833545685*x_12 + 1.95535981655121) + 1.58921740414587*std::sin(0.257839977741241*x_120 + 5.06311988830566) + 9.09027830727308*std::sin(0.187120005488396*x_18 - 7.60152006149292) - 2.5686416735044*std::sin(0.32847985625267*x_21 + 5.15607976913452) - 0.577177310943096*std::sin(0.250559985637665*x_23 - 7.5303201675415) - 2.80639562390812*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 1.88027634455018*std::sin(0.309999942779541*x_28 + 8.33735942840576) - 0.123808185240022*std::sin(0.772399842739105*x_3 + 7.61152029037476) + 0.0474283191501383*std::sin(1.05911982059479*x_39 + 8.42039966583252) + 1.18573960569199*std::sin(0.349519848823547*x_41 - 1.24535989761353) + 1.33886114204398*std::sin(0.357599824666977*x_42 + 1.97287976741791) + 0.479888554702882*std::sin(0.530159831047058*x_43 - 4.43088006973267) + 4.77373360790855*std::sin(0.172400012612343*x_46 + 1.75647985935211) - 0.664224796951778*std::sin(0.468639850616455*x_47 + 5.26352024078369) - 0.496542825717675*std::sin(0.680319845676422*x_54 - 4.14432001113892) - 6.24775844329832*std::sin(0.152720034122467*x_58 + 4.94431972503662) + 0.574594144127353*std::sin(0.427359849214554*x_73 + 2.01815986633301) - 0.775607797722252*std::sin(0.26639997959137*x_75 - 4.31455993652344) + 1.04698806948382*std::sin(0.292479932308197*x_79 + 5.12367963790894) + 0.00658966809325662*std::sin(1.34455978870392*x_86 + 1.38687980175018) + 1.10444231006778*std::sin(0.506479859352112*x_9 - 0.87367981672287) - 3.05355037024947*std::sin(0.409839868545532*x_92 - 7.41232013702393) - 0.627737952261199*std::sin(0.263759940862656*x_97 + 8.28248023986816) - 13.3483290940779, 2) + 0.000593487000600149*std::exp(0.429519861936569*x_29) - 2.23856694310446e-5*std::exp(0.69871985912323*x_85) + 0.00189794215776596*std::sin(0.788719892501831*x_1 + 1.20735991001129) + 0.0130118798717029*std::sin(0.328959852457047*x_102 - 4.24408006668091) + 0.000235987191281166*std::sin(0.308319926261902*x_104 - 4.26287984848022) - 0.0455293342188898*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.000243832443558619*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.000157527157189679*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.00102877434024179*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 1.00530724921365e-5*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.000304033139072937*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 9.29696523174286e-5*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.000458253479896883*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.00448630940739557*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 6.33686070781122e-5*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.0500649898004644*std::sin(0.340559840202332*x_12 - 4.26471996307373) - 0.000952204229881033*std::sin(0.180560007691383*x_120 - 7.61552000045776) + 0.000296820150322388*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 0.000175468783428377*std::sin(0.39183983206749*x_16 + 1.99935972690582) - 0.0432496754348311*std::sin(0.231519997119904*x_18 - 7.55200004577637) + 0.000177827864379508*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.0253734563125682*std::sin(0.302399933338165*x_21 - 4.28687953948975) - 0.000569595604319528*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 0.000352928784828805*std::sin(1.528639793396*x_22 - 1.98135983943939) + 0.00137468230744461*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.000868829534820732*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 0.0217487223903326*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.000286158296262418*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.0477231644289271*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.000480228537839718*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 2.40257315858444e-5*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.000352503994716836*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.000261132188661499*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.000273830697423054*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.000127715967854258*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.000344116927322583*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.00013275049624159*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.000140625229983389*std::sin(0.309039950370789*x_47 + 8.0740795135498) - 0.00535037749520284*std::sin(0.476639837026596*x_48 - 7.32263994216919) + 7.45731276294876e-5*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.018072470300151*std::sin(0.282959938049316*x_51 + 5.09143972396851) + 0.000466202744817517*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.000681905870204273*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.000306026257022483*std::sin(0.478079855442047*x_58 - 1.11911988258362) + 0.000261456541885194*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.000250115669280354*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.000650918505026787*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.000942258658944389*std::sin(1.25287985801697*x_7 + 9.62911987304688) + 0.00088629415143526*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.000273901482037017*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 6.83181102675309e-6*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.000735208575988329*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.000685267084509463*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.000270664449988802*std::sin(0.358319848775864*x_84 - 7.4423999786377) - 0.00747590793995977*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.000255074975374944*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.000139146446279189*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.0155720451466083*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.000426977301854613*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.000359152401390208*std::sin(0.315439850091934*x_97 - 7.45576000213623) - 0.0546022318303585*std::sin(0.00873880815622567*x_10 + 0.0217172289706078*x_100 - 0.06662454163622*x_101 - 0.00312326146968*x_102 - 0.0029580545374492*x_103 + 0.0386989365442875*x_104 + 0.00445946245825011*x_105 + 0.0033893021068064*x_106 + 0.0016992679440592*x_108 + 0.000698581541101105*x_11 + 0.00646261453158025*x_113 - 0.000360396341275406*x_115 + 0.000581829578243486*x_116 - 0.00136308021544069*x_119 + 0.0338763264624999*x_12 + 0.0376236401205369*x_120 + 0.0412688732021481*x_13 - 0.0443814780229598*x_14 + 0.00136667124284813*x_15 + 0.0033697554247706*x_17 + 0.000243533757829412*x_18 + 0.00181585106641464*x_19 - 0.00896362364384434*x_20 - 0.0233250486572178*x_22 - 0.00896257197977318*x_24 - 0.0708067704882443*x_25 - 0.0343845804541371*x_27 + 0.005537014909021*x_28 - 0.06671891920671*x_29 + 0.0356784330953933*x_3 + 0.000473297885039438*x_30 + 0.0920560974253871*x_31 - 0.00214489392882781*x_32 + 0.0210861999271741*x_33 + 0.0544112425515102*x_34 + 0.000866977712364412*x_38 + 0.012851794829034*x_4 + 0.00135139140966386*x_42 + 0.0183886728864741*x_43 + 0.0101847642484754*x_44 + 0.00183591410664398*x_47 - 0.00394177239438035*x_48 - 0.00199145594433355*x_5 - 0.000587100958343426*x_51 - 0.0377077911265812*x_52 - 0.00259979610373172*x_57 + 0.000328027349960056*x_59 + 0.00608748361927986*x_6 - 0.0283234226211235*x_61 - 0.00478709965953072*x_63 - 0.0510407401322628*x_66 + 0.0320522243235556*x_68 - 0.00275179133587167*x_72 - 0.0354256930432722*x_73 + 0.000241533338203636*x_74 - 0.000446706355811009*x_76 + 0.0100253752366374*x_77 - 0.00138396141813336*x_8 + 0.0148581877379562*x_80 + 0.00103651854051527*x_82 + 6.96797387946605e-5*x_85 - 0.00148458148124108*x_86 + 0.0101742382784233*x_89 + 0.0129192821596652*x_9 + 0.000791608263063891*x_90 - 0.0899377908641915*x_91 + 0.0263482520430157*x_95 + 0.00012083628913335*x_96 - 0.0338033649078079*x_99 + 2.04167914200735e-5*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) - 0.000679490900590544*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 0.00090542356116434*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) + 0.000152353259972721*std::pow(-8.0*x_54 - 9.99971961975098, 2) - 0.000321813029467117*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) - 0.000358191471456659*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) - 0.000148871458104242*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) - 0.000746249634245612*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) + 0.000222085068592667*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 0.000256683204304692*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) + 0.000159452123884565*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) - 0.000439642296723192*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) - 0.0397476212347081*std::exp(0.594239830970764*x_2) - 0.307141769902817*std::sin(0.431519865989685*x_107 + 5.2052001953125) + 0.203414787990118*std::sin(0.450319856405258*x_109 - 4.15903997421265) + 0.0325856595555267*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.129659547052874*std::sin(0.359679847955704*x_111 - 7.42783975601196) - 0.22029811346553*std::sin(0.346559852361679*x_112 - 7.43415975570679) + 0.381357535795608*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 0.00832931637453305*std::sin(1.12887978553772*x_117 + 0.991439819335938) - 0.128612631293313*std::sin(0.407119870185852*x_118 - 1.19191980361938) - 0.233995975643701*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.401020338408021*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 0.912657520248828*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.489488927030848*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 0.139285381079423*std::sin(0.258239984512329*x_35 - 4.14152002334595) - 0.463144766477221*std::sin(0.371439844369888*x_36 + 5.18383979797363) + 0.301957371536908*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.141455319367468*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 0.117791960496463*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.0100839929898752*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.541044126320386*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.00577547836076708*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.165332382885465*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 0.411983847652841*std::sin(0.354879856109619*x_53 + 5.16688013076782) + 0.285537454647216*std::sin(0.377519845962524*x_55 - 4.21208000183105) + 0.306031796130043*std::sin(0.320719838142395*x_56 + 8.30823993682861) - 0.276001566180962*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 0.691097706661338*std::sin(0.19480000436306*x_64 - 4.4093599319458) - 0.176425023459494*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 0.357174649472249*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 0.442148357330204*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.0551011756109512*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 0.606005230108629*std::sin(0.234479993581772*x_83 - 4.34055948257446) + 0.163776052130043*std::sin(0.404559850692749*x_84 - 4.1814398765564) - 1.21137590357229*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 0.586178916448382*std::sin(0.317679852247238*x_92 - 4.21264028549194) + 0.278404960007588*std::sin(0.353039860725403*x_93 - 7.41192007064819) + 0.233989760696481*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.512640658806134*std::sin(0.335919857025146*x_97 - 7.4507999420166) - 0.286209037630282*std::sin(0.446159869432449*x_98 - 7.38191986083984) + 0.451693300568636) - 0.0363268479704857*std::sin(-0.027301936765715*x_100 - 0.000186325850961482*x_101 + 0.000112458388758883*x_104 - 0.00536856539193772*x_105 - 0.00824084882138139*x_106 - 0.00193465656799699*x_107 + 0.00178852834747537*x_108 + 0.000553548026227646*x_11 - 0.000833981322415103*x_112 - 0.0506996268789219*x_113 + 0.0311646187167961*x_114 - 0.0227196922388203*x_116 - 0.000189716492903504*x_118 - 0.00192252902238672*x_119 - 0.0346979786909299*x_13 + 0.00713974268304649*x_14 + 0.000888166522118689*x_16 + 0.00849056271937357*x_18 - 0.00496891183404155*x_20 + 0.0174878339892581*x_23 - 0.0257903225459702*x_25 - 0.0434901030097576*x_26 - 3.3715411026441e-5*x_28 + 0.0077965608787048*x_3 + 0.0554331591061639*x_31 + 0.00219618693446035*x_32 + 0.00554902362539885*x_33 + 0.00015459814931659*x_34 - 0.00791399177727922*x_37 + 0.0531231023801969*x_4 - 0.0125738684025165*x_40 - 0.000344810511839847*x_42 - 0.00135207000421294*x_44 + 0.0014769198250374*x_45 + 0.00124220995503683*x_46 - 0.0345072722458923*x_47 + 5.94685999130926e-5*x_48 + 0.00225241315400562*x_49 + 0.00129381378222873*x_5 - 0.016098449400277*x_50 + 0.0116690536237921*x_51 - 0.00114566917627186*x_52 + 0.000715083963420059*x_54 - 0.00818124894904512*x_56 + 0.00368927490165024*x_57 + 0.0135286009694414*x_58 - 0.00594070011332373*x_59 + 0.00646759307042846*x_6 + 0.0074146210139876*x_60 - 0.00210362612708455*x_61 + 0.000253435771718722*x_62 - 0.000656696667433624*x_64 + 0.00549547429066141*x_65 + 0.000489396388266139*x_66 - 0.00952864122758844*x_68 + 0.000362108113652434*x_69 + 0.00140361029139109*x_7 - 0.0101404221059223*x_72 + 0.0153931318407485*x_74 - 0.00181469240839025*x_78 - 0.0273267376859169*x_8 - 8.94412155584085e-5*x_83 + 0.0129987276768845*x_84 - 0.00133215897501251*x_85 + 0.0313370559880803*x_88 - 0.000265181582617333*x_89 - 0.00167429172196212*x_90 + 0.00348436582513841*x_93 - 0.0149752108015639*x_94 + 0.000800330618412775*x_95 + 0.000595246754352976*x_96 + 0.0354232934446714*x_97 + 0.0239128477140829*x_98 + 0.0179003520683949*x_99 + 0.000665710180621004*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 0.000352377531360578*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 0.00182967078682741*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) + 0.00137109722495371*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) + 0.000185524091593363*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 0.000133217087413168*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 0.000351934921986347*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) + 5.42215891386924e-5*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 0.0139577485866332*std::exp(0.641439855098724*x_71) + 0.00689665747034529*std::log(8.06023979187012*x_91 + 9.42432022094727) - 0.643459528601618*std::sin(0.281039953231812*x_1 + 5.1756796836853) + 0.0511780721595456*std::sin(0.328399837017059*x_102 - 4.43911981582642) + 0.0245368003399862*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.134047022432693*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.00970785687933506*std::sin(1.31879985332489*x_110 - 0.19039985537529) + 0.0306852389947676*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.0448404378296621*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 0.666128524914022*std::sin(0.325919836759567*x_12 - 7.46208000183105) - 0.374733032444492*std::sin(0.333279848098755*x_120 - 4.27167987823486) + 0.133078795736278*std::sin(0.346559852361679*x_15 + 1.93543982505798) + 0.0417806398077767*std::sin(0.676799833774567*x_19 + 5.45519971847534) - 0.416860186590743*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.308323750311395*std::sin(0.298479825258255*x_22 - 1.12871980667114) + 0.867669817387267*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.0339520914043261*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.679717519588522*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 0.295650101579096*std::sin(0.327759832143784*x_35 - 1.21751987934113) + 0.169686232735268*std::sin(0.364079833030701*x_36 - 7.4255199432373) - 0.421248024856922*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.00687789396901795*std::sin(1.43327987194061*x_39 - 7.78567981719971) - 0.429500836215212*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.139080603297932*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.45244375040928*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.435422089920252*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.00558165220948276*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 0.463912805272411*std::sin(0.262719959020615*x_73 - 7.51200008392334) + 0.0269943468642773*std::sin(0.959439814090729*x_76 + 5.5699200630188) - 0.193551272860645*std::sin(0.437359839677811*x_77 - 4.15848016738892) + 0.341231257169937*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 1.18260268211692*std::sin(0.154000028967857*x_80 - 7.65791988372803) - 0.12143124857246*std::sin(0.426799863576889*x_81 - 4.15999984741211) - 0.143010610551308*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 0.475879154161877*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 0.267904900553837*std::sin(0.283919870853424*x_87 - 1.28575992584229) - 0.150208493534276*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.501344730037875*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 5.33589390539741) + 0.0378227338760966);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.13783273771546e-5*x_10 + 0.000886396592358731*x_100 + 8.7318711568207e-6*x_101 - 4.48992312354745e-5*x_103 + 5.57767884878268e-6*x_104 + 0.000171321007877247*x_105 + 0.00026961584858526*x_106 + 6.329615839429e-5*x_107 - 0.000157865732815487*x_108 + 5.17708008751432e-5*x_109 + 5.7360883814734e-6*x_11 - 0.000111310049939347*x_111 + 3.2653131426336e-5*x_112 + 0.0016544561719137*x_113 - 0.00102198331722832*x_114 + 0.000728116459828854*x_116 - 1.70333042775883e-6*x_117 - 0.000168107462694952*x_118 + 6.05496796563013e-5*x_119 - 2.95025881143482e-6*x_120 + 0.00113521375913072*x_13 - 0.000259170225716015*x_14 + 6.39742147663527e-5*x_16 + 6.23098656899338e-5*x_17 - 0.000277785738116058*x_18 - 8.04128880376281e-6*x_19 - 6.70769810866324e-6*x_2 - 5.09766586993544e-6*x_20 - 0.000589661167433065*x_23 + 0.000843781975526367*x_25 + 0.00139923388433483*x_26 + 1.10306709312633e-6*x_28 - 0.000255080080088919*x_3 - 6.6552079432965e-7*x_30 - 0.00177511678574043*x_31 - 0.00014211664300923*x_32 - 0.000198021361469983*x_33 + 9.93801389197668e-7*x_34 + 7.94788330721715e-6*x_35 - 1.06318600003165e-5*x_36 + 0.000241669947338941*x_37 + 9.17426802068052e-6*x_38 - 2.4042024477902e-5*x_39 - 0.00184542618901532*x_4 + 0.000407798170768448*x_40 - 5.68142099270593e-6*x_41 - 2.7287081917464e-7*x_42 + 2.69384063962714e-7*x_43 - 2.5951695587524e-5*x_44 - 8.90114096377962e-5*x_45 - 4.06413827516582e-5*x_46 + 0.00111231988762298*x_47 - 1.94563416673115e-6*x_48 - 7.36922005298999e-5*x_49 - 4.23297051514687e-5*x_5 + 0.00050639877630155*x_50 - 0.000381776424147315*x_51 + 2.00574241839331e-5*x_52 - 1.48316875834734e-6*x_53 - 3.20789061140775e-5*x_54 + 6.32282546219098e-6*x_55 + 0.000269131640605031*x_56 - 0.000126266728067457*x_57 - 0.000442615234135053*x_58 + 0.000284678758991864*x_59 - 0.000211600240677078*x_6 - 0.000422061971224841*x_60 + 6.76824257975689e-5*x_61 - 0.000109303344060538*x_62 + 0.00019800816903892*x_63 + 1.87834528864771e-5*x_64 - 0.000172970612470661*x_65 - 1.53558756720032e-5*x_66 - 3.47481418856626e-5*x_67 + 0.000311515428482294*x_68 - 1.46569307128646e-5*x_69 - 4.59219175110384e-5*x_7 + 0.000156124220348287*x_70 - 6.56408699712897e-6*x_71 + 0.00031756400089804*x_72 - 7.38895133994395e-6*x_73 - 0.000511265092142602*x_74 + 1.31496439089817e-5*x_75 + 3.33153456872449e-5*x_76 - 6.34693063796841e-8*x_77 + 6.54595642557749e-5*x_78 - 3.69458099290422e-6*x_79 + 0.000693954745345663*x_8 - 1.15105167584972e-6*x_80 - 5.32904356264971e-6*x_81 - 4.51977429113388e-6*x_82 - 3.4441356533072e-5*x_83 - 0.000425279369770605*x_84 + 4.35842448130557e-5*x_85 - 6.47097380473202e-5*x_86 - 3.51923017234568e-6*x_87 - 0.00102591670178523*x_88 + 9.92051203034707e-6*x_89 - 5.56479085573975e-5*x_9 + 5.47778017993569e-5*x_90 + 5.36959288883387e-5*x_91 - 0.000269978325325466*x_93 + 0.000478912018030968*x_94 - 2.93056857609171e-5*x_95 - 1.71550970158811e-5*x_96 - 0.00116745124882654*x_97 - 0.000784260314589689*x_98 - 0.000586173544005484*x_99 - 2.17800397932663e-5*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 9.27628056914775e-7*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 1.10420564342582e-6*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 1.15287355950107e-5*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 2.05381263570114e-6*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 5.98613386211157e-5*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) - 4.48581875254961e-5*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) - 9.97052183964091e-7*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 3.88405294137562e-6*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 6.0697916527935e-6*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) - 8.71582288174126e-7*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 1.08023030327911e-6*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) + 1.56698246553004e-6*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 4.35846341165344e-6*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 3.70090475046695e-6*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) - 1.15142547442377e-5*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 1.773967716692e-6*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) + 9.74233712145649e-7*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 7.69039314237957e-7*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) - 4.7142598420684e-5*std::exp(0.429519861936569*x_29) + 0.000456655656606745*std::exp(0.641439855098724*x_71) - 0.000225637940529204*std::log(8.06023979187012*x_91 + 9.42432022094727) + 0.0210520652173686*std::sin(0.281039953231812*x_1 + 5.1756796836853) - 0.000150759704726083*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.00167439297253612*std::sin(0.328399837017059*x_102 - 4.43911981582642) - 0.0010335758439015*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 0.000802770489863631*std::sin(0.735199868679047*x_103 - 1.60527980327606) + 0.0036165427671908*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.0043856163954552*std::sin(0.50519984960556*x_109 + 5.25952005386353) - 0.000317611950807202*std::sin(1.31879985332489*x_110 - 0.19039985537529) - 0.00100392895561321*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 0.000356362115041974*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 0.00146704459193712*std::sin(0.68071985244751*x_117 + 8.02408027648926) + 0.0217937267633841*std::sin(0.325919836759567*x_12 - 7.46208000183105) + 0.00397682460898427*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0122601405177232*std::sin(0.333279848098755*x_120 - 4.27167987823486) - 0.00435393892289928*std::sin(0.346559852361679*x_15 + 1.93543982505798) - 2.35773877703563e-5*std::sin(1.99319982528687*x_15 - 8.39608001708984) + 0.00343546207210499*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 0.00136693718091051*std::sin(0.676799833774567*x_19 + 5.45519971847534) + 0.0136384146081487*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.00201549597594989*std::sin(0.302399933338165*x_21 - 4.28687953948975) - 0.0100874280527406*std::sin(0.298479825258255*x_22 - 1.12871980667114) - 2.80342786909563e-5*std::sin(1.528639793396*x_22 - 1.98135983943939) - 0.0283875531728868*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 6.90139494456742e-5*std::sin(1.65511989593506*x_27 - 3.5927197933197) + 0.00172757159764845*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.00111081056498343*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.00379080582011423*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.0222383178983506*std::sin(0.292639940977097*x_30 - 4.29711961746216) + 0.00967278429070906*std::sin(0.327759832143784*x_35 - 1.21751987934113) - 0.00555162442896098*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.0137819715114766*std::sin(0.323279827833176*x_38 + 5.11079978942871) + 0.000225024055061523*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 0.0140519787383785*std::sin(0.278159946203232*x_41 + 5.10127973556519) + 0.00455030005921601*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.000424997847299689*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.00143555496408213*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.0148026020556518*std::sin(0.241439983248711*x_53 + 5.06199979782104) - 2.07683415914592e-5*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.0142457043941909*std::sin(0.237039983272552*x_63 - 4.33999967575073) - 0.000182614913777198*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 7.48466630644116e-5*std::sin(1.25287985801697*x_7 + 9.62911987304688) + 0.0151778351204024*std::sin(0.262719959020615*x_73 - 7.51200008392334) - 0.000883174038811812*std::sin(0.959439814090729*x_76 + 5.5699200630188) + 0.00633241694007106*std::sin(0.437359839677811*x_77 - 4.15848016738892) - 0.0111640629454316*std::sin(0.307599931955338*x_79 + 5.1352801322937) + 0.0386912116202019*std::sin(0.154000028967857*x_80 - 7.65791988372803) + 0.00397286612559692*std::sin(0.426799863576889*x_81 - 4.15999984741211) + 0.00467887810542599*std::sin(0.464319854974747*x_82 + 5.2532000541687) + 0.000593835628222921*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.0155693381536737*std::sin(0.286079943180084*x_86 + 5.12367963790894) + 0.00876504455652235*std::sin(0.283919870853424*x_87 - 1.28575992584229) + 0.00491437124096746*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.001236938079845*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.0164024953924894*std::sin(0.380959838628769*x_92 + 1.97975981235504) + 0.0478917770087719*std::sin(-0.149281180464682*x_1 + 0.0519664013253092*x_10 - 0.00350782303095488*x_100 + 0.00244267265280183*x_101 - 0.0587812640483534*x_102 - 0.00301712642147991*x_103 - 0.000152318687545844*x_105 + 0.00135522567883716*x_106 + 0.000623721346134167*x_107 - 0.0132461053108577*x_113 + 0.00341668542022161*x_114 + 0.00470227384737002*x_116 + 0.00923363261383201*x_117 + 0.000632196624127333*x_119 + 0.00740797594496265*x_12 + 0.0229486767131242*x_13 - 0.00501820003201341*x_14 - 0.0637598864193288*x_17 + 0.0172004326992351*x_20 - 0.04546665460796*x_22 - 0.0878682662920289*x_25 + 0.000272178686496452*x_26 + 0.00824923981155538*x_27 - 0.00326680747235945*x_29 - 0.0177517816800082*x_3 - 0.0227517742722656*x_31 - 0.000561783267977813*x_34 - 0.00178522876043274*x_36 - 0.00446562650433238*x_37 - 0.0134057451666014*x_38 + 8.46041061347493e-5*x_39 - 0.028413176930792*x_41 + 0.000722824076316297*x_42 - 0.000191331690119053*x_49 - 0.0226575729099955*x_5 - 0.0640341189489261*x_50 - 0.00199808775235114*x_51 + 0.00160305230195379*x_52 - 0.00758063021564025*x_53 + 0.00497135242927155*x_56 + 0.025176241037991*x_59 - 0.0158819954418062*x_6 + 0.00113400422415245*x_61 + 0.00512753914814589*x_62 - 0.048935832010698*x_63 + 0.000649381347268937*x_66 - 0.00252979315381489*x_67 + 0.0399160229306172*x_68 - 0.00897442184079948*x_69 + 0.0019716230964713*x_71 + 0.0474698119871416*x_72 - 4.17595617461009e-5*x_75 + 0.00149442397865563*x_77 - 0.0465458281948058*x_78 - 0.00382084087418045*x_79 - 0.00347978120937126*x_8 + 0.000402453282991787*x_82 - 0.0371867046185858*x_83 + 0.00210477496025245*x_86 + 0.00352154442254807*x_88 + 0.000705701067233966*x_89 - 0.0402783406989203*x_9 + 0.00482016900090872*x_91 + 0.000392453171711826*x_92 - 0.0238142505716366*x_93 + 9.76247458741081e-5*x_94 + 0.000438597527426349*x_96 - 0.00571418810838928*x_98 + 0.000670343474165093*x_99 - 0.00221579211708267*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.00190752279740147*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 0.000312339452509414*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 0.000359888275949682*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.00273501791864117*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 0.000327084853814386*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 0.000445595955993694*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 0.000107350086481578*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.00150819460762497*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 0.000143190874399735*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.0207349198716029*std::exp(0.69871985912323*x_85) + 0.218585176423346*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.225851909180506*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.14591089142948*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.952911128102869*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.00931174532126278*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.281613323935119*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.086113944335267*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.424461248112948*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.0586957202324072*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.881987401306105*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.162529477868077*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.164714596997214*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.527592853596047*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 1.27331137367037*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.265056596224326*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.444815835543181*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.0222540416235333*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.326509873085911*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.241875947666927*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.253638051206906*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.118298019540561*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.318741279391929*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.122961294991143*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.130255335209569*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.0690740042747109*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.431824323480214*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.631621208479601*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.283459466669683*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.23167180133413*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.602918893546985*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.820937621244184*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.253703616067639*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.00632802403582389*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.68099330060204*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.634734562293033*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.250705287143489*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.236265401485639*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.128885599017025*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.395491417767062*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.332668017253582*std::sin(0.315439850091934*x_97 - 7.45576000213623) - 3.03918748532791) - 0.00952091813087463*std::sin(0.0145791861730826*x_10 + 0.0362314309532461*x_100 - 0.111151495586816*x_101 - 0.00521062021498216*x_102 - 0.00493500109404278*x_103 + 0.0645624655551609*x_104 + 0.00743983987843732*x_105 + 0.00565446288882642*x_106 + 0.00283493392594287*x_108 + 0.0011654621731839*x_11 + 0.0107817517831255*x_113 - 0.000601258805734135*x_115 + 0.000970681766960954*x_116 - 0.00227406299285765*x_119 + 0.0565167768335842*x_12 + 0.0627685199194575*x_120 + 0.0688499592634747*x_13 - 0.0740428007075931*x_14 + 0.00228005399943313*x_15 + 0.00562185263907939*x_17 + 0.000406293848240159*x_18 + 0.00302943265106345*x_19 - 0.0149542518330662*x_20 - 0.0389137993179911*x_22 - 0.0149524973139132*x_24 - 0.118128819263233*x_25 - 0.0573647104916783*x_27 + 0.009237549304048*x_28 - 0.111308948198904*x_29 + 0.0595232792804862*x_3 + 0.000789615455329609*x_30 + 0.153579636803906*x_31 - 0.00357838361374457*x_32 + 0.0351786684093873*x_33 + 0.0907757237469601*x_34 + 0.00144640198646188*x_38 + 0.0214409912794874*x_4 + 0.00225456224715928*x_42 + 0.0306783122704016*x_43 + 0.0169915131964186*x_44 + 0.00306290435492425*x_47 - 0.00657616376995847*x_48 - 0.00332239894146741*x_5 - 0.000979476150644884*x_51 - 0.0629089112819682*x_52 - 0.00433730901637393*x_57 + 0.000547256756234377*x_59 + 0.0101559109004864*x_6 - 0.047252719600908*x_61 - 0.00798644573924853*x_63 - 0.0851526248771186*x_66 + 0.0534735786986713*x_68 - 0.00459088670650899*x_72 - 0.0591016263265142*x_73 + 0.000402956494950433*x_74 - 0.000745252099558714*x_76 + 0.0167256002668763*x_77 - 0.00230889965892605*x_8 + 0.0247883099564273*x_80 + 0.00172925146128288*x_82 + 0.000116248562300272*x_85 - 0.00247676678755157*x_86 + 0.0169739524405009*x_89 + 0.021553582188912*x_9 + 0.00132066112873036*x_90 - 0.150045609603031*x_91 + 0.0439574899692432*x_95 + 0.0002015943964263*x_96 - 0.0563950531304983*x_99 + 3.40618763850753e-5*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) - 0.00113361274964797*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 0.00151054221899885*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) + 0.000254174997495048*std::pow(-8.0*x_54 - 9.99971961975098, 2) - 0.000536889240002635*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) - 0.000597580362747374*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) - 0.000248366214792548*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) - 0.00124498812135047*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) + 0.000370510429270339*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) + 0.000428231419681124*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) + 0.00026601822104887*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) - 0.000733466941818917*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) - 0.0663120141280531*std::exp(0.594239830970764*x_2) - 0.512412787292185*std::sin(0.431519865989685*x_107 + 5.2052001953125) + 0.339362303354068*std::sin(0.450319856405258*x_109 - 4.15903997421265) + 0.0543635228900481*std::sin(1.160719871521*x_110 - 7.00648021697998) + 0.216314472386571*std::sin(0.359679847955704*x_111 - 7.42783975601196) - 0.367529204483649*std::sin(0.346559852361679*x_112 - 7.43415975570679) + 0.636228924296873*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 0.0138960201377474*std::sin(1.12887978553772*x_117 + 0.991439819335938) - 0.2145678749681*std::sin(0.407119870185852*x_118 - 1.19191980361938) - 0.390381712434234*std::sin(0.355999857187271*x_16 - 4.24599981307983) + 0.669032901091661*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 1.52261082542387*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.816627401502245*std::sin(0.343999862670898*x_26 + 5.15880012512207) + 0.232373507421489*std::sin(0.258239984512329*x_35 - 4.14152002334595) - 0.772676737473617*std::sin(0.371439844369888*x_36 + 5.18383979797363) + 0.503763517549586*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.235993673206107*std::sin(0.33791983127594*x_39 + 5.16007995605469) - 0.196515461956547*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.0168233938243298*std::sin(1.41703987121582*x_41 + 4.79800033569336) - 0.902638312280402*std::sin(0.266319960355759*x_45 - 7.53560018539429) + 0.0096353842257364*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.275828413604589*std::sin(0.3642398416996*x_49 + 1.96791982650757) - 0.687323615286672*std::sin(0.354879856109619*x_53 + 5.16688013076782) + 0.476369733294142*std::sin(0.377519845962524*x_55 - 4.21208000183105) + 0.510560988512395*std::sin(0.320719838142395*x_56 + 8.30823993682861) - 0.460460756830777*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 1.15297669305488*std::sin(0.19480000436306*x_64 - 4.4093599319458) - 0.294334561032102*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 0.595883971574736*std::sin(0.419119864702225*x_75 - 7.36639976501465) + 0.737647869411958*std::sin(0.213599994778633*x_78 + 5.01663970947266) + 0.0919267574280678*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 1.01101465024395*std::sin(0.234479993581772*x_83 - 4.34055948257446) + 0.273231945593785*std::sin(0.404559850692749*x_84 - 4.1814398765564) - 2.02097065275254*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 0.977937883617287*std::sin(0.317679852247238*x_92 - 4.21264028549194) + 0.464470402702297*std::sin(0.353039860725403*x_93 - 7.41192007064819) + 0.390371343872417*std::sin(0.43495985865593*x_94 + 2.01871991157532) - 0.855252051654418*std::sin(0.335919857025146*x_97 - 7.4507999420166) - 0.477490153054568*std::sin(0.446159869432449*x_98 - 7.38191986083984) - 18.4234062544507) + 0.00898415595293045*std::sin(0.00144030344058632*x_100 - 0.00289580465723912*x_101 - 0.000439099674684121*x_102 - 0.0252201896262105*x_103 + 0.00517886042222545*x_104 - 0.0253102456311219*x_106 + 0.00530105628637478*x_107 + 0.000968645940314106*x_108 + 0.0118229337632579*x_109 - 0.0210386226083366*x_11 + 0.00441857979005335*x_113 + 0.0150537621389343*x_114 - 0.00152582793957459*x_115 + 0.00237467573071313*x_116 - 0.00249693755585812*x_117 + 0.0280001893545054*x_118 + 0.0106356992319565*x_13 + 0.00655258709258283*x_15 - 0.116770821960853*x_16 - 0.0273803526524614*x_17 + 0.00255598848876975*x_19 - 0.00200380570940022*x_2 + 0.00795398489777718*x_22 + 0.0273054312415645*x_24 + 0.01703271485879*x_25 + 0.0448513731297156*x_27 + 0.0949039911786122*x_29 + 0.0119478717442542*x_30 + 0.107224634935523*x_31 + 0.00221023394281782*x_32 - 0.00565075778307438*x_33 + 0.00184733903225223*x_34 + 0.00381362865948162*x_35 - 0.0475140422218826*x_36 + 0.00190088387438947*x_37 - 0.00469196379452062*x_38 + 0.0035981095746998*x_4 + 0.00354445599876591*x_40 + 0.00315680717263723*x_44 + 0.000169747109683965*x_45 - 0.0138154420714497*x_48 - 0.00172066454126652*x_49 + 0.032187696202481*x_50 - 0.029489927525143*x_51 - 0.0508050943864489*x_52 - 0.0263001502585047*x_53 + 0.000861632669282235*x_55 + 0.000340042903517935*x_56 + 0.0445584077061829*x_57 + 0.0394048180453279*x_59 + 0.0366371040878649*x_6 + 0.00118764778930802*x_60 + 0.052890821215845*x_61 + 0.0110748298063174*x_62 + 0.00891757629589038*x_63 + 0.000892473236860928*x_64 - 0.000498343454987793*x_65 - 0.00456822060670681*x_66 - 0.00195972440542063*x_69 + 0.00382351325588451*x_70 + 0.0361534914031228*x_71 + 0.000693898613698644*x_72 - 0.0285882854939246*x_74 - 0.00598240106664742*x_76 - 7.66626121463766e-5*x_77 - 0.00393514014093196*x_78 + 0.0754479994819263*x_8 + 0.00179686873360552*x_80 + 0.00532265542562663*x_81 - 0.0623642592326723*x_82 + 0.00459544306681108*x_83 - 0.00253868128554665*x_84 + 0.00687772384640892*x_85 + 0.0155943365131125*x_87 - 0.000517392044602439*x_88 + 0.0395287806353973*x_89 - 0.0452593333835905*x_90 - 0.0429290108916974*x_91 + 0.00305584292161191*x_93 + 0.00013231100452726*x_94 + 0.00112652546862493*x_95 + 0.00297871663309083*x_96 + 0.0778150255100523*x_98 + 0.0140580524713387*x_99 - 0.00157729167879067*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 0.00135314230578221*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 0.000821360907983515*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 0.000294312073072234*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 0.00221876310864955*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 0.000582383150458249*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 0.0990888424573785*std::exp(0.448319852352142*x_20) - 1.49664583644551*std::sin(0.255999982357025*x_1 - 7.38719987869263) - 0.273884353806153*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.0249226453882256*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 0.376324166574804*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.408538138285763*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.272984363180839*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.697449506168368*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.52949172873582*std::sin(0.257839977741241*x_120 + 5.06311988830566) - 3.02867761393202*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.855814010505185*std::sin(0.32847985625267*x_21 + 5.15607976913452) + 0.192302583247006*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 0.935028314277986*std::sin(0.347119837999344*x_26 + 5.14224004745483) - 0.62646606410155*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.0412501208855165*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.0158020561770389*std::sin(1.05911982059479*x_39 + 8.42039966583252) - 0.3950619418152*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.446078616297996*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.159888143539888*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 1.59050137129242*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.221304860549409*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.165436974510058*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 2.08161351004321*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 0.191441929783664*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.258415187604655*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.348833030289342*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.00219553016559682*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.367975499463569*std::sin(0.506479859352112*x_9 - 0.87367981672287) + 1.01737475320078*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.209148259180125*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 3.44399636334264) + 0.142862908890964);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.78022728030783e-6*x_10 + 0.000137557435259752*x_100 - 5.32380415181247e-5*x_101 - 8.29681269338508e-6*x_102 - 0.000488676640888026*x_103 + 9.98956098578808e-5*x_104 + 2.08924957130708e-5*x_105 - 0.000444374195471772*x_106 + 0.000108113878559436*x_107 - 1.59091860705115e-5*x_108 + 0.000237392669294002*x_109 - 0.000393353075555135*x_11 - 3.0095777648133e-5*x_111 + 4.87842249063529e-6*x_112 + 0.000290672220502347*x_113 + 0.000155735297147963*x_114 - 2.88306034981489e-5*x_115 + 0.000134121407672368*x_116 - 4.76403164340395e-5*x_117 + 0.000482713969863446*x_118 + 7.26498274454625e-6*x_119 - 7.97684784453603e-7*x_120 + 0.000343547282658068*x_13 - 3.62555677436889e-5*x_14 + 0.000123811496338188*x_15 - 0.00218488702191359*x_16 - 0.000500506070430801*x_17 - 3.48904534639971e-5*x_18 + 4.61213573921448e-5*x_19 - 3.9675633288606e-5*x_2 - 2.49142031268358e-5*x_20 + 0.000150290985549795*x_22 - 7.65979141277385e-5*x_23 + 0.000515937636907473*x_24 + 0.000427814823006633*x_25 + 0.000172325305721615*x_26 + 0.000847469181492955*x_27 + 1.38547469504396e-7*x_28 + 0.0017932161740499*x_29 - 3.20385766536968e-5*x_3 + 0.000225575756788263*x_30 + 0.00180862954721992*x_31 + 1.37398226220188e-5*x_32 - 0.000134028298566579*x_33 + 3.59065498951063e-5*x_34 + 7.42076569234013e-5*x_35 - 0.000900655081576069*x_36 + 6.37738523319389e-5*x_37 - 8.61743966535629e-5*x_38 - 6.50043211095658e-6*x_39 - 0.000179351391251305*x_4 + 0.000117674518192279*x_40 - 1.53613068195625e-6*x_41 - 1.70701875272467e-6*x_42 + 7.28354977415785e-8*x_43 + 4.62270234546681e-5*x_44 - 1.38637113005317e-5*x_45 - 5.10464030020428e-6*x_46 + 0.000137298465445029*x_47 - 0.000261287919366316*x_48 - 4.17679420949562e-5*x_49 - 5.31669702609063e-6*x_5 + 0.000668854911111839*x_50 - 0.00060516571032637*x_51 - 0.0009599686037307*x_52 - 0.000497343813063212*x_53 - 5.28633769455453e-6*x_54 + 1.79901493242419e-5*x_55 + 4.04408117670812e-5*x_56 + 0.000825268588344672*x_57 - 5.55933732731562e-5*x_58 + 0.000793388156121153*x_59 + 0.000665682692186583*x_6 - 5.65552276445968e-5*x_60 + 0.00100771072805172*x_61 + 0.000180906746359736*x_62 + 0.000222035131530559*x_63 + 1.88314313780669e-5*x_64 - 3.01536187923996e-5*x_65 - 8.81505804138184e-5*x_66 - 9.3951296621152e-6*x_67 + 3.90932204342013e-5*x_68 - 3.92768385432743e-5*x_69 - 5.76788620165585e-6*x_7 + 0.000114458033887859*x_70 + 0.000681347440063506*x_71 + 5.09420926158616e-5*x_72 - 1.99780915291118e-6*x_73 - 0.000605500420254004*x_74 + 3.55537311727453e-6*x_75 - 0.000104030066537899*x_76 - 1.46570500390588e-6*x_77 - 6.5251401700561e-5*x_78 - 9.98933053448926e-7*x_79 + 0.00148378745889732*x_8 + 3.36407153898239e-5*x_80 + 9.91310137012185e-5*x_81 - 0.00117959818227007*x_82 + 7.70953196740149e-5*x_83 - 0.000101384477078938*x_84 + 0.000135429243082901*x_85 - 1.74960831389643e-5*x_86 + 0.000293704330775821*x_87 - 0.000138729252650239*x_88 + 0.000748324720911451*x_89 - 1.50459647034536e-5*x_9 - 0.000848297409831164*x_90 - 0.000796627847906978*x_91 + 1.24830727344677e-6*x_93 + 6.1055186815452e-5*x_94 + 1.7153023014732e-5*x_95 + 5.44641216187967e-5*x_96 - 0.000147865911812235*x_97 + 0.00137153892319729*x_98 + 0.000191926689232432*x_99 - 2.98030137033812e-5*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 2.73561727828328e-6*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) - 2.50810126815047e-7*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) + 2.98552803996272e-7*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 1.44803262940875e-6*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) + 5.55305549217421e-7*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 2.556769887531e-5*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 7.5187058328387e-6*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) - 5.63427955283893e-6*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) - 2.69580876556247e-7*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) - 1.05016208115003e-6*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 7.62378171875294e-7*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) - 2.35656589510407e-7*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) - 2.92070401854806e-7*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 1.55196598861301e-5*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 4.23677429727261e-7*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) - 5.47431865545575e-7*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) + 1.00064285774433e-6*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) + 5.56104293504386e-6*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 4.192365192869e-5*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 1.1004161910645e-5*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) - 1.44621380511114e-6*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 2.22813951809203e-7*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) + 2.63411266044957e-7*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 2.07931235468765e-7*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) - 0.0018660300411284*std::pow(-0.0357202903294038*x_10 - 0.0887701972754253*x_100 + 0.272330954949936*x_101 + 0.0127664785033792*x_102 + 0.0120911873792103*x_103 - 0.158183727584902*x_104 - 0.0182282630393124*x_105 - 0.0138539321501107*x_106 - 0.0069458378332749*x_108 - 0.0028554849838552*x_11 - 0.0264162415775899*x_113 + 0.00147313703583722*x_115 - 0.00237825583140713*x_116 + 0.00557165464298704*x_119 - 0.138471081513797*x_12 - 0.153788402758006*x_120 - 0.168688464833489*x_13 + 0.181411383782212*x_14 - 0.00558633313681383*x_15 - 0.0137740341657617*x_17 - 0.000995455716518955*x_18 - 0.00742237684221035*x_19 + 0.0366392342339641*x_20 + 0.0953422360450517*x_22 + 0.0366349355074925*x_24 + 0.289426012553631*x_25 + 0.140548593666232*x_27 - 0.0226328094830143*x_28 + 0.272716727718742*x_29 - 0.145837277336008*x_3 - 0.00193462741871237*x_30 - 0.376283638208042*x_31 + 0.00876735505503943*x_32 - 0.086190836310546*x_33 - 0.22240851914559*x_34 - 0.00354381227292609*x_38 - 0.0525323172611332*x_4 - 0.00552387609830586*x_42 - 0.0751645673568588*x_43 - 0.0416307040260282*x_44 - 0.00750438546501916*x_47 + 0.0161121804967633*x_48 + 0.00814017005959026*x_5 + 0.00239980284608468*x_51 + 0.154132373962509*x_52 + 0.0106267891413077*x_57 - 0.00134082725780066*x_59 - 0.0248828762880272*x_6 + 0.115773325270697*x_61 + 0.0195674955459923*x_63 + 0.208631431604687*x_66 - 0.131014978023625*x_68 + 0.0112480768184901*x_72 + 0.144804190457542*x_73 - 0.000987278906988878*x_74 + 0.00182593328933437*x_76 - 0.0409791939257505*x_77 + 0.00565700754343694*x_8 - 0.0607335428676822*x_80 - 0.00423681840098963*x_82 - 0.000284819217372234*x_85 + 0.00606829679511943*x_86 - 0.0415876786271936*x_89 - 0.0528081749067762*x_9 - 0.00323573609561993*x_90 + 0.36762496027166*x_91 - 0.107699722413327*x_95 - 0.000493924028655557*x_96 + 0.138172847719223*x_99 - 8.34545974785295e-5*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) + 0.00277745109074065*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) + 0.0037009614924241*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) - 0.000622751132828073*std::pow(-8.0*x_54 - 9.99971961975098, 2) + 0.00131542592981183*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) + 0.00146412452650457*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) + 0.000608519103541226*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) + 0.0030503305618941*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) - 0.000907783188065989*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) - 0.00104920469891689*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) - 0.000651768073743446*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) + 0.00179705861477808*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) + 0.162470275697203*std::exp(0.594239830970764*x_2) + 1.25545646466669*std::sin(0.431519865989685*x_107 + 5.2052001953125) - 0.831467535893289*std::sin(0.450319856405258*x_109 - 4.15903997421265) - 0.133195419683094*std::sin(1.160719871521*x_110 - 7.00648021697998) - 0.529989511373827*std::sin(0.359679847955704*x_111 - 7.42783975601196) + 0.900478924737875*std::sin(0.346559852361679*x_112 - 7.43415975570679) - 1.55881690665339*std::sin(0.345199823379517*x_114 + 1.94695973396301) + 0.0340464733662582*std::sin(1.12887978553772*x_117 + 0.991439819335938) + 0.525710193849811*std::sin(0.407119870185852*x_118 - 1.19191980361938) + 0.956469582176425*std::sin(0.355999857187271*x_16 - 4.24599981307983) - 1.63918953933383*std::sin(0.312319934368134*x_21 + 8.32975959777832) + 3.73053064122672*std::sin(0.201519995927811*x_23 + 4.99215984344482) + 2.00080906617842*std::sin(0.343999862670898*x_26 + 5.15880012512207) - 0.569335561766984*std::sin(0.258239984512329*x_35 - 4.14152002334595) + 1.89312606792086*std::sin(0.371439844369888*x_36 + 5.18383979797363) - 1.23426499192774*std::sin(0.382879853248596*x_37 + 5.18959999084473) - 0.578205286821039*std::sin(0.33791983127594*x_39 + 5.16007995605469) + 0.481480191827508*std::sin(0.339839845895767*x_40 + 8.33960056304932) - 0.0412187967556421*std::sin(1.41703987121582*x_41 + 4.79800033569336) + 2.21154337384263*std::sin(0.266319960355759*x_45 - 7.53560018539429) - 0.0236075400843783*std::sin(1.01415979862213*x_46 + 4.18032026290894) + 0.675803909634247*std::sin(0.3642398416996*x_49 + 1.96791982650757) + 1.68400340024633*std::sin(0.354879856109619*x_53 + 5.16688013076782) - 1.16714780752467*std::sin(0.377519845962524*x_55 - 4.21208000183105) - 1.2509193945408*std::sin(0.320719838142395*x_56 + 8.30823993682861) + 1.1281694138497*std::sin(0.304079920053482*x_62 + 5.10087966918945) + 2.82489445775752*std::sin(0.19480000436306*x_64 - 4.4093599319458) + 0.721145600942776*std::sin(0.467439860105515*x_65 + 2.05879974365234) + 1.45996821870526*std::sin(0.419119864702225*x_75 - 7.36639976501465) - 1.80730225565739*std::sin(0.213599994778633*x_78 + 5.01663970947266) - 0.225228653052927*std::sin(0.439199864864349*x_79 + 2.22503995895386) - 2.47707494816623*std::sin(0.234479993581772*x_83 - 4.34055948257446) - 0.669442334298296*std::sin(0.404559850692749*x_84 - 4.1814398765564) + 4.95155611613001*std::sin(0.189920008182526*x_87 + 4.97759962081909) - 2.39603395636905*std::sin(0.317679852247238*x_92 - 4.21264028549194) - 1.13799339942396*std::sin(0.353039860725403*x_93 - 7.41192007064819) - 0.95644417828666*std::sin(0.43495985865593*x_94 + 2.01871991157532) + 2.09544286129756*std::sin(0.335919857025146*x_97 - 7.4507999420166) + 1.16989293462971*std::sin(0.446159869432449*x_98 - 7.38191986083984) + 19.7966588966605, 2) + 0.00187228917093739*std::exp(0.448319852352142*x_20) - 1.27463168024562e-5*std::exp(0.429519861936569*x_29) + 5.73568788807002e-5*std::exp(0.641439855098724*x_71) + 0.13171798732661*std::exp(-0.0950787499708632*x_1 + 0.0330979461919753*x_10 - 0.00223416928955154*x_100 + 0.0015557638390417*x_101 - 0.0374384037561046*x_102 - 0.00192163947099978*x_103 - 9.70133700978311e-5*x_105 + 0.000863157452742257*x_106 + 0.000397254668913949*x_107 - 0.00843658343950949*x_113 + 0.00217612278913617*x_114 + 0.00299492754570224*x_116 + 0.00588099748327651*x_117 + 0.000402652662383302*x_119 + 0.00471821759761546*x_12 + 0.0146162529568522*x_13 - 0.0031961442471341*x_14 - 0.040609340575708*x_17 + 0.0109551360386526*x_20 - 0.028958189317806*x_22 - 0.0559642206415268*x_25 + 0.000173353460900027*x_26 + 0.00525402738008309*x_27 - 0.00208066395174907*x_29 - 0.0113062959887979*x_3 - 0.0144908437265342*x_31 - 0.000357805657133813*x_34 - 0.00113703092664206*x_36 - 0.00284420437021617*x_37 - 0.00853825973844006*x_38 + 5.38852427925255e-5*x_39 - 0.0180966504744368*x_41 + 0.000460374237469651*x_42 - 0.000121861160728401*x_49 - 0.0144308458906227*x_5 - 0.0407840021508262*x_50 - 0.00127260305173286*x_51 + 0.00102100082899425*x_52 - 0.00482818291395379*x_53 + 0.00316630651746206*x_56 + 0.0160350120450961*x_59 - 0.0101154095174585*x_6 + 0.000722259187383653*x_61 + 0.00326578347729315*x_62 - 0.0311677448013087*x_63 + 0.000413597792839888*x_66 - 0.00161125180013212*x_67 + 0.0254229337699355*x_68 - 0.00571590342251012*x_69 + 0.00125574743475802*x_71 + 0.0302340212680534*x_72 - 2.65971029823796e-5*x_75 + 0.000951814310248422*x_77 - 0.029645526297052*x_78 - 0.00243353363782252*x_79 - 0.00221630915919367*x_8 + 0.000256326718139679*x_82 - 0.0236846023032847*x_83 + 0.00134055325371788*x_86 + 0.00224290858781058*x_88 + 0.000449468413344868*x_89 - 0.0256536977577017*x_9 + 0.00307001620584808*x_91 + 0.000249957542352694*x_92 - 0.0151675460282136*x_93 + 6.21782248441517e-5*x_94 + 0.000279347366615142*x_96 - 0.0036394263547009*x_98 + 0.000426948791377099*x_99 - 0.00141126124560192*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.00121492128179389*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 0.000198932274106747*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 0.000229216618598219*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.00174196160589604*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 0.000208323774894263*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 0.000283804739191325*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 6.83723963071639e-5*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.000960584968308878*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 9.11997701437163e-5*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.0132062879996078*std::exp(0.69871985912323*x_85) + 0.13921919207632*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.143847450405818*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.0929321775260981*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.606919094632836*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.00593074828613216*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.179362480465015*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.0548468745823909*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.270343822014453*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.0373839200022745*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.561747028963737*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.103516729577107*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.104908454874892*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.336029423516923*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 0.810985372405355*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.168817326886714*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.283307872292024*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.0141738325807632*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.207957563636082*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.154053328628589*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.161544735771324*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.0753452497289588*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.203009664810818*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.0783153387866085*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.0829609895246746*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.0439939579890671*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.275033441963075*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.402286174120484*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.180538308140839*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.147554200775888*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.384005368619292*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.522863783559224*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.161586494718977*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.00403038489673557*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.433731777563835*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.404269101826955*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.159676827571234*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.150479912904583*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.0820885901735204*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.251892633140002*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.211879750262554*std::sin(0.315439850091934*x_97 - 7.45576000213623)) - 2.83405840671964e-5*std::log(8.06023979187012*x_91 + 9.42432022094727) - 0.0282792060418989*std::sin(0.255999982357025*x_1 - 7.38719987869263) + 0.00264418219153049*std::sin(0.281039953231812*x_1 + 5.1756796836853) - 4.07620924993452e-5*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.000210307161501241*std::sin(0.328399837017059*x_102 - 4.43911981582642) - 0.000279456067062148*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 0.000100829605611916*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.00517506004715935*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.000977833241793053*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.000550842335514872*std::sin(0.50519984960556*x_109 + 5.25952005386353) + 0.00047091476612575*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 3.98927067473066e-5*std::sin(1.31879985332489*x_110 - 0.19039985537529) - 0.00711066598787965*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.00771935076904717*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.000126095517878414*std::sin(0.357119828462601*x_115 - 1.02367985248566) + 9.63524406139944e-5*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 0.000184263783345152*std::sin(0.68071985244751*x_117 + 8.02408027648926) - 0.00515805467440565*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.00273733638955658*std::sin(0.325919836759567*x_12 - 7.46208000183105) + 0.00107524548989809*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.0131783470801604*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.0100047755653157*std::sin(0.257839977741241*x_120 + 5.06311988830566) + 0.00153989857469561*std::sin(0.333279848098755*x_120 - 4.27167987823486) - 0.00054686358055947*std::sin(0.346559852361679*x_15 + 1.93543982505798) - 6.37480461330408e-6*std::sin(1.99319982528687*x_15 - 8.39608001708984) - 0.0572270314012854*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.000928873023568001*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 0.00017169008899528*std::sin(0.676799833774567*x_19 + 5.45519971847534) + 0.00171301260257465*std::sin(0.299679934978485*x_21 - 4.28143978118896) + 0.000544945571185598*std::sin(0.302399933338165*x_21 - 4.28687953948975) + 0.0161706531680858*std::sin(0.32847985625267*x_21 + 5.15607976913452) - 0.00126700147182688*std::sin(0.298479825258255*x_22 - 1.12871980667114) - 7.57984942481437e-6*std::sin(1.528639793396*x_22 - 1.98135983943939) + 0.00363356797019326*std::sin(0.250559985637665*x_23 - 7.5303201675415) - 0.00356553439227157*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.0176674118288901*std::sin(0.347119837999344*x_26 + 5.14224004745483) + 1.86598467817442e-5*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 0.0118371110075448*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.00046709718217168*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.000139520065312634*std::sin(0.638239860534668*x_29 + 8.61336040496826) - 0.00102495012024137*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.000779423320713744*std::sin(0.772399842739105*x_3 + 7.61152029037476) + 0.00279317793999131*std::sin(0.292639940977097*x_30 - 4.29711961746216) + 0.00121492137231777*std::sin(0.327759832143784*x_35 - 1.21751987934113) - 0.000697295315093986*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.00173104364149324*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 0.000298580727406723*std::sin(1.05911982059479*x_39 + 8.42039966583252) + 2.82634788043862e-5*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 0.00176495709813452*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 0.00746471728972165*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.00842868018203682*std::sin(0.357599824666977*x_42 + 1.97287976741791) + 0.000571526938495918*std::sin(0.513519823551178*x_43 - 4.23767995834351) - 0.00302109533512595*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 0.0300526115754431*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.00418156760748007*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.000114910025826386*std::sin(0.476639837026596*x_48 - 7.32263994216919) - 0.000388142337769424*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.00185923691285046*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.00312594080389081*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 0.0393322026605294*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 5.6153006040121e-6*std::sin(1.12711989879608*x_58 - 7.43103981018066) - 0.00178928943436151*std::sin(0.237039983272552*x_63 - 4.33999967575073) - 2.29368044385099e-5*std::sin(1.12663984298706*x_67 + 2.37519979476929) - 2.02368836463437e-5*std::sin(1.25287985801697*x_7 + 9.62911987304688) + 0.00190636694865657*std::sin(0.262719959020615*x_73 - 7.51200008392334) - 0.00361730587529557*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.00488276929429326*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.000110928454825495*std::sin(0.959439814090729*x_76 + 5.5699200630188) + 0.000795364441891785*std::sin(0.437359839677811*x_77 - 4.15848016738892) - 0.0065912194438737*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.00140222900321821*std::sin(0.307599931955338*x_79 + 5.1352801322937) + 0.00485969484126759*std::sin(0.154000028967857*x_80 - 7.65791988372803) + 0.000499000062472309*std::sin(0.426799863576889*x_81 - 4.15999984741211) + 0.000587676602507489*std::sin(0.464319854974747*x_82 + 5.2532000541687) + 0.000160560030619651*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.00195554052558678*std::sin(0.286079943180084*x_86 + 5.12367963790894) - 4.14846641818572e-5*std::sin(1.34455978870392*x_86 + 1.38687980175018) + 0.00110090741620952*std::sin(0.283919870853424*x_87 - 1.28575992584229) + 0.000617255019104485*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.00695291746002848*std::sin(0.506479859352112*x_9 - 0.87367981672287) - 0.00033444072153241*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.00206018676864532*std::sin(0.380959838628769*x_92 + 1.97975981235504) + 0.0192233523569746*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.00395186795074118*std::sin(0.263759940862656*x_97 + 8.28248023986816) + 0.094560989563984);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00030274380784704*x_10 + 0.000597349013083413*x_100 - 2.94053448058701e-6*x_101 + 1.42523891843867e-6*x_102 + 0.000628803794294781*x_103 - 0.00014913071118473*x_104 + 0.00015897974773316*x_105 + 0.000152893448593877*x_106 + 3.62570095395149e-5*x_107 + 0.00135410033034661*x_108 - 0.000723482169188958*x_109 - 0.000343941014461547*x_11 + 0.00155552618505686*x_111 - 5.93835042526907e-5*x_112 + 0.00100706320210036*x_113 - 0.000550922853328451*x_114 + 1.64459779187568e-7*x_115 + 0.000637987111260141*x_116 + 2.38035566745925e-5*x_117 + 0.00243954967672484*x_118 + 6.94881570821679e-5*x_119 - 1.54587950310274e-5*x_12 + 2.40602171328136e-5*x_120 + 0.000631435600058558*x_13 + 0.000243911081038287*x_14 - 6.23653531069133e-7*x_15 - 0.0013167456146405*x_16 - 0.000872300314188849*x_17 - 0.000159231059687568*x_18 + 0.000111546088507562*x_19 + 9.37381669954112e-5*x_2 + 0.00244029000874585*x_20 + 1.06439270113842e-5*x_22 - 8.30148607096209e-5*x_23 + 4.08989337552625e-6*x_24 + 0.000515642523028059*x_25 + 0.00114528698439636*x_26 + 1.56907267397124e-5*x_27 - 1.89485407209759e-6*x_28 + 3.04458660194437e-5*x_29 - 0.000162394929902365*x_3 + 9.08448301403756e-6*x_30 - 0.00161875455534638*x_31 + 0.000941739772202312*x_32 + 0.000116603441227175*x_33 - 0.000112298817087846*x_34 - 0.000111069401252531*x_35 + 0.00014857720965324*x_36 + 0.000389407973816208*x_37 - 0.00012860340588894*x_38 + 0.000335980431574084*x_39 + 0.000499417659650932*x_4 + 0.000285688884751117*x_40 + 7.93962371529027e-5*x_41 + 0.000167309702992373*x_42 - 1.21558744803383e-5*x_43 + 0.00100153971616814*x_44 + 0.000540966793586901*x_45 - 2.3280006867824e-5*x_46 + 0.000878598351452691*x_47 + 6.8426120644134e-7*x_48 - 4.221202179375e-5*x_49 - 2.33383420755765e-5*x_5 + 0.000585303291058112*x_50 - 0.000218419474490487*x_51 + 0.000282193430921303*x_52 + 2.07268601687332e-5*x_53 + 0.000107948249770462*x_54 - 8.83596815861786e-5*x_55 + 0.000132840107612254*x_56 + 9.8118110591209e-6*x_57 - 0.000253536789174506*x_58 - 0.00115096877952407*x_59 - 0.000123985763998037*x_6 + 0.00236919536508654*x_60 + 6.83063316845615e-5*x_61 + 0.00140685989871101*x_62 - 0.00276492316101922*x_63 + 5.00623920761181e-5*x_64 - 0.000198364467233125*x_65 + 4.95645641272464e-6*x_66 + 0.000485595367306656*x_67 + 0.000167205786361778*x_68 + 3.24805121323438e-5*x_69 - 2.63047781019951e-5*x_7 - 0.00218179142858781*x_70 + 9.17312426918249e-5*x_71 + 0.000389738888079758*x_72 + 0.000119424304488597*x_73 - 0.000181711160398258*x_74 - 0.000183762521315373*x_75 - 0.000465368603632805*x_76 - 3.6879172847025e-6*x_77 - 5.10730958229823e-5*x_78 + 5.16307151097988e-5*x_79 + 0.00330901472061532*x_8 + 9.30537708727989e-6*x_80 + 7.44718631204215e-5*x_81 + 6.26895611383355e-5*x_82 + 0.000523877813292025*x_83 - 0.000243606540395076*x_84 + 2.49339263780624e-5*x_85 + 0.000904977583532003*x_86 + 4.91802374296734e-5*x_87 - 0.000578026710336748*x_88 - 1.7065557182227e-5*x_89 + 0.000771768182483631*x_9 + 3.10163294832644e-5*x_90 - 0.00070934394258291*x_91 + 0.00211448079745242*x_93 + 0.000434815760341915*x_94 + 1.65965040849027e-5*x_95 - 4.36261615786066e-5*x_96 - 0.00054497278861297*x_97 - 0.000421542447086219*x_98 - 0.000312666514994804*x_99 - 9.31680104404281e-9*std::pow(1.03663980960846 - 5.37296009063721*x_58, 2) + 3.10072302830863e-7*std::pow(-3.59991979598999*x_1 - 7.7818398475647, 2) - 1.24759405718801e-5*std::pow(-5.1069598197937*x_10 - 7.06960010528564, 2) + 1.29633373923614e-5*std::pow(-5.11087989807129*x_107 - 6.34032011032104, 2) - 1.54309587766096e-5*std::pow(-6.27920007705688*x_110 - 7.90143966674805, 2) + 6.60383642626492e-6*std::pow(-2.53199982643127*x_111 - 6.42400026321411, 2) - 2.87014455188422e-5*std::pow(-6.3199200630188*x_13 - 9.98655986785889, 2) - 3.42894921349558e-5*std::pow(-4.1780800819397*x_17 - 6.98343992233276, 2) - 2.56954572646542e-5*std::pow(-5.08640003204346*x_2 - 8.93936061859131, 2) + 1.39335197573749e-5*std::pow(-7.7380805015564*x_24 - 9.96592044830322, 2) + 5.42785315229763e-5*std::pow(-3.52704000473022*x_25 - 6.65879964828491, 2) - 3.47686967805071e-6*std::pow(-7.80000019073486*x_27 - 9.99855995178223, 2) + 1.21801137671341e-5*std::pow(-6.83199977874756*x_46 - 8.83520030975342, 2) + 1.50959102395353e-5*std::pow(-5.35191965103149*x_49 - 9.31184005737305, 2) - 2.18981328099766e-5*std::pow(-4.8997597694397*x_5 - 7.63431978225708, 2) + 4.13172227035786e-7*std::pow(-3.93111991882324*x_50 - 5.7915997505188, 2) - 6.95234124878996e-8*std::pow(-8.0*x_54 - 9.99971961975098, 2) - 2.49659463548424e-6*std::pow(-7.80383968353271*x_55 - 9.39080047607422, 2) - 5.1719087817224e-5*std::pow(-3.77920007705688*x_6 - 6.75815963745117, 2) + 1.46853044008569e-7*std::pow(-6.35927963256836*x_60 - 7.93936014175415, 2) + 1.63453630228771e-7*std::pow(-5.10399961471558*x_67 - 7.95560026168823, 2) + 6.79345607131048e-8*std::pow(-7.55416011810303*x_69 - 7.96439981460571, 2) + 3.40536337390426e-7*std::pow(-4.48296022415161*x_7 - 7.21151971817017, 2) - 1.01344151309502e-7*std::pow(-6.92239999771118*x_70 - 8.90960025787354, 2) - 6.59554157302366e-6*std::pow(-6.54320001602173*x_70 - 8.99143981933594, 2) - 1.17132329789242e-7*std::pow(-6.54336023330688*x_71 - 9.31999969482422, 2) - 1.01615589411024e-6*std::pow(-5.07039976119995*x_75 - 9.99376010894775, 2) - 7.27628393569205e-8*std::pow(-8.89296054840088*x_81 - 9.50112056732178, 2) - 1.36146381250703e-5*std::pow(-5.36560010910034*x_84 - 8.54975986480713, 2) + 2.00622111713833e-7*std::pow(-6.53319978713989*x_88 - 9.17039966583252, 2) - 1.07471049674954e-5*std::pow(-7.29063987731934*x_90 - 9.68136024475098, 2) + 1.81380448768093e-5*std::exp(0.594239830970764*x_2) + 0.000658804360567197*std::exp(0.429519861936569*x_29) + 0.000261579358335241*std::exp(0.641439855098724*x_71) - 0.0853355735338761*std::exp(-0.130234799731159*x_1 + 0.0453361491936475*x_10 - 0.00306026940908895*x_100 + 0.00213101867734551*x_101 - 0.0512815220743301*x_102 - 0.00263217944848705*x_103 - 0.000132884759526262*x_105 + 0.00118231611194713*x_106 + 0.000544142432080042*x_107 - 0.011556070678216*x_113 + 0.00298075979880266*x_114 + 0.00410232348703984*x_116 + 0.00805553848455807*x_117 + 0.000551536372352151*x_119 + 0.00646281239605888*x_12 + 0.0200207173236811*x_13 - 0.00437794150706612*x_14 - 0.055624935526734*x_17 + 0.0150058761653759*x_20 - 0.0396656875225765*x_22 - 0.0766573926307735*x_25 + 0.000237452146456877*x_26 + 0.00719674168872471*x_27 - 0.00285000437160691*x_29 - 0.0154868800258052*x_3 - 0.019848937130947*x_31 - 0.000490106865243578*x_34 - 0.00155745626719684*x_36 - 0.00389586933634595*x_37 - 0.0116953425179561*x_38 + 7.3809697810499e-5*x_39 - 0.0247880167867719*x_41 + 0.00063060091383846*x_42 - 0.000166920198964894*x_49 - 0.0197667546648688*x_5 - 0.0558641794720238*x_50 - 0.00174315715793992*x_51 + 0.00139852320871027*x_52 - 0.00661343817684674*x_53 + 0.00433707106283477*x_56 + 0.0219640727609456*x_59 - 0.0138556547399768*x_6 + 0.00098931970237014*x_61 + 0.00447333034206843*x_62 - 0.0426922419942858*x_63 + 0.000566528543299726*x_66 - 0.00220702371004016*x_67 + 0.0348232458790286*x_68 - 0.00782939971067534*x_69 + 0.00172006905569062*x_71 + 0.0414132674874162*x_72 - 3.64315725795796e-5*x_75 + 0.00130375447841333*x_77 - 0.0406071722798682*x_78 - 0.00333335015508698*x_79 - 0.0030358053674283*x_8 + 0.000351105360692019*x_82 - 0.0324421538842872*x_83 + 0.00183623243448618*x_86 + 0.00307224012556245*x_88 + 0.0006156625830208*x_89 - 0.0351393365064413*x_9 + 0.00420517671785294*x_91 + 0.000342381136474466*x_92 - 0.020775854962364*x_93 + 8.51690694576715e-5*x_94 + 0.000382638059058395*x_96 - 0.00498513035337572*x_98 + 0.000584816169306984*x_99 - 0.00193308521352706*std::pow(-4.8471999168396*x_15 - 7.06712007522583, 2) - 0.00166414713983973*std::pow(-3.22655987739563*x_18 - 5.63375997543335, 2) + 0.000272488909312496*std::pow(-5.26647996902466*x_19 - 9.52159976959229, 2) + 0.000313971107396137*std::pow(-4.25408029556274*x_24 - 7.29840040206909, 2) - 0.00238606440400994*std::pow(-4.68232011795044*x_4 - 7.93872022628784, 2) + 0.000285352984877352*std::pow(-7.63199996948242*x_44 - 8.80167961120605, 2) + 0.000388743577115418*std::pow(-5.05295991897583*x_55 - 7.48343992233276, 2) + 9.36535802472335e-5*std::pow(-8.17111968994141*x_60 - 8.37360000610352, 2) - 0.00131576815019976*std::pow(-5.22824001312256*x_7 - 8.45448017120361, 2) + 0.000124921539290687*std::pow(-7.29320001602173*x_73 - 9.73848056793213, 2) - 0.0180894077104294*std::exp(0.69871985912323*x_85) + 0.190696486905323*std::sin(0.308319926261902*x_104 - 4.26287984848022) + 0.19703607694864*std::sin(0.300959944725037*x_108 + 5.11872005462646) + 0.12729451672851*std::sin(0.434719860553741*x_109 + 5.23311996459961) - 0.83133178304033*std::sin(0.286399960517883*x_11 + 8.30607986450195) - 0.00812368500361049*std::sin(1.23231983184814*x_110 + 8.60128021240234) - 0.245683044106106*std::sin(0.375999838113785*x_111 - 7.40831995010376) + 0.0751268998520342*std::sin(0.421679854393005*x_112 + 8.21263980865479) - 0.370305389263088*std::sin(0.357119828462601*x_115 + 5.16096019744873) - 0.0512068925617331*std::sin(0.481039851903915*x_118 + 2.24391984939575) - 0.769457022090478*std::sin(0.180560007691383*x_120 - 7.61552000045776) - 0.141792782818773*std::sin(0.39183983206749*x_16 + 1.99935972690582) + 0.143699108527654*std::sin(0.598959863185883*x_2 + 5.59223985671997) - 0.460278713055379*std::sin(0.316159844398499*x_21 - 1.07039988040924) + 1.110853030698*std::sin(0.165360018610954*x_23 - 7.6396803855896) - 0.231238744356423*std::sin(0.482479840517044*x_28 + 2.26735997200012) + 0.388062990116291*std::sin(0.301119923591614*x_30 - 4.27631998062134) + 0.019414708840244*std::sin(1.10583996772766*x_32 + 3.84191989898682) - 0.284851364379785*std::sin(0.273119956254959*x_33 - 4.38567972183228) - 0.21101565184661*std::sin(0.271199941635132*x_35 + 8.26056003570557) - 0.221277060512981*std::sin(0.293439924716949*x_40 + 8.06552028656006) + 0.103204696234986*std::sin(0.389599829912186*x_43 - 4.21072006225586) - 0.27807394447475*std::sin(0.397519826889038*x_45 + 5.20032024383545) - 0.10727299702486*std::sin(0.479679852724075*x_46 + 5.28007984161377) + 0.11363641044456*std::sin(0.309039950370789*x_47 + 8.0740795135498) + 0.0602610395050731*std::sin(0.636399865150452*x_48 - 7.38199996948242) + 0.376729029824318*std::sin(0.324719846248627*x_54 + 1.93063986301422) - 0.551034372425494*std::sin(0.311919927597046*x_57 - 7.47584009170532) - 0.247293642498768*std::sin(0.478079855442047*x_58 - 1.11911988258362) - 0.202113424854953*std::sin(0.29479992389679*x_64 + 8.33711910247803) + 0.525994107969961*std::sin(0.212399989366531*x_65 + 5.01623964309692) + 0.716196417805019*std::sin(0.160320028662682*x_70 - 4.45192003250122) + 0.221334260131047*std::sin(0.39743983745575*x_74 - 4.18959999084473) + 0.0055206486205035*std::sin(1.73087990283966*x_76 - 7.99607992172241) + 0.594107213287678*std::sin(0.246719971299171*x_80 - 7.53208017349243) + 0.553750501874113*std::sin(0.258799970149994*x_81 + 5.05815982818604) + 0.218718479858214*std::sin(0.358319848775864*x_84 - 7.4423999786377) + 0.206120940028095*std::sin(0.268799960613251*x_87 - 4.28639984130859) - 0.112441435175975*std::sin(0.620159804821014*x_90 + 2.2008798122406) + 0.345031740959946*std::sin(0.355119854211807*x_95 - 7.42967987060547) - 0.290223807643535*std::sin(0.315439850091934*x_97 - 7.45576000213623)) - 0.0959236208909543*std::exp(0.000721674271913164*x_100 - 0.00145096349750096*x_101 - 0.000220014011697404*x_102 - 0.0126367551955567*x_103 + 0.00259490480910606*x_104 - 0.0126818783966437*x_106 + 0.00265613191501013*x_107 + 0.000485346930389374*x_108 + 0.00592396496116359*x_109 - 0.0105415513322293*x_11 + 0.00221396079674633*x_113 + 0.00754279447304996*x_114 - 0.000764526929762105*x_115 + 0.0011898481463702*x_116 - 0.00125110830249978*x_117 + 0.0140296938106442*x_118 + 0.00532909266424098*x_13 + 0.00328322031728417*x_15 - 0.0585088499719167*x_16 - 0.0137191202272952*x_17 + 0.00128069619197774*x_19 - 0.00100402108724962*x_2 + 0.00398540064416907*x_22 + 0.0136815803220668*x_24 + 0.00853436279331383*x_25 + 0.0224730991647959*x_27 + 0.0475523190499339*x_29 + 0.00598656602419588*x_30 + 0.0537256651395264*x_31 + 0.00110745342022615*x_32 - 0.00283135233447597*x_33 + 0.000925622347006744*x_34 + 0.00191084573474198*x_35 - 0.0238072484310457*x_36 + 0.000952451370582752*x_37 - 0.00235094179451185*x_38 + 0.00180285836610111*x_4 + 0.00177597486068376*x_40 + 0.00158174066220089*x_44 + 8.50529953192858e-5*x_45 - 0.00692232540527243*x_48 - 0.000862151193306751*x_49 + 0.0161278738680451*x_50 - 0.0147761377052713*x_51 - 0.0254562535002309*x_52 - 0.0131778771432266*x_53 + 0.000431727170635462*x_55 + 0.0001703809127302*x_56 + 0.0223263067578864*x_57 + 0.0197440640433077*x_59 + 0.018357281300983*x_6 + 0.000595079362782913*x_60 + 0.0265013217466841*x_61 + 0.00554912215844098*x_62 + 0.00446821496027738*x_63 + 0.000447180056135535*x_64 - 0.000249698528731281*x_65 - 0.00228893939109234*x_66 - 0.000981933836703647*x_69 + 0.00191579848199732*x_70 + 0.0181149637293418*x_71 + 0.00034768283037543*x_72 - 0.0143243635595809*x_74 - 0.00299752455795551*x_76 - 3.84123464852487e-5*x_77 - 0.00197172992583235*x_78 + 0.0378037561801969*x_8 + 0.000900333845290552*x_80 + 0.00266695431718892*x_81 - 0.0312480551715*x_82 + 0.00230257939813657*x_83 - 0.00127202429483932*x_84 + 0.00344613239780669*x_85 + 0.00781365310388207*x_87 - 0.000259242959893319*x_88 + 0.0198061763797861*x_89 - 0.0226775105484588*x_90 - 0.0215098859075184*x_91 + 0.00153115180689808*x_93 + 6.62953688560512e-5*x_94 + 0.000564453589745356*x_95 + 0.00149250713207098*x_96 + 0.0389897713887365*x_98 + 0.00704388706982496*x_99 - 0.000790313201933734*std::pow(-5.52496004104614*x_10 - 7.97535991668701, 2) - 0.000678001566060793*std::pow(-5.67000007629395*x_14 - 7.48695993423462, 2) - 0.00041154871851562*std::pow(-6.33175992965698*x_5 - 9.79744052886963, 2) + 0.000147467155228898*std::pow(-4.1159200668335*x_67 - 8.81935977935791, 2) - 0.0011117270193638*std::pow(-3.54399991035461*x_68 - 4.71335983276367, 2) - 0.000291807215228451*std::pow(-6.58455991744995*x_7 - 9.57248020172119, 2) + 0.0496491685155154*std::exp(0.448319852352142*x_20) - 0.749905029657498*std::sin(0.255999982357025*x_1 - 7.38719987869263) - 0.137231701356626*std::sin(0.423519849777222*x_105 + 2.02759981155396) + 0.0124876685411346*std::sin(0.866479873657227*x_110 - 6.98816013336182) - 0.188559897354438*std::sin(0.41967985033989*x_111 + 2.01015996932983) - 0.204700936752687*std::sin(0.344239860773087*x_112 - 4.23336029052734) - 0.136780754659597*std::sin(0.312799841165543*x_119 - 7.45648002624512) + 0.349462030275618*std::sin(0.369039833545685*x_12 + 1.95535981655121) - 0.265305592593677*std::sin(0.257839977741241*x_120 + 5.06311988830566) - 1.51754043648214*std::sin(0.187120005488396*x_18 - 7.60152006149292) + 0.428811690315058*std::sin(0.32847985625267*x_21 + 5.15607976913452) + 0.0963545755992286*std::sin(0.250559985637665*x_23 - 7.5303201675415) + 0.468502580018878*std::sin(0.347119837999344*x_26 + 5.14224004745483) - 0.31389527230786*std::sin(0.309999942779541*x_28 + 8.33735942840576) + 0.0206686661418143*std::sin(0.772399842739105*x_3 + 7.61152029037476) - 0.00791773251729033*std::sin(1.05911982059479*x_39 + 8.42039966583252) - 0.197948592765997*std::sin(0.349519848823547*x_41 - 1.24535989761353) - 0.223510859976727*std::sin(0.357599824666977*x_42 + 1.97287976741791) - 0.0801130902872274*std::sin(0.530159831047058*x_43 - 4.43088006973267) - 0.796932012213404*std::sin(0.172400012612343*x_46 + 1.75647985935211) + 0.110886372695759*std::sin(0.468639850616455*x_47 + 5.26352024078369) + 0.0828933714679323*std::sin(0.680319845676422*x_54 - 4.14432001113892) + 1.04300723856738*std::sin(0.152720034122467*x_58 + 4.94431972503662) - 0.0959233390666867*std::sin(0.427359849214554*x_73 + 2.01815986633301) + 0.129480765726683*std::sin(0.26639997959137*x_75 - 4.31455993652344) - 0.174785268200736*std::sin(0.292479932308197*x_79 + 5.12367963790894) - 0.00110008598818279*std::sin(1.34455978870392*x_86 + 1.38687980175018) - 0.184376738383094*std::sin(0.506479859352112*x_9 - 0.87367981672287) + 0.509762848292667*std::sin(0.409839868545532*x_92 - 7.41232013702393) + 0.104795221209969*std::sin(0.263759940862656*x_97 + 8.28248023986816)) - 0.000129248870228148*std::log(8.06023979187012*x_91 + 9.42432022094727) + 0.0120589455786227*std::sin(0.281039953231812*x_1 + 5.1756796836853) + 0.00210682385355723*std::sin(0.788719892501831*x_1 + 1.20735991001129) - 0.000959117954678515*std::sin(0.328399837017059*x_102 - 4.43911981582642) + 0.0144439274828023*std::sin(0.328959852457047*x_102 - 4.24408006668091) - 0.000459839239021691*std::sin(0.735199868679047*x_103 - 1.60527980327606) - 0.0505401531740279*std::sin(0.174880012869835*x_106 - 1.40583980083466) + 0.000140158103377902*std::sin(0.431519865989685*x_107 + 5.2052001953125) - 9.28243361127142e-5*std::sin(0.450319856405258*x_109 - 4.15903997421265) + 0.00251214828072435*std::sin(0.50519984960556*x_109 + 5.25952005386353) - 1.48698245831745e-5*std::sin(1.160719871521*x_110 - 7.00648021697998) - 0.00018193299281366*std::sin(1.31879985332489*x_110 - 0.19039985537529) - 5.91675831181113e-5*std::sin(0.359679847955704*x_111 - 7.42783975601196) + 0.000100528709497338*std::sin(0.346559852361679*x_112 - 7.43415975570679) - 0.000174025007874687*std::sin(0.345199823379517*x_114 + 1.94695973396301) - 0.000575065890949032*std::sin(0.357119828462601*x_115 - 1.02367985248566) - 0.00498005886810843*std::sin(0.49839985370636*x_115 + 8.25191974639893) - 0.000840345624665211*std::sin(0.68071985244751*x_117 + 8.02408027648926) + 3.80091964000351e-6*std::sin(1.12887978553772*x_117 + 0.991439819335938) + 5.86898437103356e-5*std::sin(0.407119870185852*x_118 - 1.19191980361938) + 0.0124837806781158*std::sin(0.325919836759567*x_12 - 7.46208000183105) - 0.0555749891049762*std::sin(0.340559840202332*x_12 - 4.26471996307373) + 0.00702279637474782*std::sin(0.333279848098755*x_120 - 4.27167987823486) - 0.00249400293898824*std::sin(0.346559852361679*x_15 + 1.93543982505798) + 0.0003294872661724*std::sin(1.99319982528687*x_15 - 8.39608001708984) + 0.000106779459383398*std::sin(0.355999857187271*x_16 - 4.24599981307983) - 0.0480096021324306*std::sin(0.231519997119904*x_18 - 7.55200004577637) - 0.000783002565486834*std::sin(0.676799833774567*x_19 + 5.45519971847534) + 0.00781229289574254*std::sin(0.299679934978485*x_21 - 4.28143978118896) - 0.0281659811326573*std::sin(0.302399933338165*x_21 - 4.28687953948975) - 0.000182997740961827*std::sin(0.312319934368134*x_21 + 8.32975959777832) - 0.0057782333780683*std::sin(0.298479825258255*x_22 - 1.12871980667114) + 0.000391771044993029*std::sin(1.528639793396*x_22 - 1.98135983943939) + 0.000416473301928713*std::sin(0.201519995927811*x_23 + 4.99215984344482) - 0.0162608254956227*std::sin(0.184880018234253*x_24 + 1.7682398557663) + 0.000223368640673119*std::sin(0.343999862670898*x_26 + 5.15880012512207) - 0.000964450250048703*std::sin(1.65511989593506*x_27 - 3.5927197933197) - 0.0241423201064683*std::sin(0.363919854164124*x_28 + 8.3712797164917) - 0.000636289314752968*std::sin(0.638239860534668*x_29 + 8.61336040496826) + 0.0529754296118523*std::sin(0.356959849596024*x_3 - 1.01327979564667) + 0.0127384492935672*std::sin(0.292639940977097*x_30 - 4.29711961746216) - 6.35601430783487e-5*std::sin(0.258239984512329*x_35 - 4.14152002334595) + 0.00554071907677648*std::sin(0.327759832143784*x_35 - 1.21751987934113) - 0.00318005555134607*std::sin(0.364079833030701*x_36 - 7.4255199432373) + 0.000211347001351812*std::sin(0.371439844369888*x_36 + 5.18383979797363) - 0.000137792305191771*std::sin(0.382879853248596*x_37 + 5.18959999084473) + 0.00789452448997295*std::sin(0.323279827833176*x_38 + 5.11079978942871) - 6.4550351720422e-5*std::sin(0.33791983127594*x_39 + 5.16007995605469) + 0.000128897227224488*std::sin(1.43327987194061*x_39 - 7.78567981719971) + 5.37520434995632e-5*std::sin(0.339839845895767*x_40 + 8.33960056304932) + 0.00804918876739306*std::sin(0.278159946203232*x_41 + 5.10127973556519) - 4.60163178842189e-6*std::sin(1.41703987121582*x_41 + 4.79800033569336) + 0.00260648160709755*std::sin(0.513519823551178*x_43 - 4.23767995834351) + 0.000246894841469506*std::sin(0.266319960355759*x_45 - 7.53560018539429) - 2.63552591170311e-6*std::sin(1.01415979862213*x_46 + 4.18032026290894) - 0.00593922364088145*std::sin(0.476639837026596*x_48 - 7.32263994216919) + 7.54461798520858e-5*std::sin(0.3642398416996*x_49 + 1.96791982650757) + 0.0200614709806968*std::sin(0.282959938049316*x_51 + 5.09143972396851) - 0.0084791573068015*std::sin(0.241439983248711*x_53 + 5.06199979782104) + 0.000188000722687843*std::sin(0.354879856109619*x_53 + 5.16688013076782) - 0.000130299399197219*std::sin(0.377519845962524*x_55 - 4.21208000183105) - 0.000139651588686525*std::sin(0.320719838142395*x_56 + 8.30823993682861) + 0.000290231647396832*std::sin(1.12711989879608*x_58 - 7.43103981018066) + 0.000125947884123655*std::sin(0.304079920053482*x_62 + 5.10087966918945) - 0.00816015779188085*std::sin(0.237039983272552*x_63 - 4.33999967575073) + 0.000315368840405912*std::sin(0.19480000436306*x_64 - 4.4093599319458) + 8.05080881194003e-5*std::sin(0.467439860105515*x_65 + 2.05879974365234) - 0.000104604621178319*std::sin(1.12663984298706*x_67 + 2.37519979476929) + 0.00104596075847833*std::sin(1.25287985801697*x_7 + 9.62911987304688) + 0.0086940965567234*std::sin(0.262719959020615*x_73 - 7.51200008392334) + 0.000162989623523161*std::sin(0.419119864702225*x_75 - 7.36639976501465) - 0.000505895624040596*std::sin(0.959439814090729*x_76 + 5.5699200630188) + 0.00362730546732602*std::sin(0.437359839677811*x_77 - 4.15848016738892) - 0.000201765703162629*std::sin(0.213599994778633*x_78 + 5.01663970947266) - 0.00639494634399129*std::sin(0.307599931955338*x_79 + 5.1352801322937) - 2.51443373200826e-5*std::sin(0.439199864864349*x_79 + 2.22503995895386) + 0.022162918957426*std::sin(0.154000028967857*x_80 - 7.65791988372803) + 0.00227571860076705*std::sin(0.426799863576889*x_81 - 4.15999984741211) + 0.00268013308242038*std::sin(0.464319854974747*x_82 + 5.2532000541687) - 0.000276538563009484*std::sin(0.234479993581772*x_83 - 4.34055948257446) - 7.47359789341916e-5*std::sin(0.404559850692749*x_84 - 4.1814398765564) - 0.0082986834506299*std::sin(0.349279850721359*x_85 + 1.96199989318848) + 0.00891835549395055*std::sin(0.286079943180084*x_86 + 5.12367963790894) + 0.000552787558579565*std::sin(0.189920008182526*x_87 + 4.97759962081909) + 0.00502075184595677*std::sin(0.283919870853424*x_87 - 1.28575992584229) + 0.00281502715938206*std::sin(0.467759847640991*x_9 - 4.13375997543335) - 0.000267491214872906*std::sin(0.317679852247238*x_92 - 4.21264028549194) + 0.0172858566997436*std::sin(0.356719851493835*x_92 + 5.19888019561768) + 0.00939560072844777*std::sin(0.380959838628769*x_92 + 1.97975981235504) - 0.000127044625607292*std::sin(0.353039860725403*x_93 - 7.41192007064819) - 0.00010677662331452*std::sin(0.43495985865593*x_94 + 2.01871991157532) + 0.000233933477935614*std::sin(0.335919857025146*x_97 - 7.4507999420166) + 0.000130605862877484*std::sin(0.446159869432449*x_98 - 7.38191986083984) + 0.293114068403145);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
