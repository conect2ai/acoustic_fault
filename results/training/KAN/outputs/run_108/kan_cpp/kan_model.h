
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.58842462213634e-5*x_1 + 3.0558505869217e-5*x_10 - 0.00035102724966426*x_100 + 0.000139702986544291*x_101 + 0.00243311344830882*x_102 + 0.000105472564723616*x_103 - 0.000860120023187463*x_104 - 0.00241780723318456*x_105 + 0.00134389293750992*x_106 - 9.85669197368319e-5*x_107 - 0.000789982499341947*x_108 + 0.001521681585329*x_109 + 0.000333052025117459*x_11 + 0.000251549683707804*x_110 - 0.0038695564438701*x_111 - 0.00300819096216892*x_112 - 0.000778526085280381*x_113 + 0.000364074553945848*x_114 - 0.00308294627202154*x_115 - 1.92584745670935e-5*x_116 - 0.00331939885533234*x_117 - 0.00251246348876057*x_118 + 4.69841170529971e-5*x_119 - 0.00137792530054186*x_12 - 0.000438898371975987*x_120 + 1.84308337956848e-5*x_13 + 0.000363178928866468*x_15 + 0.000614436980269688*x_17 - 0.000130369949420151*x_18 + 0.000813863875176148*x_19 - 0.000119578454414556*x_2 - 0.000355963479996038*x_20 + 0.000128544972070507*x_21 + 7.76527182999927e-5*x_22 + 0.00186129726778118*x_24 + 0.000148372642607815*x_25 + 0.000520894106406299*x_27 + 0.000557979557998223*x_28 - 0.000809145438275296*x_29 + 1.7529139272416e-5*x_3 + 0.000364618642521162*x_30 - 0.000212052952188589*x_32 - 0.0007823451876396*x_33 + 0.000452528570943753*x_34 - 3.95536387970484e-5*x_35 + 0.00214812415159323*x_36 - 0.00139627716825623*x_37 - 0.000556039712230641*x_38 + 0.000247067649561661*x_39 - 0.000875947472544506*x_4 - 0.0014717187135125*x_40 - 7.10813925810285e-5*x_41 - 0.000151737761141975*x_42 - 0.00281198373586619*x_43 - 0.00159762032460533*x_44 - 0.000868065231289286*x_45 - 0.00399968343618926*x_46 - 0.00111328797722568*x_47 + 0.00152848396103312*x_48 + 1.7028967240316e-5*x_49 - 5.41175333330828e-5*x_5 - 0.00104524134794722*x_50 - 0.00021953885222642*x_51 + 0.0022680531204921*x_52 - 0.000413364658081092*x_53 + 0.00156257081692119*x_54 - 8.64113913602261e-5*x_55 + 0.000936501263360723*x_56 - 0.000904816584266365*x_57 - 0.00109132339999542*x_58 - 0.00211437272509576*x_59 - 1.62918233991076e-5*x_6 - 3.32330630910257e-5*x_60 + 0.000390034711928963*x_61 - 0.000188921835967723*x_62 + 0.000562284161879213*x_63 + 4.00780021453414e-5*x_64 - 0.000383557588503091*x_65 + 0.000817124673962752*x_66 - 7.08472094767961e-5*x_67 + 0.000378013331844212*x_68 - 3.47061984162911e-6*x_69 + 0.000269796471363985*x_7 - 3.45848728539031e-5*x_70 - 0.000921645331120606*x_71 + 0.000378123523563151*x_72 - 0.000987084029659271*x_73 + 0.000813765584348853*x_74 + 0.000781459977913836*x_75 - 0.000761432492690038*x_76 + 8.46319675405079e-5*x_77 - 0.000939426578786984*x_78 + 0.000944481405928909*x_79 - 0.000140970402340013*x_8 - 5.42575257969302e-5*x_80 - 0.000847148030361323*x_81 + 0.00096298025222403*x_82 - 0.000547667429472275*x_83 + 0.00151605191340753*x_84 - 0.000809790157177084*x_85 - 0.000603032677003751*x_86 - 0.000433660615284793*x_87 + 0.000716171843769169*x_88 - 0.000977584894611637*x_89 + 0.00111912936244012*x_9 + 0.00102461790207361*x_90 + 0.000697561256279568*x_91 - 9.2394024864803e-5*x_92 + 0.000437659676468478*x_93 + 0.000594790798325413*x_94 - 0.000339502849327034*x_95 - 2.42161513280702e-5*x_96 + 0.000939032273805243*x_98 + 0.000914738259608974*x_99 - 7.90398560058807e-7*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) + 0.000777960621636203*std::exp(0.277599841356277*x_13) + 0.00164357628198315*std::exp(0.275439828634262*x_23) + 0.00600254003213095*std::exp(0.143199846148491*x_49) - 0.00553076968036033*std::exp(0.147999867796898*x_49) - 1.27823597486179e-6*std::exp(0.020775798775125*x_1 + 0.0211450692927572*x_101 - 0.0591563759052774*x_103 + 0.0309964744234204*x_105 + 0.0376064452919595*x_107 + 0.060756816030828*x_109 + 0.00219798878315997*x_11 + 0.0217474922569742*x_110 + 0.031203863103467*x_111 - 0.0146086616173937*x_112 - 0.0805619865993495*x_114 - 0.0608175324927105*x_115 + 0.0331917370140334*x_117 - 0.0158208783069065*x_118 - 0.031506452667599*x_119 + 0.0407384712914071*x_12 - 0.0977574975370824*x_120 + 0.029373741970174*x_15 - 0.00858504456335017*x_16 - 0.0515567854136614*x_19 + 0.0540626235273032*x_20 - 0.0358463295243771*x_21 - 0.00433000122030405*x_22 + 0.0282831460789561*x_23 + 0.0200842861354994*x_28 + 0.0222407057783836*x_32 + 0.00233772487168183*x_33 + 0.00289534594337393*x_34 - 0.0798266183203183*x_36 - 0.0621876945716799*x_37 + 0.066496489960602*x_38 + 0.00829300561972225*x_39 + 0.0512016720668195*x_40 + 0.0472882934545927*x_41 - 0.0130110094061583*x_42 - 0.0903171257482387*x_43 + 0.00534640594349696*x_44 - 0.00126911295638316*x_45 + 0.0402823590831756*x_46 - 0.0252196278234867*x_48 + 0.0187985368507874*x_5 + 0.0421693259153827*x_50 - 0.0046427911747058*x_52 - 0.00439172765916818*x_54 + 0.0491911572820286*x_56 - 0.00518214679854077*x_57 + 0.00355414588307192*x_6 + 0.0045914372280823*x_61 - 0.000440305533255218*x_62 + 0.0331009316384416*x_63 + 0.00806661611257171*x_64 - 0.0238670450097731*x_65 + 0.0102998466055424*x_66 + 0.0164863831804834*x_67 + 0.016826249768209*x_68 + 0.0117933810266444*x_69 - 0.023103466696981*x_70 + 0.016337250453511*x_71 + 0.0191153706905612*x_72 + 0.0273766017016593*x_73 - 0.0306400428866854*x_74 - 0.0209355487773683*x_75 - 0.0308782110114715*x_76 - 0.0275389091400875*x_77 - 0.0138688496979123*x_78 - 0.0435755044480421*x_79 + 0.0698619162563204*x_8 + 0.0362290285820237*x_80 - 0.0327101328310796*x_81 + 0.0349766739101555*x_82 + 0.0109534131742574*x_83 - 0.0270661853461633*x_84 + 0.0132983684603616*x_85 + 0.0431461484375051*x_86 + 0.0209884974364912*x_87 - 0.0422828013648563*x_88 + 0.0125118275897604*x_89 - 4.98569729888614e-6*x_90 - 0.013519743844926*x_91 - 0.00125355613388252*x_93 + 0.0256092379500723*x_94 - 0.0258766151287248*x_96 - 0.0309565804239369*x_99 - 6.28353004634812e-5*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 0.00100128422246003*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) - 0.403046559196198*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.247066478575917*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.162362619366405*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.324353544428817*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.307086381242225*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.413431945749405*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.337506503613394*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.272991993319165*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.251075609407332*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.19404463375988*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.449446132579787*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.295644975827098*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 0.287534804563379*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.386188897099782*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.279279906459644*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.246280611653571*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.206519388450577*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 4.07512974694768*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 0.0778400806342994*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.403718390132255*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.225954665805839*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.557552754569741*std::sin(0.198079988360405*x_47 + 1.98031985759735) - 0.107190151452317*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.590853181876287*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.369019003096795*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.401051454530386*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 4.02879108449739*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 3.77870600202399*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.233025403943339*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.240206375660472*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.493145381609725*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.336431762425367*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.184785592485035*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.461505012622485*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.38010750896083*std::sin(0.22791999578476*x_98 - 4.21591997146606)) - 0.00277587927574685*std::sin(0.304559946060181*x_1 - 4.28071975708008) - 0.00905166254335378*std::sin(0.380799859762192*x_1 - 4.21895980834961) + 0.000759531360518572*std::sin(0.444319844245911*x_1 - 7.17479991912842) - 0.00851980425307921*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.00180943161816606*std::sin(0.346559852361679*x_10 - 1.14743983745575) - 0.00209713850151164*std::sin(0.253279983997345*x_100 - 1.22375988960266) - 0.00678551297277468*std::sin(0.235039994120598*x_101 + 1.9703197479248) - 0.00141730346140289*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.000686059001495259*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 0.0071516178028337*std::sin(0.264079958200455*x_109 + 4.96231985092163) - 0.00536887137386434*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.000715415624675177*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.00335417274955234*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.000433916363566062*std::sin(0.288159936666489*x_112 + 1.95711982250214) - 0.000474190081357625*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.00401828589239328*std::sin(0.27975994348526*x_113 - 7.42360019683838) + 0.000267815126435493*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.00182952236243415*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.00194910593513165*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.00991758247773564*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.00958367553692852*std::sin(0.295919924974442*x_12 + 5.14359998703003) + 0.000777167025251495*std::sin(0.335679858922958*x_12 + 1.86047983169556) + 0.000506852333792359*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 0.00402913248520209*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.0064589147032892*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.00198887466974557*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.0185988005360377*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.00933017722580498*std::sin(0.305359929800034*x_14 - 7.44343996047974) - 0.0017723107637396*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.000826216471681764*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 0.0110100685740592*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 0.00110109728067952*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 0.00543106341685584*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.0116687868325826*std::sin(0.153840035200119*x_16 + 8.35536003112793) - 0.000827629210430356*std::sin(0.261759966611862*x_16 - 1.1658399105072) - 0.00161665575950748*std::sin(0.336639851331711*x_16 - 1.15263986587524) + 0.0122156099348498*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.000481315089976484*std::sin(0.303199917078018*x_17 + 2.02831983566284) - 0.00204838067387063*std::sin(0.350719839334488*x_17 - 1.15999984741211) - 0.00952410522985623*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.000806481798595484*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 0.00358173235975251*std::sin(0.366639852523804*x_19 - 1.15647983551025) + 0.00207024587248783*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.00746169725657889*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.00206303380640519*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.00714461370248068*std::sin(0.26759997010231*x_21 - 1.16415989398956) + 0.00151443643040602*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.00688601713730637*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.00220952875318069*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.00853955859297762*std::sin(0.384959846735001*x_22 + 1.97783982753754) - 0.0010186651214439*std::sin(0.399839848279953*x_22 + 2.00903987884521) - 0.0018187212491084*std::sin(0.288719952106476*x_23 - 4.34591960906982) + 0.00853036540234528*std::sin(0.4129598736763*x_23 + 5.19824028015137) - 0.00523742671704656*std::sin(0.322079926729202*x_25 - 1.20271992683411) + 0.00222493374487866*std::sin(0.337679862976074*x_25 - 1.15311992168427) - 0.000886923192026091*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 0.00888458880702851*std::sin(0.34239986538887*x_26 - 1.13975989818573) + 0.00749211380256734*std::sin(0.364879846572876*x_26 - 1.15215992927551) + 8.00617987041774e-5*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.00120412722789262*std::sin(0.412559866905212*x_26 - 1.19311988353729) - 0.000893043931528544*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.00484784204860751*std::sin(0.328879833221436*x_27 + 5.02975988388062) - 0.00208106125450407*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.00562020787836403*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.00046892918883808*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.00284196357424768*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.00869815183140953*std::sin(0.357999831438065*x_3 - 4.19871997833252) - 0.00148726384967483*std::sin(0.377839833498001*x_3 - 1.20415985584259) - 0.00517967735258626*std::sin(0.510479867458344*x_3 + 1.96471977233887) + 0.00795740318694229*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.0057447179605209*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.000520539642113803*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 0.00984103401327493*std::sin(0.343999862670898*x_31 - 4.24528026580811) + 0.000826515109367253*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 0.000572190071657065*std::sin(0.526799857616425*x_31 + 5.36439990997314) - 0.000624824886326171*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.015587683066829*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.0132609613263672*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.000943962191056903*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.00418347980752415*std::sin(0.232719987630844*x_35 + 1.9592798948288) + 0.000509333999442293*std::sin(0.232959985733032*x_35 + 1.97247982025146) + 0.00413930173618894*std::sin(0.250159978866577*x_36 - 7.42375993728638) + 0.00412534353240577*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.00386267491304841*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.00808496135599504*std::sin(0.233839988708496*x_39 + 1.97919988632202) + 0.00126494950170307*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.00227436890725715*std::sin(0.374879837036133*x_4 + 1.99583983421326) + 0.0137669534367748*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.00463464392280075*std::sin(0.244479969143867*x_41 - 7.42392015457153) - 0.011443745368528*std::sin(0.243519976735115*x_42 - 7.4346399307251) - 0.00589770694761328*std::sin(0.112000063061714*x_43 - 1.25247991085052) - 0.000948640994250813*std::sin(0.270159959793091*x_44 - 7.45815992355347) - 0.00483126102529242*std::sin(0.222240000963211*x_45 + 1.98055982589722) + 0.0162950141051332*std::sin(0.120480060577393*x_47 + 1.96895980834961) - 0.000658432651107228*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.00707139467329334*std::sin(0.221279993653297*x_48 - 7.40007972717285) + 0.0087848634598704*std::sin(0.0957600772380829*x_49 + 8.14239978790283) + 0.00599299021782119*std::sin(0.331039845943451*x_5 - 1.16375982761383) - 0.00283989540292488*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.000664499015443685*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.00323523208475467*std::sin(0.23039998114109*x_50 - 7.42743968963623) - 0.00865220235307437*std::sin(0.205919995903969*x_51 - 1.20511984825134) + 0.0123748229421864*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.00720801139419417*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.000496268726093722*std::sin(0.247999966144562*x_53 + 1.98495984077454) + 0.00408978196047586*std::sin(0.253679990768433*x_53 + 5.17080020904541) + 0.00348654710107083*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.0111702159937493*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.000949653768743379*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.0110631763097084*std::sin(0.246799975633621*x_57 + 5.15375995635986) - 0.00602559062072692*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.006051655913412*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.0100836437551341*std::sin(0.381519854068756*x_6 + 2.00575971603394) - 0.000553552527635565*std::sin(0.435519844293594*x_6 + 1.9508798122406) - 0.00223768453207272*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.00657567333740285*std::sin(0.395279824733734*x_60 - 1.18623995780945) + 0.000523536835115744*std::sin(0.461039870977402*x_60 + 1.88791978359222) + 0.0457335718510238*std::sin(0.133520036935806*x_61 + 8.08407974243164) - 0.00264838453100152*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.00653654555717615*std::sin(0.364559859037399*x_7 + 2.00311970710754) + 0.000641564247471455*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 0.00425409303689452*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.00499585115615296*std::sin(0.386879861354828*x_8 + 8.19487953186035) - 0.000927344168610994*std::sin(0.327839851379395*x_9 - 1.09671986103058) + 0.00167514068972831*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 0.00379660159270745*std::sin(0.242319971323013*x_91 + 8.42840003967285) - 0.00222183658292129*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.000773613301367703*std::sin(0.372959852218628*x_91 + 5.20560026168823) + 0.00346391867019941*std::sin(0.267439961433411*x_92 - 7.39351987838745) + 0.00360342280098104*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.00646836836435691*std::sin(0.2360799908638*x_93 + 1.96975982189178) + 0.000767576176906501*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.00405585264633949*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.000177391214203503*std::sin(0.304079920053482*x_94 + 1.96951985359192) - 0.000757290257373452*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 0.004843376749073*std::sin(0.287439942359924*x_95 + 1.96047985553741) - 0.00289610925903509*std::sin(0.292799949645996*x_95 - 1.22199988365173) + 0.00273868841683833*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.00393222623201112*std::sin(0.249119967222214*x_97 - 7.40423965454102) - 0.000685680448783197*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 0.00411241581344966*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.00601942609213586*std::sin(0.286639958620071*x_97 - 1.21999979019165) - 0.0139729196887253*std::sin(0.242959976196289*x_98 - 7.42695951461792) + 0.16888808987359);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.12354320444012e-6*x_1 - 2.82974893103479e-5*x_10 + 0.000173246912108368*x_100 + 0.00234514005400131*x_101 + 0.000400167382886725*x_102 + 0.00138069564306693*x_103 - 0.00289980502695007*x_104 - 0.00163352534352663*x_105 - 0.000640515196939802*x_106 + 0.00227193821400639*x_107 + 0.000263020370479632*x_108 + 0.00301684914052223*x_109 - 0.00080600032230112*x_11 - 0.00241520880813038*x_110 - 0.00323888993647956*x_111 - 0.00159658764056473*x_112 - 0.00118239451499881*x_113 + 0.00349447836876388*x_114 - 0.000212915806639978*x_115 - 1.45452439113556e-5*x_116 - 0.000532498322362105*x_117 + 0.00128135556915985*x_118 + 0.000262718841288158*x_119 - 0.0018635159900515*x_12 - 0.00137701050619038*x_120 - 3.01604401911641e-5*x_13 + 0.00149284485498187*x_15 + 0.000999848718158281*x_17 - 0.00114860080608625*x_18 + 0.000459897826783374*x_19 + 7.47735545655289e-5*x_2 - 0.00027539215421219*x_20 - 0.000210352552954772*x_21 + 0.000319191042694336*x_22 + 0.000186460121570893*x_24 - 2.62685272580625e-5*x_25 + 0.000512499462899788*x_27 + 0.000384322580695432*x_28 - 0.000837615589005468*x_29 - 2.86848963258554e-5*x_3 + 0.000298802105233714*x_30 - 8.09162453023886e-5*x_32 - 0.00123965030477475*x_33 - 0.00200424769089129*x_34 + 0.000315847002888541*x_35 + 0.00147548450397628*x_36 - 0.00047110657221998*x_37 + 0.000648090654271985*x_38 - 0.00211023951762763*x_39 - 0.00107286139555715*x_4 - 0.0014658768602468*x_40 - 0.000926628074847852*x_41 + 0.00049168361215579*x_42 - 0.00141800079370851*x_43 - 0.000268075328436245*x_44 + 7.73008936452374e-5*x_45 - 0.00220832720007607*x_46 - 0.0011567168203077*x_47 + 0.00147051029859509*x_48 - 2.78664087399613e-5*x_49 - 0.000222449803056461*x_5 - 0.000494565225895448*x_50 - 0.000869007925984385*x_51 + 0.00438404960315971*x_52 + 7.31838470857764e-5*x_53 + 0.00164795095157597*x_54 + 0.00431265483001727*x_55 + 0.00299201568529563*x_56 + 0.00149683634651955*x_57 - 0.00104990132897979*x_58 - 0.000923277857227639*x_59 + 2.66601376085784e-5*x_6 - 2.50997557930358e-5*x_60 + 0.000962827286064446*x_61 + 0.000905705027798228*x_62 - 0.000202042459665567*x_63 - 0.000750076804873191*x_64 - 0.000806079228830531*x_65 + 0.00191884138254863*x_66 + 0.000487416506683261*x_67 - 5.17938392202918e-5*x_68 + 0.000291816259361132*x_69 + 0.000203767721516091*x_7 - 0.00145198483181852*x_70 - 0.00179970212324702*x_71 + 0.00045969403232209*x_72 + 0.000638207256055635*x_73 + 0.000151609332034149*x_74 + 0.0013485057309664*x_75 - 0.00027851448009893*x_76 - 0.000412355393124398*x_77 - 0.00124277540188341*x_78 + 0.00125572161163512*x_79 - 0.000530411086876688*x_8 - 0.000620511334864442*x_80 - 0.00122523263780095*x_81 + 0.00109307830832204*x_82 + 0.000664285568753188*x_83 + 0.00133258053670226*x_84 - 0.000308586628314488*x_85 + 0.00014820719959178*x_86 + 0.000665246585375925*x_87 + 0.00144237020496037*x_88 - 0.00150179063647277*x_89 + 0.000138903169454233*x_9 - 0.000162296744822007*x_90 + 0.000526843316709752*x_91 + 0.00016611460625664*x_92 + 0.000330548856412345*x_93 + 0.00181735099241202*x_94 - 0.00139552446903078*x_95 - 0.000585801826836464*x_96 + 0.00261580297706894*x_98 + 0.00150088807378577*x_99 + 1.2934177998728e-6*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 0.00013773347590207*std::exp(0.277599841356277*x_13) - 0.000290985774770486*std::exp(0.275439828634262*x_23) + 0.00453350594050697*std::exp(0.143199846148491*x_49) + 0.000979191120095067*std::exp(0.147999867796898*x_49) + 1.12168693599044e-6*std::exp(0.0203804983661311*x_1 + 0.0207427427863204*x_101 - 0.0580308095748051*x_103 + 0.0304067055702673*x_105 + 0.0368909087503506*x_107 + 0.0596007981811121*x_109 + 0.00215616772615265*x_11 + 0.0213337034695094*x_110 + 0.030610148273029*x_111 - 0.0143307031150654*x_112 - 0.0790291364501553*x_114 - 0.0596603593929619*x_115 + 0.0325601989750448*x_117 - 0.0155198549993045*x_118 - 0.0309069804759277*x_119 + 0.03996334179879*x_12 - 0.0958974689924812*x_120 + 0.028814848791617*x_15 - 0.00842169721560891*x_16 - 0.0505758162301887*x_19 + 0.0530339758481964*x_20 - 0.0351642826449628*x_21 - 0.0042476144359567*x_22 + 0.0277450036309252*x_23 + 0.0197021431137246*x_28 + 0.0218175326342043*x_32 + 0.00229324506092253*x_33 + 0.00284025629565532*x_34 - 0.0783077599980863*x_36 - 0.0610044514451628*x_37 + 0.0652312635323622*x_38 + 0.00813521488692071*x_39 + 0.0502274596127879*x_40 + 0.0463885407208686*x_41 - 0.0127634493775237*x_42 - 0.0885986649018536*x_43 + 0.00524468006142681*x_44 - 0.0012449655877959*x_45 + 0.0395159080218628*x_46 - 0.0247397748319747*x_48 + 0.0184408577364469*x_5 + 0.04136697160103*x_50 - 0.0045544529466502*x_52 - 0.00430816640799081*x_54 + 0.0482551988236829*x_56 - 0.00508354626957426*x_57 + 0.00348652127155112*x_6 + 0.00450407610980349*x_61 - 0.00043192785501228*x_62 + 0.0324711213502124*x_63 + 0.00791313288513914*x_64 - 0.0234129275649539*x_65 + 0.0101038717783016*x_66 + 0.0161726973345328*x_67 + 0.0165060972923788*x_68 + 0.0115689887713231*x_69 - 0.0226638778304664*x_70 + 0.0160264021508291*x_71 + 0.0187516631896446*x_72 + 0.026855708042327*x_73 - 0.0300570558441271*x_74 - 0.0205372088105742*x_75 - 0.0302906923521915*x_76 - 0.0270149272627046*x_77 - 0.0136049675715402*x_78 - 0.0427463948230948*x_79 + 0.06853265597766*x_8 + 0.0355397001007973*x_80 - 0.0320877582583219*x_81 + 0.034311173938213*x_82 + 0.0107450029583842*x_83 - 0.0265511979681545*x_84 + 0.0130453408608825*x_85 + 0.0423252081546084*x_86 + 0.0205891500173804*x_87 - 0.0414782879570279*x_88 + 0.0122737654763838*x_89 - 4.89083460779535e-6*x_90 - 0.0132625041436159*x_91 - 0.00122970476442212*x_93 + 0.025121971860077*x_94 - 0.0253842616623441*x_96 - 0.0303675706325404*x_99 - 6.16397353619264e-5*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 0.000982232821984813*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) - 0.395377806171666*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.242365553182537*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.15927335138997*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.31818208069069*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.301243459224381*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.405565590331989*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.331084778973079*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.26779778404812*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.246298402419463*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.190352553184852*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.440894536467766*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.290019749036716*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 0.282063889722792*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.378840894232368*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.273966057281463*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.241594638923104*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.202589951146948*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 3.99759239336106*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 0.0763590200963193*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.396036854203601*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.221655434148182*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.546944217477972*std::sin(0.198079988360405*x_47 + 1.98031985759735) - 0.105150648125978*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.57961103869907*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.361997691212252*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.393420662293735*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 3.95213541504802*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 3.70680869284058*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.228591637594242*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.235635977209405*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.483762321388852*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.330030486848685*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.181269683370004*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.452723972614493*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.37287521645645*std::sin(0.22791999578476*x_98 - 4.21591997146606)) - 0.0114102354665326*std::sin(0.304559946060181*x_1 - 4.28071975708008) - 0.00683640020592929*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.00124290633978791*std::sin(0.444319844245911*x_1 - 7.17479991912842) - 0.0064347064720165*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.00743765804379549*std::sin(0.346559852361679*x_10 - 1.14743983745575) - 0.00862027549873939*std::sin(0.253279983997345*x_100 - 1.22375988960266) - 0.00512485767804873*std::sin(0.235039994120598*x_101 + 1.9703197479248) - 0.00582581755749718*std::sin(0.211600005626678*x_102 - 1.21039986610413) + 0.00112267527945763*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 0.00540136369267527*std::sin(0.264079958200455*x_109 + 4.96231985092163) + 0.000950527951451065*std::sin(0.235759988427162*x_11 - 7.3951997756958) + 0.00117071481404666*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.0137873073956078*std::sin(0.250879973173141*x_112 - 7.428879737854) + 0.00071006600549812*std::sin(0.288159936666489*x_112 + 1.95711982250214) + 0.000775970406253589*std::sin(0.242639973759651*x_113 + 8.37351989746094) + 0.000711414521166327*std::sin(0.27975994348526*x_113 - 7.42360019683838) - 0.000438255924430174*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.00752024093016224*std::sin(0.222719997167587*x_116 + 8.38632011413574) - 0.000345078051357431*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.00749039887074618*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.00723821078176676*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.00127176555567066*std::sin(0.335679858922958*x_12 + 1.86047983169556) - 0.000829419312688693*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 0.00304306109729828*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.00487818956972358*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.0081752576538522*std::sin(0.432719856500626*x_13 + 1.9437597990036) + 0.00329281119660022*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.00704675248357377*std::sin(0.305359929800034*x_14 - 7.44343996047974) - 0.00728507298960186*std::sin(0.363359838724136*x_14 - 4.37039995193481) + 0.00135203066531623*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 0.00831551493512762*std::sin(0.253519982099533*x_15 - 7.40231990814209) - 0.00180184895847542*std::sin(0.28247994184494*x_15 - 7.42208003997803) + 0.000961538696746443*std::sin(0.289599925279617*x_15 + 5.16944026947021) - 0.00206589192989188*std::sin(0.153840035200119*x_16 + 8.35536003112793) + 0.00135434248815642*std::sin(0.261759966611862*x_16 - 1.1658399105072) - 0.00664525400851351*std::sin(0.336639851331711*x_16 - 1.15263986587524) + 0.00922601763755294*std::sin(0.439999878406525*x_16 - 1.23111987113953) + 0.000787629856861893*std::sin(0.303199917078018*x_17 + 2.02831983566284) - 0.00841985673446483*std::sin(0.350719839334488*x_17 - 1.15999984741211) - 0.00719321943817813*std::sin(0.429519861936569*x_18 + 1.96343982219696) - 0.00131973660668008*std::sin(0.31959992647171*x_19 + 1.98879981040955) + 0.000634125216546409*std::sin(0.366639852523804*x_19 - 1.15647983551025) + 0.00850973350501626*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.00563555572439154*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.00155813638338774*std::sin(0.471999853849411*x_20 + 1.92543983459473) + 0.00126491296841036*std::sin(0.26759997010231*x_21 - 1.16415989398956) + 0.00622508205634358*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.00520076491473705*std::sin(0.30839991569519*x_21 - 7.39879989624023) + 0.000391184420930055*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.00644962622545435*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.00166695597229719*std::sin(0.399839848279953*x_22 + 2.00903987884521) - 0.0074758430172471*std::sin(0.288719952106476*x_23 - 4.34591960906982) + 0.00644268293409423*std::sin(0.4129598736763*x_23 + 5.19824028015137) - 0.00395564294575329*std::sin(0.322079926729202*x_25 - 1.20271992683411) + 0.00914557709634875*std::sin(0.337679862976074*x_25 - 1.15311992168427) + 0.00145137187952518*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 0.00671021532884744*std::sin(0.34239986538887*x_26 - 1.13975989818573) - 0.00132643587243678*std::sin(0.364879846572876*x_26 - 1.15215992927551) - 0.000131014099426132*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.00494955790115235*std::sin(0.412559866905212*x_26 - 1.19311988353729) + 0.00146138793195862*std::sin(0.294559925794601*x_27 - 4.21248006820679) - 0.000858282691191488*std::sin(0.328879833221436*x_27 + 5.02975988388062) - 0.00855419006929987*std::sin(0.261439979076385*x_28 - 1.15511989593506) - 0.000995025641209463*std::sin(0.316079914569855*x_28 + 2.00583982467651) + 0.000767361417862353*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.0116818745875574*std::sin(0.281359940767288*x_29 - 1.16695988178253) - 0.0015399580034582*std::sin(0.357999831438065*x_3 - 4.19871997833252) - 0.00611338932277078*std::sin(0.377839833498001*x_3 - 1.20415985584259) - 0.0039120268956412*std::sin(0.510479867458344*x_3 + 1.96471977233887) + 0.0060099448609933*std::sin(0.263119965791702*x_30 - 1.18575978279114) - 0.00101706943870174*std::sin(0.331519842147827*x_30 - 1.15855991840363) + 0.000851817390202885*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 0.00743258452606681*std::sin(0.343999862670898*x_31 - 4.24528026580811) + 0.00339738550481087*std::sin(0.51039981842041*x_31 + 8.16663932800293) + 0.000101302977624021*std::sin(0.526799857616425*x_31 + 5.36439990997314) - 0.00256833902706841*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.011772825071376*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.0100155345284014*std::sin(0.173360019922256*x_33 + 5.19776010513306) - 0.00154471119004707*std::sin(0.247519969940186*x_33 + 1.97295987606049) + 0.000740661158458832*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.000833480340488034*std::sin(0.232959985733032*x_35 + 1.97247982025146) + 0.0170145754859009*std::sin(0.250159978866577*x_36 - 7.42375993728638) + 0.016957200371195*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.00291734158719729*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.00610628502933293*std::sin(0.233839988708496*x_39 + 1.97919988632202) - 0.00206997872228063*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.00934878004108526*std::sin(0.374879837036133*x_4 + 1.99583983421326) + 0.010397692452564*std::sin(0.236559987068176*x_41 - 1.22183990478516) + 0.000820537183120126*std::sin(0.244479969143867*x_41 - 7.42392015457153) - 0.00864305566179669*std::sin(0.243519976735115*x_42 - 7.4346399307251) - 0.0242424897843466*std::sin(0.112000063061714*x_43 - 1.25247991085052) + 0.00155236764039872*std::sin(0.270159959793091*x_44 - 7.45815992355347) - 0.0198588700814578*std::sin(0.222240000963211*x_45 + 1.98055982589722) + 0.0123070471585078*std::sin(0.120480060577393*x_47 + 1.96895980834961) + 0.00107746718427241*std::sin(0.142560034990311*x_47 + 8.20160007476807) - 0.00125194995831489*std::sin(0.221279993653297*x_48 - 7.40007972717285) + 0.0361101296782765*std::sin(0.0957600772380829*x_49 + 8.14239978790283) + 0.00452629330391108*std::sin(0.331039845943451*x_5 - 1.16375982761383) + 0.000502787228768073*std::sin(0.341359823942184*x_5 + 2.00831985473633) + 0.00108739425652404*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.013298402491225*std::sin(0.23039998114109*x_50 - 7.42743968963623) + 0.00153182291128133*std::sin(0.205919995903969*x_51 - 1.20511984825134) + 0.00934626558437255*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.00544395577537205*std::sin(0.238319978117943*x_53 - 7.42679977416992) + 0.000812100168555549*std::sin(0.247999966144562*x_53 + 1.98495984077454) + 0.0168110247385493*std::sin(0.253679990768433*x_53 + 5.17080020904541) + 0.0143314313903911*std::sin(0.196479991078377*x_54 + 8.19679927825928) + 0.00197762281612686*std::sin(0.202719986438751*x_56 - 1.1847198009491) - 0.0015540249568744*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.00835562532735555*std::sin(0.246799975633621*x_57 + 5.15375995635986) + 0.00106679633579671*std::sin(0.376559853553772*x_59 + 1.82895994186401) - 0.00107141104669862*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.00761581907345106*std::sin(0.381519854068756*x_6 + 2.00575971603394) - 0.00227537441509112*std::sin(0.435519844293594*x_6 + 1.9508798122406) - 0.00919798913225356*std::sin(0.340719848871231*x_60 + 8.27375984191895) + 0.00116418533273858*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.000856722033220043*std::sin(0.461039870977402*x_60 + 1.88791978359222) + 0.0345409474251543*std::sin(0.133520036935806*x_61 + 8.08407974243164) - 0.0108861690667435*std::sin(0.348799854516983*x_7 + 2.02463984489441) - 0.0011572579831722*std::sin(0.364559859037399*x_7 + 2.00311970710754) - 0.00104986352376432*std::sin(0.423439860343933*x_7 - 1.21351993083954) + 0.00075316282660933*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.0037731894786327*std::sin(0.386879861354828*x_8 + 8.19487953186035) - 0.00381184276089255*std::sin(0.327839851379395*x_9 - 1.09671986103058) - 0.00274122056247749*std::sin(0.128000050783157*x_90 + 2.00159978866577) + 0.000672166584574847*std::sin(0.242319971323013*x_91 + 8.42840003967285) - 0.00913284623030558*std::sin(0.368239849805832*x_91 + 1.98719990253448) + 0.00126595019876163*std::sin(0.372959852218628*x_91 + 5.20560026168823) + 0.0142384173581395*std::sin(0.267439961433411*x_92 - 7.39351987838745) + 0.0148118482687269*std::sin(0.235599994659424*x_93 + 1.98431980609894) - 0.00114518760135199*std::sin(0.2360799908638*x_93 + 1.96975982189178) - 0.00125607097499686*std::sin(0.248079970479012*x_93 - 1.20583987236023) + 0.000718065499963284*std::sin(0.292799949645996*x_94 + 4.9814395904541) - 0.000290285136621186*std::sin(0.304079920053482*x_94 + 1.96951985359192) + 0.00123923897139211*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 0.00365803095797776*std::sin(0.287439942359924*x_95 + 1.96047985553741) + 0.000512739570288436*std::sin(0.292799949645996*x_95 - 1.22199988365173) + 0.00206843438618876*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.00296987123564607*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.00112205581120362*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 0.016904061058321*std::sin(0.278879970312119*x_97 + 1.950239777565) + 0.00106570494128838*std::sin(0.286639958620071*x_97 - 1.21999979019165) - 0.0105532514695407*std::sin(0.242959976196289*x_98 - 7.42695951461792) + 0.0622283359915099);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.75649222724801e-5*x_1 + 8.25809421388775e-6*x_10 - 0.000114366559187412*x_100 - 0.00156776296965394*x_101 + 0.000805440553584134*x_102 - 0.000271827214591556*x_103 + 0.00120382235554936*x_104 - 0.000255708966867116*x_105 + 0.00112235176201222*x_106 - 0.00181801388165027*x_107 - 0.000429487225473214*x_108 - 0.00141908737793107*x_109 + 0.000781850053164909*x_11 + 0.00150049604953667*x_110 - 0.000345538515438638*x_111 - 0.000580638435824318*x_112 + 0.000337086968580792*x_113 - 0.00153119229269999*x_114 - 0.00135163454662135*x_115 - 2.17528940691102e-6*x_116 - 0.00140580311979389*x_117 - 0.00188541951714864*x_118 + 7.72187380835121e-5*x_119 + 0.000410008444694774*x_12 + 0.00125226117834627*x_120 - 0.000990111741416946*x_15 + 4.67097089690894e-5*x_16 - 0.000184721938850104*x_17 + 0.000517903197089738*x_18 + 0.000483117113751972*x_19 - 4.59930004305477e-5*x_2 - 0.000183417342790917*x_20 + 0.000195033538537665*x_21 - 0.000153969749098556*x_22 - 0.000153883595167122*x_23 + 0.000949329054495558*x_24 + 8.23687000443454e-5*x_25 - 2.63159909422535e-5*x_27 - 4.80020753098484e-5*x_28 + 1.6032785371169e-5*x_29 - 0.000356227676206252*x_30 - 0.000283790537491551*x_32 + 0.000466264536495261*x_33 + 0.0014862742318121*x_34 - 0.000251673132017081*x_35 + 0.000733074307818388*x_36 - 0.000134719048876272*x_37 - 0.0010894131889332*x_38 + 0.00144546420410018*x_39 + 9.6134681075872e-5*x_4 + 0.000181233152289434*x_40 + 0.000157608902914842*x_41 - 0.000303964816962977*x_42 - 0.000174615221376466*x_43 - 0.000475374025424805*x_44 - 0.000615984222022539*x_45 - 0.00111700661818121*x_46 + 0.000279130316151741*x_47 + 0.000315068754062552*x_48 + 2.14432069008169e-5*x_5 - 0.000683594841189216*x_50 + 0.000488617555982069*x_51 - 0.00143666177518754*x_52 - 0.000229478352154264*x_53 - 0.000252682049931255*x_54 - 0.00249805673287054*x_55 - 0.00182465927957956*x_56 - 0.0013598994944648*x_57 - 0.000343381666477278*x_58 - 0.000352306389014411*x_59 - 1.93374791018199e-5*x_6 - 3.7537516198005e-6*x_60 - 0.00048726470304569*x_61 - 0.000655450837244239*x_62 + 3.70011787364041e-5*x_63 + 0.000573469443987805*x_64 + 0.000585726691317655*x_65 - 0.000821503764510638*x_66 - 0.000488563942546618*x_67 + 0.000426088049644121*x_68 - 0.000445465324386888*x_69 + 3.0474137717161e-5*x_7 + 0.00082016401258565*x_70 + 0.000552862989912188*x_71 - 3.04947042068433e-5*x_72 - 0.00105635580150742*x_73 + 0.000410001013659231*x_74 - 0.000372136984237073*x_75 - 5.99129423851365e-5*x_76 + 0.000440872351877536*x_77 + 0.000284579855379494*x_78 - 0.000133192235543237*x_79 - 7.73332688399139e-5*x_8 + 0.000331963799483732*x_80 + 0.00064897826019457*x_81 - 0.000343626628664834*x_82 - 0.000930640202869675*x_83 + 0.000176115968247784*x_84 - 0.000351533757935561*x_85 - 0.000581095001603899*x_86 - 0.000940410482708643*x_87 - 0.000309182302653047*x_88 + 0.000293639113320374*x_89 + 0.000475149368311337*x_9 + 0.000674678997125413*x_90 + 0.000152349698064195*x_91 - 0.000118980215766845*x_92 + 5.62550535921015e-5*x_93 - 0.00105042346645265*x_94 + 0.000776166496787643*x_95 + 0.000525663046768633*x_96 - 0.00134025543369913*x_98 - 0.000477962845239412*x_99 + 3.41875755679147e-7*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) - 5.44781034988572e-6*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) + 0.000431882885979479*std::exp(0.277599841356277*x_13) + 0.000912427246635426*std::exp(0.275439828634262*x_23) + 0.00067800083028198*std::exp(0.143199846148491*x_49) - 0.00307039290268707*std::exp(0.147999867796898*x_49) - 0.028500417918336*std::exp(-0.0103919681428262*x_10 + 0.0707606973385521*x_100 + 0.0175129200619196*x_101 - 0.0803135503356578*x_102 + 0.0336909696767968*x_103 - 0.0746170628018059*x_104 + 0.0650917387588422*x_105 - 0.00665969215391455*x_106 - 0.046592964409216*x_107 + 0.106431934793893*x_109 + 0.000758849182423463*x_110 - 0.0964876343976193*x_111 + 0.0414352648321657*x_114 - 0.0788707901738772*x_115 + 0.0915470283561274*x_117 + 0.0972822138580605*x_118 + 0.0258256043178768*x_119 - 0.0122127473148807*x_13 - 0.0810469495796225*x_18 + 0.0243383808162919*x_2 + 0.0365969535495028*x_20 - 0.0851772242047482*x_21 - 0.0600780718884947*x_24 - 0.0102786337780801*x_28 - 0.0116152611951549*x_3 - 0.138357049402013*x_30 - 0.0537863034474216*x_32 - 0.0361948494830145*x_34 - 0.00720728670193151*x_36 - 0.020519824990995*x_37 - 0.0238037389005572*x_38 - 0.00697897980322676*x_39 + 0.100203273403554*x_40 - 0.0731527404508745*x_41 + 0.00762416333305362*x_42 - 0.00724456688908793*x_43 - 0.094142841516927*x_45 - 0.0733967911075729*x_46 + 0.0840439581817116*x_48 - 0.0112838342662529*x_49 - 0.104249895770511*x_50 + 0.00385166790851901*x_51 + 0.00783467213773212*x_52 - 0.122819884744014*x_54 + 0.113258206957948*x_55 - 0.0105877124047125*x_56 - 0.102668477422949*x_58 + 0.133823789587661*x_59 + 0.0107953836857097*x_6 + 0.00218190844571361*x_61 + 0.0157240412155775*x_62 - 0.0528248731571849*x_63 + 0.0353041269956108*x_64 + 0.0398768270596118*x_65 + 0.00574154348402038*x_66 + 0.0120805956856861*x_67 + 0.0666820787402231*x_68 - 0.0432263471449861*x_69 - 0.0799242193989807*x_70 + 0.0113190537896246*x_71 + 0.0433003427848428*x_72 + 0.0400197266952887*x_73 - 0.0702216550585841*x_74 + 0.0105297484488283*x_75 - 0.0217488560219379*x_76 - 0.0338895957144026*x_77 - 0.0576983100762919*x_78 - 0.0242294236915009*x_79 + 0.00565517505976199*x_8 + 0.0576724782518749*x_80 + 0.0467351998103384*x_81 + 0.000159180346984488*x_82 - 0.0547032456843278*x_83 + 0.0545243676437799*x_84 - 0.0448459786204661*x_85 + 0.00773986855868301*x_86 - 0.0436616948553437*x_87 + 0.0292437555529712*x_88 - 0.018028089004325*x_89 + 0.00729138985964758*x_9 + 0.00177534195741052*x_92 + 0.00316324331910988*x_96 - 0.00779267495476423*x_98 - 0.0470213621571964*x_99 + 0.000523738535057692*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 0.503285130047271*std::sin(0.444319844245911*x_1 - 7.17479991912842) + 0.45460044408423*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 0.474052902116728*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.287524208767209*std::sin(0.288159936666489*x_112 + 1.95711982250214) + 0.314210616136057*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.177461231679343*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.514970977768581*std::sin(0.335679858922958*x_12 + 1.86047983169556) - 0.335853469635916*std::sin(0.268559962511063*x_120 - 1.21983981132507) + 0.547472409978766*std::sin(0.377439826726913*x_14 + 5.02719974517822) - 0.729615545726947*std::sin(0.28247994184494*x_15 - 7.42208003997803) + 0.548408527223909*std::sin(0.261759966611862*x_16 - 1.1658399105072) + 0.318931831184877*std::sin(0.303199917078018*x_17 + 2.02831983566284) - 0.534395705017054*std::sin(0.31959992647171*x_19 + 1.98879981040955) + 0.674993864335605*std::sin(0.399839848279953*x_22 + 2.00903987884521) + 0.587698253480973*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 0.0530510191773248*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.591754013830847*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.310724612642987*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.344923034247246*std::sin(0.318639844655991*x_31 + 5.33767986297607) - 0.625493769949692*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.337497885501126*std::sin(0.232959985733032*x_35 + 1.97247982025146) - 0.838188266555839*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.628594065995802*std::sin(0.270159959793091*x_44 - 7.45815992355347) + 0.436294509569191*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.440314239527284*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.328840497356087*std::sin(0.247999966144562*x_53 + 1.98495984077454) - 0.629265156577041*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.346909051873601*std::sin(0.461039870977402*x_60 + 1.88791978359222) - 0.425117068901404*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 1.10999156019282*std::sin(0.128000050783157*x_90 + 2.00159978866577) + 0.512616188381365*std::sin(0.372959852218628*x_91 + 5.20560026168823) - 0.508615833521109*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.117544007990267*std::sin(0.304079920053482*x_94 + 1.96951985359192) + 0.501800117121576*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 0.454349605263316*std::sin(0.277839958667755*x_97 + 1.94815981388092)) + 0.00634617499450334*std::sin(0.304559946060181*x_1 - 4.28071975708008) - 0.00102240629583064*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.000962331667345327*std::sin(0.333759844303131*x_10 - 4.32592010498047) + 0.00413669635772603*std::sin(0.346559852361679*x_10 - 1.14743983745575) + 0.00219290503877136*std::sin(0.248559966683388*x_100 + 1.96343982219696) + 0.00479444766729728*std::sin(0.253279983997345*x_100 - 1.22375988960266) - 0.000766439441437117*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 0.00324021864530044*std::sin(0.211600005626678*x_102 - 1.21039986610413) + 0.00134424500946276*std::sin(0.237199977040291*x_102 + 1.95759987831116) + 0.000883386293699601*std::sin(0.19743999838829*x_104 - 4.40719985961914) - 0.00176475026443549*std::sin(0.24551996588707*x_106 + 4.98847961425781) - 0.00167080268370764*std::sin(0.250399976968765*x_108 + 1.97543978691101) + 0.000807791831828779*std::sin(0.264079958200455*x_109 + 4.96231985092163) - 0.00298051546429229*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.00766826115834107*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.00223074132498827*std::sin(0.27975994348526*x_113 - 7.42360019683838) + 0.00224941009006751*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.00418262752627831*std::sin(0.222719997167587*x_116 + 8.38632011413574) - 0.00183631318889795*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.00108204126652831*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.00112021396247276*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.00108249839841283*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.000455099866999691*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.00072954940876853*std::sin(0.308319926261902*x_13 + 5.13216018676758) - 0.00148530114954392*std::sin(0.385039836168289*x_13 - 7.36183977127075) - 0.00454693646320211*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.0103250774240562*std::sin(0.135680049657822*x_14 - 1.24679982662201) - 0.00136605798119197*std::sin(0.251679986715317*x_14 - 7.24671983718872) + 0.00105386517572763*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 0.00405183119799302*std::sin(0.363359838724136*x_14 - 4.37039995193481) + 0.00124361280303258*std::sin(0.253519982099533*x_15 - 7.40231990814209) - 0.00301504122082176*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.00647789771484313*std::sin(0.153840035200119*x_16 + 8.35536003112793) + 0.00369597498181754*std::sin(0.336639851331711*x_16 - 1.15263986587524) + 0.00137978149814833*std::sin(0.439999878406525*x_16 - 1.23111987113953) + 0.00105576253018313*std::sin(0.337039858102798*x_17 - 7.58064031600952) + 0.00468297822795055*std::sin(0.350719839334488*x_17 - 1.15999984741211) + 0.00244535691051699*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.00107576979394889*std::sin(0.429519861936569*x_18 + 1.96343982219696) - 0.00198838972733941*std::sin(0.366639852523804*x_19 - 1.15647983551025) - 0.00473296612833466*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.000842816025914493*std::sin(0.406079858541489*x_2 - 7.40823984146118) + 0.00160855202056963*std::sin(0.417119860649109*x_2 - 1.17111992835999) - 0.000233024457338929*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.00396631435990448*std::sin(0.26759997010231*x_21 - 1.16415989398956) - 0.0034622826321659*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.000777791620120562*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.00122661434015944*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.000964562965892458*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.00415793417743581*std::sin(0.288719952106476*x_23 - 4.34591960906982) + 0.000963524573670449*std::sin(0.4129598736763*x_23 + 5.19824028015137) - 0.00156442601322949*std::sin(0.389839857816696*x_24 + 5.22088003158569) - 0.00210118548104369*std::sin(0.243119969964027*x_25 - 7.38488006591797) - 0.00059157950529119*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 0.00508661130170247*std::sin(0.337679862976074*x_25 - 1.15311992168427) - 0.00100353492948565*std::sin(0.34239986538887*x_26 - 1.13975989818573) + 0.00415922816804549*std::sin(0.364879846572876*x_26 - 1.15215992927551) - 0.00275285822788413*std::sin(0.412559866905212*x_26 - 1.19311988353729) - 0.00151951257275173*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.00269126734245472*std::sin(0.328879833221436*x_27 + 5.02975988388062) - 0.00133996924654035*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.00475769209805069*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.00312004429376829*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.00649725596057395*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.00482875715191858*std::sin(0.357999831438065*x_3 - 4.19871997833252) + 0.00340016107166467*std::sin(0.377839833498001*x_3 - 1.20415985584259) - 0.00112363546395342*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 0.000585056580522217*std::sin(0.510479867458344*x_3 + 1.96471977233887) + 0.0221720601549126*std::sin(0.0844800844788551*x_30 + 4.86079978942871) + 0.000898807161427632*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.00318916575328683*std::sin(0.331519842147827*x_30 - 1.15855991840363) + 0.00111156763572053*std::sin(0.343999862670898*x_31 - 4.24528026580811) + 0.000423514110582523*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.00188956687182818*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 0.000317649881759206*std::sin(0.526799857616425*x_31 + 5.36439990997314) + 0.00142846560518367*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.00176066498597437*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.00149785636438685*std::sin(0.173360019922256*x_33 + 5.19776010513306) - 0.00232244831224286*std::sin(0.232719987630844*x_35 + 1.9592798948288) + 0.00219656035206276*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.00946321167581716*std::sin(0.250159978866577*x_36 - 7.42375993728638) - 0.00943130063249807*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.000436298097828173*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.000913215152721996*std::sin(0.233839988708496*x_39 + 1.97919988632202) + 0.00122937937038267*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.00519962925391553*std::sin(0.374879837036133*x_4 + 1.99583983421326) + 0.00155500934781322*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.00257291093816116*std::sin(0.244479969143867*x_41 - 7.42392015457153) - 0.00129259760365864*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 0.0134832522015144*std::sin(0.112000063061714*x_43 - 1.25247991085052) + 0.0110451589802587*std::sin(0.222240000963211*x_45 + 1.98055982589722) + 0.00184055966867325*std::sin(0.120480060577393*x_47 + 1.96895980834961) + 0.00303354591914941*std::sin(0.198079988360405*x_47 + 1.98031985759735) + 0.00392566699967237*std::sin(0.221279993653297*x_48 - 7.40007972717285) - 0.0200838276023931*std::sin(0.0957600772380829*x_49 + 8.14239978790283) + 0.000583202654540036*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.000676922156587778*std::sin(0.331039845943451*x_5 - 1.16375982761383) - 0.00157656080318755*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.00739634073321182*std::sin(0.23039998114109*x_50 - 7.42743968963623) - 0.00321472765403234*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.00480324841438004*std::sin(0.205919995903969*x_51 - 1.20511984825134) + 0.001397764976907*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.00081416161887898*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.00935000028182409*std::sin(0.253679990768433*x_53 + 5.17080020904541) + 0.00200776712473912*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.00797089348347856*std::sin(0.196479991078377*x_54 + 8.19679927825928) + 0.00218205002717354*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 0.00620111736536009*std::sin(0.202719986438751*x_56 - 1.1847198009491) - 0.00124961144505276*std::sin(0.246799975633621*x_57 + 5.15375995635986) + 0.0219199396887812*std::sin(0.0653600990772247*x_58 + 4.88775968551636) - 0.020559270989435*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.00334509150545072*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.00335956158724619*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.00113897096923176*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 0.00126552377105081*std::sin(0.435519844293594*x_6 + 1.9508798122406) + 0.00511576196670371*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.00365046854459413*std::sin(0.395279824733734*x_60 - 1.18623995780945) + 0.00126785000593524*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.00516571310158291*std::sin(0.133520036935806*x_61 + 8.08407974243164) - 0.00130692040289678*std::sin(0.310879945755005*x_7 - 7.38831996917725) + 0.00605469835569462*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.00362874685563418*std::sin(0.364559859037399*x_7 + 2.00311970710754) - 0.00236164906924861*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.000564292984920655*std::sin(0.386879861354828*x_8 + 8.19487953186035) + 0.00268311679508066*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.00212008080666771*std::sin(0.327839851379395*x_9 - 1.09671986103058) - 0.00210767384257085*std::sin(0.242319971323013*x_91 + 8.42840003967285) + 0.00507953061489469*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.00791916069256949*std::sin(0.267439961433411*x_92 - 7.39351987838745) - 0.00183046571219129*std::sin(0.293839931488037*x_92 + 1.98743987083435) - 0.00823809301579097*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.00359089845820395*std::sin(0.2360799908638*x_93 + 1.96975982189178) - 0.00225159641412767*std::sin(0.292799949645996*x_94 + 4.9814395904541) - 0.00100538572432157*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.000547070646703235*std::sin(0.287439942359924*x_95 + 1.96047985553741) - 0.00160776778427851*std::sin(0.292799949645996*x_95 - 1.22199988365173) + 0.000309341213979516*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.000444154080753985*std::sin(0.249119967222214*x_97 - 7.40423965454102) - 0.00251096714388632*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.0094017454686651*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.00334166928287985*std::sin(0.286639958620071*x_97 - 1.21999979019165) - 0.00206809772383958*std::sin(0.22791999578476*x_98 - 4.21591997146606) - 0.001578273714079*std::sin(0.242959976196289*x_98 - 7.42695951461792) + 0.124257954234019);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000998343164780322*x_1 + 6.29147383143948e-6*x_10 - 5.90933651752701e-5*x_100 + 0.000256734367558402*x_101 - 1.78903311591497e-5*x_102 - 0.00385390966454711*x_103 + 0.00116934751662575*x_104 + 0.00213141819364215*x_105 + 0.000274550227898491*x_106 + 0.000737578284589604*x_107 - 0.000685252812460276*x_108 + 0.00251414760468499*x_109 + 0.000116795864780613*x_11 + 0.00227399842485979*x_110 + 0.00244302611133935*x_111 + 0.000142917124495375*x_112 + 0.000488509330446317*x_113 - 0.00513190550628059*x_114 - 0.0030215781690162*x_115 + 9.5936125147177e-6*x_116 + 0.00181709780266352*x_117 - 0.00112630357093367*x_118 - 0.00152259604969273*x_119 + 0.00206888668608953*x_12 - 0.00428652277833046*x_120 + 0.000996734854962327*x_15 - 0.000404519508899051*x_16 - 0.000835422093512855*x_17 + 0.000238150438488089*x_18 - 0.00280851618370443*x_19 - 3.50400166362293e-5*x_2 + 0.00256574959906113*x_20 - 0.00168904651665267*x_21 - 0.000286842113128078*x_22 + 0.00133267617629171*x_23 - 0.000822820204283001*x_24 + 6.27530405244334e-5*x_25 - 0.000279655725264881*x_27 + 0.000676123012081317*x_28 + 0.000626847662242255*x_29 - 0.000166178867712583*x_30 + 0.000923944921145879*x_32 + 0.000258020889399716*x_33 + 0.000745356262719913*x_34 - 3.88583923422731e-5*x_35 - 0.00470657883886961*x_36 - 0.00286885126141661*x_37 + 0.00267373547584274*x_38 + 0.00120333643140513*x_39 + 0.000842694471252763*x_4 + 0.00286189986968525*x_40 + 0.00242172895988747*x_41 - 0.000828016341858241*x_42 - 0.00357255797619882*x_43 - 0.000489230860917184*x_44 - 0.000616410159541851*x_45 + 0.00261784734696079*x_46 - 5.56333204560432e-7*x_47 - 0.00201508348878842*x_48 + 0.000943486179502376*x_5 + 0.00192296794040659*x_50 + 0.000227938247421789*x_51 - 0.00238111498997069*x_52 - 0.000174829326242418*x_53 - 0.00179313564390145*x_54 - 0.00183819719621744*x_55 + 0.00146580080880245*x_56 - 0.00109119699247804*x_57 + 0.000932894989519366*x_58 + 0.000920381083970743*x_59 + 0.00016746812862376*x_6 + 1.65550562616853e-5*x_60 + 2.59055990644083e-5*x_61 - 0.000344026260907583*x_62 + 0.00190048608090465*x_63 + 0.000631129732369548*x_64 - 0.000920458132802217*x_65 - 0.000337570380283805*x_66 + 0.000845669641298263*x_67 + 0.000481292877538984*x_68 + 0.000688527321453262*x_69 - 0.000134399159969129*x_7 - 0.000474233028133733*x_70 + 0.00166732504547466*x_71 + 0.000553807543096474*x_72 + 0.00125809134518316*x_73 - 0.00180677949328819*x_74 - 0.00129803662413234*x_75 - 0.0015648145970614*x_76 - 0.00137049379703192*x_77 - 0.000402198815602061*x_78 - 0.00253581963893481*x_79 + 0.00343307258538172*x_8 + 0.00195291040687713*x_80 - 0.00109302023460973*x_81 + 0.00110974311694339*x_82 + 0.000232919122556932*x_83 - 0.00153176485854055*x_84 + 0.000466960383820827*x_85 + 0.0017808464527093*x_86 + 0.000863508079121341*x_87 - 0.00231549490223053*x_88 + 0.0012905627825216*x_89 + 0.000160862554080815*x_9 + 2.35593632057012e-5*x_90 - 0.00098452832410583*x_91 - 0.00018203623843766*x_92 - 0.00027708667273358*x_93 + 0.00067864015186424*x_94 + 0.000362078744038778*x_95 - 0.00102009560858072*x_96 - 0.000580231393895217*x_98 - 0.00190503702327953*x_99 - 2.9607423348182e-6*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 4.71796038971103e-5*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) + 0.00145924161188304*std::pow(0.0289155735477197*x_10 - 0.196891110524939*x_100 - 0.0487295689445842*x_101 + 0.223471852462552*x_102 - 0.093744870865094*x_103 + 0.207621418551968*x_104 - 0.181117275723132*x_105 + 0.0185305435539294*x_106 + 0.129644574604572*x_107 - 0.29614606165661*x_109 - 0.00211149216822225*x_110 + 0.268476120261766*x_111 - 0.115293314149623*x_114 + 0.219457383115041*x_115 - 0.254728920944023*x_117 - 0.270687031661043*x_118 - 0.0718595506456955*x_119 + 0.0339818779609065*x_13 + 0.225512530367569*x_18 - 0.0677213623880977*x_2 - 0.101830749232391*x_20 + 0.237004988586617*x_21 + 0.16716678519614*x_24 + 0.0286002215264028*x_28 + 0.0323193773064374*x_3 + 0.38497745401492*x_30 + 0.149659986618369*x_32 + 0.100711897678135*x_34 + 0.0200542212836812*x_36 + 0.0570962593955843*x_37 + 0.0662337252606886*x_38 + 0.0194189590474795*x_39 - 0.278814857974992*x_40 + 0.203546952574592*x_41 - 0.0212141773884215*x_42 + 0.0201579531253092*x_43 + 0.261951751627839*x_45 + 0.20422602169953*x_46 - 0.233851684362828*x_48 + 0.0313971843583213*x_49 + 0.290074554412031*x_50 - 0.0107172371161527*x_51 - 0.0217999165612581*x_52 + 0.341745409688308*x_54 - 0.31514011284149*x_55 + 0.0294602304907863*x_56 + 0.285674269700783*x_58 - 0.372363692524195*x_59 - 0.0300380742752256*x_6 - 0.00607114391319375*x_61 - 0.0437520269488389*x_62 + 0.14698481403448*x_63 - 0.0982334690262043*x_64 - 0.110956972716269*x_65 - 0.0159758017545723*x_66 - 0.0336141670421559*x_67 - 0.185542384813679*x_68 + 0.120276987274345*x_69 + 0.222388542046357*x_70 - 0.0314951824183975*x_71 - 0.120482879588205*x_72 - 0.111354589882581*x_73 + 0.195391229416998*x_74 - 0.0292989462175426*x_75 + 0.0605160290368329*x_76 + 0.0942975463275228*x_77 + 0.160545115772114*x_78 + 0.0674181900041813*x_79 - 0.0157354822607555*x_8 - 0.160473238914089*x_80 - 0.13004034354321*x_81 - 0.000442918123624052*x_82 + 0.152211371526971*x_83 - 0.151713644718492*x_84 + 0.124783599727904*x_85 - 0.0215361263123942*x_86 + 0.121488339018756*x_87 - 0.0813705308639934*x_88 + 0.050163022669508*x_89 - 0.0202882376903052*x_9 - 0.00493987570365044*x_92 - 0.00880170085068979*x_96 + 0.0216830597141032*x_98 + 0.130836588130707*x_99 - 0.00145729855231418*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) + 1.40038710601722*std::sin(0.444319844245911*x_1 - 7.17479991912842) - 1.26492233185086*std::sin(0.256479978561401*x_108 + 5.14879989624023) - 1.31904865067632*std::sin(0.345119833946228*x_11 + 5.07279968261719) - 0.800033958061874*std::sin(0.288159936666489*x_112 + 1.95711982250214) - 0.874288686751648*std::sin(0.242639973759651*x_113 + 8.37351989746094) + 0.493784548409657*std::sin(0.20168000459671*x_116 + 8.19727993011475) + 1.43290288980417*std::sin(0.335679858922958*x_12 + 1.86047983169556) + 0.934509764564488*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 1.52333788157506*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 2.03014979300058*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 1.52594262080051*std::sin(0.261759966611862*x_16 - 1.1658399105072) - 0.887425432274966*std::sin(0.303199917078018*x_17 + 2.02831983566284) + 1.48695204793071*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 1.87816537350812*std::sin(0.399839848279953*x_22 + 2.00903987884521) - 1.63526598992959*std::sin(0.354159832000732*x_25 + 2.04983973503113) + 0.147614063642254*std::sin(0.394799828529358*x_26 + 5.19792032241821) - 1.64655111273568*std::sin(0.294559925794601*x_27 - 4.21248006820679) - 0.864588908133577*std::sin(0.278399974107742*x_29 + 5.01567983627319) - 0.959745760187296*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 1.74043173151048*std::sin(0.247519969940186*x_33 + 1.97295987606049) + 0.939085339396897*std::sin(0.232959985733032*x_35 + 1.97247982025146) + 2.33225257577047*std::sin(0.293199926614761*x_4 - 7.37039995193481) - 1.74905828204537*std::sin(0.270159959793091*x_44 - 7.45815992355347) - 1.21398620612815*std::sin(0.142560034990311*x_47 + 8.20160007476807) - 1.22517107463889*std::sin(0.371279835700989*x_5 + 2.02111983299255) - 0.91499622170538*std::sin(0.247999966144562*x_53 + 1.98495984077454) + 1.75092558656289*std::sin(0.238239988684654*x_57 - 7.42631959915161) + 0.965271839362352*std::sin(0.461039870977402*x_60 + 1.88791978359222) + 1.18288506116095*std::sin(0.423439860343933*x_7 - 1.21351993083954) + 3.08854320519259*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 1.42635070596569*std::sin(0.372959852218628*x_91 + 5.20560026168823) + 1.41521974851962*std::sin(0.248079970479012*x_93 - 1.20583987236023) + 0.327065322124049*std::sin(0.304079920053482*x_94 + 1.96951985359192) - 1.39625506867048*std::sin(0.283599942922592*x_95 - 1.20095992088318) - 1.26422437470982*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 8.0461450455213, 2) + 0.000329032317264791*std::exp(0.277599841356277*x_13) + 0.000695137642731813*std::exp(0.275439828634262*x_23) - 0.00299016637957096*std::exp(0.143199846148491*x_49) - 0.00233919547284978*std::exp(0.147999867796898*x_49) + 0.00296046670523676*std::sin(0.304559946060181*x_1 - 4.28071975708008) + 0.00450908729828989*std::sin(0.380799859762192*x_1 - 4.21895980834961) + 0.00424414199684048*std::sin(0.333759844303131*x_10 - 4.32592010498047) + 0.00192975325252286*std::sin(0.346559852361679*x_10 - 1.14743983745575) - 0.0189911881046631*std::sin(0.248559966683388*x_100 + 1.96343982219696) + 0.00223659175823664*std::sin(0.253279983997345*x_100 - 1.22375988960266) + 0.0033802044885539*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 0.00151154978004984*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.0116415482577235*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.00765037928050448*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.0152832446627173*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.0144696316033118*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.00356257967445538*std::sin(0.264079958200455*x_109 + 4.96231985092163) - 0.0022707218593196*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.00357721491543989*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.00169950236790373*std::sin(0.27975994348526*x_113 - 7.42360019683838) - 0.0194805380943142*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.00195117996945856*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.0159030001631871*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.000824359003007256*std::sin(0.269519954919815*x_116 - 1.24311995506287) - 0.00494044546688669*std::sin(0.245439976453781*x_119 - 7.43943977355957) - 0.00477410966521568*std::sin(0.295919924974442*x_12 + 5.14359998703003) + 0.0020071130607373*std::sin(0.29751992225647*x_120 + 1.75015985965729) + 0.00321750950279553*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.0128631349850266*std::sin(0.385039836168289*x_13 - 7.36183977127075) - 0.00212112871482365*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.00786621619208362*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.0118304548642144*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.00464782943665541*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 0.00189016397551084*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.00548466760916128*std::sin(0.253519982099533*x_15 - 7.40231990814209) - 0.00229702549404328*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.00493522148090028*std::sin(0.153840035200119*x_16 + 8.35536003112793) + 0.00172415839250194*std::sin(0.336639851331711*x_16 - 1.15263986587524) - 0.00608520825144314*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.00914320704730408*std::sin(0.337039858102798*x_17 - 7.58064031600952) + 0.00218459168510232*std::sin(0.350719839334488*x_17 - 1.15999984741211) - 0.0211774938948954*std::sin(0.173840016126633*x_18 + 1.95855975151062) + 0.00474443470620252*std::sin(0.429519861936569*x_18 + 1.96343982219696) - 0.00151486548981494*std::sin(0.366639852523804*x_19 - 1.15647983551025) - 0.00220791085214073*std::sin(0.374879837036133*x_2 - 7.40015983581543) - 0.00371704580922857*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.0139305229632239*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 0.00102770065585737*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.00302175809046066*std::sin(0.26759997010231*x_21 - 1.16415989398956) - 0.0016151417925797*std::sin(0.302319914102554*x_21 - 7.40903997421265) + 0.00343027065590653*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.000934502782664234*std::sin(0.330319821834564*x_22 - 1.17439985275269) + 0.00425398262475777*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.00193966061533543*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.0042494030352169*std::sin(0.4129598736763*x_23 + 5.19824028015137) + 0.013548379053256*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.0181968703650045*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.00260902504622192*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 0.0023728849920171*std::sin(0.337679862976074*x_25 - 1.15311992168427) + 0.0044258594869642*std::sin(0.34239986538887*x_26 - 1.13975989818573) + 0.0031687305206857*std::sin(0.364879846572876*x_26 - 1.15215992927551) - 0.00128419798302865*std::sin(0.412559866905212*x_26 - 1.19311988353729) + 0.0131594157459262*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.00205035661012279*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 0.0116045189215166*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.00221944542377836*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.0023770226542298*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.00303094540622348*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.00367881480554939*std::sin(0.357999831438065*x_3 - 4.19871997833252) + 0.00158616231884938*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.00973100616749263*std::sin(0.471519857645035*x_3 - 4.39256000518799) + 0.00258025719009327*std::sin(0.510479867458344*x_3 + 1.96471977233887) - 0.192016415496847*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 0.00396398180618858*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.00242968321276648*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.00490231283576504*std::sin(0.343999862670898*x_31 - 4.24528026580811) - 0.00366775395963253*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.00088147582066534*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 0.00024200328391592*std::sin(0.526799857616425*x_31 + 5.36439990997314) + 0.000666373818463083*std::sin(0.284959942102432*x_32 - 7.56984043121338) - 0.00776500707906029*std::sin(0.306559920310974*x_32 - 1.14495992660522) - 0.0066059502321748*std::sin(0.173360019922256*x_33 + 5.19776010513306) - 0.00176936983314796*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.0190228441686837*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.00441455256357251*std::sin(0.250159978866577*x_36 - 7.42375993728638) - 0.00439966618219201*std::sin(0.219839990139008*x_37 + 1.97511982917786) - 0.00192419219170275*std::sin(0.225759983062744*x_38 - 1.18391978740692) + 0.00402752493068245*std::sin(0.233839988708496*x_39 + 1.97919988632202) - 0.0106467787989628*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.00242560744056455*std::sin(0.374879837036133*x_4 + 1.99583983421326) - 0.00685801029154467*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.0019601861420814*std::sin(0.244479969143867*x_41 - 7.42392015457153) + 0.00570070378109504*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 0.00628988631033134*std::sin(0.112000063061714*x_43 - 1.25247991085052) + 0.00515252501600165*std::sin(0.222240000963211*x_45 + 1.98055982589722) - 0.00811736416100273*std::sin(0.120480060577393*x_47 + 1.96895980834961) - 0.0262713798163269*std::sin(0.198079988360405*x_47 + 1.98031985759735) + 0.00299079067878021*std::sin(0.221279993653297*x_48 - 7.40007972717285) - 0.00936902984586748*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.00505070266139484*std::sin(0.333279848098755*x_49 + 1.89679992198944) - 0.00298540913788206*std::sin(0.331039845943451*x_5 - 1.16375982761383) - 0.00120111139205059*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.00345036506245502*std::sin(0.23039998114109*x_50 - 7.42743968963623) + 0.0278404657308811*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.00365938083561151*std::sin(0.205919995903969*x_51 - 1.20511984825134) - 0.00616452023923162*std::sin(0.211520001292229*x_51 - 1.18919992446899) - 0.00359067215197435*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.0043617398751641*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 0.0173878405412587*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.00371839175397238*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.018897180583367*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 0.00472435487164063*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.00551112323707603*std::sin(0.246799975633621*x_57 + 5.15375995635986) - 0.189832979774514*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 0.178049197640524*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.00254847609208927*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.0025595002023255*std::sin(0.282239943742752*x_6 + 2.00879979133606) - 0.00502316892161876*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 0.000590362067249421*std::sin(0.435519844293594*x_6 + 1.9508798122406) + 0.00238648366732095*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.0027811292443459*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.0109799455633085*std::sin(0.416399866342545*x_60 - 1.22879981994629) - 0.0227821869133086*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.0113183064338896*std::sin(0.310879945755005*x_7 - 7.38831996917725) + 0.00282449395231158*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.00276458045789147*std::sin(0.364559859037399*x_7 + 2.00311970710754) - 0.00179923514232058*std::sin(0.34199982881546*x_8 - 1.13871991634369) - 0.00248868413779926*std::sin(0.386879861354828*x_8 + 8.19487953186035) - 0.0232365628521274*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.00098900970206266*std::sin(0.327839851379395*x_9 - 1.09671986103058) - 0.00160574273946207*std::sin(0.242319971323013*x_91 + 8.42840003967285) + 0.00236958187832061*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.00369425860208357*std::sin(0.267439961433411*x_92 - 7.39351987838745) + 0.0158523593337346*std::sin(0.293839931488037*x_92 + 1.98743987083435) - 0.00384303932825939*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.00273574545119056*std::sin(0.2360799908638*x_93 + 1.96975982189178) - 0.00171539093058835*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.00870692942501126*std::sin(0.261919945478439*x_95 - 7.4300799369812) - 0.00241272898492147*std::sin(0.287439942359924*x_95 + 1.96047985553741) - 0.0012248865997204*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.00136427811964849*std::sin(0.26471996307373*x_96 + 1.97247982025146) - 0.00195883919355594*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.0217456973790764*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.00438587880970841*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.00254586885327698*std::sin(0.286639958620071*x_97 - 1.21999979019165) + 0.0179103208747555*std::sin(0.22791999578476*x_98 - 4.21591997146606) + 0.0069606124164138*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 0.621007509497485);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.8013932106285e-5*x_1 - 0.000226129959454519*x_10 + 0.00150194184206154*x_100 - 7.47082206031991e-5*x_101 - 0.00218912139563076*x_102 - 0.00244305357952174*x_103 + 0.000485768821452837*x_104 + 0.00326519645859936*x_105 - 0.000272234112301939*x_106 - 0.00266842794581295*x_107 - 0.00242922726513446*x_108 + 0.00372249162805523*x_109 - 0.00110503885389123*x_11 + 0.00248561312588837*x_110 + 3.63121715610585e-6*x_111 + 0.00299764895518915*x_112 + 0.00103381830321615*x_113 - 0.000930219205496128*x_114 - 0.00123510066937046*x_115 + 3.30024355417362e-5*x_116 + 0.00368057286882241*x_117 + 0.00289333210894647*x_118 + 0.000653312419268554*x_119 - 0.00111162070395531*x_12 - 0.000119665479941449*x_120 - 0.000287853471382147*x_13 - 6.71783172995557e-6*x_15 - 0.00276436083534065*x_17 - 0.00193258393855081*x_18 - 0.00147288599099013*x_19 + 0.000468904151998648*x_2 + 0.000607725014983697*x_20 - 0.00200762031980777*x_21 - 1.43636608142757e-6*x_22 - 0.00545656100363514*x_24 + 0.00018759555018411*x_25 - 0.000832468216260087*x_27 - 0.00117187039227337*x_28 + 0.00211008163813508*x_29 - 0.000273770771623335*x_3 - 0.0032639467236922*x_30 - 0.00163847830262015*x_32 - 0.000576809432082091*x_33 - 0.000702432689542405*x_34 + 0.000242449536348165*x_35 - 0.00344619117242377*x_36 - 0.000138101862732772*x_37 - 0.00148964594074547*x_38 + 0.000748277147041842*x_39 + 0.00281482809471752*x_4 + 0.00277256318344388*x_40 - 0.00172084732084577*x_41 - 0.000131653702650288*x_42 + 0.00232877449845691*x_43 - 0.00301584108863261*x_44 - 0.00391441602757731*x_45 + 0.000682069959358483*x_46 - 0.00100252151168904*x_47 - 0.000849297325047496*x_48 - 0.000265959065580934*x_49 + 1.00102856657078e-6*x_5 - 0.00254016954417064*x_50 + 9.4736860018383e-5*x_51 - 0.00500360791705888*x_52 - 0.000522639275653804*x_53 - 0.00816520558144648*x_54 - 0.000548726046199738*x_55 - 0.000653402940704427*x_56 - 0.00154393850364415*x_57 + 0.00131028100857964*x_58 + 0.00652773930313715*x_59 + 0.00025444632470594*x_6 + 5.6950098446014e-5*x_60 + 0.000241426987291433*x_61 + 8.0918249211531e-5*x_62 + 4.67181365663462e-7*x_63 + 0.00086327411823256*x_64 + 0.000849467357534984*x_65 - 0.00151179421868523*x_66 + 0.00119957318041702*x_67 - 0.000313418715176182*x_68 + 0.000116974395484684*x_69 - 0.000462338832941201*x_7 - 0.000635992938134129*x_70 + 0.00238234040518647*x_71 - 0.000286057901574709*x_72 + 0.00187580923653001*x_73 - 0.00318159304486678*x_74 + 0.000184109561740743*x_75 - 0.000959544550951964*x_76 - 0.00155996160790278*x_77 - 0.00118920213087059*x_78 - 0.00146350760454639*x_79 + 0.000135741728599032*x_8 + 0.00148698364901669*x_80 + 0.00175151165595104*x_81 - 0.00144716625679441*x_82 - 0.00128737358035069*x_83 + 0.000973865906817891*x_84 - 0.00165954550567997*x_85 - 0.000543525932954292*x_86 - 0.000402802199647462*x_87 + 0.000648982107969341*x_88 + 0.00131550325691539*x_89 + 0.00057546075888533*x_9 - 0.000531196487121138*x_90 - 0.00119538130170054*x_91 - 0.000537455112529669*x_92 - 0.000749998927046275*x_93 - 0.000328050177684469*x_94 + 6.27988804509646e-6*x_95 + 0.000228617261476794*x_96 + 0.000151189004140407*x_98 - 0.00142700215112237*x_99 + 1.23444751230759e-5*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 0.00084205117309466*std::pow(-0.120629301702447*x_1 - 0.122773375447261*x_101 + 0.343476195256813*x_103 - 0.179973011165847*x_105 - 0.218352097273481*x_107 - 0.352768736874654*x_109 - 0.0127620533358195*x_11 - 0.126271188565764*x_110 - 0.181177159893211*x_111 + 0.0848214149928851*x_112 + 0.467762336958955*x_114 + 0.353121271305605*x_115 - 0.192719235569802*x_117 + 0.0918598376475683*x_118 + 0.182934067929276*x_119 - 0.236537396106835*x_12 + 0.567603623413802*x_120 - 0.170551034913392*x_15 + 0.0498468406423566*x_16 + 0.299351138783615*x_19 - 0.313900639628315*x_20 + 0.208132440342016*x_21 + 0.0251410320839941*x_22 - 0.164218771965472*x_23 - 0.116614212427694*x_28 - 0.12913490530281*x_32 - 0.0135733947895693*x_33 - 0.0168110773076213*x_34 + 0.463492611257728*x_36 + 0.361076763009883*x_37 - 0.386094668919076*x_38 - 0.0481511920552161*x_39 - 0.29728926498909*x_40 - 0.274567244314948*x_41 + 0.0755450606783905*x_42 + 0.524403029154609*x_43 - 0.0310425232051263*x_44 + 0.00736877611143056*x_45 - 0.2338890985481*x_46 + 0.146431245627258*x_48 - 0.109148841778988*x_5 - 0.244845283374907*x_50 + 0.0269571660477192*x_52 + 0.0254994306850468*x_54 - 0.28561573093262*x_56 + 0.0300887949673447*x_57 - 0.0206362287517397*x_6 - 0.0266589926399042*x_61 + 0.00255652018905257*x_62 - 0.192191997644222*x_63 - 0.0468367199400439*x_64 + 0.13857782337962*x_65 - 0.0598033951482298*x_66 - 0.0957239195559507*x_67 - 0.0976972669874065*x_68 - 0.0684752164455082*x_69 + 0.134144303414192*x_70 - 0.09485801895158*x_71 - 0.110988455517131*x_72 - 0.158955156526218*x_73 + 0.177903483642672*x_74 + 0.121556848769405*x_75 + 0.179286345254478*x_76 + 0.159897552684875*x_77 + 0.08052588844278*x_78 + 0.25300989530149*x_79 - 0.405635146201212*x_8 - 0.210354483430986*x_80 + 0.189922925453618*x_81 - 0.20308300996388*x_82 - 0.0635981603774033*x_83 + 0.157152804250582*x_84 - 0.0772135366980911*x_85 - 0.250516950683888*x_86 - 0.121864281462858*x_87 + 0.245504149220622*x_88 - 0.0726466905802581*x_89 + 2.89481617613903e-5*x_90 + 0.078498895607424*x_91 + 0.00727844944552117*x_93 - 0.148693416050399*x_94 + 0.150245872478243*x_96 + 0.179741376976862*x_99 + 0.000364836919110351*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) - 0.00581369784470803*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) + 2.34018559361596*std::sin(0.248559966683388*x_100 + 1.96343982219696) + 1.43452760143111*std::sin(0.237199977040291*x_102 + 1.95759987831116) + 0.942716552501452*std::sin(0.19743999838829*x_104 - 4.40719985961914) - 1.88327495816952*std::sin(0.24551996588707*x_106 + 4.98847961425781) - 1.78301764146531*std::sin(0.250399976968765*x_108 + 1.97543978691101) + 2.40048565434446*std::sin(0.281679958105087*x_113 + 1.98447978496552) - 1.95964421351945*std::sin(0.240959972143173*x_116 - 1.22615993022919) - 1.58505739687267*std::sin(0.385039836168289*x_13 - 7.36183977127075) - 1.45780558259862*std::sin(0.251679986715317*x_14 - 7.24671983718872) + 1.12666997418108*std::sin(0.337039858102798*x_17 - 7.58064031600952) + 2.60959271471569*std::sin(0.173840016126633*x_18 + 1.95855975151062) + 1.71658608036577*std::sin(0.417119860649109*x_2 - 1.17111992835999) - 1.6694964687066*std::sin(0.389839857816696*x_24 + 5.22088003158569) - 2.24230593906995*std::sin(0.243119969964027*x_25 - 7.38488006591797) - 1.62156653808604*std::sin(0.443999856710434*x_26 - 7.44151973724365) - 1.4299646684195*std::sin(0.375999838113785*x_27 - 4.38071966171265) - 1.19910141056224*std::sin(0.471519857645035*x_3 - 4.39256000518799) + 23.6611867992167*std::sin(0.0844800844788551*x_30 + 4.86079978942871) + 0.451958294023342*std::sin(0.408799856901169*x_31 - 1.18735992908478) + 2.34408640616982*std::sin(0.256079971790314*x_35 + 1.95967984199524) + 1.31194732138063*std::sin(0.365439832210541*x_4 - 1.18407988548279) + 3.23728585235199*std::sin(0.198079988360405*x_47 + 1.98031985759735) + 0.622371888514536*std::sin(0.333279848098755*x_49 + 1.89679992198944) - 3.43063616999135*std::sin(0.198239997029305*x_51 - 4.38799953460693) + 2.14261339072061*std::sin(0.25383996963501*x_53 - 7.41967964172363) + 2.32860153442934*std::sin(0.225679993629456*x_55 + 5.15999984741211) + 23.3921333416959*std::sin(0.0653600990772247*x_58 + 4.88775968551636) - 21.9400789975286*std::sin(0.0555201061069965*x_59 + 8.0319995880127) + 1.35300173345304*std::sin(0.416399866342545*x_60 - 1.22879981994629) - 1.39469618829249*std::sin(0.310879945755005*x_7 - 7.38831996917725) + 2.86332110092408*std::sin(0.311839938163757*x_9 + 5.14567995071411) - 1.95340400680462*std::sin(0.293839931488037*x_92 + 1.98743987083435) - 1.07290974596998*std::sin(0.261919945478439*x_95 - 7.4300799369812) - 2.67960948252372*std::sin(0.27703994512558*x_97 + 1.96351981163025) - 2.20699593185802*std::sin(0.22791999578476*x_98 - 4.21591997146606) + 56.4592679866985, 2) + 0.000983617655332705*std::exp(0.277599841356277*x_13) + 0.00207806231303145*std::exp(0.275439828634262*x_23) - 0.0102862996654771*std::exp(0.143199846148491*x_49) - 0.0069928509925599*std::exp(0.147999867796898*x_49) + 5.13462880000801e-5*std::sin(0.304559946060181*x_1 - 4.28071975708008) + 0.015511452300745*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.0118623900129827*std::sin(0.444319844245911*x_1 - 7.17479991912842) + 0.0146000291825238*std::sin(0.333759844303131*x_10 - 4.32592010498047) + 3.34696100779847e-5*std::sin(0.346559852361679*x_10 - 1.14743983745575) + 3.87914122978931e-5*std::sin(0.253279983997345*x_100 - 1.22375988960266) + 0.0116280473680013*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 2.62162956251487e-5*std::sin(0.211600005626678*x_102 - 1.21039986610413) + 0.0107148958827689*std::sin(0.256479978561401*x_108 + 5.14879989624023) - 0.0122554257729444*std::sin(0.264079958200455*x_109 + 4.96231985092163) - 0.00678815421458804*std::sin(0.235759988427162*x_11 - 7.3951997756958) + 0.0111733887531443*std::sin(0.345119833946228*x_11 + 5.07279968261719) - 6.20431592631843e-5*std::sin(0.250879973173141*x_112 - 7.428879737854) + 0.00677692246192642*std::sin(0.288159936666489*x_112 + 1.95711982250214) + 0.00740591893600241*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.00508053600401981*std::sin(0.27975994348526*x_113 - 7.42360019683838) - 0.00418274694936236*std::sin(0.20168000459671*x_116 + 8.19727993011475) + 3.38412347197111e-5*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.00246435996448903*std::sin(0.269519954919815*x_116 - 1.24311995506287) - 0.0169953427677279*std::sin(0.245439976453781*x_119 - 7.43943977355957) - 0.0164231405274863*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.012137824503347*std::sin(0.335679858922958*x_12 + 1.86047983169556) - 0.00791603925126994*std::sin(0.268559962511063*x_120 - 1.21983981132507) + 0.00690455439078245*std::sin(0.29751992225647*x_120 + 1.75015985965729) + 0.0110683696895234*std::sin(0.308319926261902*x_13 + 5.13216018676758) - 3.67888230879005e-5*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.0235154686066012*std::sin(0.135680049657822*x_14 - 1.24679982662201) - 0.0159887311642916*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 3.27829742797915e-5*std::sin(0.363359838724136*x_14 - 4.37039995193481) + 0.0129038806449651*std::sin(0.377439826726913*x_14 + 5.02719974517822) - 0.0188674901098526*std::sin(0.253519982099533*x_15 - 7.40231990814209) - 0.0171969796964504*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 0.00686678697543265*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.0147534777797651*std::sin(0.153840035200119*x_16 + 8.35536003112793) + 0.0129259448530984*std::sin(0.261759966611862*x_16 - 1.1658399105072) + 2.99037760575252e-5*std::sin(0.336639851331711*x_16 - 1.15263986587524) - 0.0209333754900151*std::sin(0.439999878406525*x_16 - 1.23111987113953) + 0.00751719759475992*std::sin(0.303199917078018*x_17 + 2.02831983566284) + 3.788952384684e-5*std::sin(0.350719839334488*x_17 - 1.15999984741211) + 0.0163210574049365*std::sin(0.429519861936569*x_18 + 1.96343982219696) - 0.0125956637613747*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 0.00452857778112132*std::sin(0.366639852523804*x_19 - 1.15647983551025) - 3.82939711134005e-5*std::sin(0.374879837036133*x_2 - 7.40015983581543) - 0.0127867958536531*std::sin(0.406079858541489*x_2 - 7.40823984146118) + 0.00353533401511694*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.00903332120269997*std::sin(0.26759997010231*x_21 - 1.16415989398956) - 2.80129938621049e-5*std::sin(0.302319914102554*x_21 - 7.40903997421265) + 0.0118002771154861*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.00279362660673345*std::sin(0.330319821834564*x_22 - 1.17439985275269) + 0.0146338813615681*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.0159095510617754*std::sin(0.399839848279953*x_22 + 2.00903987884521) + 3.36414432228722e-5*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.014618127378551*std::sin(0.4129598736763*x_23 + 5.19824028015137) + 0.00897515724995361*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 4.11552800021894e-5*std::sin(0.337679862976074*x_25 - 1.15311992168427) + 0.0138520005391085*std::sin(0.354159832000732*x_25 + 2.04983973503113) + 0.015225145085987*std::sin(0.34239986538887*x_26 - 1.13975989818573) + 0.00947268435832632*std::sin(0.364879846572876*x_26 - 1.15215992927551) - 0.00125040825269077*std::sin(0.394799828529358*x_26 + 5.19792032241821) - 2.22731096313538e-5*std::sin(0.412559866905212*x_26 - 1.19311988353729) + 0.0139475944841648*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.00612938868196913*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 3.84940265425716e-5*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.00710593253958288*std::sin(0.316079914569855*x_28 + 2.00583982467651) + 0.00732375411420939*std::sin(0.278399974107742*x_29 + 5.01567983627319) - 5.25686694821399e-5*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.0109975434131161*std::sin(0.357999831438065*x_3 - 4.19871997833252) + 2.75103743252543e-5*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.00887619459995049*std::sin(0.510479867458344*x_3 + 1.96471977233887) - 0.0136362661976038*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.00726335736504364*std::sin(0.331519842147827*x_30 - 1.15855991840363) + 0.00812980815927929*std::sin(0.318639844655991*x_31 + 5.33767986297607) - 0.0168641648930015*std::sin(0.343999862670898*x_31 - 4.24528026580811) - 1.52883027777101e-5*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 0.000723450829046157*std::sin(0.526799857616425*x_31 + 5.36439990997314) + 1.15575770327004e-5*std::sin(0.284959942102432*x_32 - 7.56984043121338) - 0.0267119549819919*std::sin(0.306559920310974*x_32 - 1.14495992660522) - 0.0227247500766589*std::sin(0.173360019922256*x_33 + 5.19776010513306) - 0.014742837820655*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.00528939959808516*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.00795479800087739*std::sin(0.232959985733032*x_35 + 1.97247982025146) - 7.65659302702945e-5*std::sin(0.250159978866577*x_36 - 7.42375993728638) - 7.630774110563e-5*std::sin(0.219839990139008*x_37 + 1.97511982917786) - 0.00661930307057547*std::sin(0.225759983062744*x_38 - 1.18391978740692) + 0.0138548572514964*std::sin(0.233839988708496*x_39 + 1.97919988632202) - 0.0197560299889198*std::sin(0.293199926614761*x_4 - 7.37039995193481) - 4.20696973210527e-5*std::sin(0.374879837036133*x_4 + 1.99583983421326) - 0.0235918474134794*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.00585983077017365*std::sin(0.244479969143867*x_41 - 7.42392015457153) + 0.0196106637400142*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 0.000109091689295727*std::sin(0.112000063061714*x_43 - 1.25247991085052) + 0.0148159115489632*std::sin(0.270159959793091*x_44 - 7.45815992355347) + 8.93653128850439e-5*std::sin(0.222240000963211*x_45 + 1.98055982589722) - 0.0279240783470579*std::sin(0.120480060577393*x_47 + 1.96895980834961) + 0.0102834264794326*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.00894074642730386*std::sin(0.221279993653297*x_48 - 7.40007972717285) - 0.00016249630637504*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.0102699345515063*std::sin(0.331039845943451*x_5 - 1.16375982761383) - 0.0035906332273478*std::sin(0.341359823942184*x_5 + 2.00831985473633) + 0.0103781711910542*std::sin(0.371279835700989*x_5 + 2.02111983299255) - 5.98430774069664e-5*std::sin(0.23039998114109*x_50 - 7.42743968963623) - 0.0109394470045231*std::sin(0.205919995903969*x_51 - 1.20511984825134) - 0.0212062121050713*std::sin(0.211520001292229*x_51 - 1.18919992446899) - 0.012352065091773*std::sin(0.238319978117943*x_53 - 7.42679977416992) + 0.00775074405900833*std::sin(0.247999966144562*x_53 + 1.98495984077454) - 7.56499478327012e-5*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 6.44917281315345e-5*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.0141231077251999*std::sin(0.202719986438751*x_56 - 1.1847198009491) - 0.0148317290999565*std::sin(0.238239988684654*x_57 - 7.42631959915161) + 0.0189584985963464*std::sin(0.246799975633621*x_57 + 5.15375995635986) - 0.00761847984784728*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.00765143560597105*std::sin(0.282239943742752*x_6 + 2.00879979133606) - 0.0172799149743285*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 1.02392304144786e-5*std::sin(0.435519844293594*x_6 + 1.9508798122406) + 4.13911352129019e-5*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.00831397915329777*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.00817661843490627*std::sin(0.461039870977402*x_60 + 1.88791978359222) - 0.078371693035632*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 4.89879787107002e-5*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.0082645077862715*std::sin(0.364559859037399*x_7 + 2.00311970710754) - 0.0100199751024054*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 0.00537867971995389*std::sin(0.34199982881546*x_8 - 1.13871991634369) - 0.00856117940092541*std::sin(0.386879861354828*x_8 + 8.19487953186035) + 1.71533687263413e-5*std::sin(0.327839851379395*x_9 - 1.09671986103058) - 0.0261624117463788*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 0.00480024856399175*std::sin(0.242319971323013*x_91 + 8.42840003967285) + 4.10979908501591e-5*std::sin(0.368239849805832*x_91 + 1.98719990253448) + 0.0120823223069937*std::sin(0.372959852218628*x_91 + 5.20560026168823) - 6.40731631245239e-5*std::sin(0.267439961433411*x_92 - 7.39351987838745) - 6.66536137006345e-5*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.00817830767705905*std::sin(0.2360799908638*x_93 + 1.96975982189178) - 0.0119880342648689*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.005128033681161*std::sin(0.292799949645996*x_94 + 4.9814395904541) - 0.00277050280889233*std::sin(0.304079920053482*x_94 + 1.96951985359192) + 0.0118273883778316*std::sin(0.283599942922592*x_95 - 1.20095992088318) - 0.00829989044089433*std::sin(0.287439942359924*x_95 + 1.96047985553741) - 0.00366170744345406*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.00469317482185441*std::sin(0.26471996307373*x_96 + 1.97247982025146) - 0.00673849023220206*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.0107089836319463*std::sin(0.277839958667755*x_97 + 1.94815981388092) + 7.6068613133998e-5*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.00761068570121525*std::sin(0.286639958620071*x_97 - 1.21999979019165) + 0.0239448030917752*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 0.0404832557209022);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00053171440336711*x_1 + 0.000337951505055615*x_10 - 0.00230041994624654*x_100 - 0.00266327264912357*x_101 + 0.00260301950142246*x_102 + 0.000241123559941738*x_103 + 0.00374917201791125*x_104 - 0.00235675531768565*x_105 + 0.000910722934007172*x_106 - 0.000861672324555498*x_107 + 0.000248695216582573*x_108 - 0.00706053929955262*x_109 + 0.000845605303040372*x_11 + 0.000661006710931904*x_110 + 0.00338891165110244*x_111 + 0.000379345585899349*x_112 + 0.000506875997583436*x_113 - 0.00127065450564704*x_114 + 0.00348891312537562*x_115 - 0.00412111795888122*x_117 - 0.00403498250532913*x_118 - 0.000177555631320904*x_119 + 0.000371455864618425*x_12 + 0.00347175120636054*x_120 + 0.000397302134225329*x_13 - 0.00179036687689535*x_15 + 0.000219567047057281*x_16 + 4.53872676818359e-6*x_17 + 0.00329954061649222*x_18 + 0.00145058476109146*x_19 - 0.00079111598980702*x_2 - 0.00229202194084292*x_20 + 0.00368775360566471*x_21 - 0.00011143583082276*x_22 - 0.000723356392645533*x_23 + 0.0029256495166163*x_24 - 1.17180714874188e-6*x_25 - 0.000101551141425333*x_27 - 0.000179284199480666*x_28 - 1.91868799095997e-6*x_29 + 0.000377864860660535*x_3 + 0.0040551771276232*x_30 + 0.00118326099669623*x_32 + 0.000863529655832833*x_33 + 0.00253822412337897*x_34 - 0.000294813280418909*x_35 + 0.00227504941667332*x_36 + 0.00226359901080365*x_37 - 0.00132229799773094*x_38 + 0.00137805868921076*x_39 - 3.4840942341638e-6*x_4 - 0.00361177014826313*x_40 + 0.00168960889979158*x_41 - 0.000212310545718311*x_42 + 0.00255178703647959*x_43 + 0.000512722569119538*x_44 + 0.00310417748576932*x_45 + 0.00164372711345146*x_46 + 0.000909732788069643*x_47 - 0.00209996738631722*x_48 + 0.000367082960175942*x_49 - 0.000325942853376578*x_5 + 0.0023186149483751*x_50 + 0.000486205974438323*x_51 - 0.00178064981787771*x_52 + 3.26464267848225e-6*x_53 + 0.00411558554310339*x_54 - 0.00588685687782452*x_55 - 0.00289452794970383*x_56 - 0.000749829005246072*x_57 + 0.00286226644529351*x_58 - 0.00451606620586298*x_59 - 0.00044209196165149*x_6 - 0.000875015310940719*x_61 - 0.00109591560006447*x_62 + 0.000709998573735099*x_63 - 0.000731974782061387*x_64 - 5.13676043276794e-5*x_65 - 0.00133788503368984*x_66 - 0.00137222916424736*x_67 - 0.00192683655075516*x_68 + 0.000536454532823771*x_69 + 0.00379851959406754*x_70 - 7.63542955655795e-5*x_71 - 0.001783357229532*x_72 - 0.00276052042198711*x_73 + 0.00329510675096114*x_74 - 0.000639797602599609*x_75 + 0.00164242644683563*x_76 + 0.00223085641705137*x_77 + 0.0028404099446853*x_78 + 0.00128522842883158*x_79 - 0.00159180605993533*x_8 - 0.00226649397373845*x_80 + 2.90728301057143e-5*x_81 - 0.00121468802169959*x_82 + 0.000812844746995477*x_83 - 0.00163991692554635*x_84 + 0.00126737035685796*x_85 - 0.00137359946364223*x_86 + 9.14123771416684e-5*x_87 - 0.000748984915981865*x_88 + 0.000775576557997894*x_89 - 0.000243408142911203*x_9 + 0.000403233558715467*x_90 + 0.000345774586386405*x_91 - 5.58109608473452e-5*x_92 + 3.20603599208015e-5*x_93 - 0.00182164031429118*x_94 + 0.000971376547757284*x_95 + 0.000956385184032717*x_96 - 0.00161663916442863*x_98 + 0.00133876411914593*x_99 + 1.60704598233788e-6*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) - 1.70381350231434e-5*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 2.56083726028795e-5*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) + 0.00182645360473543*std::pow(-0.00456251399896175*x_100 + 0.102766843907422*x_102 + 0.107015593134943*x_103 - 0.0919419059152445*x_104 - 0.141030914378328*x_105 + 0.06754869552046*x_106 + 0.022945629503649*x_107 + 0.0490843916858372*x_108 + 0.0616267306139678*x_11 - 0.0506642765021632*x_110 - 0.219926119930827*x_111 - 0.21711059421173*x_112 - 0.0571704606961495*x_113 + 0.0496169903870754*x_114 - 0.158403939790493*x_115 - 0.00183084782150291*x_116 - 0.18137871993806*x_117 - 0.133056036747744*x_118 + 0.113046643449082*x_17 + 0.0817573724951199*x_19 + 0.214336599010754*x_24 + 0.0461457042141291*x_27 + 0.0515708341871813*x_28 - 0.100018899096236*x_29 + 0.0318505897566846*x_34 - 0.0135558997729096*x_35 + 0.19085346210438*x_36 - 0.0686374010851567*x_37 - 0.12521279625578*x_4 - 0.0527548179152821*x_40 - 0.193731048568824*x_43 + 0.040883320805048*x_44 + 0.0133534439883291*x_45 - 0.238977731917358*x_46 + 0.15700504781509*x_48 - 0.0458882553300745*x_50 + 0.234021623158632*x_52 + 0.223832750974454*x_54 + 0.0744567918161594*x_55 + 0.0216936781513604*x_56 - 0.176167822950055*x_58 - 0.187208358729353*x_59 - 0.00315937178461876*x_60 - 0.00598028143667201*x_62 - 0.0225266809397853*x_63 + 0.0117094952973982*x_64 - 0.00107989118230513*x_65 + 0.0731773000623313*x_66 - 0.0392898805881037*x_67 + 0.0891019398452005*x_68 - 0.0471379254123274*x_69 + 0.0256487750431665*x_7 - 0.0373511366842923*x_70 - 0.0938490928616639*x_71 + 0.0612271901948324*x_72 - 0.0780703760937874*x_73 + 0.080540337155398*x_74 + 0.0223405665897939*x_75 - 0.0157780908089092*x_76 + 0.0317032403259072*x_77 - 0.0382168148374777*x_78 + 0.0563075369159004*x_79 + 0.00494289741779116*x_80 - 0.0419011061701931*x_81 + 0.0806875676735032*x_82 - 0.0353841761565643*x_83 + 0.0665363232711778*x_84 - 0.0141321540919935*x_85 - 0.00102229891971294*x_86 - 0.051521636373581*x_87 + 0.0194199912483773*x_88 - 0.0888161545464357*x_89 + 0.0327301951216531*x_9 + 0.0641383870699682*x_90 + 0.0663151435995081*x_91 + 0.0148719298428087*x_92 + 0.0416070474548967*x_93 + 0.0177805323435613*x_94 + 0.0301865655610586*x_99 + 0.570644227455525*std::exp(0.143199846148491*x_49) - 0.860515540353092*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.809953301443407*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.645079214384484*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 0.679883748264885*std::sin(0.264079958200455*x_109 + 4.96231985092163) + 0.942836059558068*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.911092486460852*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.383038044232396*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.614030455662139*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.886993130665132*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 1.04669557254846*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 1.16130292457137*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.905429308593384*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.709362110655654*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.196126694094331*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.654633856422397*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.811831289756668*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.810957319547697*std::sin(0.4129598736763*x_23 + 5.19824028015137) - 0.497907103793683*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 0.844632320468993*std::sin(0.34239986538887*x_26 - 1.13975989818573) - 0.492417037706311*std::sin(0.510479867458344*x_3 + 1.96471977233887) + 0.756487448623108*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.935558817068845*std::sin(0.343999862670898*x_31 - 4.24528026580811) + 1.48187622471122*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 1.26068147665747*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.367213401305019*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.768614037108168*std::sin(0.233839988708496*x_39 + 1.97919988632202) + 1.30878469219564*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 1.08792397885984*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 1.54912015340604*std::sin(0.120480060577393*x_47 + 1.96895980834961) + 0.569736354058602*std::sin(0.331039845943451*x_5 - 1.16375982761383) + 1.176438847545*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.685244924900623*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 1.05174437232643*std::sin(0.246799975633621*x_57 + 5.15375995635986) + 0.958623027882155*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 4.34775922159812*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.474941209592171*std::sin(0.386879861354828*x_8 + 8.19487953186035) + 0.460445905975845*std::sin(0.287439942359924*x_95 + 1.96047985553741) + 0.26035923584058*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.373825445283991*std::sin(0.249119967222214*x_97 - 7.40423965454102) - 1.32836531174954*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 3.15250900258012, 2) - 6.14412334949518e-6*std::exp(0.277599841356277*x_13) - 1.29805225739709e-5*std::exp(0.275439828634262*x_23) + 4.36805285366651e-5*std::exp(0.147999867796898*x_49) + 0.00794227215827746*std::sin(0.304559946060181*x_1 - 4.28071975708008) + 0.0163727498110123*std::sin(0.444319844245911*x_1 - 7.17479991912842) + 0.00517709775379216*std::sin(0.346559852361679*x_10 - 1.14743983745575) + 0.0103081285340205*std::sin(0.248559966683388*x_100 + 1.96343982219696) + 0.00600027705748345*std::sin(0.253279983997345*x_100 - 1.22375988960266) + 0.00405515107219561*std::sin(0.211600005626678*x_102 - 1.21039986610413) + 0.00631885562473841*std::sin(0.237199977040291*x_102 + 1.95759987831116) + 0.00415250970728279*std::sin(0.19743999838829*x_104 - 4.40719985961914) - 0.00829551313651035*std::sin(0.24551996588707*x_106 + 4.98847961425781) - 0.00785389632206522*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.0147889514126258*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 4.24018993393497e-5*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.015421774060387*std::sin(0.345119833946228*x_11 + 5.07279968261719) - 0.0095968701072762*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.00935366783896957*std::sin(0.288159936666489*x_112 + 1.95711982250214) - 0.0102218235724081*std::sin(0.242639973759651*x_113 + 8.37351989746094) + 3.17353391544101e-5*std::sin(0.27975994348526*x_113 - 7.42360019683838) + 0.0105737402779327*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.00577312575709732*std::sin(0.20168000459671*x_116 + 8.19727993011475) + 0.00523458085841911*std::sin(0.222719997167587*x_116 + 8.38632011413574) - 0.00863190701156969*std::sin(0.240959972143173*x_116 - 1.22615993022919) - 1.53935134422294e-5*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.0167529109754254*std::sin(0.335679858922958*x_12 + 1.86047983169556) + 0.0109259036343728*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 0.00698191435129598*std::sin(0.385039836168289*x_13 - 7.36183977127075) - 0.00569051545354888*std::sin(0.432719856500626*x_13 + 1.9437597990036) + 0.000146888314739805*std::sin(0.135680049657822*x_14 - 1.24679982662201) - 0.00642139126231425*std::sin(0.251679986715317*x_14 - 7.24671983718872) + 0.00507088854967487*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.0178102396869392*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 0.023735676011907*std::sin(0.28247994184494*x_15 - 7.42208003997803) + 4.28930753357558e-5*std::sin(0.289599925279617*x_15 + 5.16944026947021) - 9.21569339686692e-5*std::sin(0.153840035200119*x_16 + 8.35536003112793) - 0.0178406932261627*std::sin(0.261759966611862*x_16 - 1.1658399105072) + 0.0046255325800509*std::sin(0.336639851331711*x_16 - 1.15263986587524) - 0.0103754129955469*std::sin(0.303199917078018*x_17 + 2.02831983566284) + 0.00496279395145531*std::sin(0.337039858102798*x_17 - 7.58064031600952) + 0.00586077245425566*std::sin(0.350719839334488*x_17 - 1.15999984741211) + 0.0114948221192867*std::sin(0.173840016126633*x_18 + 1.95855975151062) + 0.017384831492045*std::sin(0.31959992647171*x_19 + 1.98879981040955) + 2.82875569934551e-5*std::sin(0.366639852523804*x_19 - 1.15647983551025) - 0.00592333258060189*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.00756127633824952*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 5.64262337343116e-5*std::sin(0.26759997010231*x_21 - 1.16415989398956) - 0.00433306534682013*std::sin(0.302319914102554*x_21 - 7.40903997421265) + 1.74502626819932e-5*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.0219587367178863*std::sin(0.399839848279953*x_22 + 2.00903987884521) + 0.00520367699945268*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.00735385442653274*std::sin(0.389839857816696*x_24 + 5.22088003158569) - 0.0098769849261467*std::sin(0.243119969964027*x_25 - 7.38488006591797) - 0.0063659214182531*std::sin(0.337679862976074*x_25 - 1.15311992168427) - 0.0191188570735421*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 5.9170695882542e-5*std::sin(0.364879846572876*x_26 - 1.15215992927551) + 0.00172584289173807*std::sin(0.394799828529358*x_26 + 5.19792032241821) - 0.00344521688701405*std::sin(0.412559866905212*x_26 - 1.19311988353729) - 0.00714273104947616*std::sin(0.443999856710434*x_26 - 7.44151973724365) - 0.0192507980857784*std::sin(0.294559925794601*x_27 - 4.21248006820679) - 3.82869501323457e-5*std::sin(0.328879833221436*x_27 + 5.02975988388062) - 0.00629875666331238*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.00595427726476709*std::sin(0.261439979076385*x_28 - 1.15511989593506) - 4.43868873232262e-5*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.0101084177520792*std::sin(0.278399974107742*x_29 + 5.01567983627319) - 0.00813135080037409*std::sin(0.281359940767288*x_29 - 1.16695988178253) - 6.8695659238404e-5*std::sin(0.357999831438065*x_3 - 4.19871997833252) + 0.00425531987953866*std::sin(0.377839833498001*x_3 - 1.20415985584259) - 0.00528184238853545*std::sin(0.471519857645035*x_3 - 4.39256000518799) + 0.104223594683756*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 4.5370234399867e-5*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.0112209525110646*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 0.00199080115676234*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.00236480310901021*std::sin(0.51039981842041*x_31 + 8.16663932800293) + 4.51900299558028e-6*std::sin(0.526799857616425*x_31 + 5.36439990997314) + 0.00178773239233614*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.0203484116504123*std::sin(0.247519969940186*x_33 + 1.97295987606049) + 3.30399961806429e-5*std::sin(0.232719987630844*x_35 + 1.9592798948288) + 0.0109793993725517*std::sin(0.232959985733032*x_35 + 1.97247982025146) + 0.0103253109648935*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.0118432603396262*std::sin(0.250159978866577*x_36 - 7.42375993728638) - 0.0118033234971795*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.0272677374385288*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.0057789098674687*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.00650736399366659*std::sin(0.374879837036133*x_4 + 1.99583983421326) + 3.66031687860831e-5*std::sin(0.244479969143867*x_41 - 7.42392015457153) + 0.0168743626918378*std::sin(0.112000063061714*x_43 - 1.25247991085052) - 0.0204492697296055*std::sin(0.270159959793091*x_44 - 7.45815992355347) + 0.0138230759045626*std::sin(0.222240000963211*x_45 + 1.98055982589722) - 0.0141934271899186*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.0142597060500008*std::sin(0.198079988360405*x_47 + 1.98031985759735) - 5.58479695724172e-5*std::sin(0.221279993653297*x_48 - 7.40007972717285) - 0.0251350183277785*std::sin(0.0957600772380829*x_49 + 8.14239978790283) + 0.00274144471287678*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 2.24287286142284e-5*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.0143241960701864*std::sin(0.371279835700989*x_5 + 2.02111983299255) - 0.0092565602318565*std::sin(0.23039998114109*x_50 - 7.42743968963623) - 0.0151113820588427*std::sin(0.198239997029305*x_51 - 4.38799953460693) + 6.83327626407042e-5*std::sin(0.205919995903969*x_51 - 1.20511984825134) - 0.0106977593207142*std::sin(0.247999966144562*x_53 + 1.98495984077454) - 0.011701575670784*std::sin(0.253679990768433*x_53 + 5.17080020904541) + 0.00943785582242414*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.00997561609083576*std::sin(0.196479991078377*x_54 + 8.19679927825928) + 0.0102571026789058*std::sin(0.225679993629456*x_55 + 5.15999984741211) + 8.82193558354597e-5*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.0204711014856641*std::sin(0.238239988684654*x_57 - 7.42631959915161) + 0.103038458927765*std::sin(0.0653600990772247*x_58 + 4.88775968551636) - 0.0966424009147211*std::sin(0.0555201061069965*x_59 + 8.0319995880127) + 4.75884909822852e-5*std::sin(0.376559853553772*x_59 + 1.82895994186401) - 4.77943476399924e-5*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.001583809810029*std::sin(0.435519844293594*x_6 + 1.9508798122406) + 0.00640240363237974*std::sin(0.340719848871231*x_60 + 8.27375984191895) + 5.19328960455826e-5*std::sin(0.395279824733734*x_60 - 1.18623995780945) + 0.00595974772822879*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.0112855611549033*std::sin(0.461039870977402*x_60 + 1.88791978359222) - 0.0061434048709842*std::sin(0.310879945755005*x_7 - 7.38831996917725) + 0.00757748757619395*std::sin(0.348799854516983*x_7 + 2.02463984489441) - 5.16238753812729e-5*std::sin(0.364559859037399*x_7 + 2.00311970710754) + 0.013829805400489*std::sin(0.423439860343933*x_7 - 1.21351993083954) + 3.35976804377782e-5*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.0126124534836112*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.00265329253899863*std::sin(0.327839851379395*x_9 - 1.09671986103058) + 0.0361099762785865*std::sin(0.128000050783157*x_90 + 2.00159978866577) + 2.99845362936541e-5*std::sin(0.242319971323013*x_91 + 8.42840003967285) + 0.00635705990060765*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.0166763055380844*std::sin(0.372959852218628*x_91 + 5.20560026168823) - 0.00991087222460721*std::sin(0.267439961433411*x_92 - 7.39351987838745) - 0.00860441993829188*std::sin(0.293839931488037*x_92 + 1.98743987083435) - 0.0103100177434892*std::sin(0.235599994659424*x_93 + 1.98431980609894) - 5.10854302843698e-5*std::sin(0.2360799908638*x_93 + 1.96975982189178) + 0.0165461669638013*std::sin(0.248079970479012*x_93 - 1.20583987236023) + 3.20320312538125e-5*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.0038239131651426*std::sin(0.304079920053482*x_94 + 1.96951985359192) - 0.00472598908267477*std::sin(0.261919945478439*x_95 - 7.4300799369812) - 0.0163244397306087*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 2.28726905016122e-5*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.0118032343426893*std::sin(0.27703994512558*x_97 + 1.96351981163025) - 0.0147807911849288*std::sin(0.277839958667755*x_97 + 1.94815981388092) + 0.0117663350505881*std::sin(0.278879970312119*x_97 + 1.950239777565) + 4.75398051966534e-5*std::sin(0.286639958620071*x_97 - 1.21999979019165) - 0.00972145021391245*std::sin(0.22791999578476*x_98 - 4.21591997146606) + 0.25313278692085);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000290091401975606*x_1 + 4.97405688272906e-6*x_10 - 0.000154362158765554*x_100 + 0.00142314568215664*x_101 + 0.00241042016109674*x_102 + 0.00110367299998557*x_103 - 0.00271701277392368*x_104 - 0.00299627492661709*x_105 + 0.00103207367698048*x_106 + 0.00180143221279016*x_107 + 0.000350733817214309*x_108 + 0.00279022630738638*x_109 + 0.000491655590572174*x_11 - 0.00131037467696759*x_110 - 0.00515951365677192*x_111 - 0.0046582529736655*x_112 - 0.00152568077242371*x_113 + 0.00125900162013099*x_114 - 0.00394683892561059*x_115 - 3.56102090642637e-5*x_116 - 0.00330142522997565*x_117 - 0.00222085401293908*x_118 - 0.000287970237596015*x_119 - 0.000905510172007438*x_12 - 0.00211842833419907*x_120 + 0.00123657222685877*x_15 - 0.000113532554934752*x_16 + 0.00200660717953574*x_17 - 0.000547986353818695*x_18 + 0.000800648646456124*x_19 - 2.77027355735658e-5*x_2 + 0.000418845986904261*x_20 - 0.000474048252854662*x_21 + 0.000124078056351283*x_22 + 0.000374029256603374*x_23 + 0.00332866241196125*x_24 + 4.96127301003677e-5*x_25 + 0.000980424762714421*x_27 + 0.00126866267554285*x_28 - 0.00186414489286973*x_29 + 0.000363875714376557*x_30 + 0.000196073112728436*x_32 - 0.000873838516775074*x_33 - 0.000327700775308961*x_34 - 2.30394322457159e-5*x_35 + 0.00269982192555261*x_36 - 0.00239322705781854*x_37 + 0.000962412333431775*x_38 - 0.00076844798105575*x_39 - 0.00228789202183868*x_4 - 0.00127220242304924*x_40 + 0.000201558250333764*x_41 - 9.87046377053565e-6*x_42 - 0.00522500233457216*x_43 - 0.000256331495843254*x_44 - 0.000141795314305836*x_45 - 0.0048412148241265*x_46 - 0.00100405425699494*x_47 + 0.00272912717147214*x_48 + 0.000122221458571989*x_5 - 0.000575577384572979*x_50 - 0.000499107941677616*x_51 + 0.00558381109571383*x_52 - 0.000138220556390682*x_53 + 0.00396872243244268*x_54 + 0.00276286950234107*x_55 + 0.00268924667296751*x_56 + 0.000252696083054218*x_57 - 0.00289193098597271*x_58 - 0.00350855844945601*x_59 + 4.70016503395436e-5*x_6 - 6.14501590141205e-5*x_60 + 0.00067155079693682*x_61 + 0.000261927154213436*x_62 + 0.000349746131675163*x_63 - 0.000112148284772958*x_64 - 0.000884876511394177*x_65 + 0.00220044123110719*x_66 - 3.65588464222658e-5*x_67 + 0.0013329525723118*x_68 - 0.00022199554972506*x_69 + 0.000498871741715632*x_7 - 0.00137991118372911*x_70 - 0.00207984486362122*x_71 + 0.0012976512421825*x_72 - 0.000659259855053109*x_73 + 0.000956267118876952*x_74 + 0.000926518571666742*x_75 - 0.0010236426779979*x_76 - 0.000143572791993159*x_77 - 0.0015589347314293*x_78 + 0.00105571875010845*x_79 + 0.000614612472284313*x_8 + 0.000192865782941785*x_80 - 0.00185791043074134*x_81 + 0.00229044611295081*x_82 - 0.000146729718808222*x_83 + 0.0016232173224074*x_84 - 0.000442855011846107*x_85 + 0.000372624787504701*x_86 - 0.000155068726797573*x_87 + 0.000617834315700959*x_88 - 0.00194222395504306*x_89 + 0.000899377472330486*x_9 + 0.00107983008932691*x_90 + 0.00111104619839998*x_91 + 0.000206953076341305*x_92 + 0.000792684448922181*x_93 + 0.00163672969452084*x_94 - 0.000792830420986804*x_95 - 0.000627336729572232*x_96 + 0.00161638625861115*x_98 + 0.00103989656652806*x_99 - 8.30962745629354e-7*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 1.32414404087127e-5*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) - 0.000920129416044801*std::pow(0.0288643216888134*x_10 - 0.196542127808069*x_100 - 0.0486431974607887*x_101 + 0.223075756295445*x_102 - 0.0935787113079666*x_103 + 0.207253416733433*x_104 - 0.180796251585549*x_105 + 0.0184976988032584*x_106 + 0.129414784058151*x_107 - 0.295621152954984*x_109 - 0.00210774962102674*x_110 + 0.268000255578927*x_111 - 0.115088960718421*x_114 + 0.219068402456684*x_115 - 0.254277422698829*x_117 - 0.270207248213844*x_118 - 0.0717321820654151*x_119 + 0.0339216462517982*x_13 + 0.225112817169111*x_18 - 0.067601328604077*x_2 - 0.101650257734155*x_20 + 0.236584905401509*x_21 + 0.166870487822873*x_24 + 0.0285495286181005*x_28 + 0.0322620923225197*x_3 + 0.38429509472771*x_30 + 0.149394719443038*x_32 + 0.10053338930577*x_34 + 0.0200186758666757*x_36 + 0.0569950582409265*x_37 + 0.0661163282622752*x_38 + 0.0193845396109234*x_39 - 0.278320668235392*x_40 + 0.203186172606767*x_41 - 0.0211765759891433*x_42 + 0.0201222238471846*x_43 + 0.26148745116385*x_45 + 0.203864038105053*x_46 - 0.233437190300928*x_48 + 0.0313415339296644*x_49 + 0.289560407248029*x_50 - 0.0106982411822267*x_51 - 0.0217612769594558*x_52 + 0.34113967771172*x_54 - 0.31458153783787*x_55 + 0.0294080132461942*x_56 + 0.285167921889984*x_58 - 0.371703690695091*x_59 - 0.0299848328224136*x_6 - 0.0060603830195623*x_61 - 0.0436744779869154*x_62 + 0.14672428851048*x_63 - 0.0980593535833235*x_64 - 0.110760305301011*x_65 - 0.0159474851958123*x_66 - 0.0335545870879954*x_67 - 0.185213517322536*x_68 + 0.120063800454057*x_69 + 0.221994366009678*x_70 - 0.031439358291552*x_71 - 0.120269327830877*x_72 - 0.111157217704581*x_73 + 0.19504490518777*x_74 - 0.0292470148437738*x_75 + 0.0604087664581864*x_76 + 0.0941304071721601*x_77 + 0.160260555079999*x_78 + 0.0672986935827767*x_79 - 0.0157075916600271*x_8 - 0.160188805621231*x_80 - 0.129809851509967*x_81 - 0.000442133066494143*x_82 + 0.151941582109701*x_83 - 0.151444737504861*x_84 + 0.124562425092148*x_85 - 0.021497954269729*x_86 + 0.121273005119193*x_87 - 0.0812263043986219*x_88 + 0.0500741104383211*x_89 - 0.0202522774872732*x_9 - 0.00493111994398478*x_92 - 0.00878610013886607*x_96 + 0.0216446272370405*x_98 + 0.130604684781337*x_99 - 0.00145471554078704*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) + 1.39790496806988*std::sin(0.444319844245911*x_1 - 7.17479991912842) - 1.26268030055335*std::sin(0.256479978561401*x_108 + 5.14879989624023) - 1.31671068234159*std::sin(0.345119833946228*x_11 + 5.07279968261719) - 0.798615925406523*std::sin(0.288159936666489*x_112 + 1.95711982250214) - 0.872739040145369*std::sin(0.242639973759651*x_113 + 8.37351989746094) + 0.49290933229252*std::sin(0.20168000459671*x_116 + 8.19727993011475) + 1.43036311874918*std::sin(0.335679858922958*x_12 + 1.86047983169556) + 0.932853378170456*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 1.52063781760972*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 2.02655142236553*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 1.52323794002454*std::sin(0.261759966611862*x_16 - 1.1658399105072) - 0.885852501239384*std::sin(0.303199917078018*x_17 + 2.02831983566284) + 1.4843164766032*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 1.87483639002568*std::sin(0.399839848279953*x_22 + 2.00903987884521) - 1.63236753724451*std::sin(0.354159832000732*x_25 + 2.04983973503113) + 0.147352422794982*std::sin(0.394799828529358*x_26 + 5.19792032241821) - 1.64363265755883*std::sin(0.294559925794601*x_27 - 4.21248006820679) - 0.863056454051055*std::sin(0.278399974107742*x_29 + 5.01567983627319) - 0.958044643859587*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 1.737346876168*std::sin(0.247519969940186*x_33 + 1.97295987606049) + 0.937420842953955*std::sin(0.232959985733032*x_35 + 1.97247982025146) + 2.32811873835064*std::sin(0.293199926614761*x_4 - 7.37039995193481) - 1.74595813643897*std::sin(0.270159959793091*x_44 - 7.45815992355347) - 1.21183445736038*std::sin(0.142560034990311*x_47 + 8.20160007476807) - 1.22299950107664*std::sin(0.371279835700989*x_5 + 2.02111983299255) - 0.913374422394455*std::sin(0.247999966144562*x_53 + 1.98495984077454) + 1.7478221312235*std::sin(0.238239988684654*x_57 - 7.42631959915161) + 0.9635609282495*std::sin(0.461039870977402*x_60 + 1.88791978359222) + 1.1807884381022*std::sin(0.423439860343933*x_7 - 1.21351993083954) + 3.08306886866188*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 1.42382254843105*std::sin(0.372959852218628*x_91 + 5.20560026168823) + 1.41271132022395*std::sin(0.248079970479012*x_93 - 1.20583987236023) + 0.326485610097414*std::sin(0.304079920053482*x_94 + 1.96951985359192) - 1.39378025461713*std::sin(0.283599942922592*x_95 - 1.20095992088318) - 1.26198358051732*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 8.64324784123759, 2) + 0.000260133874220815*std::exp(0.277599841356277*x_13) + 0.000549577772857576*std::exp(0.275439828634262*x_23) + 0.0110990984626595*std::exp(0.143199846148491*x_49) - 0.00184937451120495*std::exp(0.147999867796898*x_49) - 0.0064824243424212*std::sin(0.304559946060181*x_1 - 4.28071975708008) - 0.0167371301618433*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.0157536885687277*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.00422550925396078*std::sin(0.346559852361679*x_10 - 1.14743983745575) - 0.00533007199736055*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.00489738217018467*std::sin(0.253279983997345*x_100 - 1.22375988960266) - 0.0125468678594957*std::sin(0.235039994120598*x_101 + 1.9703197479248) - 0.00330978459296433*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.00326732008721338*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.00214715752102902*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.00428939958661973*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.00406105072499378*std::sin(0.250399976968765*x_108 + 1.97543978691101) + 0.0132238202054574*std::sin(0.264079958200455*x_109 + 4.96231985092163) - 0.0017952390800182*std::sin(0.235759988427162*x_11 - 7.3951997756958) + 0.00783289506512631*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.0013436313456543*std::sin(0.27975994348526*x_113 - 7.42360019683838) - 0.00546741309800015*std::sin(0.281679958105087*x_113 + 1.98447978496552) - 0.00427242654277759*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.004463340333247*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.000651740543250378*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.0183382741044139*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.0177208578117202*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.00745013576468931*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.0119429657894804*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.00361017094897418*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.00464455701868188*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.00621905261621602*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.0033203386665579*std::sin(0.251679986715317*x_14 - 7.24671983718872) + 0.0172521224596497*std::sin(0.305359929800034*x_14 - 7.44343996047974) - 0.00413882207975691*std::sin(0.363359838724136*x_14 - 4.37039995193481) + 0.0203583540517819*std::sin(0.253519982099533*x_15 - 7.40231990814209) - 0.00181603480751281*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.00390179996492933*std::sin(0.153840035200119*x_16 + 8.35536003112793) - 0.00377532580048068*std::sin(0.336639851331711*x_16 - 1.15263986587524) + 0.0225874807535782*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.0025661349664026*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.00478351953518278*std::sin(0.350719839334488*x_17 - 1.15999984741211) - 0.00594368117262447*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.0176107083249851*std::sin(0.429519861936569*x_18 + 1.96343982219696) - 0.00119765691122627*std::sin(0.366639852523804*x_19 - 1.15647983551025) + 0.00483458065192745*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.0137971778790327*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.00390974434804508*std::sin(0.417119860649109*x_2 - 1.17111992835999) - 0.00381468765331293*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.00238901043388098*std::sin(0.26759997010231*x_21 - 1.16415989398956) + 0.00353661618763018*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.0127327067896941*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.000738820524820807*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.0157902156659938*std::sin(0.384959846735001*x_22 + 1.97783982753754) - 0.0042472030395223*std::sin(0.288719952106476*x_23 - 4.34591960906982) + 0.0157732168409184*std::sin(0.4129598736763*x_23 + 5.19824028015137) + 0.00380249173476695*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.00510713856540105*std::sin(0.243119969964027*x_25 - 7.38488006591797) - 0.00968435270940235*std::sin(0.322079926729202*x_25 - 1.20271992683411) + 0.00519581841836233*std::sin(0.337679862976074*x_25 - 1.15311992168427) - 0.016428199635754*std::sin(0.34239986538887*x_26 - 1.13975989818573) + 0.00250520725003543*std::sin(0.364879846572876*x_26 - 1.15215992927551) + 0.00281196078001741*std::sin(0.412559866905212*x_26 - 1.19311988353729) + 0.00369332518757814*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.00162101769503774*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 0.00325692742368388*std::sin(0.375999838113785*x_27 - 4.38071966171265) - 0.00485983747641086*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.00187928078705359*std::sin(0.316079914569855*x_28 + 2.00583982467651) + 0.00663674894471801*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.00290848131838161*std::sin(0.357999831438065*x_3 - 4.19871997833252) - 0.00347316090687742*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.00273110682668452*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 0.00957757026749112*std::sin(0.510479867458344*x_3 + 1.96471977233887) - 0.0538913791824319*std::sin(0.0844800844788551*x_30 + 4.86079978942871) + 0.0147137713378313*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.00192091437254651*std::sin(0.331519842147827*x_30 - 1.15855991840363) + 0.0181967308677729*std::sin(0.343999862670898*x_31 - 4.24528026580811) - 0.00102939281974915*std::sin(0.408799856901169*x_31 - 1.18735992908478) + 0.00193013497062104*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 0.000191328476006647*std::sin(0.526799857616425*x_31 + 5.36439990997314) - 0.00145913407987873*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.0288226697760225*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.0245204054755163*std::sin(0.173360019922256*x_33 + 5.19776010513306) - 0.00139886875992126*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.00533895659686284*std::sin(0.256079971790314*x_35 + 1.95967984199524) + 0.00966638231343046*std::sin(0.250159978866577*x_36 - 7.42375993728638) + 0.00963378615524338*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.00714234456741293*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.0149496349339847*std::sin(0.233839988708496*x_39 + 1.97919988632202) - 0.00298812782147681*std::sin(0.365439832210541*x_4 - 1.18407988548279) + 0.00531126281206264*std::sin(0.374879837036133*x_4 + 1.99583983421326) + 0.0254560187700018*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.00154972866973195*std::sin(0.244479969143867*x_41 - 7.42392015457153) - 0.0211602514847043*std::sin(0.243519976735115*x_42 - 7.4346399307251) - 0.013772731190332*std::sin(0.112000063061714*x_43 - 1.25247991085052) - 0.0112822932713888*std::sin(0.222240000963211*x_45 + 1.98055982589722) + 0.0301305722302851*std::sin(0.120480060577393*x_47 + 1.96895980834961) - 0.00737333257505066*std::sin(0.198079988360405*x_47 + 1.98031985759735) + 0.00236452751122465*std::sin(0.221279993653297*x_48 - 7.40007972717285) + 0.0205150177944207*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.00141753157696779*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.0110814402165243*std::sin(0.331039845943451*x_5 - 1.16375982761383) - 0.000949602040256216*std::sin(0.341359823942184*x_5 + 2.00831985473633) + 0.00755513663826507*std::sin(0.23039998114109*x_50 - 7.42743968963623) + 0.00781371265282813*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.00289311676716228*std::sin(0.205919995903969*x_51 - 1.20511984825134) + 0.0228818762653958*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.0133280957321215*std::sin(0.238319978117943*x_53 - 7.42679977416992) + 0.00955074032484745*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 0.00488007603593676*std::sin(0.25383996963501*x_53 - 7.41967964172363) + 0.00814202476182928*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.00530368782097095*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 0.00373508823136312*std::sin(0.202719986438751*x_56 - 1.1847198009491) - 0.0204565538112078*std::sin(0.246799975633621*x_57 + 5.15375995635986) - 0.0532785755212022*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 0.0499713360357507*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.00201483235660646*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.00202354804912392*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.0186453325261511*std::sin(0.381519854068756*x_6 + 2.00575971603394) - 0.00129269396234392*std::sin(0.435519844293594*x_6 + 1.9508798122406) - 0.00522559493422668*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.00219876859226048*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.0030816344957988*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.0845644367728482*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.00317659894938368*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.00618468983930755*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.0021856850752071*std::sin(0.364559859037399*x_7 + 2.00311970710754) - 0.00142248035723929*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.00923766332088055*std::sin(0.386879861354828*x_8 + 8.19487953186035) - 0.00652158002387549*std::sin(0.311839938163757*x_9 + 5.14567995071411) - 0.00216559792961056*std::sin(0.327839851379395*x_9 - 1.09671986103058) - 0.00126950472005477*std::sin(0.242319971323013*x_91 + 8.42840003967285) - 0.00518858571258861*std::sin(0.368239849805832*x_91 + 1.98719990253448) + 0.00808918129259296*std::sin(0.267439961433411*x_92 - 7.39351987838745) + 0.00444912746433642*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.00841496094055832*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.00216288803791713*std::sin(0.2360799908638*x_93 + 1.96975982189178) - 0.00135619288794082*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.00244368917076083*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.00895572793216889*std::sin(0.287439942359924*x_95 + 1.96047985553741) - 0.00096839878622015*std::sin(0.292799949645996*x_95 - 1.22199988365173) + 0.00506401827131883*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.00727094961348389*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.00610315331639689*std::sin(0.27703994512558*x_97 + 1.96351981163025) - 0.00960359645615045*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.00201277106627821*std::sin(0.286639958620071*x_97 - 1.21999979019165) + 0.00502671550785367*std::sin(0.22791999578476*x_98 - 4.21591997146606) - 0.0258368641618104*std::sin(0.242959976196289*x_98 - 7.42695951461792) + 0.0842797483995868);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.78672500444496e-5*x_1 + 0.000290718144409279*x_10 - 0.0020372205622446*x_100 - 0.00186548427848394*x_101 + 0.00292455355759471*x_102 - 0.00167835258808939*x_103 + 0.00328995439393649*x_104 - 0.00174628348944535*x_105 + 0.00123114427686811*x_106 - 0.000350419557054333*x_107 - 0.000564166488491216*x_108 - 0.00381592575799068*x_109 + 0.000673261675158059*x_11 + 0.00165659847582737*x_110 + 0.0025765833356093*x_111 - 0.00043997390126153*x_112 + 0.000378412735554262*x_113 - 0.00308847057807877*x_114 + 0.000585511773176459*x_115 - 0.00354719179618718*x_117 - 0.00445672002029468*x_118 - 0.00078484935673062*x_119 + 0.000511593539444304*x_12 + 0.000664236566674799*x_120 + 0.000331037554429779*x_13 - 0.000775762624395947*x_15 - 0.000349029584655605*x_17 + 0.00267887436665913*x_18 + 9.85403528930509e-5*x_19 - 0.000710030710038679*x_2 - 0.000906534672598111*x_20 + 0.00230880564928256*x_21 - 0.000165868864495798*x_22 + 0.00226466871753031*x_24 + 9.01123560221553e-5*x_25 - 7.58138980907106e-5*x_27 + 0.000278611658871303*x_28 + 0.000147547738996517*x_29 + 0.000314842153118337*x_3 + 0.00341746139687086*x_30 + 0.00127984002328799*x_32 + 0.00040666474187359*x_33 + 0.00239928270033939*x_34 - 0.000220095448300807*x_35 + 0.000274120837542454*x_36 + 0.000127879702947207*x_37 - 9.95345816160753e-5*x_38 + 0.00164523777509394*x_39 + 0.000267927995131958*x_4 - 0.00226623098799333*x_40 + 0.00237051788998725*x_41 - 0.000578497598068488*x_42 - 0.000280440003799102*x_43 - 0.000622433030736725*x_44 + 0.00185302120983566*x_45 + 0.00128286031965693*x_46 + 0.000190095433511189*x_47 - 0.00228620628693662*x_48 + 0.000305858526651079*x_49 + 0.000115596903750281*x_5 + 0.0023885791859929*x_50 + 0.000352123364907505*x_51 - 0.00190531356629748*x_52 - 0.000251052098158276*x_53 + 0.00273562098996993*x_54 - 0.00561714965616994*x_55 - 0.00119185016351978*x_56 - 0.00140477822200046*x_57 + 0.0026967582348562*x_58 - 0.00374876277938461*x_59 - 0.000292618632180665*x_6 - 0.000477431729492123*x_61 - 0.001061815940183*x_62 + 0.00171864406847482*x_63 - 0.00037643586949759*x_64 - 0.000661761750771608*x_65 - 0.000974651870486802*x_66 - 0.000641769388408165*x_67 - 0.00144261546743134*x_68 + 0.000888078390155572*x_69 + 0.00289673995076643*x_70 + 0.000426366640812469*x_71 - 0.00118726543009508*x_72 - 0.00187885448639683*x_73 + 0.00203599023878413*x_74 - 0.000740220138085057*x_75 + 0.000342748604399903*x_76 + 0.00114184426482103*x_77 + 0.00176517188291876*x_78 + 0.000257166967934087*x_79 + 0.00012959900708338*x_8 - 0.00105946715428218*x_80 - 0.000787920311438165*x_81 - 0.00023674983916072*x_82 + 0.000663954228697372*x_83 - 0.00146231504779481*x_84 + 0.00091026167822461*x_85 - 0.000584441244495532*x_86 + 0.00044788763912028*x_87 - 0.00129593901306359*x_88 + 0.000934765713935977*x_89 + 0.000279635728372436*x_9 + 0.000602776658997007*x_90 - 0.000197619043493658*x_92 - 0.000870988151441474*x_94 + 0.000725189708020416*x_95 + 0.000284474287993344*x_96 - 0.00101667722158144*x_98 + 0.00065335840894925*x_99 - 1.41964063724533e-5*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 0.00523026147857308*std::pow(-0.00338535913096328*x_100 + 0.0762524067786836*x_102 + 0.0794049542548848*x_103 - 0.0682203650836292*x_104 - 0.104644126866771*x_105 + 0.0501207433482693*x_106 + 0.0170255250446476*x_107 + 0.0364203361609938*x_108 + 0.0457266794672599*x_11 - 0.0375926016028175*x_110 - 0.16318391536214*x_111 - 0.161094811481302*x_112 - 0.0424201528330938*x_113 + 0.036815521332324*x_114 - 0.117534811744651*x_115 - 0.00135847854742792*x_116 - 0.13458196639933*x_117 - 0.098726813558548*x_118 + 0.0838799588806061*x_17 + 0.0606634998956506*x_19 + 0.159036523005911*x_24 + 0.0342398469684876*x_27 + 0.0382652621880604*x_28 - 0.0742134475426023*x_29 + 0.0236329543063089*x_34 - 0.010058399620272*x_35 + 0.141612170561679*x_36 - 0.0509285566120128*x_37 - 0.0929071742496373*x_4 - 0.0391437713007448*x_40 - 0.143747323158418*x_43 + 0.0303351887628106*x_44 + 0.00990817859320186*x_45 - 0.177320101818302*x_46 + 0.116496841949218*x_48 - 0.0340488213780809*x_50 + 0.173642697640644*x_52 + 0.166082613114707*x_54 + 0.0552465110451008*x_55 + 0.0160965843459546*x_56 - 0.130715510821799*x_58 - 0.138907524834178*x_59 - 0.00234423568269616*x_60 - 0.00443733441080397*x_62 - 0.0167146676212178*x_63 + 0.0086883781250949*x_64 - 0.000801273042733748*x_65 + 0.0542971355269545*x_66 - 0.0291528652917365*x_67 + 0.0661131266030379*x_68 - 0.0349760693875356*x_69 + 0.0190312434789605*x_7 - 0.027714328472154*x_70 - 0.0696354868224303*x_71 + 0.0454302227755289*x_72 - 0.0579277697837166*x_73 + 0.0597604666773481*x_74 + 0.0165765718445714*x_75 - 0.0117072525807622*x_76 + 0.0235236218766357*x_77 - 0.0283566566800298*x_78 + 0.0417798683540858*x_79 + 0.00366760143871165*x_80 - 0.0310903796466169*x_81 + 0.0598697108745029*x_82 - 0.0262548550800058*x_83 + 0.0493695689652819*x_84 - 0.0104859770088152*x_85 - 0.000758539915321173*x_86 - 0.0382287576934917*x_87 + 0.0144095217485101*x_88 - 0.065901075555986*x_89 + 0.0242856164251798*x_9 + 0.0475903141035808*x_90 + 0.0492054549217435*x_91 + 0.011034886358673*x_92 + 0.0308721897721103*x_93 + 0.0131930526758627*x_94 + 0.0223982579292483*x_99 + 0.423414732839759*std::exp(0.143199846148491*x_49) - 0.638497578863991*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.600980688567589*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.47864506478404*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 0.504469828630846*std::sin(0.264079958200455*x_109 + 4.96231985092163) + 0.699578930377569*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.676025381816729*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.284212024520592*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.455607064490849*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.658143798502806*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 0.776642091327744*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 0.861680086988599*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.671823336429412*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.526342603883293*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.14552487835193*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.485734554191303*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.602374145088618*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.601725664223068*std::sin(0.4129598736763*x_23 + 5.19824028015137) - 0.369444205668849*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 0.626712321114432*std::sin(0.34239986538887*x_26 - 1.13975989818573) - 0.365370608226144*std::sin(0.510479867458344*x_3 + 1.96471977233887) + 0.561309333459171*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.694179258329498*std::sin(0.343999862670898*x_31 - 4.24528026580811) + 1.09954363086341*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.935418400734733*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.272470230535824*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.570307192329231*std::sin(0.233839988708496*x_39 + 1.97919988632202) + 0.971110709840616*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.807233331550364*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 1.14943823898092*std::sin(0.120480060577393*x_47 + 1.96895980834961) + 0.422741096003854*std::sin(0.331039845943451*x_5 - 1.16375982761383) + 0.872910854731117*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.508447790842169*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.780388271708262*std::sin(0.246799975633621*x_57 + 5.15375995635986) + 0.711292770023505*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 3.22601232202607*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.352403644335006*std::sin(0.386879861354828*x_8 + 8.19487953186035) + 0.341648212468982*std::sin(0.287439942359924*x_95 + 1.96047985553741) + 0.193185054683472*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.277376329117359*std::sin(0.249119967222214*x_97 - 7.40423965454102) - 0.985639416867443*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 1.58382076741745, 2) + 0.000472485110974268*std::exp(0.277599841356277*x_13) + 0.000998206464941908*std::exp(0.275439828634262*x_23) - 0.00335904704366924*std::exp(0.147999867796898*x_49) + 0.00592937315686467*std::sin(0.304559946060181*x_1 - 4.28071975708008) + 0.0136419983428888*std::sin(0.444319844245911*x_1 - 7.17479991912842) + 0.00386500787684632*std::sin(0.346559852361679*x_10 - 1.14743983745575) + 0.0044795596284514*std::sin(0.253279983997345*x_100 - 1.22375988960266) + 0.00302740871067335*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.0123223559263337*std::sin(0.256479978561401*x_108 + 5.14879989624023) - 0.0032607200368981*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.0128496323833582*std::sin(0.345119833946228*x_11 + 5.07279968261719) - 0.00716462781304913*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.00779360355664449*std::sin(0.288159936666489*x_112 + 1.95711982250214) - 0.00851696274881709*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.00244045804246582*std::sin(0.27975994348526*x_113 - 7.42360019683838) + 0.00481024708254192*std::sin(0.20168000459671*x_116 + 8.19727993011475) + 0.0039079223943491*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.00118376625814865*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.0139587538075981*std::sin(0.335679858922958*x_12 + 1.86047983169556) + 0.0091036118547677*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 0.00424830437771276*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.0112957598249329*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.00378571646107071*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.0148397345039902*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 0.0197768888280448*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 0.00329849163293692*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.00708689860154136*std::sin(0.153840035200119*x_16 + 8.35536003112793) - 0.014865108808027*std::sin(0.261759966611862*x_16 - 1.1658399105072) + 0.00345323204365047*std::sin(0.336639851331711*x_16 - 1.15263986587524) - 0.00864493554997331*std::sin(0.303199917078018*x_17 + 2.02831983566284) + 0.00437541123953277*std::sin(0.350719839334488*x_17 - 1.15999984741211) + 0.0144852785966572*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 0.00217532245773382*std::sin(0.366639852523804*x_19 - 1.15647983551025) - 0.00442211605226835*std::sin(0.374879837036133*x_2 - 7.40015983581543) - 0.00433919597496472*std::sin(0.26759997010231*x_21 - 1.16415989398956) - 0.00323488805751879*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.0013419309526898*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.0182963187842676*std::sin(0.399839848279953*x_22 + 2.00903987884521) + 0.0038848508465417*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.00475253464296874*std::sin(0.337679862976074*x_25 - 1.15311992168427) - 0.0159300923501417*std::sin(0.354159832000732*x_25 + 2.04983973503113) + 0.00455024601887015*std::sin(0.364879846572876*x_26 - 1.15215992927551) + 0.00143799582482728*std::sin(0.394799828529358*x_26 + 5.19792032241821) - 0.0025720569784489*std::sin(0.412559866905212*x_26 - 1.19311988353729) - 0.0160400274002135*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.00294427908639464*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 0.00444521807848708*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.00341336626720556*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.00842247147332224*std::sin(0.278399974107742*x_29 + 5.01567983627319) - 0.00607053148065942*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.00528271884082123*std::sin(0.357999831438065*x_3 - 4.19871997833252) + 0.00317684649490548*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.00348898598155765*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.00934945060106022*std::sin(0.318639844655991*x_31 + 5.33767986297607) - 0.00176546456686475*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 0.000347512820040507*std::sin(0.526799857616425*x_31 + 5.36439990997314) + 0.00133464734619146*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.0169545739854057*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.00254078659786072*std::sin(0.232719987630844*x_35 + 1.9592798948288) + 0.00914818523309521*std::sin(0.232959985733032*x_35 + 1.97247982025146) - 0.00884169020503191*std::sin(0.250159978866577*x_36 - 7.42375993728638) - 0.00881187500393398*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.0227198505592837*std::sin(0.293199926614761*x_4 - 7.37039995193481) - 0.00485812984207314*std::sin(0.374879837036133*x_4 + 1.99583983421326) - 0.00281479574581186*std::sin(0.244479969143867*x_41 - 7.42392015457153) + 0.0125977039303425*std::sin(0.112000063061714*x_43 - 1.25247991085052) - 0.0170386103119301*std::sin(0.270159959793091*x_44 - 7.45815992355347) + 0.0103197389336998*std::sin(0.222240000963211*x_45 + 1.98055982589722) - 0.0118261570255322*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.0042947272702914*std::sin(0.221279993653297*x_48 - 7.40007972717285) - 0.0187647690736342*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.00172477662402011*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.0119351154392688*std::sin(0.371279835700989*x_5 + 2.02111983299255) - 0.00691056648146576*std::sin(0.23039998114109*x_50 - 7.42743968963623) - 0.00525481197282997*std::sin(0.205919995903969*x_51 - 1.20511984825134) - 0.00891351890246614*std::sin(0.247999966144562*x_53 + 1.98495984077454) - 0.00873591426894834*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 0.00744738395932999*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.00678409754508272*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.017056800828698*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.0036595706439895*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.00367540108882742*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.00118240714823371*std::sin(0.435519844293594*x_6 + 1.9508798122406) + 0.00477977076090006*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.00399365682548159*std::sin(0.395279824733734*x_60 - 1.18623995780945) + 0.00940328340387943*std::sin(0.461039870977402*x_60 + 1.88791978359222) + 0.0056570400176899*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.00396989303452813*std::sin(0.364559859037399*x_7 + 2.00311970710754) + 0.0115231823935311*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 0.00258367270107394*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.00198083888898865*std::sin(0.327839851379395*x_9 - 1.09671986103058) + 0.0300873245020151*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 0.00230582072532498*std::sin(0.242319971323013*x_91 + 8.42840003967285) + 0.00474591899900579*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.0138949251128873*std::sin(0.372959852218628*x_91 + 5.20560026168823) - 0.00739904885637245*std::sin(0.267439961433411*x_92 - 7.39351987838745) - 0.00769703445522591*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.00392848642907892*std::sin(0.2360799908638*x_93 + 1.96975982189178) + 0.0137864918786897*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.00246327376271382*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.0031861365784225*std::sin(0.304079920053482*x_94 + 1.96951985359192) - 0.0136017457253128*std::sin(0.283599942922592*x_95 - 1.20095992088318) - 0.00175891743951108*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.0123155567133728*std::sin(0.277839958667755*x_97 + 1.94815981388092) + 0.00878426095370219*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.00365582669102524*std::sin(0.286639958620071*x_97 - 1.21999979019165) - 1.22781836986542*std::sin(0.0058132283601121*x_1 + 0.00591655309235888*x_101 - 0.0165524091668501*x_103 + 0.0086730520511904*x_105 + 0.0105225727617257*x_107 + 0.0170002246288313*x_109 + 0.000615014174317683*x_11 + 0.0060851156731903*x_110 + 0.00873108099965408*x_111 - 0.00408761592931839*x_112 - 0.0225418637480759*x_114 - 0.0170172135620589*x_115 + 0.00928730341585631*x_117 - 0.0044268034866466*x_118 - 0.00881574788802383*x_119 + 0.011398937736265*x_12 - 0.0273533000221667*x_120 + 0.00821899902438785*x_15 - 0.00240216152787575*x_16 - 0.0144259852709854*x_19 + 0.0151271380567697*x_20 - 0.0100300788264532*x_21 - 0.00121156765935417*x_22 + 0.007913841902254*x_23 + 0.00561973780258609*x_28 + 0.00622312061159395*x_32 + 0.000654113407108627*x_33 + 0.000810140073675969*x_34 - 0.0223361020451897*x_36 - 0.0174005954546941*x_37 + 0.0186062295592558*x_38 + 0.00232044678430654*x_39 + 0.0143266218240605*x_40 + 0.0132316283762182*x_41 - 0.00364058054721459*x_42 - 0.0252714267444725*x_43 + 0.0014959655217984*x_44 - 0.000355107570596304*x_45 + 0.0112713140307708*x_46 - 0.00705664592162395*x_48 + 0.00525997525931237*x_5 + 0.0117993018700018*x_50 - 0.00129908869541001*x_52 - 0.00122883919191269*x_54 + 0.0137640643170363*x_56 - 0.00145000454912041*x_57 + 0.000994477366048953*x_6 + 0.00128471946599329*x_61 - 0.00012320087620882*x_62 + 0.0092618953730487*x_63 + 0.00225710125821418*x_64 - 0.00667818284267389*x_65 + 0.0028819763341101*x_66 + 0.00461301687111112*x_67 + 0.00470811415751662*x_68 + 0.00329987875738293*x_69 - 0.0064645277552746*x_70 + 0.00457128838657771*x_71 + 0.00534862780561167*x_72 + 0.00766018380993016*x_73 - 0.00857331976459033*x_74 - 0.00585792763996269*x_75 - 0.00863996103852966*x_76 - 0.00770559868010391*x_77 - 0.00388061086164188*x_78 - 0.012192761443514*x_79 + 0.0195479017326291*x_8 + 0.0101371609675241*x_80 - 0.00915254685968252*x_81 + 0.00978674249388449*x_82 + 0.00306484928901299*x_83 - 0.00757332692511221*x_84 + 0.00372098582171262*x_85 + 0.0120726243280147*x_86 + 0.00587274308220752*x_87 - 0.0118310531739202*x_88 + 0.00350090563394911*x_89 - 1.39503646750376e-6*x_90 - 0.00378292835772338*x_91 - 0.000350754651956072*x_93 + 0.00716566183296238*x_94 - 0.00724047602492742*x_96 - 0.00866188940316393*x_99 - 1.75818005663311e-5*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 0.000280167029991965*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) - 0.112775528571746*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.0691311017995702*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.0454303102248446*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.0907566175233683*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.0859251323987067*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.115681439641413*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.0944369167108405*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.0763852603129074*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.0702528874551227*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.0542951816346573*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.125758486233693*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.0827237391257611*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 0.0804544508011134*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.108058625003089*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.0781446667930048*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.0689112101877143*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.0577857139861848*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 1.14025265995821*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 0.0217802535148977*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.112963512037169*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.0632238541381547*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.156007550910829*std::sin(0.198079988360405*x_47 + 1.98031985759735) - 0.0299926291687704*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.165325266706866*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.103254356544454*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.112217282934587*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 1.12728674564408*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 1.05731101524685*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.0652023010759955*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.0672115922176282*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.137985872363394*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.094136195856656*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.0517044306407257*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.129132653658694*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.10635700580756*std::sin(0.22791999578476*x_98 - 4.21591997146606) - 7.37659342771857) + 1.20816321697058);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000976670628558876*x_1 - 6.18958645669683e-5*x_10 + 0.000410642295451602*x_100 + 0.000813276149613742*x_101 - 0.000351230305337925*x_102 + 0.00309099537098842*x_103 - 0.00189403038793766*x_104 - 0.00175644825787258*x_105 - 0.000729607829066604*x_106 - 0.000566775552439493*x_107 - 0.000407947046140466*x_108 + 0.00017925760203409*x_109 - 0.00111743007178534*x_11 - 0.00229046570883264*x_110 - 0.00338374382621921*x_111 + 0.000607903074703122*x_112 - 0.000569674593490017*x_113 + 0.00620679499439559*x_114 + 0.00291734061514242*x_115 - 0.000822985005748238*x_117 + 0.00262711290178884*x_118 + 0.00181179874322929*x_119 - 0.003606944303998*x_12 + 0.003517793036951*x_120 - 7.47321532382499e-5*x_13 - 0.000220392530125816*x_15 + 0.00040574302039413*x_16 - 6.546738058905e-5*x_17 - 0.0012432266164958*x_18 + 0.00228831085140003*x_19 + 0.000139493313585854*x_2 - 0.00266852970523342*x_20 + 0.001172939372475*x_21 + 0.00045434710059902*x_22 - 0.00133670699454656*x_23 - 0.0014743808247558*x_24 + 1.69023491613168e-5*x_25 + 0.000114132658649714*x_27 - 0.00101211262066209*x_28 + 2.7675487719673e-5*x_29 - 7.10760205839156e-5*x_3 - 0.000345578315826831*x_30 - 0.00141366389972194*x_32 - 0.00119661094229189*x_33 - 0.00191143155473665*x_34 + 0.000331338703112401*x_35 + 0.00374340480072009*x_36 + 0.00273318425771434*x_37 - 0.00292026867746214*x_38 - 0.00189154859281089*x_39 + 5.0255178354215e-5*x_4 - 0.0029282591863224*x_40 - 0.00326613231033293*x_41 + 0.000969716988620866*x_42 + 0.00413476657554768*x_43 - 0.00117227350864934*x_44 - 0.000647172629578227*x_45 - 0.00283228884419987*x_46 - 0.00110621700779174*x_47 + 0.00171842371765403*x_48 - 6.90479553665333e-5*x_49 - 0.00106247236398779*x_5 - 0.00271292245915173*x_50 - 0.000663700152687551*x_51 + 0.00203593997913676*x_52 - 4.7089771126493e-5*x_53 - 0.000655325357102768*x_54 + 0.00301360189374926*x_55 - 0.000163349111887328*x_56 + 0.00110881026183082*x_57 - 4.50109348945482e-5*x_58 + 0.00100157470214046*x_59 - 0.000101915621287132*x_6 + 0.000584177489863522*x_61 + 0.00075376803918128*x_62 - 0.00163584707217516*x_63 - 0.000845423418339914*x_64 + 0.000648322615181429*x_65 + 0.000519226334240846*x_66 - 6.1127665528316e-5*x_67 - 0.00116687603582426*x_68 - 0.000159266775533777*x_69 - 3.25947686929919e-5*x_70 - 0.00146566702808634*x_71 - 0.00078369285254874*x_72 - 0.000235602622867541*x_73 + 0.000756906320407012*x_74 + 0.00201830878045327*x_75 + 0.00110227655529293*x_76 + 0.000601585248261595*x_77 - 0.00042506609110029*x_78 + 0.00261566131271428*x_79 - 0.00369304954033499*x_8 - 0.00194432454858372*x_80 + 0.00102158941952287*x_81 - 0.00129763231394008*x_82 - 0.00013319590171078*x_83 + 0.00231447084782487*x_84 - 0.00114119305747601*x_85 - 0.00203303281480692*x_86 - 0.000393488456713071*x_87 + 0.00319145426910956*x_88 - 0.0012624956932256*x_89 + 0.000134139838617437*x_9 - 0.000401110841116326*x_90 + 0.000638964848943613*x_91 - 1.71774122187078e-5*x_92 + 5.92450800041742e-5*x_93 + 0.00010087953098413*x_94 - 0.00109172370088066*x_95 + 0.000808183724247469*x_96 + 0.00208298626055005*x_98 + 0.00229897885470217*x_99 + 2.96969740917414e-6*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 3.20485697849636e-6*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 4.73223035356481e-5*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) + 8.86238987830604e-5*std::exp(0.277599841356277*x_13) + 0.000187233304624547*std::exp(0.275439828634262*x_23) - 0.00063005550501229*std::exp(0.147999867796898*x_49) - 0.00892626734097627*std::sin(0.304559946060181*x_1 - 4.28071975708008) - 0.00307969865350422*std::sin(0.444319844245911*x_1 - 7.17479991912842) - 0.00581850604962638*std::sin(0.346559852361679*x_10 - 1.14743983745575) + 0.0190486289361684*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.00674367184448637*std::sin(0.253279983997345*x_100 - 1.22375988960266) - 0.00455755756754565*std::sin(0.211600005626678*x_102 - 1.21039986610413) + 0.0116767593360535*std::sin(0.237199977040291*x_102 + 1.95759987831116) + 0.00767351865150018*std::sin(0.19743999838829*x_104 - 4.40719985961914) - 0.0153294704320945*std::sin(0.24551996588707*x_106 + 4.98847961425781) - 0.0145133965150324*std::sin(0.250399976968765*x_108 + 1.97543978691101) + 0.00278178768245572*std::sin(0.256479978561401*x_108 + 5.14879989624023) - 0.000611612336130718*std::sin(0.235759988427162*x_11 - 7.3951997756958) + 0.00290082102008762*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.0107858590724433*std::sin(0.250879973173141*x_112 - 7.428879737854) + 0.00175941601633863*std::sin(0.288159936666489*x_112 + 1.95711982250214) + 0.00192271528336245*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.000457756025568338*std::sin(0.27975994348526*x_113 - 7.42360019683838) + 0.0195394590159617*std::sin(0.281679958105087*x_113 + 1.98447978496552) - 0.00108591945921538*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.00588311093211642*std::sin(0.222719997167587*x_116 + 8.38632011413574) - 0.015951100447791*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.000222038702613597*std::sin(0.269519954919815*x_116 - 1.24311995506287) - 0.00315120660663805*std::sin(0.335679858922958*x_12 + 1.86047983169556) - 0.00205515207277295*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 0.0129020408799728*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.00639553281908067*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.00211874247918287*std::sin(0.135680049657822*x_14 - 1.24679982662201) - 0.0118662373103016*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.00569913822501271*std::sin(0.363359838724136*x_14 - 4.37039995193481) + 0.00335008913075567*std::sin(0.377439826726913*x_14 + 5.02719974517822) - 0.00446465806279628*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 0.000618697143728818*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.00132928756856217*std::sin(0.153840035200119*x_16 + 8.35536003112793) + 0.00335581741249353*std::sin(0.261759966611862*x_16 - 1.1658399105072) - 0.00519860558554377*std::sin(0.336639851331711*x_16 - 1.15263986587524) + 0.00195160530764627*std::sin(0.303199917078018*x_17 + 2.02831983566284) + 0.00917086163176334*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.00658688354022129*std::sin(0.350719839334488*x_17 - 1.15999984741211) + 0.0212415474365599*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.003270070254261*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 0.000408024618843956*std::sin(0.366639852523804*x_19 - 1.15647983551025) + 0.00665719445396525*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.0139726572845681*std::sin(0.417119860649109*x_2 - 1.17111992835999) - 0.000813901763152235*std::sin(0.26759997010231*x_21 - 1.16415989398956) + 0.00486990358940622*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.000251705609685367*std::sin(0.330319821834564*x_22 - 1.17439985275269) + 0.00413041747313838*std::sin(0.399839848279953*x_22 + 2.00903987884521) - 0.00584837828867323*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.0135893575404406*std::sin(0.389839857816696*x_24 + 5.22088003158569) - 0.0182519086995626*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.00715461713204475*std::sin(0.337679862976074*x_25 - 1.15311992168427) + 0.00359623881544471*std::sin(0.354159832000732*x_25 + 2.04983973503113) + 0.000853488360263554*std::sin(0.364879846572876*x_26 - 1.15215992927551) - 0.000324629405029487*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.0038720565561434*std::sin(0.412559866905212*x_26 - 1.19311988353729) - 0.0131992177729718*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.00362105679424585*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.000552257596442929*std::sin(0.328879833221436*x_27 + 5.02975988388062) - 0.0116396180007526*std::sin(0.375999838113785*x_27 - 4.38071966171265) - 0.00669197298058031*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.000640244146425205*std::sin(0.316079914569855*x_28 + 2.00583982467651) + 0.00190138375651462*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.00913877158084474*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.000990878080545069*std::sin(0.357999831438065*x_3 - 4.19871997833252) - 0.00478252597105299*std::sin(0.377839833498001*x_3 - 1.20415985584259) - 0.00976043861176959*std::sin(0.471519857645035*x_3 - 4.39256000518799) + 0.192597189196102*std::sin(0.0844800844788551*x_30 + 4.86079978942871) + 0.000654428114882802*std::sin(0.331519842147827*x_30 - 1.15855991840363) + 0.00211065048560855*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 0.00367884746447472*std::sin(0.408799856901169*x_31 - 1.18735992908478) + 0.00265778663071843*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 6.51828814786993e-5*std::sin(0.526799857616425*x_31 + 5.36439990997314) - 0.00200922065500918*std::sin(0.284959942102432*x_32 - 7.56984043121338) - 0.00382751686088642*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.000476574624359809*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.00206521457019943*std::sin(0.232959985733032*x_35 + 1.97247982025146) + 0.0190803807472601*std::sin(0.256079971790314*x_35 + 1.95967984199524) + 0.0133105622513964*std::sin(0.250159978866577*x_36 - 7.42375993728638) + 0.013265677497345*std::sin(0.219839990139008*x_37 + 1.97511982917786) - 0.00512903545481783*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.0106789810931897*std::sin(0.365439832210541*x_4 - 1.18407988548279) + 0.00731358351047856*std::sin(0.374879837036133*x_4 + 1.99583983421326) - 0.000527970442830324*std::sin(0.244479969143867*x_41 - 7.42392015457153) - 0.0189649850312619*std::sin(0.112000063061714*x_43 - 1.25247991085052) + 0.00384648816957136*std::sin(0.270159959793091*x_44 - 7.45815992355347) - 0.015535663918308*std::sin(0.222240000963211*x_45 + 1.98055982589722) + 0.00266977014307042*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.0263508403478705*std::sin(0.198079988360405*x_47 + 1.98031985759735) + 0.000805560780779573*std::sin(0.221279993653297*x_48 - 7.40007972717285) + 0.0282490814647114*std::sin(0.0957600772380829*x_49 + 8.14239978790283) + 0.00506597903899468*std::sin(0.333279848098755*x_49 + 1.89679992198944) - 0.000323515864098566*std::sin(0.341359823942184*x_5 + 2.00831985473633) + 0.00269436764496409*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.0104033870460214*std::sin(0.23039998114109*x_50 - 7.42743968963623) - 0.0279246721266191*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.000985643597199955*std::sin(0.205919995903969*x_51 - 1.20511984825134) + 0.00201223834455446*std::sin(0.247999966144562*x_53 + 1.98495984077454) + 0.0131513237857534*std::sin(0.253679990768433*x_53 + 5.17080020904541) + 0.017440431880635*std::sin(0.25383996963501*x_53 - 7.41967964172363) + 0.0112115291875187*std::sin(0.196479991078377*x_54 + 8.19679927825928) + 0.0189543370793078*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 0.00127249125994695*std::sin(0.202719986438751*x_56 - 1.1847198009491) - 0.00385059470210339*std::sin(0.238239988684654*x_57 - 7.42631959915161) + 0.190407149444431*std::sin(0.0653600990772247*x_58 + 4.88775968551636) - 0.1785877260309*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.000686424631823049*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.000689393943889019*std::sin(0.282239943742752*x_6 + 2.00879979133606) - 0.00178003340855621*std::sin(0.435519844293594*x_6 + 1.9508798122406) - 0.00719561925209244*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.000749089082502399*std::sin(0.395279824733734*x_60 - 1.18623995780945) + 0.0110131555552039*std::sin(0.416399866342545*x_60 - 1.22879981994629) - 0.00212280331001078*std::sin(0.461039870977402*x_60 + 1.88791978359222) - 0.0113525398335701*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.0085162883530175*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.000744631714946798*std::sin(0.364559859037399*x_7 + 2.00311970710754) - 0.00260137323062643*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 0.000484618758623704*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.0233068442628636*std::sin(0.311839938163757*x_9 + 5.14567995071411) - 0.00298201800000469*std::sin(0.327839851379395*x_9 - 1.09671986103058) - 0.00679225216331309*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 0.000432502142028795*std::sin(0.242319971323013*x_91 + 8.42840003967285) - 0.00714465773075835*std::sin(0.368239849805832*x_91 + 1.98719990253448) + 0.00313679719679831*std::sin(0.372959852218628*x_91 + 5.20560026168823) + 0.0111387639829113*std::sin(0.267439961433411*x_92 - 7.39351987838745) - 0.0159003064498619*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.0115873610013073*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.000736865089660523*std::sin(0.2360799908638*x_93 + 1.96975982189178) - 0.00311231825486035*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.000462035563769558*std::sin(0.292799949645996*x_94 + 4.9814395904541) - 0.000719274426210671*std::sin(0.304079920053482*x_94 + 1.96951985359192) - 0.00873326444224526*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.00307061157336881*std::sin(0.283599942922592*x_95 - 1.20095992088318) - 0.000329919647215041*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.0218114695115113*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.00278025275139399*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 0.0132241064259661*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.000685722379623251*std::sin(0.286639958620071*x_97 - 1.21999979019165) - 0.0179644925104584*std::sin(0.22791999578476*x_98 - 4.21591997146606) + 0.314677387475967*std::sin(-0.000674911934026159*x_100 + 0.0152018315759921*x_102 + 0.0158303297151738*x_103 - 0.013600547757975*x_104 - 0.0208620613990916*x_105 + 0.00999217114622162*x_106 + 0.00339424255778273*x_107 + 0.00726083070226732*x_108 + 0.00911616182566168*x_11 - 0.00749453587383891*x_110 - 0.0325326701417597*x_111 - 0.0321161822342577*x_112 - 0.00845696609509258*x_113 + 0.00733961560453705*x_114 - 0.023431973991903*x_115 - 0.000270828986913639*x_116 - 0.0268305286717897*x_117 - 0.0196823740410903*x_118 + 0.016722475543691*x_17 + 0.0120939960741238*x_19 + 0.0317058377473157*x_24 + 0.00682612403715236*x_27 + 0.00762863882686898*x_28 - 0.0147953406046686*x_29 + 0.00471151280575786*x_34 - 0.00200526256692717*x_35 + 0.0282320841653894*x_36 - 0.0101532184062238*x_37 - 0.0185221591659866*x_4 - 0.00780378015201776*x_40 - 0.0286577524365415*x_43 + 0.00604768360606146*x_44 + 0.00197531420399456*x_45 - 0.0353508884080646*x_46 + 0.0232250422676764*x_48 - 0.00678804079526211*x_50 + 0.0346177537922897*x_52 + 0.0331105602948158*x_54 + 0.0110140543957701*x_55 + 0.00320904709127631*x_56 - 0.0260597043926783*x_58 - 0.0276928806102607*x_59 - 0.000467351491294044*x_60 - 0.00088463581949853*x_62 - 0.00333226940316686*x_63 + 0.00173213235497701*x_64 - 0.000159743388525099*x_65 + 0.0108247850029873*x_66 - 0.0058119732457606*x_67 + 0.0131804445005739*x_68 - 0.00697289880387311*x_69 + 0.0037941065767085*x_7 - 0.00552518368237504*x_70 - 0.0138826692442543*x_71 + 0.00905705962957819*x_72 - 0.0115485954742491*x_73 + 0.0119139655744702*x_74 + 0.00330473835429089*x_75 - 0.00233398117474369*x_76 + 0.00468971607498042*x_77 - 0.00565323951228449*x_78 + 0.00832931770703775*x_79 + 0.000731180322228817*x_80 - 0.00619823996366823*x_81 + 0.0119357447150371*x_82 - 0.00523422016221398*x_83 + 0.00984241552621191*x_84 - 0.00209050524608879*x_85 - 0.000151224027194946*x_86 - 0.00762136121817904*x_87 + 0.00287271093419023*x_88 - 0.0131381695818011*x_89 + 0.00484162882473024*x_9 + 0.00948769973583889*x_90 + 0.00980969742386574*x_91 + 0.00219993690653781*x_92 + 0.00615474119603637*x_93 + 0.00263019323880178*x_94 + 0.00446536127868488*x_99 + 0.0844128038358925*std::exp(0.143199846148491*x_49) - 0.127292148085777*std::sin(0.380799859762192*x_1 - 4.21895980834961) - 0.119812706168669*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.0954236327339228*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 0.100572109051901*std::sin(0.264079958200455*x_109 + 4.96231985092163) + 0.139469447890076*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.134773765571771*std::sin(0.295919924974442*x_12 + 5.14359998703003) - 0.0566610748585785*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.0908307311443215*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.131208857533665*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 0.154832913031292*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 0.171786257092265*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.133936037440277*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.104932709058303*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.0290121293776816*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.0968370074519407*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 0.120090508434014*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.119961225998026*std::sin(0.4129598736763*x_23 + 5.19824028015137) - 0.0736531321247953*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 0.124942615645333*std::sin(0.34239986538887*x_26 - 1.13975989818573) - 0.0728410116311808*std::sin(0.510479867458344*x_3 + 1.96471977233887) + 0.111903745858735*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.138392958523929*std::sin(0.343999862670898*x_31 - 4.24528026580811) + 0.219207206604698*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.186486874077639*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.0543202074407865*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.113697576910969*std::sin(0.233839988708496*x_39 + 1.97919988632202) + 0.193602563857251*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.160931643565985*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 0.229154294981252*std::sin(0.120480060577393*x_47 + 1.96895980834961) + 0.0842785062555875*std::sin(0.331039845943451*x_5 - 1.16375982761383) + 0.174025245301337*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.10136516351545*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.15557975900775*std::sin(0.246799975633621*x_57 + 5.15375995635986) + 0.141804742275243*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 0.643144237058035*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.0702558919024727*std::sin(0.386879861354828*x_8 + 8.19487953186035) + 0.0681116675997711*std::sin(0.287439942359924*x_95 + 1.96047985553741) + 0.0385137569863294*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.0552982970183153*std::sin(0.249119967222214*x_97 - 7.40423965454102) - 0.196499035805734*std::sin(0.242959976196289*x_98 - 7.42695951461792) + 10.6800959407878) + 0.790981239467358);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.07260182636105e-5*x_1 - 3.47733381398431e-6*x_10 + 4.88627387245376e-5*x_100 - 0.000101167780522409*x_101 - 0.000355037160899701*x_102 + 0.000149153529918515*x_103 + 0.000114618252378023*x_104 + 0.000309771854878602*x_105 - 0.000161855087103585*x_106 + 2.38688031119159e-5*x_107 + 0.000282798236884094*x_108 - 0.00047485691882032*x_109 + 6.94574245412432e-5*x_11 - 0.000100328384780329*x_110 + 0.000583398107285217*x_111 + 0.000311515714836071*x_112 + 9.91582547536908e-5*x_113 - 8.99168520814157e-5*x_114 + 0.000436834324867755*x_115 + 1.19889907129732e-6*x_116 + 0.000404214224700173*x_117 + 0.000261429428020421*x_118 - 2.58199153151237e-5*x_119 + 0.000378454888578144*x_12 + 0.000141492812474886*x_120 - 0.00012653108440443*x_15 + 6.03137647351306e-5*x_17 + 8.56223565210555e-5*x_18 - 3.74649380629553e-5*x_19 + 1.93668189610597e-5*x_2 + 8.15034014845991e-5*x_20 - 2.70541098959582e-5*x_22 + 1.16415728482108e-5*x_24 - 3.46839668402488e-5*x_25 - 4.25833745931312e-5*x_27 - 3.37702699737689e-5*x_28 + 8.70498050193757e-6*x_29 - 5.42866166389486e-5*x_30 + 6.85448833125521e-5*x_32 + 0.000219730961148854*x_33 + 2.2111599531836e-5*x_34 - 2.70219125118801e-5*x_35 - 0.000155291887699928*x_36 + 0.00020980840710028*x_37 + 0.000122281142705087*x_38 - 4.51981317609582e-7*x_39 - 2.11312190053552e-5*x_4 + 0.000251736184792869*x_40 + 6.32272823945076e-5*x_41 + 2.08019866326657e-5*x_42 + 0.000310384330378717*x_43 + 0.000472670895467423*x_44 + 0.000260223839855191*x_45 + 0.000540726117062273*x_46 + 0.000296442158002077*x_47 - 0.000104136269937973*x_48 + 1.88544809009158e-5*x_5 + 0.000198329315871018*x_50 + 7.44619121881498e-5*x_51 - 0.000176883629754606*x_52 + 9.66291753103832e-5*x_53 + 8.18721530886542e-5*x_54 + 2.58645373626713e-5*x_55 - 0.000255412489062728*x_56 + 0.000175774295794374*x_57 - 4.54929692917885e-5*x_58 + 0.000102797643154715*x_59 + 2.06886004067399e-6*x_60 - 0.000119406226064919*x_61 + 3.86298078823674e-6*x_62 - 0.000159722329389334*x_63 + 2.43159152614137e-5*x_64 + 9.9078190988752e-5*x_65 - 9.66668737032473e-5*x_66 - 8.08702085902702e-5*x_67 + 7.57433106691716e-5*x_68 - 9.16713551171974e-5*x_69 - 1.67956573004106e-5*x_7 - 6.61883806885303e-6*x_70 + 7.06811571765611e-5*x_71 + 1.1315707745269e-5*x_72 + 4.52739447738947e-5*x_73 - 1.1075630766436e-5*x_74 - 0.000179362779865318*x_75 + 0.000162835136108682*x_76 + 6.63090342840481e-5*x_77 + 0.000195267956451573*x_78 - 0.000135360633567235*x_79 + 4.61405055329452e-5*x_8 + 2.27946172569639e-5*x_80 + 0.000134485372576297*x_81 - 9.22153295206916e-5*x_82 + 5.58185016995474e-5*x_83 - 0.000275742771767827*x_84 + 0.000185361446305716*x_85 + 0.00013547128120545*x_86 - 7.98720225459053e-6*x_87 - 0.000177836216778265*x_88 + 9.50818021987467e-5*x_89 - 0.000205134642422029*x_9 - 0.000107499327001367*x_90 - 4.34253263109189e-5*x_91 + 4.78022272122055e-5*x_92 - 2.72456563386855e-5*x_93 - 0.000153706157942376*x_94 + 0.000118282367916609*x_95 + 2.05084168926299e-5*x_96 - 0.000291604281951187*x_98 - 0.000182097192428665*x_99 - 0.000181858056374796*std::exp(0.277599841356277*x_13) - 0.000384206577855482*std::exp(0.275439828634262*x_23) - 0.000373676515493246*std::exp(0.143199846148491*x_49) + 0.0012928868073188*std::exp(0.147999867796898*x_49) + 0.000967112866465814*std::sin(0.304559946060181*x_1 - 4.28071975708008) + 0.000563493737736955*std::sin(0.380799859762192*x_1 - 4.21895980834961) + 0.00053038392895898*std::sin(0.333759844303131*x_10 - 4.32592010498047) + 0.000630403711792415*std::sin(0.346559852361679*x_10 - 1.14743983745575) + 0.00073064042996865*std::sin(0.253279983997345*x_100 - 1.22375988960266) + 0.000422418980952719*std::sin(0.235039994120598*x_101 + 1.9703197479248) + 0.000493786752610299*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.000445210128778373*std::sin(0.264079958200455*x_109 + 4.96231985092163) + 0.00125504104683827*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.0011685895891738*std::sin(0.250879973173141*x_112 - 7.428879737854) + 0.000939324744756333*std::sin(0.27975994348526*x_113 - 7.42360019683838) + 0.000637403301957703*std::sin(0.222719997167587*x_116 + 8.38632011413574) - 0.000455627967757701*std::sin(0.269519954919815*x_116 - 1.24311995506287) - 0.000617399907798946*std::sin(0.245439976453781*x_119 - 7.43943977355957) - 0.00059661317726955*std::sin(0.295919924974442*x_12 + 5.14359998703003) + 0.000250825846970064*std::sin(0.29751992225647*x_120 + 1.75015985965729) + 0.000402087237615036*std::sin(0.308319926261902*x_13 + 5.13216018676758) - 0.000692921446442004*std::sin(0.432719856500626*x_13 + 1.9437597990036) + 0.0043477029843395*std::sin(0.135680049657822*x_14 - 1.24679982662201) - 0.00058083213039989*std::sin(0.305359929800034*x_14 - 7.44343996047974) + 0.000617470852556173*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.00068541051589381*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 0.00126957921721073*std::sin(0.289599925279617*x_15 + 5.16944026947021) - 0.00272772533031577*std::sin(0.153840035200119*x_16 + 8.35536003112793) + 0.000563240843838603*std::sin(0.336639851331711*x_16 - 1.15263986587524) - 0.000760459160729472*std::sin(0.439999878406525*x_16 - 1.23111987113953) + 0.000713653263824741*std::sin(0.350719839334488*x_17 - 1.15999984741211) + 0.000592904743064283*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.000837274879066952*std::sin(0.366639852523804*x_19 - 1.15647983551025) - 0.000721271071665046*std::sin(0.374879837036133*x_2 - 7.40015983581543) - 0.000464513525204105*std::sin(0.406079858541489*x_2 - 7.40823984146118) + 0.000128430177890639*std::sin(0.471999853849411*x_20 + 1.92543983459473) + 0.00167014309638086*std::sin(0.26759997010231*x_21 - 1.16415989398956) - 0.000527627757477372*std::sin(0.302319914102554*x_21 - 7.40903997421265) + 0.000428675673251934*std::sin(0.30839991569519*x_21 - 7.39879989624023) + 0.000516505069000227*std::sin(0.330319821834564*x_22 - 1.17439985275269) + 0.000531613697167038*std::sin(0.384959846735001*x_22 + 1.97783982753754) + 0.000633640207589459*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.000531041392871961*std::sin(0.4129598736763*x_23 + 5.19824028015137) + 0.0003260458664667*std::sin(0.322079926729202*x_25 - 1.20271992683411) - 0.000775164132859195*std::sin(0.337679862976074*x_25 - 1.15311992168427) + 0.000553092885550002*std::sin(0.34239986538887*x_26 - 1.13975989818573) - 0.00175137560485783*std::sin(0.364879846572876*x_26 - 1.15215992927551) - 0.000419516419583287*std::sin(0.412559866905212*x_26 - 1.19311988353729) - 0.00113324390470761*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 0.000725039137227204*std::sin(0.261439979076385*x_28 - 1.15511989593506) - 0.00131379410828271*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.000990136553378251*std::sin(0.281359940767288*x_29 - 1.16695988178253) - 0.00203330212625173*std::sin(0.357999831438065*x_3 - 4.19871997833252) + 0.000518160864349195*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.000322450791520434*std::sin(0.510479867458344*x_3 + 1.96471977233887) - 0.000495372738766364*std::sin(0.263119965791702*x_30 - 1.18575978279114) - 0.00134289990221414*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.000612634531256195*std::sin(0.343999862670898*x_31 - 4.24528026580811) - 0.000287956829960629*std::sin(0.51039981842041*x_31 + 8.16663932800293) + 0.000133756608515295*std::sin(0.526799857616425*x_31 + 5.36439990997314) + 0.000217688208609684*std::sin(0.284959942102432*x_32 - 7.56984043121338) - 0.000970381048997001*std::sin(0.306559920310974*x_32 - 1.14495992660522) - 0.000825535488976725*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.000977940895105252*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.00144212754575775*std::sin(0.250159978866577*x_36 - 7.42375993728638) - 0.00143726452502432*std::sin(0.219839990139008*x_37 + 1.97511982917786) - 0.000240463352891407*std::sin(0.225759983062744*x_38 - 1.18391978740692) + 0.000503313625770729*std::sin(0.233839988708496*x_39 + 1.97919988632202) - 0.000792387281578153*std::sin(0.374879837036133*x_4 + 1.99583983421326) - 0.000857035048775089*std::sin(0.236559987068176*x_41 - 1.22183990478516) + 0.00108340616780465*std::sin(0.244479969143867*x_41 - 7.42392015457153) + 0.000712408225620012*std::sin(0.243519976735115*x_42 - 7.4346399307251) + 0.00205475372128603*std::sin(0.112000063061714*x_43 - 1.25247991085052) + 0.0016832052962959*std::sin(0.222240000963211*x_45 + 1.98055982589722) - 0.00101441457418449*std::sin(0.120480060577393*x_47 + 1.96895980834961) - 0.0016530272296296*std::sin(0.221279993653297*x_48 - 7.40007972717285) - 0.00306063543772097*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.000373082010281156*std::sin(0.331039845943451*x_5 - 1.16375982761383) + 0.00066386118258457*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.00112715081037789*std::sin(0.23039998114109*x_50 - 7.42743968963623) + 0.00202256085916305*std::sin(0.205919995903969*x_51 - 1.20511984825134) - 0.000770370658442818*std::sin(0.211520001292229*x_51 - 1.18919992446899) - 0.000448720802693571*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.00142487491785889*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 0.0012147086476149*std::sin(0.196479991078377*x_54 + 8.19679927825928) + 0.00261117814117312*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.000688716635219447*std::sin(0.246799975633621*x_57 + 5.15375995635986) + 0.00140855741064491*std::sin(0.376559853553772*x_59 + 1.82895994186401) - 0.00141465049985113*std::sin(0.282239943742752*x_6 + 2.00879979133606) - 0.000627737731314398*std::sin(0.381519854068756*x_6 + 2.00575971603394) + 0.000192857008018474*std::sin(0.435519844293594*x_6 + 1.9508798122406) + 0.000779606491163709*std::sin(0.340719848871231*x_60 + 8.27375984191895) + 0.00153714614755251*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.00284705502651744*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.000922693856919077*std::sin(0.348799854516983*x_7 + 2.02463984489441) - 0.0015279995379885*std::sin(0.364559859037399*x_7 + 2.00311970710754) + 0.000994447623454348*std::sin(0.34199982881546*x_8 - 1.13871991634369) - 0.00031100704734349*std::sin(0.386879861354828*x_8 + 8.19487953186035) + 0.000323085548042949*std::sin(0.327839851379395*x_9 - 1.09671986103058) + 0.000887503258233168*std::sin(0.242319971323013*x_91 + 8.42840003967285) + 0.000774085085508444*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.00120682493061219*std::sin(0.267439961433411*x_92 - 7.39351987838745) - 0.00125542799522772*std::sin(0.235599994659424*x_93 + 1.98431980609894) - 0.00151206226374816*std::sin(0.2360799908638*x_93 + 1.96975982189178) + 0.0009481064448411*std::sin(0.292799949645996*x_94 + 4.9814395904541) - 0.000301515048150723*std::sin(0.287439942359924*x_95 + 1.96047985553741) + 0.000677001876765252*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.000170491748351165*std::sin(0.26471996307373*x_96 + 1.97247982025146) - 0.000244793135679831*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.00143276052391529*std::sin(0.278879970312119*x_97 + 1.950239777565) + 0.00140711637474045*std::sin(0.286639958620071*x_97 - 1.21999979019165) + 0.00086985707926986*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 0.151295840740204*std::sin(0.015325039356384*x_1 + 0.0155974276903836*x_101 - 0.0436360497491376*x_103 + 0.022864208283381*x_105 + 0.0277399805606038*x_107 + 0.0448165967970309*x_109 + 0.00162132223994909*x_11 + 0.0160417983610733*x_110 + 0.0230171862611803*x_111 - 0.0107759184931415*x_112 - 0.0594256629372889*x_114 - 0.0448613836270345*x_115 + 0.024483519577396*x_117 - 0.0116700967953251*x_118 - 0.0232403881235657*x_119 + 0.0300502850753078*x_12 - 0.0721097423667357*x_120 + 0.0216672175452604*x_15 - 0.00633266365513597*x_16 - 0.0380302954464024*x_19 + 0.0398786993575083*x_20 - 0.0264416505323842*x_21 - 0.00319397775424167*x_22 + 0.0208627514866636*x_23 + 0.0148149526669429*x_28 + 0.0164056118879808*x_32 + 0.00172439702803708*x_33 + 0.00213572007569107*x_34 - 0.0588832266180133*x_36 - 0.0458720686077714*x_37 + 0.0490504041138362*x_38 + 0.00611724434186975*x_39 + 0.0377683499936555*x_40 + 0.0348816893218833*x_41 - 0.00959742791956549*x_42 - 0.06662143398811*x_43 + 0.00394371751412016*x_44 - 0.000936147207372626*x_45 + 0.0297138389238152*x_46 - 0.0186029809554684*x_48 + 0.0138665338550392*x_5 + 0.0311057392440276*x_50 - 0.00342470382226788*x_52 - 0.00323950958265228*x_54 + 0.0362853158857008*x_56 - 0.00382255356329708*x_57 + 0.00262167660199048*x_6 + 0.00338682314862308*x_61 - 0.000324786531627798*x_62 + 0.0244165379912833*x_63 + 0.00595025061303616*x_64 - 0.0176052631263109*x_65 + 0.00759756851243893*x_66 + 0.0121609991423214*x_67 + 0.0124116979909765*x_68 + 0.00869925774380107*x_69 - 0.0170420179860455*x_70 + 0.0120509930272779*x_71 + 0.0141002428506126*x_72 + 0.0201940490020681*x_73 - 0.0226012904823643*x_74 - 0.0154428771877021*x_75 - 0.0227769725788888*x_76 - 0.0203137732980468*x_77 - 0.0102302043713842*x_78 - 0.0321429913655157*x_79 + 0.0515328737888239*x_8 + 0.0267239442811622*x_80 - 0.0241282695512548*x_81 + 0.0258001586379593*x_82 + 0.008079664700219*x_83 - 0.0199650737931564*x_84 + 0.00980939516389363*x_85 + 0.031826281628836*x_86 + 0.0154819341834744*x_87 - 0.0311894431606851*x_88 + 0.00922921194553283*x_89 - 3.67764475154281e-6*x_90 - 0.00997269028037531*x_91 - 0.000924671888437208*x_93 + 0.018890372578202*x_94 - 0.019087600411904*x_96 - 0.0228347809136425*x_99 - 4.63497679678154e-5*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 0.000738586288893922*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) - 0.297302859398712*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.182245869282895*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.119764999590529*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.239255822967721*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.226518890045341*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.304963525512292*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.248957958579368*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 0.201369539957376*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.185203160525525*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.143134888889364*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.331528994139404*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.218079263238351*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 0.212096884647337*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.284867990449484*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.206007749895313*std::sin(0.443999856710434*x_26 - 7.44151973724365) + 0.181666183195048*std::sin(0.375999838113785*x_27 - 4.38071966171265) + 0.15233675441884*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 3.00597461644259*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 0.0574178789531317*std::sin(0.408799856901169*x_31 - 1.18735992908478) - 0.297798428096087*std::sin(0.256079971790314*x_35 + 1.95967984199524) - 0.166672972900521*std::sin(0.365439832210541*x_4 - 1.18407988548279) - 0.411272654280424*std::sin(0.198079988360405*x_47 + 1.98031985759735) - 0.0790676357334732*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.4358363480561*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.272202807070073*std::sin(0.25383996963501*x_53 - 7.41967964172363) - 0.295831192395454*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 2.97179341198159*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 2.78732090274946*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.171888625083561*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.177185589853643*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.363763264334111*std::sin(0.311839938163757*x_9 + 5.14567995071411) + 0.248165187568119*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.136305058976433*std::sin(0.261919945478439*x_95 - 7.4300799369812) + 0.340424094310933*std::sin(0.27703994512558*x_97 + 1.96351981163025) + 0.28038212140639*std::sin(0.22791999578476*x_98 - 4.21591997146606) - 5.4527290810564) - 0.103811457753181*std::sin(-0.00878508068745554*x_10 + 0.0598191244503507*x_100 + 0.0148049352829406*x_101 - 0.067894840543929*x_102 + 0.0284814082358016*x_103 - 0.0630791885007191*x_104 + 0.0550267446189157*x_105 - 0.00562991842562005*x_106 - 0.0393883955548181*x_107 + 0.0899745959606139*x_109 + 0.000641509982091491*x_110 - 0.0815679611287056*x_111 + 0.0350282198572702*x_114 - 0.0666751712512899*x_115 + 0.0773913102649904*x_117 + 0.082239676493556*x_118 + 0.0218322472333085*x_119 - 0.010324316732129*x_13 - 0.0685148358562507*x_18 + 0.0205749898704939*x_2 + 0.0309380461360813*x_20 - 0.0720064550899112*x_21 - 0.0507883301635721*x_24 - 0.00868927096928932*x_28 - 0.00981921859294271*x_3 - 0.116963199460347*x_30 - 0.045469444206462*x_32 - 0.0305981185477455*x_34 - 0.00609283961843189*x_36 - 0.0173468890359138*x_37 - 0.0201230184725766*x_38 - 0.0058998353194331*x_39 + 0.0847090589480948*x_40 - 0.0618412911333896*x_41 + 0.00644525552182846*x_42 - 0.00612435525124671*x_43 - 0.0795857384766402*x_45 - 0.0620476047672898*x_46 + 0.0710484235297778*x_48 - 0.0095390394899679*x_49 - 0.0881299608905168*x_50 + 0.00325609286831591*x_51 + 0.00662321380741048*x_52 - 0.103828512815928*x_54 + 0.0957453364913336*x_55 - 0.00895055743941851*x_56 - 0.0867930738261016*x_58 + 0.113130907761707*x_59 + 0.00912611696144098*x_6 + 0.00184452468336972*x_61 + 0.0132926668859242*x_62 - 0.0446566777931119*x_63 + 0.0298451265433026*x_64 + 0.0337107599314798*x_65 + 0.0048537410896966*x_66 + 0.010212599422232*x_67 + 0.0563711737842959*x_68 - 0.0365423510035309*x_69 - 0.0675657110040937*x_70 + 0.00956881309496184*x_71 + 0.0366049048583663*x_72 + 0.0338315633069689*x_73 - 0.0593634331069608*x_74 + 0.00890155632409477*x_75 - 0.0183858776688489*x_76 - 0.0286493211607657*x_77 - 0.0487765457498987*x_78 - 0.0204828805491789*x_79 + 0.00478072762722923*x_8 + 0.0487547082443668*x_80 + 0.0395086374048987*x_81 + 0.000134566635780273*x_82 - 0.0462446016575092*x_83 + 0.0460933831397242*x_84 - 0.0379115423829191*x_85 + 0.00654306949981069*x_86 - 0.0369103818433127*x_87 + 0.0247218571695129*x_88 - 0.0152404447710857*x_89 + 0.00616393808760066*x_9 + 0.00150082468780885*x_92 + 0.00267411787743196*x_96 - 0.00658771055759794*x_98 - 0.0397505510898049*x_99 + 0.000442753983304674*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 0.425463243872048*std::sin(0.444319844245911*x_1 - 7.17479991912842) + 0.384306565122605*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 0.400751131833754*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.243064965067319*std::sin(0.288159936666489*x_112 + 1.95711982250214) + 0.265624911246087*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.15002078699351*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.43534213434997*std::sin(0.335679858922958*x_12 + 1.86047983169556) - 0.283921177332536*std::sin(0.268559962511063*x_120 - 1.21983981132507) + 0.462817940713123*std::sin(0.377439826726913*x_14 + 5.02719974517822) - 0.616796679121645*std::sin(0.28247994184494*x_15 - 7.42208003997803) + 0.463609308182544*std::sin(0.261759966611862*x_16 - 1.1658399105072) + 0.269616095069658*std::sin(0.303199917078018*x_17 + 2.02831983566284) - 0.451763258227977*std::sin(0.31959992647171*x_19 + 1.98879981040955) + 0.570621029647711*std::sin(0.399839848279953*x_22 + 2.00903987884521) + 0.496823749432984*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 0.0448478553455034*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.500252376371879*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.262677940899136*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.291588334873394*std::sin(0.318639844655991*x_31 + 5.33767986297607) - 0.528775027308193*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.285311320745318*std::sin(0.232959985733032*x_35 + 1.97247982025146) - 0.708581036023936*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.531395931312684*std::sin(0.270159959793091*x_44 - 7.45815992355347) + 0.368831237488454*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.372229405336766*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.277992605719302*std::sin(0.247999966144562*x_53 + 1.98495984077454) - 0.531963252615419*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.293267258909191*std::sin(0.461039870977402*x_60 + 1.88791978359222) - 0.359382140185982*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 0.938355976910898*std::sin(0.128000050783157*x_90 + 2.00159978866577) + 0.433351460929465*std::sin(0.372959852218628*x_91 + 5.20560026168823) - 0.429969672249708*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.0993684334217537*std::sin(0.304079920053482*x_94 + 1.96951985359192) + 0.424207855268577*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 0.384094512963573*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 0.764219976068637) + 0.0822121055853443);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.48244205968239e-5*x_1 - 8.19352239172774e-6*x_10 + 0.000165234878213354*x_100 + 0.00231297681422729*x_101 - 0.00196505173173868*x_102 - 0.000789381686245517*x_103 - 0.000815742197033554*x_104 + 0.00154587368734998*x_105 - 0.00223131838402508*x_106 + 0.00221682412755304*x_107 - 0.000250577391153933*x_108 + 0.00236446458117823*x_109 - 0.00192933753497616*x_11 - 0.00156448567750057*x_110 + 0.00228470448168694*x_111 + 0.00305476736658837*x_112 + 6.00511218019599e-5*x_113 + 0.00203913353198965*x_114 + 0.0035267287596863*x_115 + 2.29295917919145e-5*x_116 + 0.00357021942106198*x_117 + 0.00404173021974791*x_118 + 2.84778872562113e-5*x_119 - 0.00115508943256296*x_12 - 0.0016253532603068*x_120 + 0.0014721173147002*x_15 - 3.72304995246588e-5*x_16 - 0.00109925778482833*x_17 - 0.000846116070270668*x_18 - 0.00141832963311522*x_19 + 4.56333712270673e-5*x_2 - 1.55885644379522e-5*x_20 - 0.000155453678134117*x_21 + 0.000268744902861085*x_22 + 0.000122654652387444*x_23 - 0.0038599056197645*x_24 - 8.17246413895203e-5*x_25 - 0.000446511783414757*x_27 - 0.000558775731412234*x_28 + 0.00111882572167652*x_29 + 0.000576941319117098*x_30 + 0.00025796054423632*x_32 - 0.000926153784345809*x_33 - 0.00256060839959903*x_34 + 0.000551295362620802*x_35 - 0.00280786571365375*x_36 + 0.000978388951275111*x_37 + 0.00121172033141063*x_38 - 0.0021291552507293*x_39 + 0.00132517964194729*x_4 - 0.000113976564348185*x_40 - 0.000466886248630681*x_41 + 0.000465285102611752*x_42 + 0.00246704653535247*x_43 - 0.0003162859935111*x_44 + 0.000461017689320119*x_45 + 0.00363919793828235*x_46 - 0.000729857629840996*x_47 - 0.00206163154161505*x_48 - 0.000118856535014736*x_5 + 0.00115409310444115*x_50 - 0.000791358100791832*x_51 - 0.000397229123658531*x_52 + 0.000227684011358302*x_53 - 0.00228405590246424*x_54 + 0.0027437197514554*x_55 + 0.00250510411836727*x_56 + 0.00180193191532604*x_57 + 0.00257709783133799*x_58 + 0.002554951701794*x_59 + 1.54131554744825e-5*x_6 + 3.95680648546385e-5*x_60 + 0.000822180838744888*x_61 + 0.00101848264287487*x_62 + 0.000262255828685065*x_63 - 0.00102338289119695*x_64 - 0.000861781462633514*x_65 + 0.000419956199623499*x_66 + 0.00119185974523219*x_67 - 0.00178789305507136*x_68 + 0.00124816974703871*x_69 - 0.00032122601059201*x_7 - 0.000671837846166365*x_70 + 0.000141747675775478*x_71 - 0.000741265960225317*x_72 + 0.00228644693038903*x_73 - 0.00140159269257642*x_74 + 0.000554358907780947*x_75 + 0.00020074615070273*x_76 - 0.000979849005147864*x_77 - 0.000137562952649275*x_78 - 0.000151257656664047*x_79 - 0.000187398947494076*x_8 - 0.000693418062981054*x_80 - 0.000490835453494811*x_81 - 0.000453727685536332*x_82 + 0.00165936322240622*x_83 - 0.000623739478590496*x_84 + 0.000423208227737382*x_85 + 0.000553860994769535*x_86 + 0.00189336879848816*x_87 + 0.000571021583535663*x_88 + 0.000447367749059273*x_89 - 0.000842764266623054*x_9 - 0.0016010942865543*x_90 - 0.00088916346120961*x_91 - 5.06749457337026e-5*x_92 - 0.000526524140578561*x_93 + 0.00139817513883219*x_94 - 0.00125706830889773*x_95 - 0.000693822540167823*x_96 + 0.00226623278765811*x_98 + 0.000656515980660282*x_99 - 2.72495920874349e-7*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) + 4.34223858633058e-6*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) - 0.000428505900420206*std::exp(0.277599841356277*x_13) - 0.000905292780936959*std::exp(0.275439828634262*x_23) - 0.00714676503436898*std::exp(0.143199846148491*x_49) + 0.00304638483746783*std::exp(0.147999867796898*x_49) + 0.0809981452291236*std::exp(-0.00882528595633274*x_10 + 0.0600928890369366*x_100 + 0.0148726906542271*x_101 - 0.0682055639643002*x_102 + 0.0286117545259338*x_103 - 0.0633678728992413*x_104 + 0.0552785766898493*x_105 - 0.00565568396974101*x_106 - 0.0395686581033663*x_107 + 0.0903863682540522*x_109 + 0.000644445877871507*x_110 - 0.0819412601256776*x_111 + 0.0351885278894619*x_114 - 0.0669803128069525*x_115 + 0.0777454946542592*x_117 + 0.0826160496224356*x_118 + 0.021932163375395*x_119 - 0.0103715663755821*x_13 - 0.0688283967096656*x_18 + 0.0206691521245834*x_2 + 0.0310796353266294*x_20 - 0.0723359954767079*x_21 - 0.051020764963285*x_24 - 0.00872903776120576*x_28 - 0.00986415663480464*x_3 - 0.11749848616406*x_30 - 0.0456775369144354*x_32 - 0.0307381520462545*x_34 - 0.00612072373968242*x_36 - 0.017426277758987*x_37 - 0.0202151122617055*x_38 - 0.00592683614888339*x_39 + 0.0850967333033465*x_40 - 0.0621243102456991*x_41 + 0.00647475248838534*x_42 - 0.00615238360503605*x_43 - 0.0799499657533245*x_45 - 0.0623315680820966*x_46 + 0.0713735794472864*x_48 - 0.00958269528109479*x_49 - 0.0885332911386726*x_50 + 0.00327099450598063*x_51 + 0.00665352520709272*x_52 - 0.104303688107243*x_54 + 0.0961835188068209*x_55 - 0.00899152001918929*x_56 - 0.0871902857577849*x_58 + 0.113648655831042*x_59 + 0.00916788299630091*x_6 + 0.00185296622346296*x_61 + 0.0133535013011398*x_62 - 0.0448610508434811*x_63 + 0.0299817139441516*x_64 + 0.0338650385562664*x_65 + 0.00487595442757183*x_66 + 0.0102593377870022*x_67 + 0.0566291586884252*x_68 - 0.0367095885167389*x_69 - 0.0678749281501215*x_70 + 0.00961260514616838*x_71 + 0.0367724286517626*x_72 + 0.0339863947931766*x_73 - 0.0596351122041087*x_74 + 0.00894229464832517*x_75 - 0.0184700213644527*x_76 - 0.0287804359110335*x_77 - 0.048999773538754*x_78 - 0.0205766212613201*x_79 + 0.00480260681610861*x_8 + 0.0489778360930152*x_80 + 0.0396894502450249*x_81 + 0.000135182485305841*x_82 - 0.0464562419041849*x_83 + 0.0463043313288784*x_84 - 0.0380850460545736*x_85 + 0.00657301411590257*x_86 - 0.0370793036642005*x_87 + 0.024834997725645*x_88 - 0.0153101932687523*x_89 + 0.00619214759380454*x_9 + 0.00150769327129233*x_92 + 0.00268635608355623*x_96 - 0.00661785947525462*x_98 - 0.0399324710574684*x_99 + 0.000444780264403109*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) - 0.427410393218288*std::sin(0.444319844245911*x_1 - 7.17479991912842) + 0.386065359302389*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 0.40258518522284*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.244177361483793*std::sin(0.288159936666489*x_112 + 1.95711982250214) + 0.266840554147624*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 0.150707363052721*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.437334494828811*std::sin(0.335679858922958*x_12 + 1.86047983169556) - 0.285220553818728*std::sin(0.268559962511063*x_120 - 1.21983981132507) + 0.464936045305393*std::sin(0.377439826726913*x_14 + 5.02719974517822) - 0.619619473494161*std::sin(0.28247994184494*x_15 - 7.42208003997803) + 0.465731034499306*std::sin(0.261759966611862*x_16 - 1.1658399105072) + 0.270850003781661*std::sin(0.303199917078018*x_17 + 2.02831983566284) - 0.453830770629068*std::sin(0.31959992647171*x_19 + 1.98879981040955) + 0.573232499335944*std::sin(0.399839848279953*x_22 + 2.00903987884521) + 0.499097482952479*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 0.0450531033274948*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.50254180113803*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.263880096874441*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.292922800409013*std::sin(0.318639844655991*x_31 + 5.33767986297607) - 0.531194987113324*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 0.286617059277766*std::sin(0.232959985733032*x_35 + 1.97247982025146) - 0.711823885132347*std::sin(0.293199926614761*x_4 - 7.37039995193481) + 0.533827885788547*std::sin(0.270159959793091*x_44 - 7.45815992355347) + 0.370519208219868*std::sin(0.142560034990311*x_47 + 8.20160007476807) + 0.373932927917604*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.27926484986326*std::sin(0.247999966144562*x_53 + 1.98495984077454) - 0.53439780345964*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.294609408106997*std::sin(0.461039870977402*x_60 + 1.88791978359222) - 0.361026866750244*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 0.942650400115014*std::sin(0.128000050783157*x_90 + 2.00159978866577) + 0.435334711012743*std::sin(0.372959852218628*x_91 + 5.20560026168823) - 0.431937445443474*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 0.0998231969834968*std::sin(0.304079920053482*x_94 + 1.96951985359192) + 0.426149259279271*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 0.385852336678273*std::sin(0.277839958667755*x_97 + 1.94815981388092)) - 0.0102781754962711*std::sin(0.304559946060181*x_1 - 4.28071975708008) + 0.0107771218553261*std::sin(0.380799859762192*x_1 - 4.21895980834961) + 0.0101438788928757*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.00669973506503048*std::sin(0.346559852361679*x_10 - 1.14743983745575) - 0.00174787965511896*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.00776501980718319*std::sin(0.253279983997345*x_100 - 1.22375988960266) + 0.00807899099289594*std::sin(0.235039994120598*x_101 + 1.9703197479248) - 0.00524781240850326*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.00107144562212852*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.000704112993070406*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.00140661407084951*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.00133173209370113*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.00851488399558709*std::sin(0.264079958200455*x_109 + 4.96231985092163) + 0.00295721017017469*std::sin(0.235759988427162*x_11 - 7.3951997756958) + 0.0124194075966916*std::sin(0.250879973173141*x_112 - 7.428879737854) + 0.0022132986767947*std::sin(0.27975994348526*x_113 - 7.42360019683838) - 0.00179291764254924*std::sin(0.281679958105087*x_113 + 1.98447978496552) - 0.00677412453767157*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.0014636541056514*std::sin(0.240959972143173*x_116 - 1.22615993022919) - 0.00107358055217674*std::sin(0.269519954919815*x_116 - 1.24311995506287) - 0.01180810645126*std::sin(0.245439976453781*x_119 - 7.43943977355957) - 0.0114105490111563*std::sin(0.295919924974442*x_12 + 5.14359998703003) + 0.0047971796955863*std::sin(0.29751992225647*x_120 + 1.75015985965729) + 0.00769013542839325*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.0011838760069917*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.00736415415264531*std::sin(0.432719856500626*x_13 + 1.9437597990036) + 0.0102443434137692*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.00108883189687781*std::sin(0.251679986715317*x_14 - 7.24671983718872) - 0.0111087279726441*std::sin(0.305359929800034*x_14 - 7.44343996047974) - 0.00656228864951082*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.0131088460368263*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 0.00299146596235733*std::sin(0.289599925279617*x_15 + 5.16944026947021) - 0.00642724563357841*std::sin(0.153840035200119*x_16 + 8.35536003112793) - 0.00598594894181942*std::sin(0.336639851331711*x_16 - 1.15263986587524) - 0.014544191873533*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.000841507413461883*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.00758448547570495*std::sin(0.350719839334488*x_17 - 1.15999984741211) - 0.0019490992623155*std::sin(0.173840016126633*x_18 + 1.95855975151062) + 0.0113396232055154*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.00197284207862857*std::sin(0.366639852523804*x_19 - 1.15647983551025) + 0.00766544517399297*std::sin(0.374879837036133*x_2 - 7.40015983581543) - 0.00888407187039342*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.00128211450165184*std::sin(0.417119860649109*x_2 - 1.17111992835999) + 0.00245629646673153*std::sin(0.471999853849411*x_20 + 1.92543983459473) + 0.00393530089131899*std::sin(0.26759997010231*x_21 - 1.16415989398956) + 0.00560746410899714*std::sin(0.302319914102554*x_21 - 7.40903997421265) + 0.00819865360989452*std::sin(0.30839991569519*x_21 - 7.39879989624023) + 0.00121702317772168*std::sin(0.330319821834564*x_22 - 1.17439985275269) + 0.0101673988735684*std::sin(0.384959846735001*x_22 + 1.97783982753754) - 0.00673413153823274*std::sin(0.288719952106476*x_23 - 4.34591960906982) - 0.0101564532450489*std::sin(0.4129598736763*x_23 + 5.19824028015137) + 0.0012469433706052*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.00167477354879229*std::sin(0.243119969964027*x_25 - 7.38488006591797) + 0.00623580316517608*std::sin(0.322079926729202*x_25 - 1.20271992683411) + 0.00823820390794403*std::sin(0.337679862976074*x_25 - 1.15311992168427) + 0.0105781999438454*std::sin(0.34239986538887*x_26 - 1.13975989818573) - 0.00412670626473052*std::sin(0.364879846572876*x_26 - 1.15215992927551) + 0.00445849035159822*std::sin(0.412559866905212*x_26 - 1.19311988353729) + 0.00121114460710906*std::sin(0.443999856710434*x_26 - 7.44151973724365) - 0.00267022374187072*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 0.0010680375771425*std::sin(0.375999838113785*x_27 - 4.38071966171265) - 0.00770549100573838*std::sin(0.261439979076385*x_28 - 1.15511989593506) - 0.00309564799359896*std::sin(0.316079914569855*x_28 + 2.00583982467651) + 0.0105228640976357*std::sin(0.281359940767288*x_29 - 1.16695988178253) - 0.00479100005688045*std::sin(0.357999831438065*x_3 - 4.19871997833252) - 0.00550685290595171*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.000895606299630155*std::sin(0.471519857645035*x_3 - 4.39256000518799) + 0.00616704541654423*std::sin(0.510479867458344*x_3 + 1.96471977233887) - 0.0176724902226311*std::sin(0.0844800844788551*x_30 + 4.86079978942871) - 0.00947427098468284*std::sin(0.263119965791702*x_30 - 1.18575978279114) - 0.00316422897749736*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.0117169660529762*std::sin(0.343999862670898*x_31 - 4.24528026580811) - 0.000337566690967039*std::sin(0.408799856901169*x_31 - 1.18735992908478) + 0.0030603158496908*std::sin(0.51039981842041*x_31 + 8.16663932800293) + 0.000315166108730847*std::sin(0.526799857616425*x_31 + 5.36439990997314) - 0.00231352274294067*std::sin(0.284959942102432*x_32 - 7.56984043121338) - 0.01855906128281*std::sin(0.306559920310974*x_32 - 1.14495992660522) - 0.0157888117733644*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.00230428858730998*std::sin(0.232719987630844*x_35 + 1.9592798948288) - 0.00175079316373979*std::sin(0.256079971790314*x_35 + 1.95967984199524) + 0.0153264841336167*std::sin(0.250159978866577*x_36 - 7.42375993728638) + 0.0152748014580229*std::sin(0.219839990139008*x_37 + 1.97511982917786) - 0.0045989914036289*std::sin(0.225759983062744*x_38 - 1.18391978740692) + 0.00962614473438789*std::sin(0.233839988708496*x_39 + 1.97919988632202) - 0.000979890671015447*std::sin(0.365439832210541*x_4 - 1.18407988548279) + 0.00842124618901587*std::sin(0.374879837036133*x_4 + 1.99583983421326) - 0.0163912578550183*std::sin(0.236559987068176*x_41 - 1.22183990478516) + 0.00255279279186379*std::sin(0.244479969143867*x_41 - 7.42392015457153) + 0.0136251918061733*std::sin(0.243519976735115*x_42 - 7.4346399307251) - 0.021837285058745*std::sin(0.112000063061714*x_43 - 1.25247991085052) - 0.0178885836715251*std::sin(0.222240000963211*x_45 + 1.98055982589722) - 0.0194012262171906*std::sin(0.120480060577393*x_47 + 1.96895980834961) - 0.0024179219351519*std::sin(0.198079988360405*x_47 + 1.98031985759735) - 0.00389497136157515*std::sin(0.221279993653297*x_48 - 7.40007972717285) + 0.0325274838643817*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.000464848243156499*std::sin(0.333279848098755*x_49 + 1.89679992198944) - 0.00713539480132958*std::sin(0.331039845943451*x_5 - 1.16375982761383) + 0.00156423333377739*std::sin(0.341359823942184*x_5 + 2.00831985473633) + 0.0119790091121052*std::sin(0.23039998114109*x_50 - 7.42743968963623) + 0.00256233487719998*std::sin(0.198239997029305*x_51 - 4.38799953460693) + 0.00476569077766985*std::sin(0.205919995903969*x_51 - 1.20511984825134) - 0.0147337546165982*std::sin(0.211520001292229*x_51 - 1.18919992446899) - 0.00858202752894799*std::sin(0.238319978117943*x_53 - 7.42679977416992) + 0.0151431285569668*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 0.00160031339593*std::sin(0.25383996963501*x_53 - 7.41967964172363) + 0.0129095466412817*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.0017392275458883*std::sin(0.225679993629456*x_55 + 5.15999984741211) + 0.00615262948942426*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.0131720773532624*std::sin(0.246799975633621*x_57 + 5.15375995635986) - 0.0174715347660114*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 0.0163869984569166*std::sin(0.0555201061069965*x_59 + 8.0319995880127) + 0.00331893551252978*std::sin(0.376559853553772*x_59 + 1.82895994186401) - 0.00333329244963059*std::sin(0.282239943742752*x_6 + 2.00879979133606) - 0.0120058229053812*std::sin(0.381519854068756*x_6 + 2.00575971603394) - 0.00204962444698249*std::sin(0.435519844293594*x_6 + 1.9508798122406) - 0.00828541591375465*std::sin(0.340719848871231*x_60 + 8.27375984191895) + 0.00362192474265181*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.00101055412429454*std::sin(0.416399866342545*x_60 - 1.22879981994629) - 0.0544514639556124*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.00104169562415846*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.00980610404388696*std::sin(0.348799854516983*x_7 + 2.02463984489441) - 0.00360037290026907*std::sin(0.364559859037399*x_7 + 2.00311970710754) + 0.00234318282513052*std::sin(0.34199982881546*x_8 - 1.13871991634369) - 0.00594817763289962*std::sin(0.386879861354828*x_8 + 8.19487953186035) - 0.00213860845568446*std::sin(0.311839938163757*x_9 + 5.14567995071411) - 0.00343365296672096*std::sin(0.327839851379395*x_9 - 1.09671986103058) + 0.00209119348560121*std::sin(0.242319971323013*x_91 + 8.42840003967285) - 0.00822673612747665*std::sin(0.368239849805832*x_91 + 1.98719990253448) + 0.0128257609429144*std::sin(0.267439961433411*x_92 - 7.39351987838745) + 0.00145899330849482*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.013342299234459*std::sin(0.235599994659424*x_93 + 1.98431980609894) - 0.00356282044763247*std::sin(0.2360799908638*x_93 + 1.96975982189178) + 0.00223399069548805*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.000801354013064461*std::sin(0.261919945478439*x_95 - 7.4300799369812) - 0.00576663802544641*std::sin(0.287439942359924*x_95 + 1.96047985553741) + 0.00159519630074343*std::sin(0.292799949645996*x_95 - 1.22199988365173) - 0.00326074670268264*std::sin(0.26471996307373*x_96 + 1.97247982025146) - 0.00468180083626846*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.00200139463764927*std::sin(0.27703994512558*x_97 + 1.96351981163025) - 0.0152269343316106*std::sin(0.278879970312119*x_97 + 1.950239777565) + 0.00331554004905629*std::sin(0.286639958620071*x_97 - 1.21999979019165) + 0.00164840057931662*std::sin(0.22791999578476*x_98 - 4.21591997146606) + 0.0166364861083611*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 0.0559386661204721);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000784499551306069*x_1 + 0.000436289565912985*x_10 - 0.00301888080733174*x_100 + 0.00136020646993369*x_101 + 0.00443184423940415*x_102 - 0.00243650699758022*x_103 + 0.00110267348962566*x_104 - 0.00345646645602567*x_105 + 0.000390716543104504*x_106 + 0.00477726751951473*x_107 + 0.000265030633825045*x_108 - 0.000441376180375477*x_109 - 5.41043797954181e-5*x_11 - 0.000744220934461485*x_110 + 0.00210901373788267*x_111 - 0.0027525928314539*x_112 - 0.00100094441309011*x_113 - 0.00262475997387202*x_114 - 7.69789887016243e-5*x_115 - 1.84254473793545e-5*x_116 - 0.00419000825534899*x_117 - 0.00496958420328492*x_118 - 0.00215064998585853*x_119 + 0.000334918829811078*x_12 - 0.0045037435124463*x_120 + 0.000512328126399745*x_13 + 0.00198013406629834*x_15 - 0.000323735516961073*x_16 + 0.00112441327337562*x_17 + 0.00284297170026155*x_18 - 0.00123219504214559*x_19 - 0.0010229156280345*x_2 + 0.000263943483393422*x_20 + 0.00222147021536288*x_21 + 2.32657324880863e-5*x_22 + 0.00106653598005126*x_23 + 0.00385951440055667*x_24 + 3.42746019246156e-6*x_25 + 0.00054967038381647*x_27 + 0.00170755781906262*x_28 - 0.00100096695773647*x_29 + 0.000487263418486241*x_3 + 0.00617844016520289*x_30 + 0.00308825685426102*x_32 - 0.000694680862154099*x_33 + 0.000752734354642628*x_34 + 0.000111108440434771*x_35 - 0.000784129979637713*x_36 - 0.00219128922079904*x_37 + 0.00382653030146148*x_38 - 0.000527244898604427*x_39 - 0.00124993680435446*x_4 - 0.00361478138233173*x_40 + 0.00441601089758673*x_41 - 0.000565092901037681*x_42 - 0.00506970195758144*x_43 + 3.80116977010866e-5*x_44 + 0.00400926915180128*x_45 + 0.00192793354846764*x_46 - 0.000776971860855577*x_47 - 0.00288746813291784*x_48 + 0.000473359967186965*x_49 + 0.000578870849205121*x_5 + 0.00548504157310569*x_50 - 0.000675017378838559*x_51 + 0.00321971227393409*x_52 - 9.54886888608131e-6*x_53 + 0.0072167722462453*x_54 - 0.00217696891397596*x_55 + 0.00418063964615793*x_56 + 0.000525407807847916*x_57 + 0.00294240866764099*x_58 - 0.00736151315032605*x_59 - 0.000318845185588308*x_6 - 3.17955637195036e-5*x_60 + 0.000660633845864076*x_61 - 0.000241422622289913*x_62 + 0.0033844183795985*x_63 - 0.00157883884445226*x_64 - 0.00311877454024844*x_65 + 0.00162510987084673*x_66 + 0.000190392033742471*x_67 - 0.00183469742820152*x_68 + 0.00226449729954823*x_69 + 0.000258126398793114*x_7 + 0.00160303832534994*x_70 - 0.00139368881664683*x_71 - 0.000577960974985614*x_72 - 0.000801493608145077*x_73 + 0.00240933509701993*x_74 - 0.00030273078606347*x_75 - 0.000542240379131414*x_76 + 0.000343716600624043*x_77 + 0.000995002033915678*x_78 + 0.000459992936591403*x_79 + 0.00207905006718527*x_8 - 0.00145095145284877*x_80 - 0.00421569630547064*x_81 + 0.00238882093186674*x_82 + 0.00292003039267183*x_83 - 0.00215790113046641*x_84 + 0.00210463042781737*x_85 + 0.00129772038833934*x_86 + 0.00276584291068207*x_87 - 0.00188362063387885*x_88 - 9.14118912871357e-5*x_89 + 4.16705626087055e-5*x_9 + 0.000314940544361146*x_90 + 0.000157568893509157*x_91 + 6.95071784535525e-5*x_92 + 0.000371458013929882*x_93 + 0.00212421551393443*x_94 - 0.000815594988143207*x_95 - 0.00144025109330302*x_96 + 0.00190165319387839*x_98 + 0.00193708726360283*x_99 - 2.36947150697273e-6*std::pow(-7.43688011169434*x_10 - 9.26567935943604, 2) - 2.19709763471903e-5*std::pow(-4.7247200012207*x_23 - 6.10896015167236, 2) + 3.7757668348849e-5*std::pow(-2.23535990715027*x_29 - 9.33080005645752, 2) + 1.79711637879818e-5*std::exp(0.277599841356277*x_13) + 3.79671897781142e-5*std::exp(0.275439828634262*x_23) + 0.00574289958008804*std::exp(0.143199846148491*x_49) - 0.000127762723504326*std::exp(0.147999867796898*x_49) - 0.0066685544156034*std::sin(0.304559946060181*x_1 - 4.28071975708008) - 0.00866013200096405*std::sin(0.380799859762192*x_1 - 4.21895980834961) + 0.0211129503521125*std::sin(0.444319844245911*x_1 - 7.17479991912842) - 0.00815127929268818*std::sin(0.333759844303131*x_10 - 4.32592010498047) - 0.00434683644655521*std::sin(0.346559852361679*x_10 - 1.14743983745575) - 0.0151985799535378*std::sin(0.248559966683388*x_100 + 1.96343982219696) - 0.00503800087293952*std::sin(0.253279983997345*x_100 - 1.22375988960266) - 0.00649200495014367*std::sin(0.235039994120598*x_101 + 1.9703197479248) - 0.00340481855186059*std::sin(0.211600005626678*x_102 - 1.21039986610413) - 0.00931668945633449*std::sin(0.237199977040291*x_102 + 1.95759987831116) - 0.00612257119085069*std::sin(0.19743999838829*x_104 - 4.40719985961914) + 0.0122311260715044*std::sin(0.24551996588707*x_106 + 4.98847961425781) + 0.0115799944484344*std::sin(0.250399976968765*x_108 + 1.97543978691101) - 0.0190706143157799*std::sin(0.256479978561401*x_108 + 5.14879989624023) + 0.00684227388022321*std::sin(0.264079958200455*x_109 + 4.96231985092163) - 0.000124022815722211*std::sin(0.235759988427162*x_11 - 7.3951997756958) - 0.0198866503083953*std::sin(0.345119833946228*x_11 + 5.07279968261719) + 0.00805780125063467*std::sin(0.250879973173141*x_112 - 7.428879737854) - 0.0120617200515389*std::sin(0.288159936666489*x_112 + 1.95711982250214) - 0.0131812222188328*std::sin(0.242639973759651*x_113 + 8.37351989746094) - 9.28238164127869e-5*std::sin(0.27975994348526*x_113 - 7.42360019683838) - 0.0155902050010065*std::sin(0.281679958105087*x_113 + 1.98447978496552) + 0.00744454773285036*std::sin(0.20168000459671*x_116 + 8.19727993011475) - 0.00439510087310009*std::sin(0.222719997167587*x_116 + 8.38632011413574) + 0.0127271141831287*std::sin(0.240959972143173*x_116 - 1.22615993022919) + 4.502503214971e-5*std::sin(0.269519954919815*x_116 - 1.24311995506287) + 0.00948859648448805*std::sin(0.245439976453781*x_119 - 7.43943977355957) + 0.00916913272083383*std::sin(0.295919924974442*x_12 + 5.14359998703003) + 0.0216031748948865*std::sin(0.335679858922958*x_12 + 1.86047983169556) + 0.0140891459068974*std::sin(0.268559962511063*x_120 - 1.21983981132507) - 0.00385485196825445*std::sin(0.29751992225647*x_120 + 1.75015985965729) - 0.00617953372052327*std::sin(0.308319926261902*x_13 + 5.13216018676758) + 0.0102943209474647*std::sin(0.385039836168289*x_13 - 7.36183977127075) + 0.00477791634416277*std::sin(0.432719856500626*x_13 + 1.9437597990036) - 0.000429638829263829*std::sin(0.135680049657822*x_14 - 1.24679982662201) + 0.00946787073823645*std::sin(0.251679986715317*x_14 - 7.24671983718872) + 0.00892659950377712*std::sin(0.305359929800034*x_14 - 7.44343996047974) - 0.00425766022053582*std::sin(0.363359838724136*x_14 - 4.37039995193481) - 0.0229666189619936*std::sin(0.377439826726913*x_14 + 5.02719974517822) + 0.0105338269886153*std::sin(0.253519982099533*x_15 - 7.40231990814209) + 0.0306075738649693*std::sin(0.28247994184494*x_15 - 7.42208003997803) - 0.000125459473773821*std::sin(0.289599925279617*x_15 + 5.16944026947021) + 0.000269553077036654*std::sin(0.153840035200119*x_16 + 8.35536003112793) - 0.023005889339242*std::sin(0.261759966611862*x_16 - 1.1658399105072) - 0.00388372686008605*std::sin(0.336639851331711*x_16 - 1.15263986587524) + 0.0116872225407655*std::sin(0.439999878406525*x_16 - 1.23111987113953) - 0.0133792784954369*std::sin(0.303199917078018*x_17 + 2.02831983566284) - 0.00731727591630144*std::sin(0.337039858102798*x_17 - 7.58064031600952) - 0.00492086889618119*std::sin(0.350719839334488*x_17 - 1.15999984741211) - 0.0169482726622088*std::sin(0.173840016126633*x_18 + 1.95855975151062) - 0.00911213913317928*std::sin(0.429519861936569*x_18 + 1.96343982219696) + 0.0224180475734451*std::sin(0.31959992647171*x_19 + 1.98879981040955) - 8.2739276374232e-5*std::sin(0.366639852523804*x_19 - 1.15647983551025) + 0.00497339613252779*std::sin(0.374879837036133*x_2 - 7.40015983581543) + 0.00713894081708244*std::sin(0.406079858541489*x_2 - 7.40823984146118) - 0.0111485477308903*std::sin(0.417119860649109*x_2 - 1.17111992835999) - 0.00197379707875197*std::sin(0.471999853849411*x_20 + 1.92543983459473) - 0.000165043087629674*std::sin(0.26759997010231*x_21 - 1.16415989398956) + 0.00363816316990859*std::sin(0.302319914102554*x_21 - 7.40903997421265) - 0.0065881617972778*std::sin(0.30839991569519*x_21 - 7.39879989624023) - 5.10408907769037e-5*std::sin(0.330319821834564*x_22 - 1.17439985275269) - 0.00817017915669579*std::sin(0.384959846735001*x_22 + 1.97783982753754) - 0.0283161792289783*std::sin(0.399839848279953*x_22 + 2.00903987884521) - 0.00436915312652797*std::sin(0.288719952106476*x_23 - 4.34591960906982) + 0.00816138361841708*std::sin(0.4129598736763*x_23 + 5.19824028015137) + 0.0108427193257692*std::sin(0.389839857816696*x_24 + 5.22088003158569) + 0.0145628903058875*std::sin(0.243119969964027*x_25 - 7.38488006591797) - 0.0050108813157537*std::sin(0.322079926729202*x_25 - 1.20271992683411) + 0.00534500613137928*std::sin(0.337679862976074*x_25 - 1.15311992168427) - 0.024654104218421*std::sin(0.354159832000732*x_25 + 2.04983973503113) - 0.00850028505532935*std::sin(0.34239986538887*x_26 - 1.13975989818573) + 0.000173070462076806*std::sin(0.364879846572876*x_26 - 1.15215992927551) + 0.00222550492186134*std::sin(0.394799828529358*x_26 + 5.19792032241821) + 0.0028927007066441*std::sin(0.412559866905212*x_26 - 1.19311988353729) + 0.0105314333813162*std::sin(0.443999856710434*x_26 - 7.44151973724365) - 0.0248242444864217*std::sin(0.294559925794601*x_27 - 4.21248006820679) + 0.000111986855183695*std::sin(0.328879833221436*x_27 + 5.02975988388062) + 0.00928705501093459*std::sin(0.375999838113785*x_27 - 4.38071966171265) - 0.00499937815708159*std::sin(0.261439979076385*x_28 - 1.15511989593506) + 0.000129828777312867*std::sin(0.316079914569855*x_28 + 2.00583982467651) - 0.0130349834084997*std::sin(0.278399974107742*x_29 + 5.01567983627319) + 0.00682731014551575*std::sin(0.281359940767288*x_29 - 1.16695988178253) + 0.000200930364426714*std::sin(0.357999831438065*x_3 - 4.19871997833252) - 0.0035728858954963*std::sin(0.377839833498001*x_3 - 1.20415985584259) + 0.00778768945101922*std::sin(0.471519857645035*x_3 - 4.39256000518799) - 0.00495562990566161*std::sin(0.510479867458344*x_3 + 1.96471977233887) - 0.153670050932937*std::sin(0.0844800844788551*x_30 + 4.86079978942871) + 0.00761320493928613*std::sin(0.263119965791702*x_30 - 1.18575978279114) + 0.000132705003971987*std::sin(0.331519842147827*x_30 - 1.15855991840363) - 0.0144696166498663*std::sin(0.318639844655991*x_31 + 5.33767986297607) + 0.0094153591312918*std::sin(0.343999862670898*x_31 - 4.24528026580811) - 0.00293529038300097*std::sin(0.408799856901169*x_31 - 1.18735992908478) + 0.00198555500244188*std::sin(0.51039981842041*x_31 + 8.16663932800293) - 1.32177917617208e-5*std::sin(0.526799857616425*x_31 + 5.36439990997314) - 0.00150103024691815*std::sin(0.284959942102432*x_32 - 7.56984043121338) + 0.0149134363219328*std::sin(0.306559920310974*x_32 - 1.14495992660522) + 0.0126873571563207*std::sin(0.173360019922256*x_33 + 5.19776010513306) + 0.0262396365838648*std::sin(0.247519969940186*x_33 + 1.97295987606049) - 9.66398539126683e-5*std::sin(0.232719987630844*x_35 + 1.9592798948288) + 0.0141581296070856*std::sin(0.232959985733032*x_35 + 1.97247982025146) - 0.0152239141884145*std::sin(0.256079971790314*x_35 + 1.95967984199524) + 0.00994393348138346*std::sin(0.250159978866577*x_36 - 7.42375993728638) + 0.00991040138858483*std::sin(0.219839990139008*x_37 + 1.97511982917786) + 0.00369559453455026*std::sin(0.225759983062744*x_38 - 1.18391978740692) - 0.00773524556734835*std::sin(0.233839988708496*x_39 + 1.97919988632202) + 0.0351622295215726*std::sin(0.293199926614761*x_4 - 7.37039995193481) - 0.00852057901442904*std::sin(0.365439832210541*x_4 - 1.18407988548279) + 0.00546376528392796*std::sin(0.374879837036133*x_4 + 1.99583983421326) + 0.0131714625288518*std::sin(0.236559987068176*x_41 - 1.22183990478516) - 0.000107061903545262*std::sin(0.244479969143867*x_41 - 7.42392015457153) - 0.0109487450512217*std::sin(0.243519976735115*x_42 - 7.4346399307251) - 0.014168188094873*std::sin(0.112000063061714*x_43 - 1.25247991085052) - 0.0263696948601589*std::sin(0.270159959793091*x_44 - 7.45815992355347) - 0.0116062421462757*std::sin(0.222240000963211*x_45 + 1.98055982589722) + 0.0155901716874808*std::sin(0.120480060577393*x_47 + 1.96895980834961) - 0.018302675301709*std::sin(0.142560034990311*x_47 + 8.20160007476807) - 0.0210248913563319*std::sin(0.198079988360405*x_47 + 1.98031985759735) + 0.000163351702321308*std::sin(0.221279993653297*x_48 - 7.40007972717285) + 0.0211040662062042*std::sin(0.0957600772380829*x_49 + 8.14239978790283) - 0.00404205928548026*std::sin(0.333279848098755*x_49 + 1.89679992198944) + 0.0057337628439237*std::sin(0.331039845943451*x_5 - 1.16375982761383) - 6.56025819396368e-5*std::sin(0.341359823942184*x_5 + 2.00831985473633) - 0.0184713040848128*std::sin(0.371279835700989*x_5 + 2.02111983299255) + 0.00777206753650624*std::sin(0.23039998114109*x_50 - 7.42743968963623) + 0.0222806252048354*std::sin(0.198239997029305*x_51 - 4.38799953460693) - 0.000199868915327405*std::sin(0.205919995903969*x_51 - 1.20511984825134) + 0.0118395487740074*std::sin(0.211520001292229*x_51 - 1.18919992446899) + 0.00689622816131257*std::sin(0.238319978117943*x_53 - 7.42679977416992) - 0.0137949497808348*std::sin(0.247999966144562*x_53 + 1.98495984077454) + 0.00982497106040342*std::sin(0.253679990768433*x_53 + 5.17080020904541) - 0.0139154266299326*std::sin(0.25383996963501*x_53 - 7.41967964172363) + 0.00837580699895517*std::sin(0.196479991078377*x_54 + 8.19679927825928) - 0.0151233460702875*std::sin(0.225679993629456*x_55 + 5.15999984741211) - 0.000258035915427961*std::sin(0.202719986438751*x_56 - 1.1847198009491) + 0.0263978472955828*std::sin(0.238239988684654*x_57 - 7.42631959915161) - 0.0105846375440013*std::sin(0.246799975633621*x_57 + 5.15375995635986) - 0.151922655129347*std::sin(0.0653600990772247*x_58 + 4.88775968551636) + 0.142492136410271*std::sin(0.0555201061069965*x_59 + 8.0319995880127) - 0.00013919326114047*std::sin(0.376559853553772*x_59 + 1.82895994186401) + 0.000139795378562609*std::sin(0.282239943742752*x_6 + 2.00879979133606) + 0.00964747476520512*std::sin(0.381519854068756*x_6 + 2.00575971603394) - 0.00132981112856192*std::sin(0.435519844293594*x_6 + 1.9508798122406) - 0.00537563762136815*std::sin(0.340719848871231*x_60 + 8.27375984191895) - 0.000151900365232101*std::sin(0.395279824733734*x_60 - 1.18623995780945) - 0.00878721118498434*std::sin(0.416399866342545*x_60 - 1.22879981994629) + 0.0145529306383795*std::sin(0.461039870977402*x_60 + 1.88791978359222) + 0.0437553617590669*std::sin(0.133520036935806*x_61 + 8.08407974243164) + 0.00905800018019275*std::sin(0.310879945755005*x_7 - 7.38831996917725) - 0.00636227105145782*std::sin(0.348799854516983*x_7 + 2.02463984489441) + 0.000150996499756706*std::sin(0.364559859037399*x_7 + 2.00311970710754) + 0.0178337785753931*std::sin(0.423439860343933*x_7 - 1.21351993083954) - 9.82710443294072e-5*std::sin(0.34199982881546*x_8 - 1.13871991634369) + 0.00477975512920783*std::sin(0.386879861354828*x_8 + 8.19487953186035) - 0.0185961381882553*std::sin(0.311839938163757*x_9 + 5.14567995071411) - 0.00222777881747436*std::sin(0.327839851379395*x_9 - 1.09671986103058) + 0.0465644528369313*std::sin(0.128000050783157*x_90 + 2.00159978866577) - 8.7702831175129e-5*std::sin(0.242319971323013*x_91 + 8.42840003967285) - 0.00533756575267582*std::sin(0.368239849805832*x_91 + 1.98719990253448) - 0.0215043908290483*std::sin(0.372959852218628*x_91 + 5.20560026168823) + 0.00832144623336851*std::sin(0.267439961433411*x_92 - 7.39351987838745) + 0.0126865865083406*std::sin(0.293839931488037*x_92 + 1.98743987083435) + 0.00865658000357488*std::sin(0.235599994659424*x_93 + 1.98431980609894) + 0.000149421582640487*std::sin(0.2360799908638*x_93 + 1.96975982189178) + 0.0213365748366555*std::sin(0.248079970479012*x_93 - 1.20583987236023) - 9.36916216324525e-5*std::sin(0.292799949645996*x_94 + 4.9814395904541) + 0.00493100363337523*std::sin(0.304079920053482*x_94 + 1.96951985359192) + 0.00696812449471509*std::sin(0.261919945478439*x_95 - 7.4300799369812) - 0.0210506536493081*std::sin(0.283599942922592*x_95 - 1.20095992088318) + 0.00463387601741408*std::sin(0.287439942359924*x_95 + 1.96047985553741) - 6.69011417731485e-5*std::sin(0.292799949645996*x_95 - 1.22199988365173) + 0.00262022618339278*std::sin(0.26471996307373*x_96 + 1.97247982025146) + 0.00376213740445658*std::sin(0.249119967222214*x_97 - 7.40423965454102) + 0.0174030038794771*std::sin(0.27703994512558*x_97 + 1.96351981163025) - 0.0190600915578915*std::sin(0.277839958667755*x_97 + 1.94815981388092) - 0.00987934485162312*std::sin(0.278879970312119*x_97 + 1.950239777565) - 0.000139050858363383*std::sin(0.286639958620071*x_97 - 1.21999979019165) + 0.0143335657731519*std::sin(0.22791999578476*x_98 - 4.21591997146606) - 0.0133685196905712*std::sin(0.242959976196289*x_98 - 7.42695951461792) - 0.288568256270284);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
