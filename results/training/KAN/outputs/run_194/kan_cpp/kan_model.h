
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000270438158864052*x_1 + 4.28210395701552e-5*x_10 + 8.21879208567525e-5*x_100 - 0.00013961817942193*x_101 + 0.000155836084426174*x_102 + 0.000296417299898856*x_103 + 0.000110247609841287*x_104 - 9.76917025684964e-6*x_105 - 4.88618425498574e-5*x_106 - 0.00013836791222363*x_107 + 0.00014407213909493*x_108 - 7.62841439576523e-5*x_109 + 0.000177086209759241*x_11 - 0.000238341526409395*x_110 + 3.48431419284664e-5*x_111 - 7.4217138379641e-7*x_112 - 0.000112720673482049*x_113 - 0.000150373785577051*x_114 + 1.6916993401988e-5*x_115 + 0.000203595651146745*x_116 + 7.36677775444177e-5*x_117 + 9.29518645400115e-5*x_118 + 0.000117129971152558*x_119 + 0.000113623002418346*x_12 + 7.51546423104948e-5*x_120 + 0.000956167150182697*x_13 + 0.00010280327195961*x_14 + 0.000168865968594193*x_15 + 3.40800575396716e-5*x_16 + 0.000124434589018954*x_17 + 8.28765244335835e-5*x_18 + 7.37110498793872e-5*x_19 + 4.74790359490098e-6*x_2 + 0.000121302986577743*x_20 - 3.74820618343405e-5*x_21 - 7.60811082426154e-5*x_22 + 1.445357618768e-5*x_23 + 3.65168982206536e-5*x_24 - 3.62850628871952e-5*x_25 + 2.9705758191437e-5*x_26 - 0.000319244648115962*x_27 - 0.000181901385985164*x_28 - 0.000295304632155087*x_29 + 8.49453322229077e-5*x_3 + 0.000312784433320121*x_30 + 4.64152681264013e-5*x_31 + 3.21146524890238e-5*x_32 + 0.000142659407838769*x_33 + 2.55284697574742e-5*x_34 + 7.03038513588192e-6*x_35 + 0.000258589190800819*x_36 + 0.000212298858322996*x_37 + 0.000146758832009785*x_38 - 2.40894246821647e-5*x_39 - 6.25414010133518e-6*x_4 - 0.000161834575891736*x_40 + 0.000369755077579191*x_41 + 0.000252475977255016*x_42 - 0.000601564839608257*x_43 + 0.000179207115405478*x_44 - 1.06135015189342e-5*x_45 + 0.000234269677802059*x_46 + 8.18496225225729e-6*x_47 + 0.000243697323698716*x_48 + 0.000331338079443315*x_49 + 0.000115194497641765*x_5 + 5.13653468669916e-5*x_50 - 3.00213513499071e-5*x_51 - 5.84111432730043e-5*x_52 - 0.000191225672516368*x_53 + 2.02278015861878e-6*x_54 + 4.22367677126502e-5*x_55 - 8.6888760831835e-5*x_56 - 0.000124242641511926*x_57 - 3.53501803016493e-5*x_58 + 0.000358107760599016*x_59 + 0.000155589912709516*x_6 + 0.000337646110413838*x_60 - 3.93746194699938e-5*x_61 - 8.73661179653724e-5*x_62 + 6.33514769100401e-5*x_63 + 1.26746462636928e-5*x_64 + 8.62456020140573e-5*x_65 + 6.61953939010634e-5*x_66 + 1.28752797806146e-6*x_67 - 2.58272632639627e-6*x_68 - 5.21073839885137e-5*x_69 + 0.000169176789560664*x_7 + 0.000135273596352678*x_70 + 0.000131702593301124*x_71 + 4.11975993359521e-5*x_72 - 4.343715378541e-5*x_73 + 3.68052537900126e-5*x_74 - 4.44351788834465e-5*x_75 + 6.87764424328404e-6*x_76 + 1.48546327829405e-5*x_77 - 6.05069170579912e-5*x_78 + 9.95349884152756e-5*x_79 + 5.19181540473942e-5*x_8 + 9.42121547946573e-5*x_80 - 5.40100722572049e-5*x_81 - 3.38149367247463e-5*x_82 - 5.65915786526326e-5*x_83 - 3.91783574502786e-5*x_84 - 5.8855647096836e-5*x_85 + 7.28795200561865e-5*x_86 + 8.02893616074926e-5*x_87 + 0.000106632672251273*x_88 + 3.94060773842655e-5*x_89 + 2.60743198367622e-5*x_9 - 2.88168118092418e-5*x_90 + 9.17881109036653e-6*x_91 + 0.000110367855304697*x_92 - 8.54504078443458e-5*x_93 - 6.18717825882337e-5*x_94 + 6.33469323705812e-5*x_95 + 2.52068757820324e-5*x_96 + 0.000101591144128516*x_97 - 8.745883607418e-5*x_98 - 2.62364418017572e-5*x_99 + 3.25849143100506e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0221074735824351);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000239923794081519*x_1 + 8.84445409803492e-5*x_10 + 0.00012365379099748*x_100 - 4.34900098691541e-5*x_101 - 5.0097419029776e-5*x_102 + 0.000124899812680728*x_103 + 0.00012350090722497*x_104 + 4.75720954152394e-5*x_105 - 5.70480623938249e-5*x_106 + 0.000165461938086934*x_107 + 5.24625790762446e-5*x_108 + 5.90107974001065e-5*x_109 + 8.09230552136064e-5*x_11 - 6.9164427484658e-5*x_110 + 6.1770691940453e-5*x_111 - 0.000160020287720188*x_112 - 8.39058443744828e-5*x_113 - 6.75152437519909e-5*x_114 - 5.48892249749438e-5*x_115 - 6.58573398620486e-5*x_116 - 6.54367306742748e-5*x_117 - 0.000154997789895563*x_118 - 0.000104733627962032*x_119 + 1.94128114923039e-5*x_12 - 1.95882660398556e-5*x_120 + 0.000151646746655542*x_13 + 8.65028396423143e-5*x_14 + 7.91031106264439e-5*x_15 + 3.13437057953056e-5*x_16 + 2.45704911533217e-5*x_17 + 9.93136843065789e-5*x_18 + 0.000137980228358532*x_19 - 3.84412086477181e-5*x_2 + 5.26881820678752e-5*x_20 + 0.000105159350824171*x_21 + 4.57686655281002e-5*x_22 + 9.20448659549349e-5*x_23 + 0.000104771527199921*x_24 + 5.47345336317485e-5*x_25 + 2.88079604516142e-5*x_26 - 6.72376876440479e-5*x_27 + 6.70756498888143e-5*x_28 + 0.000329821008439824*x_29 + 2.41570582875298e-5*x_3 - 0.000107133281019606*x_30 - 1.69598418545145e-5*x_31 + 0.000123339726576526*x_32 + 0.000142761636821515*x_33 - 4.21609622772715e-5*x_34 - 0.000106674440924369*x_35 - 0.000252148540496104*x_36 - 7.59970517916151e-5*x_37 + 1.2454476875149e-6*x_38 + 0.000145021246102815*x_39 + 3.28293363116594e-5*x_4 - 2.19088954318824e-5*x_40 - 0.000342659754686771*x_41 - 1.21360457753766e-5*x_42 + 0.00144702463976259*x_43 + 3.19484498201398e-5*x_44 + 0.000186628700548645*x_45 - 9.21908754471059e-5*x_46 + 0.000255556114030789*x_47 + 0.000195432649817648*x_48 + 5.82576791620084e-5*x_49 + 9.17278568758238e-5*x_5 + 2.91701496839978e-5*x_50 + 0.00011938041052806*x_51 + 3.17171309874009e-5*x_52 + 2.9893131419068e-5*x_53 - 6.01834206959921e-5*x_54 + 0.000199579348184087*x_55 + 0.000189761437997168*x_56 + 4.19770224173669e-5*x_57 - 4.53779845303688e-5*x_58 - 0.00013073511509234*x_59 + 8.81975193570094e-5*x_6 + 3.54205459727227e-5*x_60 - 1.91129852291166e-5*x_61 - 1.32671058957442e-5*x_62 - 2.84358315066852e-5*x_63 + 4.15437510384317e-5*x_64 + 4.54241698474111e-6*x_65 - 2.20630685406688e-5*x_66 - 2.0717126085105e-5*x_67 - 1.50880360332977e-5*x_68 - 4.22864592050946e-5*x_69 + 6.77616258372661e-5*x_7 - 6.61473153743612e-5*x_70 + 1.11367274047152e-5*x_71 - 5.01270581479038e-5*x_72 + 9.95217871619643e-5*x_73 - 8.1212649255862e-5*x_74 + 4.11247772774932e-6*x_75 + 1.12164424361504e-5*x_76 - 6.98404194944629e-5*x_77 - 1.6037917241972e-5*x_78 - 3.18871499542126e-5*x_79 + 3.06983716846405e-5*x_8 + 3.03331988717621e-5*x_80 + 7.73993024167945e-6*x_81 - 1.79995700958699e-5*x_82 - 9.39926321277159e-6*x_83 - 3.9455137146099e-5*x_84 - 5.16052428976696e-5*x_85 - 3.27878442733535e-5*x_86 - 6.64113168177952e-5*x_87 - 3.33217020918264e-5*x_88 + 2.80796899833663e-6*x_89 + 3.27990872910733e-5*x_9 + 5.02854274717153e-5*x_90 + 3.64973611363251e-5*x_91 - 5.5250777111454e-5*x_92 - 6.32865979839452e-5*x_93 - 5.00645678686042e-5*x_94 - 1.3249326994407e-5*x_95 + 6.36397382734883e-5*x_96 - 3.98908174133056e-5*x_97 - 3.0447252800438e-5*x_98 - 6.30487805679395e-6*x_99 + 1.24245388854924e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0443531004073635);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000135945827627787*x_1 - 8.66749858542108e-6*x_10 - 0.00012855343795078*x_100 - 0.000146250280704099*x_101 - 1.43623949079548e-5*x_102 + 0.000382163179602549*x_103 + 0.000230914322468825*x_104 - 9.63870267722423e-5*x_105 - 8.14706695695522e-5*x_106 - 5.12318798525721e-5*x_107 - 9.06119219798248e-5*x_108 - 0.000167752769042612*x_109 - 7.55899086675157e-6*x_11 + 6.57423866312959e-5*x_110 - 3.92364825252471e-5*x_111 - 0.000151667228077383*x_112 - 0.00012996301040095*x_113 - 0.00015069381693735*x_114 - 4.05494929920462e-5*x_115 - 1.83144873961001e-5*x_116 - 8.24310188190634e-5*x_117 - 7.69749849511904e-5*x_118 - 1.23893559054076e-5*x_119 + 9.91916077035694e-5*x_12 - 0.000121770398113226*x_120 + 0.00045424007791141*x_13 + 1.78256496586309e-5*x_14 + 6.77513977100657e-5*x_15 + 2.72793444046652e-5*x_16 - 1.55476074512152e-6*x_17 + 8.05650490278315e-6*x_18 + 1.08101097586077e-5*x_19 + 9.82431848548636e-5*x_2 + 0.00012910808542305*x_20 - 3.57146805031193e-5*x_21 - 3.9047450981852e-5*x_22 - 1.40044146898243e-5*x_23 - 2.30233046754423e-5*x_24 + 5.02969163333839e-5*x_25 + 0.000125941204792233*x_26 - 0.000103376700298637*x_27 - 0.000196940830510022*x_28 - 0.000126638711652921*x_29 + 0.000105927387425934*x_3 + 4.26564408286717e-5*x_30 + 5.04941067217231e-5*x_31 - 7.30306962638765e-5*x_32 - 0.000100329324516196*x_33 - 0.000117613278377987*x_34 - 0.000195969436263299*x_35 + 1.71571572724861e-5*x_36 - 5.74451504451062e-5*x_37 - 3.91508445107172e-5*x_38 - 0.000165846849149768*x_39 - 2.19678057140656e-5*x_4 - 0.000319733573870673*x_40 - 0.000236254050537923*x_41 + 2.80085741216494e-5*x_42 - 0.00146054422697683*x_43 + 8.28437530132302e-5*x_44 + 0.000155747498658791*x_45 - 7.74975883322513e-5*x_46 - 2.49011324896503e-6*x_47 + 5.54272135365794e-5*x_48 - 6.74011636390482e-5*x_49 + 2.16724283009247e-5*x_5 + 0.000424719343372942*x_50 - 8.98492563179037e-5*x_51 - 0.000139581428303244*x_52 - 0.000167711493869256*x_53 - 0.000547333131775073*x_54 + 4.93514709044364e-5*x_55 + 0.000118558264349692*x_56 - 8.72202993315854e-5*x_57 - 7.7822121395648e-5*x_58 + 0.000327968859600632*x_59 - 4.92333917462478e-5*x_6 + 3.96372126774397e-5*x_60 - 5.51830945887103e-5*x_61 - 7.29235699131304e-5*x_62 - 1.96104363754526e-5*x_63 - 8.11191479843332e-5*x_64 - 2.66611056703501e-5*x_65 - 1.76798141841985e-5*x_66 - 1.04560742219053e-5*x_67 + 4.05478649636173e-6*x_68 + 2.80371190669071e-5*x_69 + 4.5465346528472e-5*x_7 + 5.3501512844725e-5*x_70 + 6.26184926238667e-5*x_71 + 0.00010879904867137*x_72 - 3.45313787867095e-5*x_73 - 5.30537915453342e-5*x_74 - 2.7475622743857e-5*x_75 - 1.29750655142042e-5*x_76 + 9.31517332236661e-5*x_77 - 3.66706819389862e-5*x_78 + 2.45103644495111e-5*x_79 + 1.36649708906135e-6*x_8 - 8.42736861258016e-6*x_80 - 4.06143414673086e-5*x_81 + 9.69644193249292e-6*x_82 - 9.55546590831385e-5*x_83 - 2.15004372093402e-5*x_84 + 2.96106112034883e-5*x_85 + 5.35033611756623e-5*x_86 + 1.39556944990239e-6*x_87 + 1.6435367206162e-5*x_88 + 3.23628028573391e-5*x_89 + 1.26468827357863e-5*x_9 - 1.98291436736778e-5*x_90 - 7.12619220330267e-5*x_91 + 6.00526453273239e-5*x_92 - 6.86496647104994e-5*x_93 - 8.09173852580599e-5*x_94 - 6.72025953806833e-5*x_95 - 0.000242317981328842*x_96 + 7.88722808108397e-5*x_97 - 2.1972650110185e-5*x_98 + 1.38868114328292e-5*x_99 + 5.16122502437776e-6*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0135484631962918);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000216268869167579*x_1 - 0.000179690044960878*x_10 - 0.000384904551888649*x_100 - 0.000381760187550992*x_101 - 0.000531685230051801*x_102 + 0.000444601480583083*x_103 + 0.000388590012860794*x_104 - 0.00037354589360125*x_105 - 0.000347493098842516*x_106 + 2.8989112317143e-5*x_107 - 0.000380861718637478*x_108 - 0.000400913830747481*x_109 - 0.000264345159107709*x_11 + 0.000311692699595286*x_110 - 0.000276325647127017*x_111 - 0.00043718748761784*x_112 - 0.000196466892906048*x_113 - 0.000288682716517876*x_114 - 0.000269727847591055*x_115 - 0.000334535867277512*x_116 - 0.000416065380655339*x_117 - 0.000326279422702316*x_118 - 0.000309063469964297*x_119 + 0.000157692375006728*x_12 - 0.000340445334893887*x_120 - 0.00129267721919595*x_13 - 6.38240697510373e-5*x_14 - 7.93127318180505e-5*x_15 + 4.10145353080742e-5*x_16 - 0.000194807628587081*x_17 + 6.2593415670934e-5*x_18 + 0.000123910236694542*x_19 - 5.94341192725181e-5*x_2 + 0.000189249952018308*x_20 + 0.000246783151907727*x_21 + 0.000169149161505686*x_22 + 6.00823927688288e-5*x_23 + 8.0457922407137e-5*x_24 + 0.000342491145126326*x_25 + 0.00048463335966864*x_26 + 0.00029032661150561*x_27 + 8.14402220906422e-5*x_28 + 0.000677104346872997*x_29 - 8.30969240306357e-6*x_3 + 2.1093084312177e-6*x_30 + 0.000138146782351803*x_31 - 0.000165656679393012*x_32 - 0.000762630793400135*x_33 - 0.00066031717388025*x_34 - 0.000728940351066043*x_35 - 0.000941918180267298*x_36 - 0.000860658889403116*x_37 - 0.000425563900695909*x_38 - 0.000518577969673351*x_39 + 5.63769703694822e-5*x_4 - 0.000815937687086453*x_40 - 0.00125638713773031*x_41 - 0.000600377098650321*x_42 - 0.00425734508148287*x_43 - 0.000356809048325998*x_44 - 0.00026012361491935*x_45 - 0.000888676066472952*x_46 - 0.000329094383805296*x_47 - 0.000525501928254484*x_48 - 0.00216871922422172*x_49 - 4.21289835890128e-5*x_5 + 0.000523862431003921*x_50 - 0.000359153393437833*x_51 - 0.000387527712549872*x_52 - 0.000223272730548099*x_53 - 0.00158205119088414*x_54 + 0.000144855298648065*x_55 + 0.000431836206827243*x_56 - 0.000147392484821296*x_57 - 0.000503071516393932*x_58 - 0.000292288375850825*x_59 - 0.000377071898559985*x_6 - 0.000294391558588266*x_60 - 5.17005160553312e-5*x_61 + 8.60172367763008e-5*x_62 - 0.000198022697557951*x_63 - 0.000130997532984499*x_64 - 0.000429867916816618*x_65 - 0.000115833926349788*x_66 - 4.51096943633336e-6*x_67 + 3.75343786503576e-5*x_68 + 0.000194773476491826*x_69 - 0.000418574463314292*x_7 - 0.000110955439045992*x_70 - 2.98247386324979e-5*x_71 + 0.000190930075379575*x_72 + 0.000228380080823323*x_73 - 4.10625227729278e-5*x_74 + 6.39682373921114e-5*x_75 + 4.20205183078663e-5*x_76 + 0.000137990608010017*x_77 - 6.48345838169836e-5*x_78 - 0.000109734559839054*x_79 - 5.15498674041114e-5*x_8 - 1.09804755688508e-5*x_80 - 4.15699484748e-6*x_81 + 2.19633370152479e-5*x_82 - 0.00013647956734349*x_83 + 8.71848147637025e-6*x_84 + 4.86419650629197e-5*x_85 - 7.79437898371996e-6*x_86 - 0.00013226285625384*x_87 - 0.000230242492637814*x_88 - 7.51304098492827e-5*x_89 + 3.19485884505318e-5*x_9 - 9.69957867855754e-5*x_90 - 7.91715469298616e-5*x_91 - 0.000433926600782963*x_92 + 7.53957779222387e-5*x_93 - 0.000192610012957202*x_94 - 0.000462751444972966*x_95 - 0.000576672774756098*x_96 - 9.75496840891082e-5*x_97 - 0.000153853147529985*x_98 - 7.80884455225032e-5*x_99 - 9.80212391019078e-7*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0329942718089051);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.17168918039064e-5*x_1 + 6.13725322460156e-5*x_10 - 1.96159209134393e-5*x_100 + 4.76239086006039e-5*x_101 - 0.000147249574573641*x_102 + 0.000482122886107389*x_103 + 0.000341726985273274*x_104 - 0.000489655908052853*x_105 - 8.02548425964053e-6*x_106 - 7.95511642399993e-5*x_107 - 0.000184333859696562*x_108 - 0.000156257375504326*x_109 - 0.000236698973319261*x_11 + 0.000538582407662845*x_110 + 3.1769697074968e-5*x_111 + 6.15719199466986e-5*x_112 - 0.000103512112395891*x_113 - 0.000172043462940347*x_114 - 9.57311499359138e-5*x_115 - 0.000190872378899668*x_116 - 0.000170701037210191*x_117 + 5.72656833228039e-5*x_118 + 3.03176161966951e-5*x_119 + 8.3310065242341e-5*x_12 - 0.000107261149382631*x_120 - 0.000840963879322197*x_13 + 2.65197625395412e-5*x_14 - 4.81247840448716e-5*x_15 - 1.56303689223998e-5*x_16 - 8.39437441400484e-5*x_17 + 2.07013457108422e-5*x_18 + 0.000197849459156112*x_19 + 7.24648509013084e-5*x_2 + 0.00014429752442369*x_20 + 0.000114680861194492*x_21 + 7.90476858497351e-5*x_22 + 0.000106709703574544*x_23 + 1.38702034829502e-5*x_24 + 0.000225952648662302*x_25 + 0.000297643247557672*x_26 + 0.000338088817093802*x_27 + 4.94470752468448e-5*x_28 + 4.96626398211724e-5*x_29 - 1.62455938995663e-5*x_3 + 0.000501783045592578*x_30 + 0.000113723428240986*x_31 - 4.30375031581254e-5*x_32 - 0.000285466341604779*x_33 - 0.000162223890822985*x_34 - 0.000113912989268265*x_35 - 0.000225641113292737*x_36 - 0.000252322215844374*x_37 + 9.85447375489743e-5*x_38 - 3.56956355206435e-5*x_39 - 1.22764676738747e-5*x_4 - 9.05544471268191e-5*x_40 + 0.000215412412653797*x_41 - 0.000310021607042992*x_42 - 0.000654214806818412*x_43 + 0.000107134059204002*x_44 - 6.35172536366506e-5*x_45 + 0.000119769061663087*x_46 + 5.55795589172559e-5*x_47 - 0.000215558456239749*x_48 - 6.10276166690715e-5*x_49 - 0.000322305859084014*x_5 + 7.01243824368187e-5*x_50 - 7.70841468080707e-5*x_51 - 0.000154313484871006*x_52 - 0.000115562372711665*x_53 - 0.000143291567027022*x_54 - 0.00012696680764669*x_55 + 0.000661425733545694*x_56 + 0.000192594424124673*x_57 - 1.37419963139892e-5*x_58 + 0.000229113181486293*x_59 - 0.000148149910273129*x_6 - 5.81070241064842e-5*x_60 - 1.68328146418488e-5*x_61 + 2.35822228592463e-5*x_62 - 3.78023311042076e-5*x_63 - 0.000129295444930808*x_64 - 0.000124500080705773*x_65 + 3.68008520836051e-5*x_66 + 9.55488806907972e-5*x_67 + 3.40196314797527e-5*x_68 + 0.000185730322745317*x_69 - 0.000174410805251736*x_7 + 7.58050840898383e-5*x_70 - 3.61389171944799e-5*x_71 + 9.11527772787509e-5*x_72 + 5.54717866746152e-5*x_73 - 2.93566759055329e-6*x_74 + 3.42379411397328e-5*x_75 + 3.15831262981734e-5*x_76 + 3.11963892084107e-5*x_77 - 2.97915553509904e-5*x_78 + 6.25717714986843e-5*x_79 + 1.06436574464406e-5*x_8 - 0.000177409955670684*x_80 - 2.04704073433614e-5*x_81 - 5.63168417626632e-6*x_82 - 3.1959491674399e-5*x_83 + 0.000126869063284968*x_84 + 0.000150975033899741*x_85 + 5.59205771098051e-5*x_86 + 6.50468989354496e-6*x_87 - 4.15755570121855e-5*x_88 + 3.158498316499e-6*x_89 + 2.50559440547667e-5*x_9 - 7.20280352688691e-5*x_90 - 0.000157843061621504*x_91 - 0.000139604225382466*x_92 + 0.000310699669004392*x_93 + 0.000102595739984211*x_94 - 0.000160360640166361*x_95 - 2.35446077147615e-6*x_96 + 0.000219719145744653*x_97 - 4.18470038780661e-5*x_98 + 5.2482815794631e-5*x_99 + 1.45610308070156e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0323024843627144);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000205371071651732*x_1 - 0.000193217220250167*x_10 - 0.000122243239824077*x_100 - 5.89073567994429e-5*x_101 - 0.000202868450312802*x_102 - 0.000417928337279265*x_103 - 0.000227993646223663*x_104 + 2.73226696099174e-5*x_105 - 2.10157422451433e-5*x_106 - 2.17453923615544e-5*x_107 - 3.94456570235026e-5*x_108 - 6.11666682816302e-5*x_109 - 0.000153768145077165*x_11 + 4.85132125971403e-5*x_110 - 7.56725795377267e-8*x_111 - 7.45101868494541e-5*x_112 + 0.000137389674683698*x_113 + 8.77517056061344e-5*x_114 + 1.70593898576074e-5*x_115 - 0.00011866847524295*x_116 - 4.92503771835028e-5*x_117 + 1.37552311420881e-5*x_118 - 9.67767319608795e-5*x_119 - 0.000189617754960654*x_12 + 2.75660399401083e-5*x_120 - 0.000810396878044424*x_13 - 0.000113500266837949*x_14 - 0.000150904080535616*x_15 - 6.41995038698404e-5*x_16 - 2.40803155998374e-5*x_17 + 3.75413269150739e-6*x_18 + 8.32325176145288e-5*x_19 - 1.29811571195789e-5*x_2 - 0.000187072553592184*x_20 + 9.71843357076774e-6*x_21 + 7.66606715909314e-5*x_22 - 7.07218977564782e-6*x_23 + 1.63274731385977e-5*x_24 - 6.34404557974302e-5*x_25 - 5.69240428377654e-5*x_26 + 0.000178641677068055*x_27 + 0.000215694375222252*x_28 + 0.000275262574338059*x_29 - 9.43171672979535e-5*x_3 - 7.65826002227525e-5*x_30 - 9.93328064271481e-5*x_31 + 1.60903815674173e-5*x_32 - 0.000233253612915934*x_33 - 0.000149269095081282*x_34 - 7.54888633716732e-5*x_35 - 0.000386693698511709*x_36 - 0.000139782165697009*x_37 - 0.000347543107316217*x_38 - 6.52228374792441e-5*x_39 - 1.36084264731589e-5*x_4 - 1.69146973567094e-5*x_40 - 0.000313529361269093*x_41 - 0.000371374215481468*x_42 - 0.00132789259174038*x_43 - 0.000425359220571695*x_44 - 0.000483470465021922*x_45 - 0.000146506075776037*x_46 - 0.000298970007876806*x_47 - 0.000431877659475754*x_48 - 0.0011651537197442*x_49 - 0.000145863367068353*x_5 - 0.000899645946638166*x_50 + 2.59293278823669e-5*x_51 - 4.60013914051368e-5*x_52 + 0.000113645709467904*x_53 - 0.000193193537671341*x_54 - 0.000139882942567497*x_55 + 6.94140283035368e-5*x_56 - 0.000120639094289234*x_57 - 0.000170435944293046*x_58 - 0.000474154309054445*x_59 + 5.88384286954263e-6*x_6 - 0.000278717120247479*x_60 + 3.41283222588779e-5*x_61 + 9.86266670275925e-5*x_62 - 4.3851272538347e-5*x_63 + 2.36818225972215e-5*x_64 - 0.000142586629752082*x_65 - 7.51619747856222e-5*x_66 + 2.24275477115079e-5*x_67 + 1.23431631260938e-5*x_68 + 0.000104385577269409*x_69 - 0.000176680636285391*x_7 - 8.97893200075481e-6*x_70 - 0.000132669175530794*x_71 - 9.35182309563398e-5*x_72 + 6.50394322520824e-5*x_73 + 0.000108124697257906*x_74 + 4.15474914923949e-5*x_75 + 4.46903568449637e-5*x_76 - 3.87870202135856e-5*x_77 + 6.04209741287632e-5*x_78 - 6.19606501430322e-6*x_79 - 9.76438797533712e-5*x_8 - 6.09034549196795e-6*x_80 + 4.64568825264858e-5*x_81 + 3.15675761956579e-5*x_82 + 7.56225889468943e-5*x_83 + 5.49608145743251e-5*x_84 + 2.0019665724524e-5*x_85 - 1.80722013780589e-5*x_86 - 1.91739098004975e-5*x_87 - 5.80288002147209e-5*x_88 - 5.04217408656713e-5*x_89 - 0.000119635732045188*x_9 - 1.98754247049946e-5*x_90 - 1.34999402426491e-5*x_91 - 0.000222439181156295*x_92 + 9.11105265551118e-5*x_93 + 0.000103408659042229*x_94 - 0.000146976458088765*x_95 - 4.47122021339956e-5*x_96 - 0.000148972466404847*x_97 + 8.69786303210488e-6*x_98 - 5.78450829850737e-5*x_99 - 2.25620749002462e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0415316594471539);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000422221980896689*x_1 + 3.83164440901218e-5*x_10 + 0.000370318057992765*x_100 - 0.000182856294963809*x_101 - 5.472555694722e-5*x_102 + 0.000794262248840382*x_103 + 0.000518116817937451*x_104 - 0.00027788250589277*x_105 - 0.000341222923987438*x_106 + 5.96312975621071e-5*x_107 - 0.000120448612271393*x_108 - 0.000107620846267462*x_109 - 0.000203915289840476*x_11 + 7.60289575504607e-5*x_110 - 0.000157626359629448*x_111 - 0.000325511668088671*x_112 - 0.000234935686624479*x_113 - 0.000262075469000864*x_114 - 0.000169857127638725*x_115 - 0.000171537358344174*x_116 - 0.000298447066083529*x_117 - 0.00033872452151194*x_118 - 8.76714528245534e-5*x_119 - 8.0563020212719e-7*x_12 - 0.000163854456653951*x_120 + 0.000321039295138267*x_13 + 1.47576036502176e-5*x_14 + 0.000101003850247544*x_15 - 2.91363847700518e-6*x_16 - 0.000109454307170282*x_17 + 0.000240374189651391*x_18 + 2.96617864372851e-5*x_19 + 2.77228804166764e-5*x_2 + 0.000159131754628373*x_20 + 8.71109823642046e-5*x_21 + 6.47033406643033e-5*x_22 + 0.000156481583935406*x_23 + 0.000136166133790833*x_24 - 0.000139812387195842*x_25 - 0.000135752841243048*x_26 - 0.000423063680996811*x_27 - 0.000137029326071969*x_28 + 0.000176948967609597*x_29 + 0.000103959790056225*x_3 + 5.10646358778513e-5*x_30 - 1.112689936614e-5*x_31 + 0.000166775716526509*x_32 + 7.29529552022167e-6*x_33 - 0.000289356504997015*x_34 - 0.000439006372554552*x_35 - 0.000812405021379658*x_36 - 0.000305546468667896*x_37 - 0.000109098970756214*x_38 - 0.000125745604311272*x_39 - 2.7070398439342e-5*x_4 - 0.000412103015475359*x_40 - 0.00115165051462086*x_41 - 0.000336034210954057*x_42 + 3.96708271627595e-6*x_43 - 0.000101906637388518*x_44 + 0.000154416304746384*x_45 - 0.000348765865939652*x_46 - 9.31153021975365e-5*x_47 + 8.4266713868151e-5*x_48 - 0.000237275307543021*x_49 - 3.58945960531155e-5*x_5 - 0.00072457838867825*x_50 - 0.000407622357137772*x_51 - 0.000265831308654493*x_52 - 0.00019242413883083*x_53 - 0.00056616407410808*x_54 - 0.000534994090604438*x_55 + 0.000375131093294271*x_56 - 0.000350556392892575*x_57 - 0.000724350637980382*x_58 + 6.2308471734715e-5*x_59 - 9.34769748604503e-6*x_6 - 0.00037864583602404*x_60 - 0.000138819862941708*x_61 - 0.000131906251607926*x_62 - 0.000163793768956101*x_63 - 6.60368424275348e-5*x_64 + 6.62753968340976e-5*x_65 + 1.68572319811662e-5*x_66 + 1.66889595416628e-5*x_67 - 0.000132901626330142*x_68 - 3.64087174954154e-5*x_69 + 0.000108870412330707*x_7 + 3.97346283557179e-5*x_70 + 3.31836188213959e-5*x_71 + 3.02528214908572e-5*x_72 + 0.000134948703373939*x_73 - 0.000165126894119474*x_74 - 3.39195407926894e-5*x_75 + 1.0921920916639e-5*x_76 - 0.000179426299234449*x_77 - 0.000135509986133158*x_78 + 2.87876725313032e-5*x_79 - 3.47923434856736e-5*x_8 - 5.55718682944873e-5*x_80 - 0.000113719492826934*x_81 - 7.7308634774735e-5*x_82 - 9.84081205585766e-5*x_83 - 1.90032453688276e-6*x_84 - 5.78562652752719e-5*x_85 + 6.56927493786055e-5*x_86 - 2.79335459922106e-5*x_87 - 4.71765597804414e-5*x_88 + 1.32801212183571e-5*x_89 - 8.28090427634076e-5*x_9 + 6.6094219503744e-6*x_90 - 0.000228575581313108*x_91 - 0.000379536479727235*x_92 - 0.000299015916902978*x_93 - 0.000355159062677311*x_94 - 8.1012324578446e-5*x_95 - 0.000189031473638799*x_96 - 3.91892019808636e-5*x_97 - 0.000352698975462424*x_98 + 1.86768284574334e-5*x_99 + 6.53331593326264e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0052414087985181);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000151525879999283*x_1 + 9.29585819347198e-5*x_10 - 0.000204734911807265*x_100 + 0.000174496559670673*x_101 + 0.000196529816351487*x_102 - 5.00900120353811e-5*x_103 - 0.000139383786455419*x_104 + 2.06621052301771e-5*x_105 + 0.000270721408356579*x_106 - 0.000164538502259123*x_107 + 1.54946953070409e-5*x_108 - 5.90706014618924e-5*x_109 - 6.12058168887809e-5*x_11 + 0.000356108828097314*x_110 + 0.000212531558331096*x_111 + 0.000177758020796109*x_112 + 9.52735559820024e-5*x_113 + 5.98889402016576e-5*x_114 + 0.000193910348714514*x_115 + 3.78709491196504e-5*x_116 + 0.000152816554442101*x_117 + 0.000243618488459849*x_118 + 0.000198979886512532*x_119 - 0.000128167627508035*x_12 + 2.04908186846036e-5*x_120 + 0.000765202964842699*x_13 - 2.67894563538258e-5*x_14 - 6.02202216587972e-5*x_15 - 4.42983609600277e-5*x_16 + 4.36481299795494e-5*x_17 - 0.000135526723580015*x_18 - 1.61954203788093e-6*x_19 + 0.000369457328140411*x_2 - 9.46005574639532e-5*x_20 - 0.000290210118184482*x_21 - 0.000126284041933404*x_22 - 9.03554449443271e-5*x_23 - 0.000200593866104679*x_24 - 0.000182082860145119*x_25 - 0.000187574952392927*x_26 + 0.000177844995511598*x_27 - 0.000227202560309695*x_28 - 0.00069508559942969*x_29 + 0.000122905260695718*x_3 + 0.000114309004415956*x_30 - 9.4561759019252e-5*x_31 - 9.5942636526462e-5*x_32 + 0.000113983383459954*x_33 + 0.000173841455870373*x_34 + 0.000220245927110604*x_35 + 0.000546189323500623*x_36 + 0.000406026396432094*x_37 + 7.0707094742345e-5*x_38 + 0.000192620568668778*x_39 - 0.000122598522970902*x_4 + 0.000325611711778671*x_40 + 0.000718986127729733*x_41 + 0.0001425382763979*x_42 + 0.000566916985182155*x_43 + 0.000209534126382234*x_44 + 0.000155470216359558*x_45 + 0.000501128449971901*x_46 + 0.000162677427094398*x_47 + 4.03405667024893e-5*x_48 + 0.000915118675744924*x_49 - 0.000261937103065008*x_5 + 6.59703816903686e-5*x_50 + 0.000365452697564305*x_51 + 9.69116178779912e-5*x_52 + 8.65045952921088e-5*x_53 + 0.000306780149761003*x_54 - 0.000213016149507568*x_55 + 1.17119776737226e-5*x_56 + 6.6394413684006e-5*x_57 + 0.000421218621921238*x_58 + 0.000537248917958943*x_59 + 0.000143898204158108*x_6 - 7.44841497254603e-5*x_60 - 1.41046094374325e-5*x_61 - 7.96457737332295e-5*x_62 + 0.000106410344860395*x_63 - 0.000105099096087536*x_64 + 0.000124288796448685*x_65 - 2.66346934514739e-5*x_66 + 5.22320205171104e-5*x_67 + 3.03844089491795e-5*x_68 + 0.00010049239900765*x_69 + 0.000186730670295491*x_7 + 0.000180582017407776*x_70 - 6.28056071573096e-5*x_71 + 1.38503757150191e-5*x_72 - 0.000237888746419536*x_73 + 3.5048384925732e-5*x_74 - 4.00190649281497e-5*x_75 - 4.33985131423177e-5*x_76 + 0.00012952138427391*x_77 + 0.00010299987201953*x_78 + 8.36641430756016e-5*x_79 - 5.54511483946549e-5*x_8 - 0.000172326596347776*x_80 - 3.00631626605075e-6*x_81 + 8.02903751991485e-5*x_82 + 6.39291706013761e-6*x_83 + 5.26195971480477e-5*x_84 + 0.000155438522295479*x_85 + 8.86768271012454e-5*x_86 + 0.000105116183624198*x_87 + 0.000170130214857661*x_88 + 0.000116082860774401*x_89 - 5.82366855460445e-5*x_9 + 3.71860644905867e-5*x_90 - 0.000115082108011724*x_91 + 0.000386068242353826*x_92 + 1.7810494679316e-5*x_93 + 0.000198329826671783*x_94 + 7.66422432936007e-5*x_95 - 1.00883173856008e-6*x_96 + 0.0003590757603474*x_97 + 0.0003038244385615*x_98 + 0.000138960306258846*x_99 - 4.76921530733234e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0359079072044952);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.10659016571422e-5*x_1 - 0.000137523910664852*x_10 - 0.000526236077972964*x_100 + 6.90996524381901e-6*x_101 - 3.05535740499574e-5*x_102 + 0.000146190192030551*x_103 - 0.000114788246608512*x_104 - 0.000192367499219617*x_105 + 0.000144994005963484*x_106 - 0.000162060608656493*x_107 - 6.95600401543636e-5*x_108 - 8.70813729176467e-5*x_109 - 0.000124508882068846*x_11 + 0.000194408046276356*x_110 - 7.24120414405166e-6*x_111 + 0.000179456186468999*x_112 + 0.000104988188362375*x_113 + 5.58218708224303e-5*x_114 + 2.08629556307342e-5*x_115 - 5.5051595782829e-5*x_116 - 1.61247019136755e-5*x_117 + 0.000148727596117277*x_118 + 0.000108049629360496*x_119 - 8.43479636012597e-5*x_12 - 0.000119102263198104*x_120 - 0.000221797507472184*x_13 - 0.000120497761614887*x_14 - 8.96081719364108e-5*x_15 - 3.16845596979198e-5*x_16 - 2.8455602319569e-7*x_17 - 7.50822835920646e-5*x_18 - 4.50691806098417e-5*x_19 + 0.000367083017361442*x_2 - 8.95639117329295e-5*x_20 - 0.000202880725747467*x_21 - 3.76353120920159e-5*x_22 - 0.000104149954040937*x_23 - 0.00016326325966217*x_24 - 4.10712050912171e-5*x_25 + 1.83992558876701e-5*x_26 - 0.000296553248490695*x_27 - 0.000146506565433391*x_28 - 0.000527200453368591*x_29 + 9.27048725196712e-5*x_3 + 6.81370033899928e-5*x_30 - 2.71400260562409e-5*x_31 - 9.85701645048083e-5*x_32 - 9.74886438267077e-5*x_33 - 4.83441843134481e-5*x_34 - 1.17314496790954e-7*x_35 + 0.000281026484330319*x_36 + 9.93864546534056e-5*x_37 + 6.52451835719677e-5*x_38 - 0.000145333164543681*x_39 - 0.000126985658283156*x_4 - 4.91945291872968e-5*x_40 + 0.000408027415005644*x_41 - 2.61423598254393e-6*x_42 - 0.00187805095187855*x_43 - 0.000137547761001561*x_44 - 0.000396335112662222*x_45 + 5.41266314062462e-5*x_46 + 7.12667947436559e-6*x_47 - 8.10537876451513e-5*x_48 - 0.000866435869741808*x_49 - 0.000222063064765317*x_5 - 0.00016792040607106*x_50 - 0.000192184845148731*x_51 - 2.28503036585486e-5*x_52 + 2.73802971138385e-5*x_53 - 6.4966454687579e-5*x_54 - 0.000515956260286306*x_55 - 0.000529003129523797*x_56 - 0.000109759770057903*x_57 - 1.07742687937049e-5*x_58 + 0.000417264580460112*x_59 + 9.97104889862737e-5*x_6 - 0.000182711991397887*x_60 + 9.09017919855934e-6*x_61 - 4.70055461329921e-5*x_62 + 1.04080256691049e-5*x_63 - 0.000186017427922796*x_64 - 0.000135440430615582*x_65 - 7.99992505975946e-5*x_66 - 3.78192533121469e-5*x_67 + 4.894670056784e-5*x_68 + 0.000160051269074066*x_69 - 0.000106992624002844*x_7 + 0.000153170152260881*x_70 - 2.99266811410566e-5*x_71 + 0.000116702671396645*x_72 - 0.000122413370623017*x_73 + 3.68864526148704e-5*x_74 + 4.95896906327241e-7*x_75 + 9.47262278001794e-6*x_76 + 0.000191686353292509*x_77 + 9.95096914218077e-5*x_78 + 4.51911740309311e-5*x_79 - 0.000193423617610491*x_8 - 0.000212015070396438*x_80 - 2.22863378941114e-5*x_81 + 7.7092939079073e-5*x_82 - 9.97858182316805e-5*x_83 + 4.30105835560183e-5*x_84 + 0.000171507679909119*x_85 + 9.44460332485792e-5*x_86 + 8.37888374466469e-5*x_87 - 5.68428055313419e-6*x_88 + 3.72057389513058e-6*x_89 - 0.000235896568694306*x_9 - 7.35544951604912e-5*x_90 - 0.000176893020121721*x_91 + 0.000362800645945838*x_92 + 0.000110442827623291*x_93 + 0.000125166848111967*x_94 - 0.000121364393317954*x_95 - 9.9520842336732e-5*x_96 + 0.000294066862281409*x_97 + 0.000282902489538643*x_98 + 7.4882600180902e-5*x_99 - 4.70179489530092e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0366672528130533);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.52562829394287e-5*x_1 + 0.00023692830023336*x_10 + 0.00044893450499937*x_100 + 5.653552130456e-5*x_101 + 8.12480650644412e-6*x_102 + 6.64167592269912e-5*x_103 + 5.1592636987312e-5*x_104 - 0.000141860812988172*x_105 - 7.00484546397708e-6*x_106 + 1.94750117307142e-5*x_107 + 0.000290235677043499*x_108 + 0.000135806545362782*x_109 + 0.000169358563881176*x_11 - 0.000162986401698408*x_110 + 6.73030609737926e-5*x_111 + 0.000156183764408142*x_112 - 9.99021811926479e-5*x_113 - 0.000167512856682395*x_114 - 8.22488885352546e-5*x_115 + 0.000150025310998766*x_116 + 4.41083887986859e-5*x_117 + 0.00012010354569067*x_118 + 4.21890401929951e-5*x_119 + 0.000113231302506057*x_12 + 0.000223046099577776*x_120 - 0.000266729860520065*x_13 + 0.000205329566073141*x_14 + 0.00012133023904068*x_15 + 3.95330351163023e-5*x_16 - 6.58597783439327e-6*x_17 + 0.000210673675761254*x_18 + 0.000387749967714533*x_19 - 0.000323586551855683*x_2 + 0.000129367270238235*x_20 + 0.000318143073445753*x_21 + 0.000101895718027022*x_22 + 0.000214944743438564*x_23 + 0.000239516984595531*x_24 + 0.000178756447693372*x_25 + 5.26337553840107e-5*x_26 + 0.000264680383624425*x_27 + 0.000346920043657973*x_28 + 0.000425082422994672*x_29 - 0.000138657404272201*x_3 + 0.000667404443542084*x_30 + 9.60946951368702e-5*x_31 + 0.000254525282657846*x_32 + 0.000241084297787665*x_33 - 1.62844390730605e-7*x_34 + 9.37321943092659e-5*x_35 - 0.00019433870884291*x_36 - 8.93828006237389e-5*x_37 + 0.000335776256403207*x_38 + 0.000374322231588269*x_39 + 0.000108414602581731*x_4 + 0.000285240668830886*x_40 + 0.000742081904364785*x_41 - 6.52131247792434e-5*x_42 + 0.00289590074462874*x_43 + 0.000151472788094492*x_44 - 0.00027144327419465*x_45 + 0.000209430541954854*x_46 + 0.000164426654095364*x_47 + 0.000140502511572775*x_48 + 0.000337264155691778*x_49 + 3.5683568643884e-5*x_5 - 0.000111110139211136*x_50 + 0.000137593638360907*x_51 + 9.34449023487432e-5*x_52 - 5.71069637293852e-5*x_53 + 0.000788476784680693*x_54 + 0.000160782256577253*x_55 + 0.000140016805895145*x_56 + 0.000259492635668325*x_57 + 0.000123268027245962*x_58 - 0.000383524627523824*x_59 + 0.000205365573759435*x_6 + 0.000397612080076293*x_60 + 3.76649700094813e-5*x_61 + 8.35545456237782e-5*x_62 + 4.62380858136117e-5*x_63 + 0.000169684923983971*x_64 + 1.69265476084619e-5*x_65 + 0.000184859240365928*x_66 + 7.78772087772277e-5*x_67 + 1.81394001468819e-5*x_68 - 4.39642330942839e-5*x_69 - 2.50379722766025e-5*x_7 - 2.91225999577542e-5*x_70 + 4.77025709557156e-5*x_71 - 0.000118490065251742*x_72 + 0.000252619859956329*x_73 + 9.84311004797945e-5*x_74 + 4.75612956430088e-5*x_75 + 6.4978128829626e-5*x_76 - 0.00019745253237662*x_77 - 7.775689355886e-5*x_78 + 4.80150380045896e-6*x_79 + 0.000162834409126934*x_8 + 7.61085915966853e-5*x_80 + 1.06089748465658e-5*x_81 - 9.48782381087111e-5*x_82 + 6.38442672619172e-5*x_83 + 7.60878462960376e-6*x_84 - 0.000131915262170484*x_85 - 5.5966056633686e-5*x_86 + 6.27878475458413e-6*x_87 + 2.38598057900588e-6*x_88 - 2.68284901072987e-5*x_89 + 0.000179920971541611*x_9 + 9.81059372117763e-6*x_90 + 0.000193224345123359*x_91 - 0.000311080281692694*x_92 + 0.000189714175552004*x_93 + 4.31419773618147e-5*x_94 + 4.17741076240148e-5*x_95 + 0.000557911473467431*x_96 + 8.76609704523266e-5*x_97 - 0.000151651476743819*x_98 - 7.39718137342541e-5*x_99 + 5.70401833110967e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.06207702486099);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.05451377003316e-5*x_1 + 0.000360044281011102*x_10 + 5.56546083435421e-5*x_100 + 0.000257033341049899*x_101 + 6.07140893891675e-5*x_102 + 1.42290760689759e-5*x_103 - 0.000138706060780262*x_104 - 2.43619717374768e-5*x_105 + 9.78100698046893e-5*x_106 + 9.13952607898415e-5*x_107 + 7.85155771754155e-5*x_108 + 0.000190833509746578*x_109 + 3.38068438665373e-5*x_11 + 0.000215986186249482*x_110 + 1.91370497398206e-6*x_111 + 0.000293975370801865*x_112 + 4.86225978612236e-5*x_113 + 3.80103588776187e-5*x_114 - 1.27646052344863e-5*x_115 - 1.00025508472267e-6*x_116 + 6.29428482373146e-5*x_117 + 5.54002705380062e-5*x_118 + 8.29359826507498e-5*x_119 + 3.25816967645822e-5*x_12 + 1.19623005186779e-5*x_120 - 0.000217620791383281*x_13 + 9.6547014059773e-5*x_14 - 4.17826940081818e-5*x_15 + 6.30451611273247e-5*x_16 - 8.50406666781554e-5*x_17 + 1.52746972621911e-5*x_18 - 0.000101294283472366*x_19 + 6.39704325161987e-5*x_2 + 9.67717621617669e-6*x_20 + 6.35863180672818e-5*x_21 + 6.76866394329743e-5*x_22 + 7.14898948318062e-5*x_23 - 3.10280601188803e-5*x_24 - 4.09256451936618e-5*x_25 - 0.000164250616423009*x_26 + 0.000165448352333433*x_27 + 4.26517570202684e-5*x_28 - 0.000103672924927926*x_29 + 1.03608309752988e-5*x_3 + 3.60165890419966e-5*x_30 + 6.28982156043217e-6*x_31 - 2.24736326458652e-6*x_32 + 0.000145633007487995*x_33 - 2.60506550647632e-5*x_34 + 6.86053873320256e-5*x_35 - 9.74275856554613e-5*x_36 - 0.000114963992662288*x_37 + 0.000391390820616509*x_38 + 0.000356246128202074*x_39 + 3.33422500453506e-5*x_4 + 0.000510788343698569*x_40 + 0.000483143174808684*x_41 + 0.000154647610320937*x_42 + 0.00410143960403345*x_43 + 0.000271735222537477*x_44 + 0.00015721489133223*x_45 - 0.000208768631475221*x_46 + 0.000422743799465939*x_47 + 0.000255229046731209*x_48 + 0.000529568684595105*x_49 + 2.14378803368621e-5*x_5 + 0.000627009714491314*x_50 + 0.000236359915013188*x_51 + 0.000260271677855184*x_52 + 0.000256077014271941*x_53 + 0.000769784900752246*x_54 - 0.000184971329588492*x_55 - 0.000449858112390729*x_56 + 0.000145545728054029*x_57 + 0.000183779490089136*x_58 - 7.24532090737177e-5*x_59 + 4.44958670916995e-5*x_6 - 0.000134076498534446*x_60 + 3.9272300109305e-6*x_61 + 3.38478286496663e-5*x_62 + 1.29864340619838e-5*x_63 - 1.03831149724854e-5*x_64 + 1.86059889199131e-5*x_65 - 8.04539473859708e-6*x_66 + 2.96117803486783e-6*x_67 - 1.06420047283482e-5*x_68 - 2.7736408719466e-5*x_69 - 7.55258295902279e-6*x_7 - 8.58142036626351e-5*x_70 - 4.11696747084219e-5*x_71 + 3.42990246460191e-5*x_72 + 4.54766828689758e-5*x_73 - 4.71557930336172e-5*x_74 + 3.24665769545163e-5*x_75 - 4.01961642374675e-5*x_76 + 2.33653822056079e-5*x_77 + 3.90494700822292e-5*x_78 - 0.000147544541502132*x_79 + 9.39185945744243e-6*x_8 - 9.67225999629707e-5*x_80 + 1.48404541924527e-5*x_81 + 6.86612838610371e-6*x_82 - 9.70662936712695e-6*x_83 - 4.50949427062895e-5*x_84 - 1.79444113153235e-5*x_85 - 4.64545575191922e-5*x_86 + 2.24151574411172e-5*x_87 - 2.06672514697125e-5*x_88 + 4.05312079396591e-5*x_89 + 0.000108196733098258*x_9 + 5.38001077811599e-5*x_90 + 5.95535046788888e-5*x_91 + 0.000161479702188301*x_92 - 0.000138041397375384*x_93 - 0.000163192022965863*x_94 + 4.95323901299865e-5*x_95 + 0.000230713312712072*x_96 + 0.000347068513869645*x_97 + 0.000180635018780084*x_98 + 0.000126231578910088*x_99 - 2.10762099935788e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.05217816326137);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.81793708102426e-5*x_1 - 3.36449978968652e-5*x_10 + 0.000100694429576289*x_100 + 0.000148523109318364*x_101 + 0.000158386641852833*x_102 - 0.000458329730505796*x_103 - 0.000255368878833194*x_104 + 0.000232890849514205*x_105 + 0.000111128581473094*x_106 - 4.83061316072043e-5*x_107 + 2.53633985168986e-5*x_108 + 7.77371401528857e-5*x_109 - 3.12930677529648e-5*x_11 - 3.17511414148346e-5*x_110 + 1.09421864282138e-5*x_111 + 9.65576727749484e-5*x_112 + 0.000140436354964327*x_113 + 0.000181618029762322*x_114 + 0.000144829726331805*x_115 + 9.40284713914212e-5*x_116 + 0.000153785279452183*x_117 + 9.35222724656935e-5*x_118 + 7.07878591702852e-5*x_119 - 0.000133737285948117*x_12 + 0.000103733365600413*x_120 + 0.000301204140219856*x_13 - 9.00931280964625e-5*x_14 - 8.61946525058478e-5*x_15 - 5.26651442660037e-5*x_16 - 2.52748951102765e-5*x_17 - 0.000123276494984447*x_18 - 0.000184601542377917*x_19 - 2.09569610797947e-5*x_2 - 0.000152743332160696*x_20 - 0.000150234311961079*x_21 - 8.04270679538938e-5*x_22 - 0.000104535160786983*x_23 - 9.95582071320987e-5*x_24 - 0.000204426763455398*x_25 - 0.000285441857303931*x_26 + 0.000192350554223386*x_27 - 2.30983709870867e-5*x_28 - 0.000229704786467592*x_29 - 4.32752884141093e-5*x_3 - 0.000189093043747664*x_30 - 8.61605338493315e-5*x_31 - 4.46532778899899e-5*x_32 + 9.09590825150607e-5*x_33 + 0.000217065836275795*x_34 + 0.00024191235295357*x_35 + 0.000289159810828361*x_36 + 0.00023834788080775*x_37 - 9.60165204313121e-5*x_38 + 5.65445982302554e-5*x_39 - 2.50626907379002e-5*x_4 + 0.000277380615699287*x_40 + 0.000138223660354441*x_41 + 5.82885272820726e-5*x_42 + 0.000447233898345088*x_43 - 1.756013887575e-5*x_44 + 9.74934230726837e-5*x_45 + 0.000184028872048801*x_46 - 0.000203976482116795*x_47 - 0.00011003592971333*x_48 + 0.000687214982537307*x_49 - 2.72374333467181e-5*x_5 - 0.000191137105687564*x_50 + 0.000117453205459386*x_51 + 9.14221221770817e-5*x_52 + 9.53211069558755e-5*x_53 + 0.000318011759293631*x_54 - 7.95275324518568e-5*x_55 - 0.000112589572810047*x_56 + 7.947900418281e-7*x_57 + 0.000189489088295863*x_58 - 8.62108194502519e-5*x_59 - 3.06475013521016e-5*x_6 - 0.000103196700828933*x_60 + 2.45393909658577e-5*x_61 + 7.47173790828728e-6*x_62 + 4.71173853051379e-5*x_63 + 5.96230837248628e-5*x_64 + 0.000159648819654659*x_65 + 2.74890656927461e-5*x_66 + 2.26527306244785e-5*x_67 - 2.4182473082996e-5*x_68 - 6.0751300706975e-5*x_69 + 9.82468639299217e-5*x_7 - 6.7953613693777e-6*x_70 - 5.63396487372379e-5*x_71 - 8.1858171676863e-5*x_72 - 0.000123943736749475*x_73 + 4.62079678616058e-5*x_74 - 2.25903645199926e-5*x_75 - 4.05324477894204e-5*x_76 - 3.9328666371308e-5*x_77 + 3.49120422343562e-5*x_78 - 2.415725833123e-8*x_79 + 1.15090803903265e-5*x_8 + 1.8725202551728e-5*x_80 + 1.97503743586998e-5*x_81 + 1.52525553261061e-5*x_82 + 9.63852673606888e-5*x_83 + 1.21032377961785e-5*x_84 - 1.09773109823273e-5*x_85 - 2.32708552569525e-5*x_86 + 2.97641160504327e-5*x_87 + 8.12410997842134e-5*x_88 + 2.29927849067339e-5*x_89 + 6.67279130562673e-6*x_9 + 4.96637148869124e-5*x_90 + 3.81668961836387e-5*x_91 + 9.24784596642496e-6*x_92 - 7.2064351141985e-5*x_93 + 6.39784493899332e-5*x_94 + 0.00015966169301556*x_95 + 2.66387200461093e-5*x_96 - 0.000106239443075059*x_97 + 3.50630432443428e-5*x_98 + 1.30469487835528e-5*x_99 - 1.75664953860379e-5*std::sin(1.67079985141754*x_108 - 2.40847992897034) + 0.0271484401136936);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
