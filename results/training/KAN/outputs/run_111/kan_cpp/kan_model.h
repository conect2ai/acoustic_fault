
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0318679126775383*x_1 + 0.537208303486786*x_10 + 34.6419587051924*x_100 + 16.8353961683419*x_101 + 26.9495747904187*x_102 - 49.9265830799487*x_103 + 234.543173005448*x_104 + 24.0526612312823*x_105 + 54.8604162439715*x_106 + 19.0942646431422*x_107 - 15.0131224330736*x_108 + 41.2279518635106*x_109 - 1.30386931624683*x_110 + 23.120490627408*x_111 + 10.9950601505757*x_112 + 44.2577326721956*x_113 - 36.8653176701591*x_114 - 28.8919906460397*x_115 + 45.9448349519092*x_116 + 21.4810763280656*x_117 - 3.94296472517848*x_118 - 2.86397342063605*x_119 + 5.54639365425211*x_12 - 44.6188712081018*x_120 + 92.6241068363692*x_13 + 25.7376086690004*x_14 - 0.00497417074911938*x_17 + 114.100961577322*x_18 + 0.00845467993952389*x_19 - 15.8441475241233*x_2 + 3.35496997309943*x_20 + 0.0583380420781117*x_21 + 0.93315446517351*x_22 - 17.3094393519682*x_24 - 69.8276174985053*x_25 + 8.3687261293694*x_26 + 20.7497776479166*x_27 + 37.31467243369*x_28 - 95.1770938612625*x_29 - 9.3672104984821*x_3 + 0.754346700401471*x_30 - 8.27586824259493*x_31 + 2.64844958881521*x_32 - 92.4429963598787*x_33 + 262.698889464518*x_34 + 285.38644924287*x_35 - 133.266629235847*x_36 + 603.826185567929*x_37 + 13.0556835297509*x_38 + 389.142952429345*x_39 + 12.2527162117254*x_4 - 45.3344083750088*x_40 + 0.188690439533975*x_42 + 44.462586861961*x_43 - 11.374341008828*x_44 + 36.5916244591963*x_45 + 1.70357232377953*x_46 - 310.322982992739*x_47 + 203.872813647674*x_48 + 8.41320345240765*x_5 + 3.09518895213115*x_52 - 21.841679640923*x_53 + 8.26742956186242*x_54 + 2.00556097100871*x_55 - 46.0594158365738*x_56 - 111.159553753921*x_59 + 8.97693514421723*x_6 - 2.48886458131561*x_61 + 0.00412094743381532*x_62 + 16.9682876801958*x_63 + 1.93818202336466*x_64 - 13.3187228147166*x_65 + 9.68170674201683*x_66 + 15.2809250933315*x_67 + 9.83293200450405*x_68 + 10.625560015434*x_69 + 47.0899115972108*x_7 - 18.2978584032787*x_70 + 10.2987148499695*x_71 - 9.48871497178095*x_72 + 9.00213916286147*x_73 - 29.6413702876925*x_74 - 19.0845140831763*x_75 - 24.8076598691124*x_76 - 21.7593405936935*x_77 - 14.5503901576363*x_78 - 89.2161031808088*x_79 + 45.635404808704*x_8 + 12.0475228615676*x_80 - 30.1163427018707*x_81 + 23.2335893530945*x_82 - 40.4441776041725*x_83 + 18.7664607181146*x_84 + 49.5464394427719*x_85 + 114.259869184062*x_86 + 188.99016387233*x_87 + 4.45749635815787*x_88 + 7.6157642231124*x_89 - 21.331228648223*x_9 + 12.4132431939672*x_90 + 7.19424152359683*x_91 - 21.1558536428488*x_92 + 7.03149974148853*x_93 + 21.6601739690499*x_94 + 20.7731285917766*x_95 + 14.1686783065935*x_96 - 3.08855573073075*x_97 - 24.4395945633073*x_98 + 16.242199217688*x_99 + 0.000184301591177345*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) + 0.0351353553001107*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) - 0.00545645168645891*std::exp(0.785679876804352*x_1) + 1.03385261287877*std::exp(1.17999982833862*x_1) + 0.250376519929197*std::exp(1.20335984230042*x_1) - 1.00215431202558*std::exp(1.76671993732452*x_1) - 1.03384542705357*std::exp(0.52215987443924*x_10) - 0.0116873470148444*std::exp(0.591439843177795*x_10) + 1.32003761119721*std::exp(0.900879800319672*x_10) + 0.00723685853620459*std::exp(0.885119915008545*x_11) - 0.471209108316928*std::exp(0.925119876861572*x_11) - 0.900206059087595*std::exp(0.944479823112488*x_11) - 0.000668555686706501*std::exp(1.00215983390808*x_11) - 0.818977163769479*std::exp(1.00799977779388*x_11) + 0.0658237998779656*std::exp(0.298719853162766*x_12) + 0.699725846310076*std::exp(0.684399843215942*x_12) - 2.16511328397807e-5*std::exp(1.34319984912872*x_12) - 2.80996728292139*std::exp(0.298239856958389*x_13) - 0.00114116234928226*std::exp(0.889039874076843*x_13) + 4.93949821872248e-6*std::exp(1.44815993309021*x_13) - 0.194181638156996*std::exp(0.24711985886097*x_15) + 0.596996167570691*std::exp(0.588559865951538*x_15) + 0.00666655298961745*std::exp(0.64167982339859*x_15) - 0.186257103136791*std::exp(0.977839827537537*x_15) - 1.84766212180726*std::exp(1.00783979892731*x_15) - 1.28026901029972*std::exp(0.590879797935486*x_16) + 2.53446331113039*std::exp(0.653999865055084*x_16) + 18.1010274219942*std::exp(0.721039831638336*x_16) - 0.00113628180059576*std::exp(0.929839789867401*x_16) - 0.0511227217322638*std::exp(0.602319836616516*x_17) - 1.73846200625416*std::exp(0.615119874477386*x_17) - 24.3672926545929*std::exp(0.655999839305878*x_17) + 4.71824146964106*std::exp(0.666399836540222*x_17) - 41.7235803314879*std::exp(0.753679871559143*x_19) - 1.69020510763304*std::exp(0.754959881305695*x_19) - 2.36225045013134*std::exp(0.772639811038971*x_19) - 0.0235509549267288*std::exp(0.822639882564545*x_19) + 0.0144821147745449*std::exp(0.812879860401154*x_2) - 0.575944815696839*std::exp(0.509519815444946*x_20) - 0.000893775683783554*std::exp(0.882799863815308*x_20) - 0.174272087973658*std::exp(0.894479870796204*x_20) + 0.00153182354001625*std::exp(0.971199810504913*x_20) + 6.83008722689221*std::exp(0.57015985250473*x_22) + 3.66684306068613e-5*std::exp(1.32799983024597*x_22) + 0.00332498028939397*std::exp(1.35727989673615*x_22) + 0.0558232720692318*std::exp(0.473199844360352*x_23) + 38.8376208970229*std::exp(0.541199862957001*x_23) + 0.552649503697663*std::exp(0.599999845027924*x_23) - 0.594696389664616*std::exp(0.88975989818573*x_23) + 0.000495049225122344*std::exp(1.0971999168396*x_23) - 2.38806126567759*std::exp(0.481039851903915*x_24) - 0.0628585650798707*std::exp(0.518959879875183*x_24) + 7.62145557394581*std::exp(0.579039871692657*x_24) + 1.02064095869532*std::exp(0.539999842643738*x_25) - 0.0434908745337059*std::exp(0.599599838256836*x_25) + 0.00367910842950399*std::exp(0.719999849796295*x_25) - 0.0218566749753699*std::exp(0.472639858722687*x_26) + 6.43665061588634*std::exp(0.830559849739075*x_26) - 0.0766997913940065*std::exp(0.873839855194092*x_26) - 0.000572618080146891*std::exp(0.995279788970947*x_26) + 0.158074301759523*std::exp(0.952159821987152*x_27) - 0.0723241275615421*std::exp(0.953839838504791*x_27) + 0.0080645185033068*std::exp(0.630799829959869*x_28) + 0.0127372908533671*std::exp(0.639919817447662*x_28) + 0.156054768942518*std::exp(1.00135982036591*x_28) - 0.000171441157097826*std::exp(1.18399977684021*x_29) - 0.000242991303035631*std::exp(1.33479988574982*x_29) + 0.0211784693513914*std::exp(0.598319828510284*x_3) - 1.96857082661821*std::exp(0.64167982339859*x_3) - 0.00422277459922964*std::exp(0.719519853591919*x_3) - 0.00590809262357315*std::exp(0.833439886569977*x_30) + 0.310734121204572*std::exp(0.888719916343689*x_30) + 0.00123778092187383*std::exp(1.12327992916107*x_30) + 5.74912497502955*std::exp(0.879999876022339*x_32) + 0.0407111710756738*std::exp(0.414639860391617*x_33) - 2.64584811674038*std::exp(0.464239865541458*x_33) - 1.66339713599113*std::exp(0.618639826774597*x_4) - 0.849999490177085*std::exp(0.686719834804535*x_4) + 0.000494198342921744*std::exp(1.15263986587524*x_4) + 8.97616692047687*std::exp(0.735999822616577*x_41) + 0.593533771625705*std::exp(0.797439873218536*x_41) + 0.0213245278785072*std::exp(0.80103987455368*x_41) - 0.0014311430578744*std::exp(0.811199843883514*x_41) - 0.614873475052596*std::exp(0.823679864406586*x_41) + 1.48576718714516*std::exp(0.798799872398376*x_42) - 0.0304355198963691*std::exp(0.846959888935089*x_43) - 0.0126002387216673*std::exp(0.912319839000702*x_44) + 0.000393804830530635*std::exp(0.976159811019897*x_44) + 0.00442383747880723*std::exp(0.542799830436707*x_45) + 0.603623428658032*std::exp(0.54535984992981*x_45) - 0.829842310143903*std::exp(0.739759802818298*x_46) + 7.8622798944894*std::exp(0.763999879360199*x_46) - 0.0345115421677021*std::exp(0.56335985660553*x_47) + 5.46342646177321*std::exp(0.64167982339859*x_49) - 0.0445239459022839*std::exp(0.711119830608368*x_49) + 0.736693859713007*std::exp(0.730319857597351*x_49) - 0.0110378323013488*std::exp(0.731119871139526*x_49) - 2.41707257607615*std::exp(0.733759820461273*x_49) - 0.0598651928842971*std::exp(0.500079810619354*x_50) + 0.705628263757135*std::exp(0.545759856700897*x_50) - 1.87254337876447*std::exp(0.560399830341339*x_50) + 53.7746125140051*std::exp(0.56335985660553*x_50) - 0.0115226896887223*std::exp(0.596959829330444*x_50) + 14.1016293456899*std::exp(0.485359847545624*x_51) - 30.0511824376824*std::exp(0.49431985616684*x_51) - 0.417046700884286*std::exp(0.494879871606827*x_51) - 0.130853433244784*std::exp(0.500959813594818*x_51) + 110.995726611652*std::exp(0.503039836883545*x_51) + 0.971334319248824*std::exp(0.511919856071472*x_52) - 2.89517081531274*std::exp(0.670159876346588*x_52) - 0.00143923821841663*std::exp(0.767999827861786*x_52) + 0.000222546362287575*std::exp(0.831919848918915*x_52) - 0.0168602629207897*std::exp(0.497679859399796*x_53) + 39.8129026752952*std::exp(0.447279840707779*x_54) + 8.64268664740009*std::exp(0.459519863128662*x_54) - 0.0434574659831517*std::exp(0.508319854736328*x_54) - 0.075889162030894*std::exp(0.512159824371338*x_54) - 304.809650491798*std::exp(0.652319848537445*x_55) + 0.621536884411645*std::exp(0.652479827404022*x_55) + 22.2361449005697*std::exp(0.653519809246063*x_55) - 0.00659151345537981*std::exp(0.700159847736359*x_55) - 4.66099697795167*std::exp(0.471919864416122*x_56) + 0.0202704244939278*std::exp(0.553919851779938*x_56) - 0.0859986804201547*std::exp(0.583439826965332*x_56) - 7.62764889901794*std::exp(0.610639870166779*x_57) + 143.463777135873*std::exp(0.630239844322205*x_57) - 0.0513288676519725*std::exp(0.633599877357483*x_57) - 3.39180843468188*std::exp(0.638239860534668*x_57) + 0.0166284547960033*std::exp(0.663359880447388*x_57) - 0.0782422530405979*std::exp(0.589439868927002*x_58) - 1.77006165641178*std::exp(0.592319846153259*x_58) + 57.3886172241549*std::exp(0.619999825954437*x_58) + 3.51123172334728*std::exp(0.620639801025391*x_58) + 0.00195726451141258*std::exp(0.712479829788208*x_58) + 0.34763990888386*std::exp(0.610799849033356*x_59) + 0.00345963653872756*std::exp(0.726239860057831*x_59) + 0.315531986814651*std::exp(0.798399865627289*x_60) + 0.00569066280731493*std::exp(0.802639901638031*x_60) - 6.61602468647057*std::exp(0.808239877223969*x_60) + 0.0109112233310364*std::exp(0.813839852809906*x_60) - 1.13960369078689*std::exp(0.834959864616394*x_60) + 0.554254945393507*std::exp(1.13743984699249*x_61) - 1.42298687722858*std::exp(1.35527992248535*x_61) + 0.0015320249488887*std::exp(1.38071978092194*x_61) - 0.000460594549983585*std::exp(1.79559993743896*x_61) + 0.00404254040049195*std::exp(0.925839841365814*x_66) + 1.13653344391447*std::exp(1.02399981021881*x_66) + 0.86326271426529*std::exp(1.04943978786469*x_66) - 7.95319344513994*std::exp(0.33927983045578*x_8) + 0.00221563503153656*std::exp(0.773439824581146*x_8) + 0.0849766713088918*std::log(5.44279956817627 - 0.804559826850891*x_5) - 0.119674863469413*std::log(9.53880023956299 - 1.21599996089935*x_21) + 9.12296773298209*std::sin(0.276399940252304*x_100 + 1.92679977416992) - 16.2585274622037*std::sin(0.231199979782104*x_101 + 1.96639978885651) + 0.17177306480092*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 181.707791390776*std::sin(0.222479999065399*x_110 - 1.2066398859024) - 23.4104613371607*std::sin(0.268559962511063*x_120 + 1.97511982917786) - 0.0373791743255762*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 5167.69709504726*std::sin(0.0630401000380516*x_30 + 1.65183997154236) - 0.0335707498864571*std::sin(0.320079833269119*x_31 + 5.15208005905151) - 18.1049568570771*std::sin(0.385919839143753*x_31 - 7.40183973312378) - 24.2896153213464*std::sin(0.273439943790436*x_42 + 5.1384801864624) + 0.0467079833054848*std::sin(0.328239858150482*x_91 + 2.00375986099243) + 10.5321291835264*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.266331458537141*std::sin(0.269759953022003*x_95 + 1.96215975284576) - 8.16908910894369*std::sin(0.273519963026047*x_95 - 1.20119988918304) + 0.0757425000810531*std::sin(0.32551982998848*x_97 - 7.55847978591919) - 12.3214407026381*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 5428.20284264172);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00676904145383782*x_1 - 0.040050088401918*x_10 + 26.2232000228996*x_100 + 12.744874876187*x_101 + 19.8545630112977*x_102 - 38.0902381300475*x_103 + 130.749607652878*x_104 + 21.7265324798798*x_105 + 34.601820101041*x_106 + 12.1386741016535*x_107 - 12.6781036655237*x_108 + 28.652812874907*x_109 - 0.92569858971094*x_110 + 22.6165840305176*x_111 + 9.65360792067933*x_112 + 33.4630389848874*x_113 - 31.532417957405*x_114 - 19.6458133519324*x_115 + 34.8644019719464*x_116 + 19.3088840211834*x_117 - 0.760197821976301*x_118 - 5.80453194925053*x_119 + 3.46041803326456*x_12 - 34.0677658810722*x_120 + 73.2481049293286*x_13 + 16.9183336501445*x_14 - 0.0607439118088824*x_17 + 87.1056074260728*x_18 + 0.10324742726407*x_19 - 12.7315685893526*x_2 + 2.59859957384224*x_20 + 0.376038590886799*x_21 - 0.0689168994151605*x_22 - 13.389264468485*x_24 - 52.1580110468246*x_25 - 0.43263786141524*x_26 + 16.5133928121555*x_27 + 29.3505915935178*x_28 - 76.6398366633494*x_29 - 5.9351872028624*x_3 - 0.0389974457500771*x_30 - 6.04233850530714*x_31 + 0.139924860822694*x_32 - 68.5984335750641*x_33 + 191.913428720115*x_34 + 235.809523979028*x_35 - 111.562281921006*x_36 + 445.157261692275*x_37 - 51.8171744169434*x_38 + 307.664374196598*x_39 + 9.4757744114299*x_4 + 223.541960044349*x_40 + 0.13190824065801*x_42 + 35.0600957332872*x_43 - 11.7217201173981*x_44 + 38.036010500395*x_45 + 0.515139189756386*x_46 - 256.037124866889*x_47 + 158.901968929692*x_48 + 4.39879737185607*x_5 - 0.16001191916493*x_52 - 16.8669858989818*x_53 + 3.7549462123808*x_54 + 0.910896611266855*x_55 - 34.6705266699408*x_56 - 80.5671157797948*x_59 + 10.4803535998913*x_6 + 0.128666780722296*x_61 - 0.789586570722845*x_62 + 13.5328096738638*x_63 + 3.11714361080226*x_64 - 7.63011669469888*x_65 + 7.4957467266568*x_66 + 12.5024859362545*x_67 + 6.25500914260735*x_68 + 10.2349117191914*x_69 + 34.6906867210486*x_7 - 12.1986565329913*x_70 + 11.0771006738879*x_71 - 6.14303106555764*x_72 + 11.406343465111*x_73 - 24.0859923419831*x_74 - 16.3945337794787*x_75 - 18.1961948706137*x_76 - 16.7086253503952*x_77 - 8.37914395225022*x_78 - 70.1243826356458*x_79 + 35.4917455508959*x_8 + 9.06063955328348*x_80 - 22.448647339226*x_81 + 15.9751171940525*x_82 - 32.0699143645*x_83 + 14.1227637822193*x_84 + 41.3832818904296*x_85 + 88.9589627613562*x_86 + 151.609429786045*x_87 - 6.09073098180222*x_88 + 8.23531355546893*x_89 - 16.4970570451146*x_9 + 8.04981860476993*x_90 + 2.76130231225418*x_91 - 16.8145259896449*x_92 + 5.33909699571006*x_93 + 17.5030100978203*x_94 + 16.7350000965447*x_95 + 11.9936999592715*x_96 - 3.77901444491779*x_97 - 15.3801328962889*x_98 + 8.69976516806241*x_99 + 3.91473744550278e-5*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.00181639173538709*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) - 0.0666334624902788*std::exp(0.785679876804352*x_1) - 0.0534470571195683*std::exp(1.17999982833862*x_1) + 0.113717372266965*std::exp(1.20335984230042*x_1) - 0.776220886933301*std::exp(1.76671993732452*x_1) - 0.469557550076967*std::exp(0.52215987443924*x_10) - 0.00248250135581145*std::exp(0.591439843177795*x_10) + 1.02243811462307*std::exp(0.900879800319672*x_10) + 0.00153717615341831*std::exp(0.885119915008545*x_11) - 0.214016320704569*std::exp(0.925119876861572*x_11) + 0.0465379339957019*std::exp(0.944479823112488*x_11) - 0.008164313153065*std::exp(1.00215983390808*x_11) - 0.634340612828733*std::exp(1.00799977779388*x_11) + 0.0139815881426437*std::exp(0.298719853162766*x_12) - 0.0361737125871715*std::exp(0.684399843215942*x_12) - 0.000264400755445493*std::exp(1.34319984912872*x_12) - 1.27624625368356*std::exp(0.298239856958389*x_13) - 0.000242393511178884*std::exp(0.889039874076843*x_13) + 6.03204954778301e-5*std::exp(1.44815993309021*x_13) - 0.0412459884511136*std::exp(0.24711985886097*x_15) + 0.271146972762406*std::exp(0.588559865951538*x_15) + 0.081411058706068*std::exp(0.64167982339859*x_15) + 0.00962892960395769*std::exp(0.977839827537537*x_15) - 1.43111087158171*std::exp(1.00783979892731*x_15) - 0.581479556019403*std::exp(0.590879797935486*x_16) - 0.131024097313298*std::exp(0.653999865055084*x_16) + 14.0201916923406*std::exp(0.721039831638336*x_16) - 0.0138761222657357*std::exp(0.929839789867401*x_16) - 0.0108589422263172*std::exp(0.602319836616516*x_17) - 0.789584147878902*std::exp(0.615119874477386*x_17) - 18.8737415880406*std::exp(0.655999839305878*x_17) - 0.243918831553402*std::exp(0.666399836540222*x_17) - 32.3170934279368*std::exp(0.753679871559143*x_19) - 0.767666566683593*std::exp(0.754959881305695*x_19) + 0.122121212604316*std::exp(0.772639811038971*x_19) - 0.00500244216775631*std::exp(0.822639882564545*x_19) + 0.00307613605698207*std::exp(0.812879860401154*x_2) + 0.0297746072107454*std::exp(0.509519815444946*x_20) - 0.0109146698115024*std::exp(0.882799863815308*x_20) - 0.0791518466246197*std::exp(0.894479870796204*x_20) + 0.000325373586505495*std::exp(0.971199810504913*x_20) + 5.29025949544062*std::exp(0.57015985250473*x_22) + 0.000447789999036049*std::exp(1.32799983024597*x_22) + 0.00151015766756507*std::exp(1.35727989673615*x_22) + 0.011857382896365*std::exp(0.473199844360352*x_23) + 30.0817670266103*std::exp(0.541199862957001*x_23) + 0.251005363294101*std::exp(0.599999845027924*x_23) + 0.0307440069418607*std::exp(0.88975989818573*x_23) + 0.00604547531409352*std::exp(1.0971999168396*x_23) - 1.08462267956346*std::exp(0.481039851903915*x_24) - 0.0133517446548769*std::exp(0.518959879875183*x_24) - 0.394006230985556*std::exp(0.579039871692657*x_24) + 0.46356027267928*std::exp(0.539999842643738*x_25) - 0.0092378668022965*std::exp(0.599599838256836*x_25) + 0.0449287829567716*std::exp(0.719999849796295*x_25) - 0.266910808675864*std::exp(0.472639858722687*x_26) + 4.98552227934288*std::exp(0.830559849739075*x_26) - 0.0348359292365647*std::exp(0.873839855194092*x_26) - 0.000121629413289542*std::exp(0.995279788970947*x_26) - 0.00817196390475029*std::exp(0.952159821987152*x_27) - 0.0328485663916295*std::exp(0.953839838504791*x_27) + 0.00171297883882437*std::exp(0.630799829959869*x_28) + 0.155546102316249*std::exp(0.639919817447662*x_28) - 0.00806756015852893*std::exp(1.00135982036591*x_28) - 0.00209361661519295*std::exp(1.18399977684021*x_29) - 5.16136158591142e-5*std::exp(1.33479988574982*x_29) + 0.258628651771914*std::exp(0.598319828510284*x_3) - 0.894096225907027*std::exp(0.64167982339859*x_3) - 0.000896956653598026*std::exp(0.719519853591919*x_3) - 0.0721488415629021*std::exp(0.833439886569977*x_30) + 0.141130916537466*std::exp(0.888719916343689*x_30) + 0.00026291619585236*std::exp(1.12327992916107*x_30) + 4.45299774062532*std::exp(0.879999876022339*x_32) + 0.497159408107344*std::exp(0.414639860391617*x_33) - 1.20170571640783*std::exp(0.464239865541458*x_33) + 0.0859926072946617*std::exp(0.618639826774597*x_4) - 0.386057400584258*std::exp(0.686719834804535*x_4) + 0.00603508445379541*std::exp(1.15263986587524*x_4) + 6.95251037157247*std::exp(0.735999822616577*x_41) + 0.269574402903527*std::exp(0.797439873218536*x_41) + 0.00452952832693296*std::exp(0.80103987455368*x_41) - 0.0174769287340624*std::exp(0.811199843883514*x_41) + 0.0317871013073476*std::exp(0.823679864406586*x_41) + 1.15080433217033*std::exp(0.798799872398376*x_42) - 0.013823370287169*std::exp(0.846959888935089*x_43) - 0.00572284508854772*std::exp(0.912319839000702*x_44) + 8.36478136976421e-5*std::exp(0.976159811019897*x_44) + 0.0540233150856491*std::exp(0.542799830436707*x_45) + 0.274156978318808*std::exp(0.54535984992981*x_45) + 0.0429003407236119*std::exp(0.739759802818298*x_46) + 6.08974665855915*std::exp(0.763999879360199*x_46) - 0.00733057297893578*std::exp(0.56335985660553*x_47) + 4.23170931159374*std::exp(0.64167982339859*x_49) - 0.00945730078247075*std::exp(0.711119830608368*x_49) + 0.334595631872597*std::exp(0.730319857597351*x_49) - 0.134792540443664*std::exp(0.731119871139526*x_49) + 0.124955350914059*std::exp(0.733759820461273*x_49) - 0.0127159245218287*std::exp(0.500079810619354*x_50) + 0.320486090207077*std::exp(0.545759856700897*x_50) + 0.0968048362764352*std::exp(0.560399830341339*x_50) + 41.651247636452*std::exp(0.56335985660553*x_50) - 0.140713554390304*std::exp(0.596959829330444*x_50) - 0.7290116402757*std::exp(0.485359847545624*x_51) - 13.648809805707*std::exp(0.49431985616684*x_51) - 0.0885846034234239*std::exp(0.494879871606827*x_51) - 1.59796472815451*std::exp(0.500959813594818*x_51) + 85.9719908625245*std::exp(0.503039836883545*x_51) + 0.441165914475262*std::exp(0.511919856071472*x_52) - 2.24246109717692*std::exp(0.670159876346588*x_52) - 0.0175757857582493*std::exp(0.767999827861786*x_52) + 4.72709200307052e-5*std::exp(0.831919848918915*x_52) - 0.00358127687207678*std::exp(0.497679859399796*x_53) + 30.8371737318015*std::exp(0.447279840707779*x_54) - 0.446800792642856*std::exp(0.459519863128662*x_54) - 0.530696796362573*std::exp(0.508319854736328*x_54) - 0.0161195648074626*std::exp(0.512159824371338*x_54) - 236.091003562467*std::exp(0.652319848537445*x_55) + 0.132020222919621*std::exp(0.652479827404022*x_55) - 1.14954152247145*std::exp(0.653519809246063*x_55) - 0.08049468589142*std::exp(0.700159847736359*x_55) + 0.240959464251921*std::exp(0.471919864416122*x_56) + 0.2475397287087*std::exp(0.553919851779938*x_56) - 0.0182669206681266*std::exp(0.583439826965332*x_56) + 0.394326407183562*std::exp(0.610639870166779*x_57) + 111.120192763654*std::exp(0.630239844322205*x_57) - 0.626821306939093*std::exp(0.633599877357483*x_57) - 1.5405100387769*std::exp(0.638239860534668*x_57) + 0.0035320386674321*std::exp(0.663359880447388*x_57) - 0.0166193832533869*std::exp(0.589439868927002*x_58) - 0.803936249192138*std::exp(0.592319846153259*x_58) + 44.4504831512137*std::exp(0.619999825954437*x_58) - 0.181520073693317*std::exp(0.620639801025391*x_58) + 0.0239018539701215*std::exp(0.712479829788208*x_58) + 0.157892988306488*std::exp(0.610799849033356*x_59) + 0.000734859022077247*std::exp(0.726239860057831*x_59) + 0.143310037286578*std::exp(0.798399865627289*x_60) + 0.0694936175568206*std::exp(0.802639901638031*x_60) - 5.12445687104295*std::exp(0.808239877223969*x_60) + 0.00231764545695916*std::exp(0.813839852809906*x_60) + 0.0589140684043516*std::exp(0.834959864616394*x_60) + 0.251734531552493*std::exp(1.13743984699249*x_61) - 1.10217770126066*std::exp(1.35527992248535*x_61) + 0.0187088849735966*std::exp(1.38071978092194*x_61) - 9.7834572154084e-5*std::exp(1.79559993743896*x_61) + 0.0493669658635664*std::exp(0.925839841365814*x_66) - 0.0587553459153653*std::exp(1.02399981021881*x_66) + 0.392081363979568*std::exp(1.04943978786469*x_66) + 0.411156076843242*std::exp(0.33927983045578*x_8) + 0.0270570404082237*std::exp(0.773439824581146*x_8) + 1.03772381129328*std::log(5.44279956817627 - 0.804559826850891*x_5) - 1.46145352039093*std::log(9.53880023956299 - 1.21599996089935*x_21) + 4.14351920125901*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 0.840516757541305*std::sin(0.231199979782104*x_101 + 1.96639978885651) + 2.09766982793178*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 140.742180424245*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 1.21025013497682*std::sin(0.268559962511063*x_120 + 1.97511982917786) - 0.456469506826565*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 4002.6514623407*std::sin(0.0630401000380516*x_30 + 1.65183997154236) - 0.409961533954584*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 0.935971579733277*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 1.25569974029226*std::sin(0.273439943790436*x_42 + 5.1384801864624) + 0.570391681705222*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 0.544479264307487*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.0565712822656779*std::sin(0.269759953022003*x_95 + 1.96215975284576) - 3.71028140956054*std::sin(0.273519963026047*x_95 - 1.20119988918304) + 0.924957340059606*std::sin(0.32551982998848*x_97 - 7.55847978591919) - 5.59621908493444*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 4135.5354885354);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000853160823255183*x_1 + 0.229104059616064*x_10 + 116.766124709316*x_100 + 58.263738775235*x_101 + 87.7054230713377*x_102 - 170.857306614884*x_103 + 641.541937607978*x_104 + 92.6137619194981*x_105 + 155.404791764632*x_106 + 56.7242326946238*x_107 - 55.7476284249227*x_108 + 133.354113564518*x_109 - 3.79755351761515*x_110 + 94.2954212523147*x_111 + 43.8979266059545*x_112 + 147.625767929606*x_113 - 135.712988707279*x_114 - 91.8073733274718*x_115 + 157.01424545984*x_116 + 82.4888554036986*x_117 - 5.17092171142435*x_118 - 22.8587263645785*x_119 + 19.77859472441*x_12 - 153.721547273674*x_120 + 324.21492779602*x_13 + 78.0646059436673*x_14 + 0.18669770622779*x_17 + 394.305478329075*x_18 - 0.317333165910855*x_19 - 55.9825562383547*x_2 + 11.5399226516813*x_20 + 2.10925365165872*x_21 + 0.36202506805272*x_22 - 59.6021840158231*x_24 - 232.989991636384*x_25 + 2.97808071358018*x_26 + 69.306395450038*x_27 + 127.973231471394*x_28 - 338.543171311672*x_29 - 27.2925472761638*x_3 + 0.268440539825354*x_30 - 28.7339362896223*x_31 - 3.45289433012028*x_32 - 306.686108457052*x_33 + 814.467611160789*x_34 + 1042.60082586714*x_35 - 490.223159314742*x_36 + 1977.20470377363*x_37 - 151.528835460401*x_38 + 1353.82012494916*x_39 + 42.0550591262759*x_4 + 598.285551393013*x_40 + 0.577481823804728*x_42 + 158.417914697463*x_43 - 50.8406881933876*x_44 + 162.158390658715*x_45 + 6.44847456362234*x_46 - 1106.39841219834*x_47 + 706.784920459153*x_48 + 21.6883178161027*x_5 + 1.10144870088165*x_52 - 71.596666994778*x_53 + 30.6589691926206*x_54 + 7.43743040856663*x_55 - 159.271275661208*x_56 - 358.780851825776*x_59 + 43.818155773846*x_6 - 0.885683136686341*x_61 - 2.07589379475787*x_62 + 61.3988670101876*x_63 + 11.5350735733098*x_64 - 38.633042309322*x_65 + 33.2816970211118*x_66 + 56.1168967249247*x_67 + 27.1360001929126*x_68 + 45.1738134389465*x_69 + 156.083027731753*x_7 - 56.4706985470585*x_70 + 45.5594837154536*x_71 - 28.8667766256869*x_72 + 46.1509275711874*x_73 - 106.926275456134*x_74 - 69.2575596835676*x_75 - 83.1400805053293*x_76 - 74.906261628416*x_77 - 40.1073736526344*x_78 - 306.269586980751*x_79 + 156.868339005002*x_8 + 40.7353512426144*x_80 - 101.54155283969*x_81 + 73.7868317211546*x_82 - 136.465823222855*x_83 + 66.6161463441378*x_84 + 179.299799498221*x_85 + 353.864439803764*x_86 + 666.220173000083*x_87 - 18.9349392668518*x_88 + 34.7086090981621*x_89 - 72.1589957217349*x_9 + 36.8980617791261*x_90 + 15.9710990598077*x_91 - 72.3346707037176*x_92 + 20.0307862917247*x_93 + 77.7831374560242*x_94 + 73.7391748268664*x_95 + 53.224434184568*x_96 - 13.8593453429952*x_97 - 70.0085940948003*x_98 + 33.9514439533926*x_99 - 4.9340820921394e-6*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) + 0.0125032080589703*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) + 0.204799365639988*std::exp(0.785679876804352*x_1) + 0.367905040683981*std::exp(1.17999982833862*x_1) + 0.928497298177834*std::exp(1.20335984230042*x_1) - 3.44706013423428*std::exp(1.76671993732452*x_1) - 3.83391655904556*std::exp(0.52215987443924*x_10) + 0.000312891110934973*std::exp(0.591439843177795*x_10) + 4.54046744163649*std::exp(0.900879800319672*x_10) - 0.000193743601879561*std::exp(0.885119915008545*x_11) - 1.74743376125196*std::exp(0.925119876861572*x_11) - 0.320345804292535*std::exp(0.944479823112488*x_11) + 0.0250931903002619*std::exp(1.00215983390808*x_11) - 2.81699484620485*std::exp(1.00799977779388*x_11) - 0.00176222044606178*std::exp(0.298719853162766*x_12) + 0.249003255152123*std::exp(0.684399843215942*x_12) + 0.000812641351151017*std::exp(1.34319984912872*x_12) - 10.4204940259511*std::exp(0.298239856958389*x_13) + 3.05509500805084e-5*std::exp(0.889039874076843*x_13) - 0.000185396327119451*std::exp(1.44815993309021*x_13) + 0.00519858855982845*std::exp(0.24711985886097*x_15) + 2.21390300004433*std::exp(0.588559865951538*x_15) - 0.250218622235262*std::exp(0.64167982339859*x_15) - 0.0662811374209459*std::exp(0.977839827537537*x_15) - 6.35531111844774*std::exp(1.00783979892731*x_15) - 4.74775477085573*std::exp(0.590879797935486*x_16) + 0.901909823487404*std::exp(0.653999865055084*x_16) + 62.2611999632299*std::exp(0.721039831638336*x_16) + 0.0426485572167316*std::exp(0.929839789867401*x_16) + 0.00136864638112574*std::exp(0.602319836616516*x_17) - 6.44691952842969*std::exp(0.615119874477386*x_17) - 83.8149595136633*std::exp(0.655999839305878*x_17) + 1.67902542221334*std::exp(0.666399836540222*x_17) - 143.514515371883*std::exp(0.753679871559143*x_19) - 6.26796345059611*std::exp(0.754959881305695*x_19) - 0.840626446299103*std::exp(0.772639811038971*x_19) + 0.000630501040248418*std::exp(0.822639882564545*x_19) - 0.000387712025213231*std::exp(0.812879860401154*x_2) - 0.20495474713814*std::exp(0.509519815444946*x_20) + 0.033546470047114*std::exp(0.882799863815308*x_20) - 0.646271315206032*std::exp(0.894479870796204*x_20) - 4.10096464649559e-5*std::exp(0.971199810504913*x_20) + 23.4931099039785*std::exp(0.57015985250473*x_22) - 0.00137629209582037*std::exp(1.32799983024597*x_22) + 0.0123303703401177*std::exp(1.35727989673615*x_22) - 0.001494488491835*std::exp(0.473199844360352*x_23) + 133.587824845097*std::exp(0.541199862957001*x_23) + 2.04944765255028*std::exp(0.599999845027924*x_23) - 0.211627650507116*std::exp(0.88975989818573*x_23) - 0.018580897090545*std::exp(1.0971999168396*x_23) - 8.85589604684897*std::exp(0.481039851903915*x_24) + 0.00168283582532788*std::exp(0.518959879875183*x_24) + 2.71215827872796*std::exp(0.579039871692657*x_24) + 3.78494905523178*std::exp(0.539999842643738*x_25) + 0.00116432822873326*std::exp(0.599599838256836*x_25) - 0.138089570984938*std::exp(0.719999849796295*x_25) + 0.820356053195465*std::exp(0.472639858722687*x_26) + 22.1398256433885*std::exp(0.830559849739075*x_26) - 0.284433816319028*std::exp(0.873839855194092*x_26) + 1.53300066311924e-5*std::exp(0.995279788970947*x_26) + 0.0562520534314775*std::exp(0.952159821987152*x_27) - 0.268207086882391*std::exp(0.953839838504791*x_27) - 0.000215901534407285*std::exp(0.630799829959869*x_28) - 0.478074257161529*std::exp(0.639919817447662*x_28) + 0.0555333859019407*std::exp(1.00135982036591*x_28) + 0.00643477524145485*std::exp(1.18399977684021*x_29) + 6.50531028622559e-6*std::exp(1.33479988574982*x_29) - 0.794900667617879*std::exp(0.598319828510284*x_3) - 7.30025600764637*std::exp(0.64167982339859*x_3) + 0.000113051202629884*std::exp(0.719519853591919*x_3) + 0.221751000646231*std::exp(0.833439886569977*x_30) + 1.15232767062861*std::exp(0.888719916343689*x_30) - 3.31376014802427e-5*std::exp(1.12327992916107*x_30) + 19.7749780351683*std::exp(0.879999876022339*x_32) - 1.52803002571254*std::exp(0.414639860391617*x_33) - 9.81187384694486*std::exp(0.464239865541458*x_33) - 0.591933688967901*std::exp(0.618639826774597*x_4) - 3.15214154388415*std::exp(0.686719834804535*x_4) - 0.0185489605601896*std::exp(1.15263986587524*x_4) + 30.874873039531*std::exp(0.735999822616577*x_41) + 2.20106303693177*std::exp(0.797439873218536*x_41) - 0.000570895619818195*std::exp(0.80103987455368*x_41) + 0.053715712560989*std::exp(0.811199843883514*x_41) - 0.21880783395694*std::exp(0.823679864406586*x_41) + 5.11051918662079*std::exp(0.798799872398376*x_42) - 0.112867204961582*std::exp(0.846959888935089*x_43) - 0.0467267761880077*std::exp(0.912319839000702*x_44) - 1.0542857224979e-5*std::exp(0.976159811019897*x_44) - 0.166041809112415*std::exp(0.542799830436707*x_45) + 2.23847956183876*std::exp(0.54535984992981*x_45) - 0.295306279707185*std::exp(0.739759802818298*x_46) + 27.0434914695995*std::exp(0.763999879360199*x_46) + 0.000923935496671416*std::exp(0.56335985660553*x_47) + 18.7922751284019*std::exp(0.64167982339859*x_49) + 0.00119198539060061*std::exp(0.711119830608368*x_49) + 2.73195848604797*std::exp(0.730319857597351*x_49) + 0.414287742887327*std::exp(0.731119871139526*x_49) - 0.860135355233371*std::exp(0.733759820461273*x_49) + 0.00160269791631181*std::exp(0.500079810619354*x_50) + 2.61675470448144*std::exp(0.545759856700897*x_50) - 0.666360116872526*std::exp(0.560399830341339*x_50) + 184.965848878362*std::exp(0.56335985660553*x_50) + 0.432486105315126*std::exp(0.596959829330444*x_50) + 5.01818194731867*std::exp(0.485359847545624*x_51) - 111.441926376833*std::exp(0.49431985616684*x_51) + 0.0111650835202985*std::exp(0.494879871606827*x_51) + 4.91137861384382*std::exp(0.500959813594818*x_51) + 381.786457117621*std::exp(0.503039836883545*x_51) + 3.6021001142798*std::exp(0.511919856071472*x_52) - 9.95837445342285*std::exp(0.670159876346588*x_52) + 0.0540195517295674*std::exp(0.767999827861786*x_52) - 5.95796278165216e-6*std::exp(0.831919848918915*x_52) + 0.000451379289862888*std::exp(0.497679859399796*x_53) + 136.942452867135*std::exp(0.447279840707779*x_54) + 3.07557183975844*std::exp(0.459519863128662*x_54) + 1.631107902551*std::exp(0.508319854736328*x_54) + 0.00203168813124239*std::exp(0.512159824371338*x_54) - 1048.43853100474*std::exp(0.652319848537445*x_55) - 0.0166396502134844*std::exp(0.652479827404022*x_55) + 7.91291688233928*std::exp(0.653519809246063*x_55) + 0.247402130879181*std::exp(0.700159847736359*x_55) - 1.65865449430585*std::exp(0.471919864416122*x_56) - 0.760818626491647*std::exp(0.553919851779938*x_56) + 0.00230233795757301*std::exp(0.583439826965332*x_56) - 2.71436222490389*std::exp(0.610639870166779*x_57) + 493.465188881129*std::exp(0.630239844322205*x_57) + 1.92654863237046*std::exp(0.633599877357483*x_57) - 12.5781961041294*std::exp(0.638239860534668*x_57) - 0.000445173373191121*std::exp(0.663359880447388*x_57) + 0.00209468457168539*std::exp(0.589439868927002*x_58) - 6.56410379875587*std::exp(0.592319846153259*x_58) + 197.396760377523*std::exp(0.619999825954437*x_58) + 1.24950097715761*std::exp(0.620639801025391*x_58) - 0.0734628570654674*std::exp(0.712479829788208*x_58) + 1.28918924278016*std::exp(0.610799849033356*x_59) - 9.26206365447003e-5*std::exp(0.726239860057831*x_59) + 1.1701200948433*std::exp(0.798399865627289*x_60) - 0.213590113131839*std::exp(0.802639901638031*x_60) - 22.7568096750957*std::exp(0.808239877223969*x_60) - 0.000292112896568515*std::exp(0.813839852809906*x_60) - 0.405537440249936*std::exp(0.834959864616394*x_60) + 2.0554012790221*std::exp(1.13743984699249*x_61) - 4.89457689017853*std::exp(1.35527992248535*x_61) - 0.0575021562924646*std::exp(1.38071978092194*x_61) + 1.23309370597033e-5*std::exp(1.79559993743896*x_61) - 0.151730420641196*std::exp(0.925839841365814*x_66) + 0.40444486739532*std::exp(1.02399981021881*x_66) + 3.20132693768429*std::exp(1.04943978786469*x_66) - 2.83020995599581*std::exp(0.33927983045578*x_8) - 0.0831603897592469*std::exp(0.773439824581146*x_8) - 3.18946622792385*std::log(5.44279956817627 - 0.804559826850891*x_5) + 4.49180851035702*std::log(9.53880023956299 - 1.21599996089935*x_21) + 33.8316504032919*std::sin(0.276399940252304*x_100 + 1.92679977416992) - 5.78573205980288*std::sin(0.231199979782104*x_101 + 1.96639978885651) - 6.44723287710356*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 625.011214607153*std::sin(0.222479999065399*x_110 - 1.2066398859024) - 8.33080714154837*std::sin(0.268559962511063*x_120 + 1.97511982917786) + 1.40296874780772*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 17775.0695959496*std::sin(0.0630401000380516*x_30 + 1.65183997154236) + 1.26002550299625*std::sin(0.320079833269119*x_31 + 5.15208005905151) - 6.44279929857442*std::sin(0.385919839143753*x_31 - 7.40183973312378) - 8.64366139010386*std::sin(0.273439943790436*x_42 + 5.1384801864624) - 1.75311097778534*std::sin(0.328239858150482*x_91 + 2.00375986099243) + 3.74794566216237*std::sin(0.307119935750961*x_92 + 8.21607971191406) + 0.00713016785013523*std::sin(0.269759953022003*x_95 + 1.96215975284576) - 30.294283059662*std::sin(0.273519963026047*x_95 - 1.20119988918304) - 2.84287607770487*std::sin(0.32551982998848*x_97 - 7.55847978591919) - 45.6928804877275*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 18382.1970964793);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0161688663334578*x_1 + 0.884414090480668*x_10 - 126.184214262249*x_100 - 62.4238154616705*x_101 - 93.8568209188229*x_102 + 185.070166018817*x_103 - 557.199188976144*x_104 - 109.52337698023*x_105 - 154.440300811677*x_106 - 54.4488833171202*x_107 + 63.5966212102172*x_108 - 136.904573761283*x_109 + 2.60278375415213*x_110 - 115.585538109041*x_111 - 50.0309407744828*x_112 - 160.02567262598*x_113 + 157.311871400081*x_114 + 93.5719904560716*x_115 - 170.0314509651*x_116 - 96.8682871021764*x_117 + 0.593544551170694*x_118 + 33.6358807595167*x_119 - 17.7919113134908*x_12 + 165.942378056791*x_120 - 358.378628937123*x_13 - 76.3450077339633*x_14 - 0.152277587547789*x_17 - 427.404335932775*x_18 + 0.25882872334194*x_19 + 62.8480084320443*x_2 - 12.6203853326817*x_20 - 2.83296340985175*x_21 + 1.67993037742825*x_22 + 65.1663924918822*x_24 + 249.931212478079*x_25 + 14.2285101866857*x_26 - 76.2013616010739*x_27 - 142.015209133756*x_28 + 377.503634978037*x_29 + 26.5094287557018*x_3 + 1.28254044224098*x_30 + 29.7565177844724*x_31 + 9.0904935995529*x_32 + 327.857592366571*x_33 - 874.099631046303*x_34 - 1173.37284477448*x_35 + 558.85416765046*x_36 - 2095.16235251468*x_37 + 311.123181503642*x_38 - 1495.82187871624*x_39 - 45.9801879436742*x_4 - 1308.74479634565*x_40 - 0.389872320814472*x_42 - 175.461428535766*x_43 + 63.1515358201072*x_44 - 201.774603201273*x_45 - 4.49285825779928*x_46 + 1252.87878253684*x_47 - 773.814583341104*x_48 - 18.0499202653918*x_5 + 5.26244100408069*x_52 + 78.7214475202075*x_53 - 21.3618484009826*x_54 - 5.18208097221022*x_55 + 169.567082506413*x_56 + 377.738460851826*x_59 - 56.5846020236004*x_6 - 4.23156816235767*x_61 + 4.93442438160118*x_62 - 68.0757118200306*x_63 - 17.6159892776628*x_64 + 34.6164167553417*x_65 - 36.395047326644*x_66 - 62.8819629379483*x_67 - 26.8693185773921*x_68 - 54.5058756860761*x_69 - 164.618167808957*x_7 + 55.8682784687973*x_70 - 58.5778341004998*x_71 + 28.4306013394839*x_72 - 62.0112206012256*x_73 + 119.692424216884*x_74 + 81.011939077151*x_75 + 88.5345654424062*x_76 + 81.2758229427267*x_77 + 36.0266922242501*x_78 + 338.866495779061*x_79 - 172.20992294719*x_8 - 44.1394774366343*x_80 + 108.333130737965*x_81 - 75.4270134123791*x_82 + 153.219145977154*x_83 - 71.5003038124483*x_84 - 204.840334772418*x_85 - 391.605657775936*x_86 - 738.994896158764*x_87 + 44.3963172817974*x_88 - 44.6246041473774*x_89 + 78.191390436113*x_9 - 36.4698126550425*x_90 - 9.58550416121289*x_91 + 80.9645767150011*x_92 - 22.7013234916789*x_93 - 86.1721622673951*x_94 - 82.2478871891755*x_95 - 60.8900115809977*x_96 + 19.5523399000117*x_97 + 67.4104394126273*x_98 - 29.2699560879867*x_99 + 9.35093497632953e-5*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) + 0.0597371395684705*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) - 0.167041973686193*std::exp(0.785679876804352*x_1) + 1.75775646215174*std::exp(1.17999982833862*x_1) - 0.646936901230549*std::exp(1.20335984230042*x_1) + 3.76980231774985*std::exp(1.76671993732452*x_1) + 2.67130782518483*std::exp(0.52215987443924*x_10) - 0.00592982520028527*std::exp(0.591439843177795*x_10) - 4.96558343011071*std::exp(0.900879800319672*x_10) + 0.00367177478895597*std::exp(0.885119915008545*x_11) + 1.21753653438577*std::exp(0.925119876861572*x_11) - 1.5305305591126*std::exp(0.944479823112488*x_11) - 0.0204669385607732*std::exp(1.00215983390808*x_11) + 3.08074512389422*std::exp(1.00799977779388*x_11) + 0.033397111149274*std::exp(0.298719853162766*x_12) + 1.18967405292069*std::exp(0.684399843215942*x_12) - 0.000662820486631309*std::exp(1.34319984912872*x_12) + 7.26055113748869*std::exp(0.298239856958389*x_13) - 0.000578993098074*std::exp(0.889039874076843*x_13) + 0.000151216134383169*std::exp(1.44815993309021*x_13) - 0.098522202678976*std::exp(0.24711985886097*x_15) - 1.542552196204*std::exp(0.588559865951538*x_15) + 0.204087607305835*std::exp(0.64167982339859*x_15) - 0.316674371745045*std::exp(0.977839827537537*x_15) + 6.95034773150765*std::exp(1.00783979892731*x_15) + 3.30803090680796*std::exp(0.590879797935486*x_16) + 4.30909513380349*std::exp(0.653999865055084*x_16) - 68.0906067162096*std::exp(0.721039831638336*x_16) - 0.0347857482374953*std::exp(0.929839789867401*x_16) - 0.0259382050734107*std::exp(0.602319836616516*x_17) + 4.4919356797161*std::exp(0.615119874477386*x_17) + 91.6624069010927*std::exp(0.655999839305878*x_17) + 8.02195528641219*std::exp(0.666399836540222*x_17) + 156.951527275822*std::exp(0.753679871559143*x_19) + 4.36724679728507*std::exp(0.754959881305695*x_19) - 4.01629878593354*std::exp(0.772639811038971*x_19) - 0.0119490801323792*std::exp(0.822639882564545*x_19) + 0.00734781033150173*std::exp(0.812879860401154*x_2) - 0.979221514771781*std::exp(0.509519815444946*x_20) - 0.0273617476761389*std::exp(0.882799863815308*x_20) + 0.450293999599236*std::exp(0.894479870796204*x_20) + 0.000777203399406331*std::exp(0.971199810504913*x_20) - 25.6927285043849*std::exp(0.57015985250473*x_22) + 0.00112255498124284*std::exp(1.32799983024597*x_22) - 0.00859127064183763*std::exp(1.35727989673615*x_22) + 0.0283231297109661*std::exp(0.473199844360352*x_23) - 146.095418157269*std::exp(0.541199862957001*x_23) - 1.42796679772477*std::exp(0.599999845027924*x_23) - 1.01110294536139*std::exp(0.88975989818573*x_23) + 0.0151552701990335*std::exp(1.0971999168396*x_23) + 6.17040669629502*std::exp(0.481039851903915*x_24) - 0.0318926359242145*std::exp(0.518959879875183*x_24) + 12.9580006078454*std::exp(0.579039871692657*x_24) - 2.63718937891638*std::exp(0.539999842643738*x_25) - 0.0220660243479428*std::exp(0.599599838256836*x_25) + 0.112630985993151*std::exp(0.719999849796295*x_25) - 0.669112884324429*std::exp(0.472639858722687*x_26) - 24.2127386163409*std::exp(0.830559849739075*x_26) + 0.198181224755021*std::exp(0.873839855194092*x_26) - 0.000290530016562463*std::exp(0.995279788970947*x_26) + 0.268757966035636*std::exp(0.952159821987152*x_27) + 0.18687513901902*std::exp(0.953839838504791*x_27) + 0.00409170575566349*std::exp(0.630799829959869*x_28) + 0.389935131074593*std::exp(0.639919817447662*x_28) + 0.26532435585233*std::exp(1.00135982036591*x_28) - 0.00524844182598284*std::exp(1.18399977684021*x_29) - 0.000123286828940795*std::exp(1.33479988574982*x_29) + 0.64835052583501*std::exp(0.598319828510284*x_3) + 5.08650376155633*std::exp(0.64167982339859*x_3) - 0.00214251490965675*std::exp(0.719519853591919*x_3) - 0.180868357180116*std::exp(0.833439886569977*x_30) - 0.802892258169939*std::exp(0.888719916343689*x_30) + 0.000628014595069117*std::exp(1.12327992916107*x_30) - 21.6264744818528*std::exp(0.879999876022339*x_32) + 1.24631807598211*std::exp(0.414639860391617*x_33) + 6.8364908269144*std::exp(0.464239865541458*x_33) - 2.82810821241882*std::exp(0.618639826774597*x_4) + 2.1962763775861*std::exp(0.686719834804535*x_4) + 0.015129221578001*std::exp(1.15263986587524*x_4) - 33.765633151773*std::exp(0.735999822616577*x_41) - 1.53360586328062*std::exp(0.797439873218536*x_41) + 0.0108194548033484*std::exp(0.80103987455368*x_41) - 0.0438125314309853*std::exp(0.811199843883514*x_41) - 1.04540803081196*std::exp(0.823679864406586*x_41) - 5.5890081183361*std::exp(0.798799872398376*x_42) + 0.0786410040952153*std::exp(0.846959888935089*x_43) + 0.0325572038291202*std::exp(0.912319839000702*x_44) + 0.00019980529414491*std::exp(0.976159811019897*x_44) + 0.13542987021415*std::exp(0.542799830436707*x_45) - 1.55967608526796*std::exp(0.54535984992981*x_45) - 1.41089809616162*std::exp(0.739759802818298*x_46) - 29.5755260575954*std::exp(0.763999879360199*x_46) - 0.0175101682346574*std::exp(0.56335985660553*x_47) - 20.5517628286399*std::exp(0.64167982339859*x_49) - 0.0225901751776654*std::exp(0.711119830608368*x_49) - 1.90351093182811*std::exp(0.730319857597351*x_49) - 0.337908479499629*std::exp(0.731119871139526*x_49) - 4.10950737770761*std::exp(0.733759820461273*x_49) - 0.0303738845894077*std::exp(0.500079810619354*x_50) - 1.82324190185575*std::exp(0.545759856700897*x_50) - 3.18369870490298*std::exp(0.560399830341339*x_50) - 202.283876304093*std::exp(0.56335985660553*x_50) - 0.352751740211384*std::exp(0.596959829330444*x_50) + 23.9755936199019*std::exp(0.485359847545624*x_51) + 77.647931403655*std::exp(0.49431985616684*x_51) - 0.211597553615754*std::exp(0.494879871606827*x_51) - 4.00590292168581*std::exp(0.500959813594818*x_51) - 417.532452257965*std::exp(0.503039836883545*x_51) - 2.50978811723807*std::exp(0.511919856071472*x_52) + 10.8907595555694*std::exp(0.670159876346588*x_52) - 0.0440603539486181*std::exp(0.767999827861786*x_52) + 0.000112913651459869*std::exp(0.831919848918915*x_52) - 0.0085544146010338*std::exp(0.497679859399796*x_53) - 149.764134106571*std::exp(0.447279840707779*x_54) + 14.6942979256188*std::exp(0.459519863128662*x_54) - 1.33039222307076*std::exp(0.508319854736328*x_54) - 0.0385039876772511*std::exp(0.512159824371338*x_54) + 1146.60198844424*std::exp(0.652319848537445*x_55) + 0.315350017023519*std::exp(0.652479827404022*x_55) + 37.8058989312648*std::exp(0.653519809246063*x_55) - 0.201790372285015*std::exp(0.700159847736359*x_55) - 7.92462818781402*std::exp(0.471919864416122*x_56) + 0.620551946483023*std::exp(0.553919851779938*x_56) - 0.0436332678150996*std::exp(0.583439826965332*x_56) - 12.9685305006291*std::exp(0.610639870166779*x_57) - 539.667467445032*std::exp(0.630239844322205*x_57) - 1.57136466193604*std::exp(0.633599877357483*x_57) + 8.76394495346947*std::exp(0.638239860534668*x_57) + 0.00843680179649885*std::exp(0.663359880447388*x_57) - 0.0396978786732303*std::exp(0.589439868927002*x_58) + 4.57358462890159*std::exp(0.592319846153259*x_58) - 215.878672204482*std::exp(0.619999825954437*x_58) + 5.96979702420077*std::exp(0.620639801025391*x_58) + 0.0599190363627097*std::exp(0.712479829788208*x_58) - 0.898251503220005*std::exp(0.610799849033356*x_59) + 0.00175532051072991*std::exp(0.726239860057831*x_59) - 0.815289252549374*std::exp(0.798399865627289*x_60) + 0.174212034035877*std::exp(0.802639901638031*x_60) + 24.8874897788299*std::exp(0.808239877223969*x_60) + 0.00553604226794507*std::exp(0.813839852809906*x_60) - 1.93755447035613*std::exp(0.834959864616394*x_60) - 1.43211502806246*std::exp(1.13743984699249*x_61) + 5.35284752411163*std::exp(1.35527992248535*x_61) + 0.0469008956560446*std::exp(1.38071978092194*x_61) - 0.000233692485226774*std::exp(1.79559993743896*x_61) + 0.12375696991511*std::exp(0.925839841365814*x_66) + 1.93233443588201*std::exp(1.02399981021881*x_66) - 2.23054664020647*std::exp(1.04943978786469*x_66) - 13.5220214165835*std::exp(0.33927983045578*x_8) + 0.0678287044224384*std::exp(0.773439824581146*x_8) + 2.60144718736292*std::log(5.44279956817627 - 0.804559826850891*x_5) - 3.66368595257001*std::log(9.53880023956299 - 1.21599996089935*x_21) - 23.5724359331726*std::sin(0.276399940252304*x_100 + 1.92679977416992) - 27.6427523186143*std::sin(0.231199979782104*x_101 + 1.96639978885651) + 5.25860273658781*std::sin(0.231199979782104*x_102 + 1.9916797876358) - 683.529916419368*std::sin(0.222479999065399*x_110 - 1.2066398859024) - 39.8024720204223*std::sin(0.268559962511063*x_120 + 1.97511982917786) - 1.14431345000264*std::sin(0.299279928207397*x_120 - 7.47304010391235) - 19439.3181295228*std::sin(0.0630401000380516*x_30 + 1.65183997154236) - 1.02772362725686*std::sin(0.320079833269119*x_31 + 5.15208005905151) - 30.7820520217977*std::sin(0.385919839143753*x_31 - 7.40183973312378) - 41.2972098367015*std::sin(0.273439943790436*x_42 + 5.1384801864624) + 1.42990246529853*std::sin(0.328239858150482*x_91 + 2.00375986099243) + 17.9067285819504*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.135128955481202*std::sin(0.269759953022003*x_95 + 1.96215975284576) + 21.107750820687*std::sin(0.273519963026047*x_95 - 1.20119988918304) + 2.31875538032605*std::sin(0.32551982998848*x_97 - 7.55847978591919) + 31.8368298637381*std::sin(0.267439961433411*x_98 + 1.9625598192215) + 19709.3174189311);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0307380283064997*x_1 - 0.105832143004184*x_10 - 46.3312195907462*x_100 - 22.9403437933305*x_101 - 35.0882982574128*x_102 + 67.6666720994896*x_103 - 254.469130899714*x_104 - 36.7362442498498*x_105 - 62.4890051683581*x_106 - 22.6085164085939*x_107 + 22.0456646080127*x_108 - 52.4775375638614*x_109 + 1.68323856375731*x_110 - 37.5802775354406*x_111 - 17.1408847502592*x_112 - 58.8829907631792*x_113 + 53.8634723514455*x_114 + 36.0839665087054*x_115 - 62.0334201159929*x_116 - 32.7728411613208*x_117 + 2.12692978839352*x_118 + 8.91059104071348*x_119 - 7.39446765977504*x_12 + 60.6838983088393*x_120 - 128.501882729292*x_13 - 31.0966446113079*x_14 + 0.00451901802225674*x_17 - 155.237627026619*x_18 - 0.00768104935398228*x_19 + 22.1708849138009*x_2 - 4.57753194738497*x_20 - 0.745763491217573*x_21 - 0.276105906185067*x_22 + 23.617764938896*x_24 + 92.5532956680248*x_25 - 1.65974807820645*x_26 - 28.0859810920315*x_27 - 51.0051334690535*x_28 + 134.05185396988*x_29 + 10.9174601146911*x_3 - 0.149607654371534*x_30 + 11.1926117199256*x_31 + 0.238531127535551*x_32 + 121.805928449535*x_33 - 331.091918319984*x_34 - 412.139909593371*x_35 + 193.270235283889*x_36 - 789.450699352272*x_37 + 63.8583932504418*x_38 - 538.269635328218*x_39 - 16.6571806301349*x_4 - 253.652805088298*x_40 - 0.263127707396196*x_42 - 62.2296921302341*x_43 + 19.7969980752253*x_44 - 63.736478348338*x_45 - 1.83538628079982*x_46 + 440.927047194818*x_47 - 280.356328217762*x_48 - 8.73012302467876*x_5 - 0.613860919280987*x_52 + 28.9419412033381*x_53 - 10.7315593659253*x_54 - 2.60332385795546*x_55 + 62.6354943892551*x_56 + 143.279644565542*x_59 - 17.2205890967646*x_6 + 0.493610155464122*x_61 + 0.879829315981836*x_62 - 24.0973376126298*x_63 - 4.54659128633189*x_64 + 15.1166832606492*x_65 - 13.1963243287072*x_66 - 22.0342403121129*x_67 - 11.040318353296*x_68 - 17.5761541302494*x_69 - 62.1400382587187*x_7 + 22.4220556334161*x_70 - 18.005733208718*x_71 + 11.4566423920744*x_72 - 18.1688190136133*x_73 + 42.1785382167521*x_74 + 27.6800477098592*x_75 + 32.7302659975849*x_76 + 29.6161657198819*x_77 + 15.9870141781587*x_78 + 122.114971382278*x_79 - 62.3062733053213*x_8 - 16.0724350857455*x_80 + 40.2027290737463*x_81 - 29.1926072735625*x_82 + 54.8451548430776*x_83 - 25.8271221367812*x_84 - 71.2491719533695*x_85 - 147.026465858827*x_86 - 264.82885126258*x_87 + 7.00630793231005*x_88 - 13.5762310069514*x_89 + 28.8977293055129*x_9 - 14.7015864249112*x_90 - 6.28978345194051*x_91 + 28.9494356976968*x_92 - 8.58525334429836*x_93 - 30.7646101936743*x_94 - 29.2293965461426*x_95 - 20.8926217734021*x_96 + 5.6163877344273*x_97 + 28.1743723192644*x_98 - 14.9403343776079*x_99 + 0.000177767134730952*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.00696830527549524*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) + 0.00495716869249942*std::exp(0.785679876804352*x_1) - 0.205041348091476*std::exp(1.17999982833862*x_1) - 0.325001920772176*std::exp(1.20335984230042*x_1) + 1.36734260404385*std::exp(1.76671993732452*x_1) + 1.34198586061088*std::exp(0.52215987443924*x_10) - 0.0112729693659347*std::exp(0.591439843177795*x_10) - 1.80106361173263*std::exp(0.900879800319672*x_10) + 0.00698027400749027*std::exp(0.885119915008545*x_11) + 0.611654261077087*std::exp(0.925119876861572*x_11) + 0.178535568432208*std::exp(0.944479823112488*x_11) + 0.000607380676999031*std::exp(1.00215983390808*x_11) + 1.11741510695852*std::exp(1.00799977779388*x_11) + 0.0634900015060091*std::exp(0.298719853162766*x_12) - 0.138774839889765*std::exp(0.684399843215942*x_12) + 1.96699840918339e-5*std::exp(1.34319984912872*x_12) + 3.64748565286664*std::exp(0.298239856958389*x_13) - 0.00110070216865108*std::exp(0.889039874076843*x_13) - 4.48751814063957e-6*std::exp(1.44815993309021*x_13) - 0.187296882311317*std::exp(0.24711985886097*x_15) - 0.774932494504556*std::exp(0.588559865951538*x_15) - 0.00605654180885212*std::exp(0.64167982339859*x_15) + 0.0369398955354373*std::exp(0.977839827537537*x_15) + 2.52095621074435*std::exp(1.00783979892731*x_15) + 1.66185666120036*std::exp(0.590879797935486*x_16) - 0.502653635082021*std::exp(0.653999865055084*x_16) - 24.6971007100022*std::exp(0.721039831638336*x_16) + 0.00103230833725674*std::exp(0.929839789867401*x_16) - 0.0493101535582912*std::exp(0.602319836616516*x_17) + 2.25661532232267*std::exp(0.615119874477386*x_17) + 33.2468133819487*std::exp(0.655999839305878*x_17) - 0.935756779549533*std::exp(0.666399836540222*x_17) + 56.9277887605728*std::exp(0.753679871559143*x_19) + 2.19397532418384*std::exp(0.754959881305695*x_19) + 0.468499098218578*std::exp(0.772639811038971*x_19) - 0.0227159502571728*std::exp(0.822639882564545*x_19) + 0.0139686479746035*std::exp(0.812879860401154*x_2) + 0.114225664244294*std::exp(0.509519815444946*x_20) + 0.00081199231521913*std::exp(0.882799863815308*x_20) + 0.226214356459756*std::exp(0.894479870796204*x_20) + 0.00147751237459519*std::exp(0.971199810504913*x_20) - 9.31899323547195*std::exp(0.57015985250473*x_22) - 3.33131504964145e-5*std::exp(1.32799983024597*x_22) - 0.0043159996827508*std::exp(1.35727989673615*x_22) + 0.0538440447728133*std::exp(0.473199844360352*x_23) - 52.9901763181234*std::exp(0.541199862957001*x_23) - 0.717368187185931*std::exp(0.599999845027924*x_23) + 0.117944616014879*std::exp(0.88975989818573*x_23) - 0.000449750618357475*std::exp(1.0971999168396*x_23) + 3.09982940287822*std::exp(0.481039851903915*x_24) - 0.0606298998080557*std::exp(0.518959879875183*x_24) - 1.5115438175948*std::exp(0.579039871692657*x_24) - 1.32484576464493*std::exp(0.539999842643738*x_25) - 0.0419488953047659*std::exp(0.599599838256836*x_25) - 0.00334245809750473*std::exp(0.719999849796295*x_25) + 0.0198567184565972*std::exp(0.472639858722687*x_26) - 8.78218704328822*std::exp(0.830559849739075*x_26) + 0.0995603722462732*std::exp(0.873839855194092*x_26) - 0.000552315770865488*std::exp(0.995279788970947*x_26) - 0.0313504725215526*std::exp(0.952159821987152*x_27) + 0.0938805299407471*std::exp(0.953839838504791*x_27) + 0.00777858909496934*std::exp(0.630799829959869*x_28) - 0.0115717875047378*std::exp(0.639919817447662*x_28) - 0.0309499437361578*std::exp(1.00135982036591*x_28) + 0.000155753736201916*std::exp(1.18399977684021*x_29) - 0.000234375988993059*std::exp(1.33479988574982*x_29) - 0.0192405708428271*std::exp(0.598319828510284*x_3) + 2.55530870070369*std::exp(0.64167982339859*x_3) - 0.00407305512841374*std::exp(0.719519853591919*x_3) + 0.00536748302173098*std::exp(0.833439886569977*x_30) - 0.403349268811222*std::exp(0.888719916343689*x_30) + 0.00119389510693055*std::exp(1.12327992916107*x_30) - 7.84412482189648*std::exp(0.879999876022339*x_32) - 0.0369859671244132*std::exp(0.414639860391617*x_33) + 3.43445032407686*std::exp(0.464239865541458*x_33) + 0.329897305405479*std::exp(0.618639826774597*x_4) + 1.10334414361635*std::exp(0.686719834804535*x_4) - 0.000448977594632865*std::exp(1.15263986587524*x_4) - 12.2471113521126*std::exp(0.735999822616577*x_41) - 0.770438122057361*std::exp(0.797439873218536*x_41) + 0.0205684617058179*std::exp(0.80103987455368*x_41) + 0.00130018883491424*std::exp(0.811199843883514*x_41) + 0.121946285824455*std::exp(0.823679864406586*x_41) - 2.02718558439143*std::exp(0.798799872398376*x_42) + 0.0395069091495358*std::exp(0.846959888935089*x_43) + 0.0163557740473742*std::exp(0.912319839000702*x_44) + 0.000379842387249256*std::exp(0.976159811019897*x_44) - 0.0040190420278202*std::exp(0.542799830436707*x_45) - 0.783535028733618*std::exp(0.54535984992981*x_45) + 0.164580505824192*std::exp(0.739759802818298*x_46) - 10.7273202695937*std::exp(0.763999879360199*x_46) - 0.0332879272886764*std::exp(0.56335985660553*x_47) - 7.45431684083037*std::exp(0.64167982339859*x_49) - 0.0429453388839642*std::exp(0.711119830608368*x_49) - 0.95626746268181*std::exp(0.730319857597351*x_49) + 0.010027834912035*std::exp(0.731119871139526*x_49) + 0.479371830432954*std::exp(0.733759820461273*x_49) - 0.0577426583306971*std::exp(0.500079810619354*x_50) - 0.915942681594327*std::exp(0.545759856700897*x_50) + 0.371376745542603*std::exp(0.560399830341339*x_50) - 73.3702562809228*std::exp(0.56335985660553*x_50) + 0.0104683262787926*std::exp(0.596959829330444*x_50) - 2.79674013037062*std::exp(0.485359847545624*x_51) + 39.0080188688769*std::exp(0.49431985616684*x_51) - 0.402260211599893*std::exp(0.494879871606827*x_51) + 0.118879920479617*std::exp(0.500959813594818*x_51) - 151.442930536472*std::exp(0.503039836883545*x_51) - 1.26084314758058*std::exp(0.511919856071472*x_52) + 3.95018048044923*std::exp(0.670159876346588*x_52) + 0.00130754326205968*std::exp(0.767999827861786*x_52) + 0.000214655928448227*std::exp(0.831919848918915*x_52) - 0.0162624783166154*std::exp(0.497679859399796*x_53) - 54.320853949679*std::exp(0.447279840707779*x_54) - 1.7140819680096*std::exp(0.459519863128662*x_54) + 0.039480967157036*std::exp(0.508319854736328*x_54) - 0.0731984938664125*std::exp(0.512159824371338*x_54) + 415.883278892196*std::exp(0.652319848537445*x_55) + 0.599500147370636*std::exp(0.652479827404022*x_55) - 4.41003782354887*std::exp(0.653519809246063*x_55) + 0.00598836863492928*std::exp(0.700159847736359*x_55) + 0.924403625724133*std::exp(0.471919864416122*x_56) - 0.0184156150295145*std::exp(0.553919851779938*x_56) - 0.0829495768933596*std::exp(0.583439826965332*x_56) + 1.51277212393764*std::exp(0.610639870166779*x_57) - 195.742444313231*std::exp(0.630239844322205*x_57) + 0.0466321100903823*std::exp(0.633599877357483*x_57) + 4.40274613799491*std::exp(0.638239860534668*x_57) + 0.0160388890036454*std::exp(0.663359880447388*x_57) - 0.075468155478578*std::exp(0.589439868927002*x_58) + 2.2976333339152*std::exp(0.592319846153259*x_58) - 78.3012160663624*std::exp(0.619999825954437*x_58) - 0.696373619458176*std::exp(0.620639801025391*x_58) - 0.00177816847219466*std::exp(0.712479829788208*x_58) - 0.451254926605213*std::exp(0.610799849033356*x_59) + 0.00333697430809651*std::exp(0.726239860057831*x_59) - 0.409577151279287*std::exp(0.798399865627289*x_60) - 0.00516994873756497*std::exp(0.802639901638031*x_60) + 9.02692560882396*std::exp(0.808239877223969*x_60) + 0.010524363330653*std::exp(0.813839852809906*x_60) + 0.22601468926825*std::exp(0.834959864616394*x_60) - 0.719452135133543*std::exp(1.13743984699249*x_61) + 1.94152792527254*std::exp(1.35527992248535*x_61) - 0.00139183970630697*std::exp(1.38071978092194*x_61) - 0.000444264061423572*std::exp(1.79559993743896*x_61) - 0.00367263486657716*std::exp(0.925839841365814*x_66) - 0.225405775047934*std::exp(1.02399981021881*x_66) - 1.12056050761693*std::exp(1.04943978786469*x_66) + 1.57733654227849*std::exp(0.33927983045578*x_8) - 0.0020128972532818*std::exp(0.773439824581146*x_8) - 0.0772010307817145*std::log(5.44279956817627 - 0.804559826850891*x_5) + 0.108724226028055*std::log(9.53880023956299 - 1.21599996089935*x_21) - 11.8420930093613*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 3.2245122247647*std::sin(0.231199979782104*x_101 + 1.96639978885651) - 0.156055273275663*std::sin(0.231199979782104*x_102 + 1.9916797876358) - 247.922701797424*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 4.64293700303069*std::sin(0.268559962511063*x_120 + 1.97511982917786) + 0.0339588588639142*std::sin(0.299279928207397*x_120 - 7.47304010391235) - 7050.82273065288*std::sin(0.0630401000380516*x_30 + 1.65183997154236) + 0.0304989175903202*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 3.59070985058138*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 4.81729736721789*std::sin(0.273439943790436*x_42 + 5.1384801864624) - 0.0424340516211916*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 2.08881028026869*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.256888613768423*std::sin(0.269759953022003*x_95 + 1.96215975284576) + 10.6039082742925*std::sin(0.273519963026047*x_95 - 1.20119988918304) - 0.0688118161158136*std::sin(0.32551982998848*x_97 - 7.55847978591919) + 15.9938795226097*std::sin(0.267439961433411*x_98 + 1.9625598192215) + 7326.02219744636);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0185892529088707*x_1 - 0.17663617231687*x_10 - 14.1327723224942*x_100 - 7.78451770618129*x_101 - 10.0013571987798*x_102 + 20.9589107469354*x_103 - 115.020886587246*x_104 - 9.35833281885225*x_105 - 15.9143530044865*x_106 - 8.74348770676125*x_107 + 6.26511487008908*x_108 - 18.2049311712541*x_109 + 1.93083013218196*x_110 - 8.5621851305285*x_111 - 5.89875390098126*x_112 - 16.898692877346*x_113 + 13.3995549500396*x_114 + 12.1671359800127*x_115 - 18.9595311068675*x_116 - 8.84914581874392*x_117 + 0.607642590087231*x_118 + 1.91383542144969*x_119 - 4.96625816069827*x_12 + 19.7823786497838*x_120 - 38.0543516610785*x_13 - 12.0657864640646*x_14 + 0.0104882448634054*x_17 - 48.9922692263516*x_18 - 0.0178270425202325*x_19 + 5.97055114781534*x_2 - 1.37328260444443*x_20 - 0.521554793036629*x_21 - 0.290248340791107*x_22 + 7.0825907457702*x_24 + 28.4022968976731*x_25 - 2.77937574913019*x_26 - 8.58179219108591*x_27 - 13.8270548051939*x_28 + 39.426366485034*x_29 + 3.71088622103672*x_3 - 0.250529518247027*x_30 + 4.55719229343682*x_31 - 0.17327326230704*x_32 + 37.571322504832*x_33 - 81.544260327035*x_34 - 123.807404291464*x_35 + 54.1516205896837*x_36 - 252.713853493184*x_37 + 3.43120916500889*x_38 - 158.326848092475*x_39 - 5.01989514853527*x_4 + 39.8317379741532*x_40 - 0.282248520394262*x_42 - 18.2237161982523*x_43 + 4.92153130684458*x_44 - 15.8647078970146*x_45 - 2.30037209727846*x_46 + 120.38788835402*x_47 - 85.4588021340429*x_48 - 3.65035162549112*x_5 - 1.02795729953911*x_52 + 7.5562764633021*x_53 - 11.929990413863*x_54 - 2.89404620620217*x_55 + 22.0957654196934*x_56 + 45.0057794837637*x_59 - 4.20457953205096*x_6 + 0.82658815131986*x_61 - 0.879044807468678*x_62 - 7.35475207428814*x_63 + 0.277279923367888*x_64 + 6.74422128634057*x_65 - 3.9639952709862*x_66 - 6.76742514339695*x_67 - 2.88657892136719*x_68 - 4.76624975422682*x_69 - 20.880124245901*x_7 + 8.55317552231972*x_70 - 3.19827499625397*x_71 + 3.97817987974906*x_72 - 3.47946968913684*x_73 + 12.564974288515*x_74 + 6.08821637513051*x_75 + 10.2549370013953*x_76 + 9.37299398903532*x_77 + 6.48881253667803*x_78 + 34.0608562014172*x_79 - 18.2211324311859*x_8 - 4.7107746261693*x_80 + 13.0269561437595*x_81 - 9.7992775062981*x_82 + 13.0616071379312*x_83 - 8.84682366235418*x_84 - 18.7184518895933*x_85 - 33.7903687313148*x_86 - 80.0626659187358*x_87 - 0.590026600354865*x_88 - 2.45151642395772*x_89 + 9.17293742402927*x_9 - 4.90278578955045*x_90 - 3.94072063987623*x_91 + 7.37837033181583*x_92 - 0.730788285219216*x_93 - 9.87544115432986*x_94 - 8.5642181651057*x_95 - 5.96552110965487*x_96 + 0.0302176731249926*x_97 + 9.67842781134839*x_98 - 2.31238525405256*x_99 - 0.000107507163226217*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.0116689628682542*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) + 0.0115051541773177*std::exp(0.785679876804352*x_1) - 0.343357499814211*std::exp(1.17999982833862*x_1) - 0.361296030436189*std::exp(1.20335984230042*x_1) + 0.410209657525574*std::exp(1.76671993732452*x_1) + 1.49185015026444*std::exp(0.52215987443924*x_10) + 0.00681748603026046*std::exp(0.591439843177795*x_10) - 0.540328140998173*std::exp(0.900879800319672*x_10) - 0.00422141842035506*std::exp(0.885119915008545*x_11) + 0.679959847626388*std::exp(0.925119876861572*x_11) + 0.298971534158288*std::exp(0.944479823112488*x_11) + 0.00140967733129011*std::exp(1.00215983390808*x_11) + 0.335230151524378*std::exp(1.00799977779388*x_11) - 0.0383964671842735*std::exp(0.298719853162766*x_12) - 0.232389137630958*std::exp(0.684399843215942*x_12) + 4.56523095500773e-5*std::exp(1.34319984912872*x_12) + 4.05481322794228*std::exp(0.298239856958389*x_13) + 0.000665665044822372*std::exp(0.889039874076843*x_13) - 1.04151363982605e-5*std::exp(1.44815993309021*x_13) + 0.113270411478925*std::exp(0.24711985886097*x_15) - 0.86147193670518*std::exp(0.588559865951538*x_15) - 0.014056702850893*std::exp(0.64167982339859*x_15) + 0.0618586948071924*std::exp(0.977839827537537*x_15) + 0.756299541013385*std::exp(1.00783979892731*x_15) + 1.84744205024721*std::exp(0.590879797935486*x_16) - 0.841732153152297*std::exp(0.653999865055084*x_16) - 7.40925441375314*std::exp(0.721039831638336*x_16) + 0.00239589719765638*std::exp(0.929839789867401*x_16) + 0.0298210056393402*std::exp(0.602319836616516*x_17) + 2.50861950673881*std::exp(0.615119874477386*x_17) + 9.97421121150738*std::exp(0.655999839305878*x_17) - 1.56699666311686*std::exp(0.666399836540222*x_17) + 17.0786229157926*std::exp(0.753679871559143*x_19) + 2.43898427929055*std::exp(0.754959881305695*x_19) + 0.784537755564196*std::exp(0.772639811038971*x_19) + 0.0137377889103778*std::exp(0.822639882564545*x_19) - 0.00844773540468051*std::exp(0.812879860401154*x_2) + 0.191279655808939*std::exp(0.509519815444946*x_20) + 0.00188456301507926*std::exp(0.882799863815308*x_20) + 0.251476510730776*std::exp(0.894479870796204*x_20) - 0.000893546291696543*std::exp(0.971199810504913*x_20) - 2.79574483549369*std::exp(0.57015985250473*x_22) - 7.7316903331e-5*std::exp(1.32799983024597*x_22) - 0.00479798257510857*std::exp(1.35727989673615*x_22) - 0.0325629398196219*std::exp(0.473199844360352*x_23) - 15.897319380959*std::exp(0.541199862957001*x_23) - 0.797479220355645*std::exp(0.599999845027924*x_23) + 0.19750732644105*std::exp(0.88975989818573*x_23) - 0.00104383177707389*std::exp(1.0971999168396*x_23) + 3.44599827480516*std::exp(0.481039851903915*x_24) + 0.0366667806449093*std::exp(0.518959879875183*x_24) - 2.53119632161917*std::exp(0.579039871692657*x_24) - 1.47279595938741*std::exp(0.539999842643738*x_25) + 0.0253691816629351*std::exp(0.599599838256836*x_25) - 0.0077575523708124*std::exp(0.719999849796295*x_25) + 0.046085703648619*std::exp(0.472639858722687*x_26) - 2.63470027826125*std::exp(0.830559849739075*x_26) + 0.110678629824293*std::exp(0.873839855194092*x_26) + 0.000334020694099153*std::exp(0.995279788970947*x_26) - 0.0524987762867813*std::exp(0.952159821987152*x_27) + 0.10436449951511*std::exp(0.953839838504791*x_27) - 0.00470421064483153*std::exp(0.630799829959869*x_28) - 0.0268571048531415*std::exp(0.639919817447662*x_28) - 0.051828060045219*std::exp(1.00135982036591*x_28) + 0.000361490774241292*std::exp(1.18399977684021*x_29) + 0.000141742160288055*std::exp(1.33479988574982*x_29) - 0.0446556790252614*std::exp(0.598319828510284*x_3) + 2.84066902715468*std::exp(0.64167982339859*x_3) + 0.00246323710613037*std::exp(0.719519853591919*x_3) + 0.0124574577828243*std::exp(0.833439886569977*x_30) - 0.448392702894173*std::exp(0.888719916343689*x_30) - 0.000722024778821038*std::exp(1.12327992916107*x_30) - 2.35327689436555*std::exp(0.879999876022339*x_32) - 0.085841188904351*std::exp(0.414639860391617*x_33) + 3.81798749333879*std::exp(0.464239865541458*x_33) + 0.552438398566009*std::exp(0.618639826774597*x_4) + 1.22655847185914*std::exp(0.686719834804535*x_4) - 0.0010420376567431*std::exp(1.15263986587524*x_4) - 3.67419499587726*std::exp(0.735999822616577*x_41) - 0.856475661850511*std::exp(0.797439873218536*x_41) - 0.0124390651470323*std::exp(0.80103987455368*x_41) + 0.00301762436044377*std::exp(0.811199843883514*x_41) + 0.204208430163237*std::exp(0.823679864406586*x_41) - 0.608165869954361*std::exp(0.798799872398376*x_42) + 0.0439187849001551*std::exp(0.846959888935089*x_43) + 0.0181822809661789*std::exp(0.912319839000702*x_44) - 0.000229715000964865*std::exp(0.976159811019897*x_44) - 0.00932784438930942*std::exp(0.542799830436707*x_45) - 0.871035146243349*std::exp(0.54535984992981*x_45) + 0.275602709033798*std::exp(0.739759802818298*x_46) - 3.21825002815173*std::exp(0.763999879360199*x_46) + 0.0201313400134535*std::exp(0.56335985660553*x_47) - 2.23633253971664*std::exp(0.64167982339859*x_49) + 0.0259717948663077*std::exp(0.711119830608368*x_49) - 1.06305721972768*std::exp(0.730319857597351*x_49) + 0.0232737261699846*std::exp(0.731119871139526*x_49) + 0.802744981492169*std::exp(0.733759820461273*x_49) + 0.03492068094403*std::exp(0.500079810619354*x_50) - 1.01822922824843*std::exp(0.545759856700897*x_50) + 0.621898909783591*std::exp(0.560399830341339*x_50) - 22.011445860423*std::exp(0.56335985660553*x_50) + 0.0242960680354111*std::exp(0.596959829330444*x_50) - 4.68335634608544*std::exp(0.485359847545624*x_51) + 43.3641817839735*std::exp(0.49431985616684*x_51) + 0.243272494059909*std::exp(0.494879871606827*x_51) + 0.275909878914297*std::exp(0.500959813594818*x_51) - 45.4336407615096*std::exp(0.503039836883545*x_51) - 1.40164594455694*std::exp(0.511919856071472*x_52) + 1.18507400943774*std::exp(0.670159876346588*x_52) + 0.00303469334143733*std::exp(0.767999827861786*x_52) - 0.00012981617761959*std::exp(0.831919848918915*x_52) + 0.00983496141451159*std::exp(0.497679859399796*x_53) - 16.2965293623513*std::exp(0.447279840707779*x_54) - 2.87036202449191*std::exp(0.459519863128662*x_54) + 0.0916318653627036*std::exp(0.508319854736328*x_54) + 0.0442678138448924*std::exp(0.512159824371338*x_54) + 124.767075128385*std::exp(0.652319848537445*x_55) - 0.362556106307622*std::exp(0.652479827404022*x_55) - 7.38494735463942*std::exp(0.653519809246063*x_55) + 0.0138984788877009*std::exp(0.700159847736359*x_55) + 1.5479849342691*std::exp(0.471919864416122*x_56) - 0.0427410288669974*std::exp(0.553919851779938*x_56) + 0.050164917807315*std::exp(0.583439826965332*x_56) + 2.53325321501559*std::exp(0.610639870166779*x_57) - 58.7237176750578*std::exp(0.630239844322205*x_57) + 0.108229041512201*std::exp(0.633599877357483*x_57) + 4.89441631266816*std::exp(0.638239860534668*x_57) - 0.00969974264754723*std::exp(0.663359880447388*x_57) + 0.0456404234770196*std::exp(0.589439868927002*x_58) + 2.55421814421626*std::exp(0.592319846153259*x_58) - 23.4907585936585*std::exp(0.619999825954437*x_58) - 1.16613115910192*std::exp(0.620639801025391*x_58) - 0.00412697321694938*std::exp(0.712479829788208*x_58) - 0.501648154293602*std::exp(0.610799849033356*x_59) - 0.00201808192591497*std::exp(0.726239860057831*x_59) - 0.455316074941911*std::exp(0.798399865627289*x_60) - 0.0119989980176615*std::exp(0.802639901638031*x_60) + 2.70812307870264*std::exp(0.808239877223969*x_60) - 0.00636475605095936*std::exp(0.813839852809906*x_60) + 0.378478971928192*std::exp(0.834959864616394*x_60) - 0.799795890113532*std::exp(1.13743984699249*x_61) + 0.58246814144968*std::exp(1.35527992248535*x_61) - 0.00323033800229628*std::exp(1.38071978092194*x_61) + 0.000268674910237445*std::exp(1.79559993743896*x_61) - 0.00852386372101817*std::exp(0.925839841365814*x_66) - 0.377459298256343*std::exp(1.02399981021881*x_66) - 1.24569744789095*std::exp(1.04943978786469*x_66) + 2.64137129687966*std::exp(0.33927983045578*x_8) - 0.00467175815040294*std::exp(0.773439824581146*x_8) - 0.179176827921028*std::log(5.44279956817627 - 0.804559826850891*x_5) + 0.252339401956403*std::log(9.53880023956299 - 1.21599996089935*x_21) - 13.1645412623195*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 5.39969360288066*std::sin(0.231199979782104*x_101 + 1.96639978885651) - 0.36219061536812*std::sin(0.231199979782104*x_102 + 1.9916797876358) - 74.3780573327875*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 7.77495493467144*std::sin(0.268559962511063*x_120 + 1.97511982917786) + 0.0788155358735859*std::sin(0.299279928207397*x_120 - 7.47304010391235) - 2115.28227750731*std::sin(0.0630401000380516*x_30 + 1.65183997154236) + 0.0707853153452033*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 6.01291967854134*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 8.06693476835505*std::sin(0.273439943790436*x_42 + 5.1384801864624) - 0.0984857156482827*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 3.49787339039201*std::sin(0.307119935750961*x_92 + 8.21607971191406) + 0.15535698526703*std::sin(0.269759953022003*x_95 + 1.96215975284576) + 11.7880840750382*std::sin(0.273519963026047*x_95 - 1.20119988918304) - 0.159706195762827*std::sin(0.32551982998848*x_97 - 7.55847978591919) + 17.7799724046685*std::sin(0.267439961433411*x_98 + 1.9625598192215) + 2216.00733910345);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0157148843253074*x_1 - 0.365799757159853*x_10 + 18.2610073119175*x_100 + 7.18807681410824*x_101 + 15.0705048915481*x_102 - 25.8353168029437*x_103 + 2.82750052286098*x_104 + 19.3937497713335*x_105 + 31.269159602684*x_106 + 3.87526812035175*x_107 - 9.92466063839553*x_108 + 15.4902266246778*x_109 + 3.21439649804336*x_110 + 22.0916046872143*x_111 + 5.33127626670514*x_112 + 25.3544108338598*x_113 - 29.1141326215294*x_114 - 11.6444246629756*x_115 + 24.6031624044775*x_116 + 15.8903371701169*x_117 - 0.743637163650783*x_118 - 5.93234290462294*x_119 - 3.51989470232263*x_12 - 21.036129347165*x_120 + 53.6848704077447*x_13 + 5.39885265849718*x_14 + 0.127695208657364*x_17 + 58.620500781922*x_18 - 0.217045649106409*x_19 - 10.8338071151027*x_2 + 1.85991979868621*x_20 - 0.368921764144763*x_21 - 0.774341038477387*x_22 - 9.63678124293074*x_24 - 35.7212301190514*x_25 - 6.08753800372541*x_26 + 10.3714523721869*x_27 + 24.225674458191*x_28 - 56.9221192297635*x_29 - 3.14488225959247*x_3 - 0.548723202993004*x_30 - 1.73059919542144*x_31 - 2.32033393693765*x_32 - 46.6336448827762*x_33 + 168.803238934762*x_34 + 169.039761896374*x_35 - 90.84071136112*x_36 + 272.198547966156*x_37 - 61.9993962427888*x_38 + 225.01412223296*x_39 + 6.79103968559027*x_4 + 393.424651396556*x_40 - 0.482837850896069*x_42 + 27.2024218281432*x_43 - 11.2692678258258*x_44 + 35.2554945537637*x_45 - 2.50661049150237*x_46 - 207.599359631554*x_47 + 110.075656679847*x_48 + 0.534764693871935*x_5 - 2.25148727339571*x_52 - 13.9346651793177*x_53 - 16.3211404906635*x_54 - 3.95927683755806*x_55 - 17.6030462255566*x_56 - 51.5064613888616*x_59 + 9.77799942497993*x_6 + 1.81043775249299*x_61 - 3.22910506090812*x_62 + 9.7602969353312*x_63 + 6.24054818018949*x_64 - 0.581337268856513*x_65 + 5.36696702885309*x_66 + 8.8858968408298*x_67 + 5.23713833445124*x_68 + 8.97849991658545*x_69 + 18.9499061433435*x_7 - 4.36176885139707*x_70 + 13.2314571283982*x_71 - 3.13979958313557*x_72 + 12.8690177647129*x_73 - 17.7746733617931*x_74 - 16.7339146275541*x_75 - 12.5076961950611*x_76 - 10.9414716687404*x_77 - 1.95986153849696*x_78 - 55.3815500071983*x_79 + 26.4194598735135*x_8 + 6.9668355559746*x_80 - 13.8576446527745*x_81 + 9.1808874881538*x_82 - 30.103633240324*x_83 + 8.48286537646764*x_84 + 35.6942240887941*x_85 + 77.6999419603996*x_86 + 105.308520241108*x_87 - 10.9879441669432*x_88 + 10.0343331503804*x_89 - 10.043553947274*x_9 + 4.61066797668321*x_90 - 2.76461662358522*x_91 - 14.8059477291458*x_92 + 7.27344497595468*x_93 + 10.9851187338955*x_94 + 12.4534184439219*x_95 + 9.63153195642082*x_96 - 6.51434258094296*x_97 - 7.61981075759939*x_98 + 9.43760206399484*x_99 + 9.08838371570997e-5*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.025557989036491*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) + 0.140076159780914*std::exp(0.785679876804352*x_1) - 0.752040032599868*std::exp(1.17999982833862*x_1) - 0.49428063786337*std::exp(1.20335984230042*x_1) - 0.555571781929594*std::exp(1.76671993732452*x_1) + 2.04096525217569*std::exp(0.52215987443924*x_10) - 0.00576333028982663*std::exp(0.591439843177795*x_10) + 0.731799124213317*std::exp(0.900879800319672*x_10) + 0.00356868038160613*std::exp(0.885119915008545*x_11) + 0.930237143210491*std::exp(0.925119876861572*x_11) + 0.654823507325427*std::exp(0.944479823112488*x_11) + 0.0171629327216336*std::exp(1.00215983390808*x_11) - 0.454022496111797*std::exp(1.00799977779388*x_11) + 0.032459402390151*std::exp(0.298719853162766*x_12) - 0.508991167323872*std::exp(0.684399843215942*x_12) + 0.000555820470403748*std::exp(1.34319984912872*x_12) + 5.5472950154046*std::exp(0.298239856958389*x_13) - 0.000562736395597279*std::exp(0.889039874076843*x_13) - 0.000126805107326505*std::exp(1.44815993309021*x_13) - 0.0957559414892811*std::exp(0.24711985886097*x_15) - 1.17855958135481*std::exp(0.588559865951538*x_15) - 0.171141466180123*std::exp(0.64167982339859*x_15) + 0.135486234855968*std::exp(0.977839827537537*x_15) - 1.02430227071664*std::exp(1.00783979892731*x_15) + 2.52744220275368*std::exp(0.590879797935486*x_16) - 1.8436069584603*std::exp(0.653999865055084*x_16) + 10.0348019650462*std::exp(0.721039831638336*x_16) + 0.0291702374001391*std::exp(0.929839789867401*x_16) - 0.0252099240557936*std::exp(0.602319836616516*x_17) + 3.43198359652708*std::exp(0.615119874477386*x_17) - 13.5086782928162*std::exp(0.655999839305878*x_17) - 3.43212023110589*std::exp(0.666399836540222*x_17) - 23.1306133148241*std::exp(0.753679871559143*x_19) + 3.33671727267811*std::exp(0.754959881305695*x_19) + 1.71833671782202*std::exp(0.772639811038971*x_19) - 0.0116135793444963*std::exp(0.822639882564545*x_19) + 0.00714150188531826*std::exp(0.812879860401154*x_2) + 0.418950972872538*std::exp(0.509519815444946*x_20) + 0.0229447033867553*std::exp(0.882799863815308*x_20) + 0.34403912487385*std::exp(0.894479870796204*x_20) + 0.000755381439058144*std::exp(0.971199810504913*x_20) + 3.78644654405499*std::exp(0.57015985250473*x_22) - 0.00094133939779011*std::exp(1.32799983024597*x_22) - 0.00656400759460006*std::exp(1.35727989673615*x_22) + 0.0275278858739456*std::exp(0.473199844360352*x_23) + 21.5307023965729*std::exp(0.541199862957001*x_23) - 1.09101264479514*std::exp(0.599999845027924*x_23) + 0.432591151484418*std::exp(0.88975989818573*x_23) - 0.0127087342365269*std::exp(1.0971999168396*x_23) + 4.71438953616624*std::exp(0.481039851903915*x_24) - 0.0309971691299763*std::exp(0.518959879875183*x_24) - 5.54396209565004*std::exp(0.579039871692657*x_24) - 2.01489765987666*std::exp(0.539999842643738*x_25) - 0.0214464646435839*std::exp(0.599599838256836*x_25) - 0.0944488121284842*std::exp(0.719999849796295*x_25) + 0.561097077745101*std::exp(0.472639858722687*x_26) + 3.56833414716167*std::exp(0.830559849739075*x_26) + 0.15141684142322*std::exp(0.873839855194092*x_26) - 0.000282372648097236*std::exp(0.995279788970947*x_26) - 0.114985638733761*std::exp(0.952159821987152*x_27) + 0.142778627621072*std::exp(0.953839838504791*x_27) + 0.0039768207193593*std::exp(0.630799829959869*x_28) - 0.326987370415098*std::exp(0.639919817447662*x_28) - 0.113516600007527*std::exp(1.00135982036591*x_28) + 0.00440117869535189*std::exp(1.18399977684021*x_29) - 0.000119825237940737*std::exp(1.33479988574982*x_29) - 0.543686415137294*std::exp(0.598319828510284*x_3) + 3.88625276897062*std::exp(0.64167982339859*x_3) - 0.00208235835933846*std::exp(0.719519853591919*x_3) + 0.15167053130771*std::exp(0.833439886569977*x_30) - 0.613435555691655*std::exp(0.888719916343689*x_30) + 0.000610381489498363*std::exp(1.12327992916107*x_30) + 3.18718541504572*std::exp(0.879999876022339*x_32) - 1.04512324714911*std::exp(0.414639860391617*x_33) + 5.22329927423649*std::exp(0.464239865541458*x_33) + 1.20998024359975*std::exp(0.618639826774597*x_4) + 1.67802591995079*std::exp(0.686719834804535*x_4) - 0.0126868906799566*std::exp(1.15263986587524*x_4) + 4.97618479615894*std::exp(0.735999822616577*x_41) - 1.17172429473645*std::exp(0.797439873218536*x_41) + 0.0105156711170083*std::exp(0.80103987455368*x_41) + 0.0367398146567773*std::exp(0.811199843883514*x_41) + 0.447268268671069*std::exp(0.823679864406586*x_41) + 0.82367586886528*std::exp(0.798799872398376*x_42) + 0.0600842610654335*std::exp(0.846959888935089*x_43) + 0.0248747527696993*std::exp(0.912319839000702*x_44) + 0.00019419525279728*std::exp(0.976159811019897*x_44) - 0.11356724133818*std::exp(0.542799830436707*x_45) - 1.19164278435829*std::exp(0.54535984992981*x_45) + 0.603639851753753*std::exp(0.739759802818298*x_46) + 4.35867091384545*std::exp(0.763999879360199*x_46) - 0.0170185257673205*std::exp(0.56335985660553*x_47) + 3.02880059326748*std::exp(0.64167982339859*x_49) - 0.0219558986068705*std::exp(0.711119830608368*x_49) - 1.45434368602913*std::exp(0.730319857597351*x_49) + 0.283359452245434*std::exp(0.731119871139526*x_49) + 1.75821516168253*std::exp(0.733759820461273*x_49) - 0.0295210605981117*std::exp(0.500079810619354*x_50) - 1.393015560736*std::exp(0.545759856700897*x_50) + 1.36211638493565*std::exp(0.560399830341339*x_50) + 29.8114341658559*std::exp(0.56335985660553*x_50) + 0.295806545112256*std::exp(0.596959829330444*x_50) - 10.2577385410037*std::exp(0.485359847545624*x_51) + 59.3255215307194*std::exp(0.49431985616684*x_51) - 0.205656414618802*std::exp(0.494879871606827*x_51) + 3.35922454304234*std::exp(0.500959813594818*x_51) + 61.533531193978*std::exp(0.503039836883545*x_51) - 1.91755899088565*std::exp(0.511919856071472*x_52) - 1.60501750035158*std::exp(0.670159876346588*x_52) + 0.036947630846991*std::exp(0.767999827861786*x_52) + 0.000109743313776312*std::exp(0.831919848918915*x_52) - 0.00831422767394585*std::exp(0.497679859399796*x_53) + 22.071376650963*std::exp(0.447279840707779*x_54) - 6.28682102951106*std::exp(0.459519863128662*x_54) + 1.11562518987135*std::exp(0.508319854736328*x_54) - 0.0374228903827952*std::exp(0.512159824371338*x_54) - 168.979605876049*std::exp(0.652319848537445*x_55) + 0.306495763976577*std::exp(0.652479827404022*x_55) - 16.1749082292842*std::exp(0.653519809246063*x_55) + 0.169215076945551*std::exp(0.700159847736359*x_55) + 3.39047972175284*std::exp(0.471919864416122*x_56) - 0.520375398408609*std::exp(0.553919851779938*x_56) - 0.0424081529470352*std::exp(0.583439826965332*x_56) + 5.54846721401132*std::exp(0.610639870166779*x_57) + 79.5330872194989*std::exp(0.630239844322205*x_57) + 1.31769711888664*std::exp(0.633599877357483*x_57) + 6.69593633252435*std::exp(0.638239860534668*x_57) + 0.00819991714775781*std::exp(0.663359880447388*x_57) - 0.03858325985533*std::exp(0.589439868927002*x_58) + 3.4943660245622*std::exp(0.592319846153259*x_58) + 31.8149569892638*std::exp(0.619999825954437*x_58) - 2.55412307982571*std::exp(0.620639801025391*x_58) - 0.0502462245042012*std::exp(0.712479829788208*x_58) - 0.68629309153458*std::exp(0.610799849033356*x_59) + 0.00170603542704041*std::exp(0.726239860057831*x_59) - 0.622907258848177*std::exp(0.798399865627289*x_60) - 0.146088747497747*std::exp(0.802639901638031*x_60) - 3.66777509236404*std::exp(0.808239877223969*x_60) + 0.00538060381393256*std::exp(0.813839852809906*x_60) + 0.828964966663768*std::exp(0.834959864616394*x_60) - 1.09418202643563*std::exp(1.13743984699249*x_61) - 0.788871878869021*std::exp(1.35527992248535*x_61) - 0.0393296200278739*std::exp(1.38071978092194*x_61) - 0.000227130974880598*std::exp(1.79559993743896*x_61) - 0.103778713273571*std::exp(0.925839841365814*x_66) - 0.826731622636528*std::exp(1.02399981021881*x_66) - 1.70420950483446*std::exp(1.04943978786469*x_66) + 5.78527324228704*std::exp(0.33927983045578*x_8) - 0.0568790240485239*std::exp(0.773439824581146*x_8) - 2.18149201567281*std::log(5.44279956817627 - 0.804559826850891*x_5) + 3.07225212654265*std::log(9.53880023956299 - 1.21599996089935*x_21) - 18.0101005938596*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 11.8266988644108*std::sin(0.231199979782104*x_101 + 1.96639978885651) - 4.40969931628334*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 100.734707461786*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 17.0291237724431*std::sin(0.268559962511063*x_120 + 1.97511982917786) + 0.959585367227183*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 2864.85489222194*std::sin(0.0630401000380516*x_30 + 1.65183997154236) + 0.861816798768769*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 13.1698195423645*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 17.6686336819711*std::sin(0.273439943790436*x_42 + 5.1384801864624) - 1.19907135781667*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 7.6612301171927*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.131334866687129*std::sin(0.269759953022003*x_95 + 1.96215975284576) + 16.1270017518945*std::sin(0.273519963026047*x_95 - 1.20119988918304) - 1.944435533057*std::sin(0.32551982998848*x_97 - 7.55847978591919) + 24.3243638485666*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 2804.73409014256);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0181287870267632*x_1 + 0.58827675247105*x_10 + 38.8568532497497*x_100 + 19.510968678799*x_101 + 29.7323587961158*x_102 - 56.7249561709652*x_103 + 264.304635088005*x_104 + 26.7806973605907*x_105 + 60.0734585668866*x_106 + 21.2966316342054*x_107 - 17.160183640178*x_108 + 47.7616977174213*x_109 - 0.771950619486875*x_110 + 25.4172103329209*x_111 + 13.2498799558328*x_112 + 49.0951234666852*x_113 - 41.242604661919*x_114 - 33.5780942881031*x_115 + 52.5904256284095*x_116 + 23.8104157154147*x_117 - 4.45126240530166*x_118 - 3.40555216391208*x_119 + 7.5846486763788*x_12 - 50.9684020307864*x_120 + 104.522156732391*x_13 + 28.4535453519709*x_14 + 0.245704089758717*x_17 + 131.65192890476*x_18 - 0.41762728774636*x_19 - 17.9495485693038*x_2 + 3.77769067811274*x_20 + 0.373254505771566*x_21 + 0.96805730075175*x_22 - 19.5690320732326*x_24 - 78.3345627718893*x_25 + 8.37825721861187*x_26 + 21.1452439264558*x_27 + 41.2974162669954*x_28 - 107.713484745858*x_29 - 10.3479592798289*x_3 + 0.755205821086047*x_30 - 9.89307803594305*x_31 - 0.440284926953689*x_32 - 103.610712144154*x_33 + 273.502902326932*x_34 + 325.296575490498*x_35 - 152.272020432113*x_36 + 664.326915384969*x_37 + 28.2332068010154*x_38 + 434.546740195308*x_39 + 13.7820739702188*x_4 - 127.17521079562*x_40 + 0.127219633660753*x_42 + 52.1156816113435*x_43 - 13.7781562182041*x_44 + 42.7069466642662*x_45 + 3.55655124233863*x_46 - 342.313389341923*x_47 + 230.130540996202*x_48 + 9.40099745524278*x_5 + 3.09871404324645*x_52 - 22.9594488301786*x_53 + 13.5549162350983*x_54 + 3.28823012799655*x_55 - 53.4737091754082*x_56 - 122.503954567528*x_59 + 10.4283711400411*x_6 - 2.49169913344101*x_61 + 0.121515697891986*x_62 + 20.0077464369818*x_63 + 2.1178747516693*x_64 - 15.8435942202897*x_65 + 10.8983737063647*x_66 + 17.8265508617589*x_67 + 10.2151530948468*x_68 + 12.9025141849305*x_69 + 52.6135779791404*x_7 - 20.4721861985456*x_70 + 11.6077626259587*x_71 - 10.872033924378*x_72 + 10.1789533860994*x_73 - 33.9268293304309*x_74 - 20.8481495156518*x_75 - 28.7245690764627*x_76 - 24.7075947361173*x_77 - 16.220425470329*x_78 - 98.6839157577247*x_79 + 51.1607517125445*x_8 + 13.7889784800289*x_80 - 34.2731680813098*x_81 + 26.5702345453204*x_82 - 43.4443850171727*x_83 + 22.9244311992791*x_84 + 55.3772720434438*x_85 + 107.660974988168*x_86 + 210.760730259934*x_87 + 4.47988389759298*x_88 + 9.08689783062008*x_89 - 23.1688784776255*x_9 + 13.7884132819523*x_90 + 8.33526828915068*x_91 - 23.0549579011001*x_92 + 6.23853803710493*x_93 + 24.5481489454856*x_94 + 23.4124833856564*x_95 + 16.5179091358751*x_96 - 2.94478062778669*x_97 - 26.4790198176216*x_98 + 14.3516399123324*x_99 + 0.000104844152453783*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) + 0.0351753707339718*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) + 0.269526834230843*std::exp(0.785679876804352*x_1) + 1.03503006107872*std::exp(1.17999982833862*x_1) + 0.410506400989661*std::exp(1.20335984230042*x_1) - 1.128424108986*std::exp(1.76671993732452*x_1) - 1.69504778467004*std::exp(0.52215987443924*x_10) - 0.00664861320174666*std::exp(0.591439843177795*x_10) + 1.4863601816296*std::exp(0.900879800319672*x_10) + 0.0041168515953082*std::exp(0.885119915008545*x_11) - 0.772573862850358*std::exp(0.925119876861572*x_11) - 0.901231298072972*std::exp(0.944479823112488*x_11) + 0.0330239701731825*std::exp(1.00215983390808*x_11) - 0.92216694097592*std::exp(1.00799977779388*x_11) + 0.0374453658560764*std::exp(0.298719853162766*x_12) + 0.700522759649496*std::exp(0.684399843215942*x_12) + 0.00106947914636529*std::exp(1.34319984912872*x_12) - 4.607099565634*std::exp(0.298239856958389*x_13) - 0.000649176160435523*std::exp(0.889039874076843*x_13) - 0.000243991405785754*std::exp(1.44815993309021*x_13) - 0.110464641919814*std::exp(0.24711985886097*x_15) + 0.978808828493054*std::exp(0.588559865951538*x_15) - 0.329300986386967*std::exp(0.64167982339859*x_15) - 0.186469230173164*std::exp(0.977839827537537*x_15) - 2.0804645137867*std::exp(1.00783979892731*x_15) - 2.09907312341171*std::exp(0.590879797935486*x_16) + 2.53734979536069*std::exp(0.653999865055084*x_16) + 20.3817271405141*std::exp(0.721039831638336*x_16) + 0.0561277647282622*std::exp(0.929839789867401*x_16) - 0.0290823231471299*std::exp(0.602319836616516*x_17) - 2.85030633721753*std::exp(0.615119874477386*x_17) - 27.4375314981016*std::exp(0.655999839305878*x_17) + 4.72361504500002*std::exp(0.666399836540222*x_17) - 46.9806829091041*std::exp(0.753679871559143*x_19) - 2.77118643499395*std::exp(0.754959881305695*x_19) - 2.36494080222378*std::exp(0.772639811038971*x_19) - 0.0133974964241852*std::exp(0.822639882564545*x_19) + 0.00823848041449902*std::exp(0.812879860401154*x_2) - 0.576600755603617*std::exp(0.509519815444946*x_20) + 0.0441489349498892*std::exp(0.882799863815308*x_20) - 0.285728900007279*std::exp(0.894479870796204*x_20) + 0.000871412665163677*std::exp(0.971199810504913*x_20) + 7.69066699690635*std::exp(0.57015985250473*x_22) - 0.00181127344024823*std::exp(1.32799983024597*x_22) + 0.00545149238573434*std::exp(1.35727989673615*x_22) + 0.0317563381298412*std::exp(0.473199844360352*x_23) + 43.7310973269959*std::exp(0.541199862957001*x_23) + 0.906099976290927*std::exp(0.599999845027924*x_23) - 0.59537368562035*std::exp(0.88975989818573*x_23) - 0.0244534466907832*std::exp(1.0971999168396*x_23) - 3.91536089643446*std::exp(0.481039851903915*x_24) - 0.0357585245909157*std::exp(0.518959879875183*x_24) + 7.63013560148045*std::exp(0.579039871692657*x_24) + 1.67339831536573*std::exp(0.539999842643738*x_25) - 0.0247407732664258*std::exp(0.599599838256836*x_25) - 0.181733204063198*std::exp(0.719999849796295*x_25) + 1.07963210368807*std::exp(0.472639858722687*x_26) + 7.24765801925756*std::exp(0.830559849739075*x_26) - 0.125753626301361*std::exp(0.873839855194092*x_26) - 0.00032574682024825*std::exp(0.995279788970947*x_26) + 0.158254331581711*std::exp(0.952159821987152*x_27) - 0.118579479091736*std::exp(0.953839838504791*x_27) + 0.00458768479439468*std::exp(0.630799829959869*x_28) - 0.629171094633747*std::exp(0.639919817447662*x_28) + 0.156232498731558*std::exp(1.00135982036591*x_28) + 0.00846850572215684*std::exp(1.18399977684021*x_29) - 0.0001382311300606*std::exp(1.33479988574982*x_29) - 1.04613146530761*std::exp(0.598319828510284*x_3) - 3.22758270366888*std::exp(0.64167982339859*x_3) - 0.0024022213863231*std::exp(0.719519853591919*x_3) + 0.29183608555099*std::exp(0.833439886569977*x_30) + 0.509466086502224*std::exp(0.888719916343689*x_30) + 0.00070413983323914*std::exp(1.12327992916107*x_30) + 6.47350527713072*std::exp(0.879999876022339*x_32) - 2.01096860897482*std::exp(0.414639860391617*x_33) - 4.33801695253018*std::exp(0.464239865541458*x_33) - 1.66529156846552*std::exp(0.618639826774597*x_4) - 1.39362202036483*std::exp(0.686719834804535*x_4) - 0.0244114165219098*std::exp(1.15263986587524*x_4) + 10.1071492062693*std::exp(0.735999822616577*x_41) + 0.973132035403273*std::exp(0.797439873218536*x_41) + 0.0121309427532169*std::exp(0.80103987455368*x_41) + 0.0706927285139519*std::exp(0.811199843883514*x_41) - 0.615573750563224*std::exp(0.823679864406586*x_41) + 1.67297141188384*std::exp(0.798799872398376*x_42) - 0.0499007484345609*std::exp(0.846959888935089*x_43) - 0.0206588007961167*std::exp(0.912319839000702*x_44) + 0.000224024835734925*std::exp(0.976159811019897*x_44) - 0.218519832911499*std::exp(0.542799830436707*x_45) + 0.98967459617028*std::exp(0.54535984992981*x_45) - 0.830787412300778*std::exp(0.739759802818298*x_46) + 8.8529142449185*std::exp(0.763999879360199*x_46) - 0.0196326757969439*std::exp(0.56335985660553*x_47) + 6.15180922055407*std::exp(0.64167982339859*x_49) - 0.0253284594137397*std::exp(0.711119830608368*x_49) + 1.20785105994559*std::exp(0.730319857597351*x_49) + 0.545224656590732*std::exp(0.731119871139526*x_49) - 2.41982536474099*std::exp(0.733759820461273*x_49) - 0.0340556767271572*std::exp(0.500079810619354*x_50) + 1.15691726633727*std::exp(0.545759856700897*x_50) - 1.87467600657156*std::exp(0.560399830341339*x_50) + 60.550125348994*std::exp(0.56335985660553*x_50) + 0.56917466736358*std::exp(0.596959829330444*x_50) + 14.1176896021352*std::exp(0.485359847545624*x_51) - 49.2706055322808*std::exp(0.49431985616684*x_51) - 0.23724650236896*std::exp(0.494879871606827*x_51) + 6.46363491098587*std::exp(0.500959813594818*x_51) + 124.981005819202*std::exp(0.503039836883545*x_51) + 1.592557303957*std::exp(0.511919856071472*x_52) - 3.25995758181018*std::exp(0.670159876346588*x_52) + 0.0710925969850595*std::exp(0.767999827861786*x_52) + 0.000126600560454529*std::exp(0.831919848918915*x_52) - 0.00959134408328118*std::exp(0.497679859399796*x_53) + 44.8292630071223*std::exp(0.447279840707779*x_54) + 8.65252974854328*std::exp(0.459519863128662*x_54) + 2.14662456541144*std::exp(0.508319854736328*x_54) - 0.043171276073795*std::exp(0.512159824371338*x_54) - 343.215165707697*std::exp(0.652319848537445*x_55) + 0.353575394811425*std::exp(0.652479827404022*x_55) + 22.2614695053159*std::exp(0.653519809246063*x_55) + 0.325594334286405*std::exp(0.700159847736359*x_55) - 4.66630535792121*std::exp(0.471919864416122*x_56) - 1.00127769039394*std::exp(0.553919851779938*x_56) - 0.0489223055709742*std::exp(0.583439826965332*x_56) - 7.63633598009132*std::exp(0.610639870166779*x_57) + 161.539977370453*std::exp(0.630239844322205*x_57) + 2.53544024539293*std::exp(0.633599877357483*x_57) - 5.56106089245658*std::exp(0.638239860534668*x_57) + 0.00945947475855169*std::exp(0.663359880447388*x_57) - 0.0445098854204806*std::exp(0.589439868927002*x_58) - 2.90211574275765*std::exp(0.592319846153259*x_58) + 64.6194887154792*std::exp(0.619999825954437*x_58) + 3.51523064294256*std::exp(0.620639801025391*x_58) - 0.0966810186961936*std::exp(0.712479829788208*x_58) + 0.569975203252458*std::exp(0.610799849033356*x_59) + 0.0019680929414874*std::exp(0.726239860057831*x_59) + 0.517332457296827*std::exp(0.798399865627289*x_60) - 0.281095924469952*std::exp(0.802639901638031*x_60) - 7.44963292805688*std::exp(0.808239877223969*x_60) + 0.00620709758970912*std::exp(0.813839852809906*x_60) - 1.14090157822041*std::exp(0.834959864616394*x_60) + 0.908732188339987*std::exp(1.13743984699249*x_61) - 1.60228088605425*std::exp(1.35527992248535*x_61) - 0.0756758894175449*std::exp(1.38071978092194*x_61) - 0.000262019686913026*std::exp(1.79559993743896*x_61) - 0.19968528615379*std::exp(0.925839841365814*x_66) + 1.13782783466326*std::exp(1.02399981021881*x_66) + 1.41536782299643*std::exp(1.04943978786469*x_66) - 7.96225128683728*std::exp(0.33927983045578*x_8) - 0.109443486385664*std::exp(0.773439824581146*x_8) - 4.19750682631339*std::log(5.44279956817627 - 0.804559826850891*x_5) + 5.91145838750243*std::log(9.53880023956299 - 1.21599996089935*x_21) + 14.9576192347043*std::sin(0.276399940252304*x_100 + 1.92679977416992) - 16.2770441962679*std::sin(0.231199979782104*x_101 + 1.96639978885651) - 8.48490063181832*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 204.602674593608*std::sin(0.222479999065399*x_110 - 1.2066398859024) - 23.4371233634671*std::sin(0.268559962511063*x_120 + 1.97511982917786) + 1.8463813300386*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 5818.81843944949*std::sin(0.0630401000380516*x_30 + 1.65183997154236) + 1.65826043362701*std::sin(0.320079833269119*x_31 + 5.15208005905151) - 18.1255764778973*std::sin(0.385919839143753*x_31 - 7.40183973312378) - 24.3172786105633*std::sin(0.273439943790436*x_42 + 5.1384801864624) - 2.30718708732934*std::sin(0.328239858150482*x_91 + 2.00375986099243) + 10.5441241588201*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.151508708436689*std::sin(0.269759953022003*x_95 + 1.96215975284576) - 13.3936815258261*std::sin(0.273519963026047*x_95 - 1.20119988918304) - 3.74137579449991*std::sin(0.32551982998848*x_97 - 7.55847978591919) - 20.2016957471805*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 6082.06229935217);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.03284270428635*x_1 - 0.190436441106929*x_10 - 82.8218894465164*x_100 - 39.5923890303052*x_101 - 63.8141445181586*x_102 + 119.869077986062*x_103 - 420.054931553742*x_104 - 66.8415030756837*x_105 - 120.152174746468*x_106 - 38.5370722648385*x_107 + 39.2588902110453*x_108 - 91.5105085734524*x_109 + 0.817573405970108*x_110 - 68.8740601606516*x_111 - 28.6062982467642*x_112 - 106.632491651864*x_113 + 99.1983547993501*x_114 + 63.8196279997514*x_115 - 110.519838532118*x_116 - 58.7806521762818*x_117 + 4.97730983401307*x_118 + 15.3371331139198*x_119 - 9.1455049861283*x_12 + 106.191476063114*x_120 - 229.46335201517*x_13 - 52.8869581246187*x_14 - 0.0333168240165317*x_17 - 274.375075397229*x_18 + 0.0566291544597835*x_19 + 40.4546842395346*x_2 - 8.17318403850587*x_20 - 0.598925964680141*x_21 - 0.264599036094678*x_22 + 42.1824724297538*x_24 + 165.224210029855*x_25 - 2.85686308609823*x_26 - 50.0330952543987*x_27 - 93.2471691629665*x_28 + 239.110568378156*x_29 + 19.4727704817172*x_3 - 0.257514131682948*x_30 + 18.2552626022204*x_31 - 0.238592963675374*x_32 + 217.590679713246*x_33 - 625.391925196439*x_34 - 727.107512446697*x_35 + 348.06155774598*x_36 - 1396.1418511322*x_37 + 104.82858538434*x_38 - 962.310519594506*x_39 - 29.8128677775831*x_4 - 518.594376784063*x_40 - 0.113467854706582*x_42 - 111.303629723728*x_43 + 35.4787300806545*x_44 - 113.717399587012*x_45 - 1.48173708714376*x_46 + 798.57857972401*x_47 - 497.076595340673*x_48 - 14.7874249439292*x_5 - 1.05661613549646*x_52 + 53.5568027847896*x_53 - 6.29996453343742*x_54 - 1.52828190339669*x_55 + 106.956058045525*x_56 + 255.44367593769*x_59 - 30.4108836530429*x_6 + 0.849632935615454*x_61 + 2.9495319628178*x_62 - 42.4622385728669*x_63 - 10.0682583453841*x_64 + 24.6831114860245*x_65 - 23.5779107697591*x_66 - 38.7572890769291*x_67 - 21.2616865965435*x_68 - 31.1492399368111*x_69 - 107.944518583134*x_7 + 38.2314748516461*x_70 - 34.1847474261886*x_71 + 20.0521057783832*x_72 - 33.4807181022507*x_73 + 74.9699154526056*x_74 + 52.1703843106686*x_75 + 58.3049463723814*x_76 + 52.2489380729937*x_77 + 27.3715948065843*x_78 + 221.563670636636*x_79 - 111.92293710954*x_8 - 29.0972952692484*x_80 + 70.5488071833977*x_81 - 51.4109869850792*x_82 + 103.063338382061*x_83 - 44.5780507011809*x_84 - 129.879548419016*x_85 - 280.032880097798*x_86 - 468.968420818955*x_87 + 12.3517012138826*x_88 - 25.6372293347002*x_89 + 50.7634687459391*x_9 - 26.3607813496434*x_90 - 9.38153190704506*x_91 + 53.5990270444157*x_92 - 18.1695504311781*x_93 - 53.5293536774263*x_94 - 52.1867601580165*x_95 - 37.3204419117641*x_96 + 12.152550527329*x_97 + 50.1720640909841*x_98 - 32.0114738637568*x_99 - 0.000189939100178584*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.0119942865882021*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) - 0.0365471250910804*std::exp(0.785679876804352*x_1) - 0.352930101970264*std::exp(1.17999982833862*x_1) - 0.190792456561806*std::exp(1.20335984230042*x_1) + 2.44139044249042*std::exp(1.76671993732452*x_1) + 0.787813125561932*std::exp(0.52215987443924*x_10) + 0.0120448454150258*std::exp(0.591439843177795*x_10) - 3.21579937244485*std::exp(0.900879800319672*x_10) - 0.00745822317488147*std::exp(0.885119915008545*x_11) + 0.359071782591707*std::exp(0.925119876861572*x_11) + 0.307306682084373*std::exp(0.944479823112488*x_11) - 0.0044779629173758*std::exp(1.00215983390808*x_11) + 1.99514485568933*std::exp(1.00799977779388*x_11) - 0.0678372511017844*std::exp(0.298719853162766*x_12) - 0.238868008082698*std::exp(0.684399843215942*x_12) - 0.000145018540569648*std::exp(1.34319984912872*x_12) + 2.14125733882108*std::exp(0.298239856958389*x_13) + 0.00117606879243805*std::exp(0.889039874076843*x_13) + 3.30845886044993e-5*std::exp(1.44815993309021*x_13) + 0.200121362963452*std::exp(0.24711985886097*x_15) - 0.454924309200423*std::exp(0.588559865951538*x_15) + 0.0446523418584474*std::exp(0.64167982339859*x_15) + 0.0635832782970023*std::exp(0.977839827537537*x_15) + 4.50116772537189*std::exp(1.00783979892731*x_15) + 0.975593356773673*std::exp(0.590879797935486*x_16) - 0.865199143180024*std::exp(0.653999865055084*x_16) - 44.0966773450212*std::exp(0.721039831638336*x_16) - 0.00761077628674865*std::exp(0.929839789867401*x_16) + 0.0526864890448105*std::exp(0.602319836616516*x_17) + 1.32474657330645*std::exp(0.615119874477386*x_17) + 59.3621907149683*std::exp(0.655999839305878*x_17) - 1.61068359479594*std::exp(0.666399836540222*x_17) + 101.644576115116*std::exp(0.753679871559143*x_19) + 1.2879737471781*std::exp(0.754959881305695*x_19) + 0.806410199924616*std::exp(0.772639811038971*x_19) + 0.0242713432833299*std::exp(0.822639882564545*x_19) - 0.0149251009250004*std::exp(0.812879860401154*x_2) + 0.196612418444374*std::exp(0.509519815444946*x_20) - 0.00598647868534544*std::exp(0.882799863815308*x_20) + 0.132799192927723*std::exp(0.894479870796204*x_20) - 0.00157867972253744*std::exp(0.971199810504913*x_20) - 16.6390639415668*std::exp(0.57015985250473*x_22) + 0.000245603882759249*std::exp(1.32799983024597*x_22) - 0.00253370866250738*std::exp(1.35727989673615*x_22) - 0.0575308221601373*std::exp(0.473199844360352*x_23) - 94.6139684570233*std::exp(0.541199862957001*x_23) - 0.421131168601422*std::exp(0.599999845027924*x_23) + 0.203013712816618*std::exp(0.88975989818573*x_23) + 0.00331582262547813*std::exp(1.0971999168396*x_23) + 1.81975560418991*std::exp(0.481039851903915*x_24) + 0.0647813142226154*std::exp(0.518959879875183*x_24) - 2.60176456427832*std::exp(0.579039871692657*x_24) - 0.777751028060232*std::exp(0.539999842643738*x_25) + 0.0448211950973498*std::exp(0.599599838256836*x_25) + 0.024642541292983*std::exp(0.719999849796295*x_25) - 0.146395254700465*std::exp(0.472639858722687*x_26) - 15.6805963978868*std::exp(0.830559849739075*x_26) + 0.0584469407194364*std::exp(0.873839855194092*x_26) + 0.000590133607606412*std::exp(0.995279788970947*x_26) - 0.0539624108348688*std::exp(0.952159821987152*x_27) + 0.0551125879138275*std::exp(0.953839838504791*x_27) - 0.00831120001789721*std::exp(0.630799829959869*x_28) + 0.0853139345657044*std::exp(0.639919817447662*x_28) - 0.0532729954248201*std::exp(1.00135982036591*x_28) - 0.0011483069537229*std::exp(1.18399977684021*x_29) + 0.000250424042217834*std::exp(1.33479988574982*x_29) + 0.141852656836265*std::exp(0.598319828510284*x_3) + 1.50009459366479*std::exp(0.64167982339859*x_3) + 0.00435194293500626*std::exp(0.719519853591919*x_3) - 0.0395722005015215*std::exp(0.833439886569977*x_30) - 0.236786286265819*std::exp(0.888719916343689*x_30) - 0.00127564278212175*std::exp(1.12327992916107*x_30) - 14.0056861486237*std::exp(0.879999876022339*x_32) + 0.2726820189024*std::exp(0.414639860391617*x_33) + 2.0161948972894*std::exp(0.464239865541458*x_33) + 0.567840051385771*std::exp(0.618639826774597*x_4) + 0.647718447612536*std::exp(0.686719834804535*x_4) + 0.00331012344586287*std::exp(1.15263986587524*x_4) - 21.8672193163118*std::exp(0.735999822616577*x_41) - 0.452285886763205*std::exp(0.797439873218536*x_41) - 0.0219768131740073*std::exp(0.80103987455368*x_41) - 0.00958574681219455*std::exp(0.811199843883514*x_41) + 0.209901639310912*std::exp(0.823679864406586*x_41) - 3.61954019150045*std::exp(0.798799872398376*x_42) + 0.0231925406160533*std::exp(0.846959888935089*x_43) + 0.00960166112881481*std::exp(0.912319839000702*x_44) - 0.000405850729118193*std::exp(0.976159811019897*x_44) + 0.0296307107642518*std::exp(0.542799830436707*x_45) - 0.459974429009931*std::exp(0.54535984992981*x_45) + 0.283286348063494*std::exp(0.739759802818298*x_46) - 19.1536320906446*std::exp(0.763999879360199*x_46) + 0.0355671984340109*std::exp(0.56335985660553*x_47) - 13.3096839348648*std::exp(0.64167982339859*x_49) + 0.0458858665682497*std::exp(0.711119830608368*x_49) - 0.561377046331622*std::exp(0.730319857597351*x_49) - 0.073931019833433*std::exp(0.731119871139526*x_49) + 0.825125032444169*std::exp(0.733759820461273*x_49) + 0.0616963792652187*std::exp(0.500079810619354*x_50) - 0.537704373795661*std::exp(0.545759856700897*x_50) + 0.639237080197411*std::exp(0.560399830341339*x_50) - 131.002604553945*std::exp(0.56335985660553*x_50) - 0.0771785778813947*std::exp(0.596959829330444*x_50) - 4.81392552567337*std::exp(0.485359847545624*x_51) + 22.8996669555667*std::exp(0.49431985616684*x_51) + 0.429803533395351*std::exp(0.494879871606827*x_51) - 0.876451780057464*std::exp(0.500959813594818*x_51) - 270.4013771684*std::exp(0.503039836883545*x_51) - 0.740178276160558*std::exp(0.511919856071472*x_52) + 7.05304789199101*std::exp(0.670159876346588*x_52) - 0.00963996791813842*std::exp(0.767999827861786*x_52) - 0.000229353721424166*std::exp(0.831919848918915*x_52) + 0.0173759930529715*std::exp(0.497679859399796*x_53) - 96.989893585157*std::exp(0.447279840707779*x_54) - 2.95038600451033*std::exp(0.459519863128662*x_54) - 0.291076607416704*std::exp(0.508319854736328*x_54) + 0.078210497572886*std::exp(0.512159824371338*x_54) + 742.559662279363*std::exp(0.652319848537445*x_55) - 0.640548764656895*std::exp(0.652479827404022*x_55) - 7.59083527905527*std::exp(0.653519809246063*x_55) - 0.0441497296477748*std::exp(0.700159847736359*x_55) + 1.59114183029537*std::exp(0.471919864416122*x_56) + 0.135770603718047*std::exp(0.553919851779938*x_56) + 0.088629250953302*std::exp(0.583439826965332*x_56) + 2.60387880263494*std::exp(0.610639870166779*x_57) - 349.498166240647*std::exp(0.630239844322205*x_57) - 0.343798984148537*std::exp(0.633599877357483*x_57) + 2.58463319013703*std::exp(0.638239860534668*x_57) - 0.0171370942656374*std::exp(0.663359880447388*x_57) + 0.0806355661041251*std::exp(0.589439868927002*x_58) + 1.34882620697885*std::exp(0.592319846153259*x_58) - 139.80683405493*std::exp(0.619999825954437*x_58) - 1.19864219979245*std::exp(0.620639801025391*x_58) + 0.0131096901512841*std::exp(0.712479829788208*x_58) - 0.264909314314419*std::exp(0.610799849033356*x_59) - 0.0035654616268535*std::exp(0.726239860057831*x_59) - 0.240442366182015*std::exp(0.798399865627289*x_60) + 0.0381158630958335*std::exp(0.802639901638031*x_60) + 16.1175771465599*std::exp(0.808239877223969*x_60) - 0.0112449812728442*std::exp(0.813839852809906*x_60) + 0.389030739763935*std::exp(0.834959864616394*x_60) - 0.422354550750449*std::exp(1.13743984699249*x_61) + 3.46659842717563*std::exp(1.35527992248535*x_61) + 0.0102614502367249*std::exp(1.38071978092194*x_61) + 0.000474683445824726*std::exp(1.79559993743896*x_61) + 0.027076796092445*std::exp(0.925839841365814*x_66) - 0.387982638198725*std::exp(1.02399981021881*x_66) - 0.657825318282493*std::exp(1.04943978786469*x_66) + 2.71501115208926*std::exp(0.33927983045578*x_8) + 0.0148402469785813*std::exp(0.773439824581146*x_8) + 0.569170811840391*std::log(5.44279956817627 - 0.804559826850891*x_5) - 0.801578105479951*std::log(9.53880023956299 - 1.21599996089935*x_21) - 6.95190357866608*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 5.55023383762996*std::sin(0.231199979782104*x_101 + 1.96639978885651) + 1.15053006006393*std::sin(0.231199979782104*x_102 + 1.9916797876358) - 442.666024487616*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 7.99171603763593*std::sin(0.268559962511063*x_120 + 1.97511982917786) - 0.250364419659088*std::sin(0.299279928207397*x_120 - 7.47304010391235) - 12589.2451353459*std::sin(0.0630401000380516*x_30 + 1.65183997154236) - 0.224855724196461*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 6.18055629026565*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 8.2918360948095*std::sin(0.273439943790436*x_42 + 5.1384801864624) + 0.312848460264747*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 3.59539201275088*std::sin(0.307119935750961*x_92 + 8.21607971191406) + 0.274478138037978*std::sin(0.269759953022003*x_95 + 1.96215975284576) + 6.22502692907631*std::sin(0.273519963026047*x_95 - 1.20119988918304) + 0.507320651632101*std::sin(0.32551982998848*x_97 - 7.55847978591919) + 9.38921086011476*std::sin(0.267439961433411*x_98 + 1.9625598192215) + 13058.4003744456);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0462863381065686*x_1 + 0.860610890463611*x_10 + 25.8547764084136*x_100 + 12.4793221012194*x_101 + 21.0600092174625*x_102 - 37.0176973184621*x_103 + 223.328139577176*x_104 + 14.3715227210899*x_105 + 48.3154532046183*x_106 + 16.8440215816841*x_107 - 9.88869671161729*x_108 + 32.9051447274221*x_109 - 1.4165929758428*x_110 + 12.4116211369945*x_111 + 6.76039455256564*x_112 + 33.4942543538778*x_113 - 23.767842009228*x_114 - 23.3362674912465*x_115 + 33.9607982690924*x_116 + 13.0925417241474*x_117 - 5.16262243076682*x_118 + 1.61692081199224*x_119 + 4.59373688793494*x_12 - 32.7959465864077*x_120 + 66.0163836493013*x_13 + 22.064462852325*x_14 - 0.0553489780855058*x_17 + 83.0699694813239*x_18 + 0.0940775695678561*x_19 - 11.0020227451436*x_2 + 2.44992264184392*x_20 - 0.322402754095625*x_21 + 1.75195904636605*x_22 - 12.6238083161533*x_24 - 53.0653230462947*x_25 + 13.5550341178755*x_26 + 15.4061862247055*x_27 + 26.9568307335688*x_28 - 66.3331111066582*x_29 - 8.26153395044372*x_3 + 1.22183413611353*x_30 - 6.25626738858049*x_31 + 5.25501972509472*x_32 - 70.5847150080038*x_33 + 211.474091144764*x_34 + 192.929574396111*x_35 - 86.9466493213587*x_36 + 470.841965732648*x_37 + 63.8329889827156*x_38 + 279.808997815856*x_39 + 8.89071689750362*x_4 - 274.351914605321*x_40 + 0.236109966987363*x_42 + 31.0912730558143*x_43 - 4.94076714921499*x_44 + 16.5205196678754*x_45 + 1.00553110958231*x_46 - 213.026314898632*x_47 + 148.423264736231*x_48 + 8.53015892205625*x_5 + 5.0133546251645*x_52 - 16.5701197730137*x_53 + 7.76019202717838*x_54 + 1.88251235051779*x_55 - 34.2880019875546*x_56 - 87.9214127161298*x_59 + 2.92046471364244*x_6 - 4.03127594247694*x_61 + 0.793567318707575*x_62 + 11.7565275022605*x_63 - 0.404374333863791*x_64 - 12.3047576389001*x_65 + 7.05735432623722*x_66 + 10.2415884406017*x_67 + 8.71891060589761*x_68 + 5.3517829463685*x_69 + 36.7741565558023*x_7 - 15.4285082958991*x_70 + 4.20346133111963*x_71 - 8.20310989559303*x_72 + 1.90418838857832*x_73 - 20.2153330903367*x_74 - 12.4187319960017*x_75 - 18.7796810191566*x_76 - 15.9240519159046*x_77 - 13.6389872424941*x_78 - 64.748306847037*x_79 + 33.2433974929378*x_8 + 8.89176709233276*x_80 - 22.8887878180091*x_81 + 18.92802221515*x_82 - 29.3519914389977*x_83 + 13.4184176543575*x_84 + 33.2142308863256*x_85 + 90.2223780945213*x_86 + 133.980821347788*x_87 + 13.4357245927768*x_88 + 2.90573120712334*x_89 - 16.0440362170283*x_9 + 10.6502556100177*x_90 + 8.09187850723615*x_91 - 15.2188681728385*x_92 + 5.94256077289738*x_93 + 15.0850248087364*x_94 + 14.5076219730751*x_95 + 9.03091477492336*x_96 - 0.834799504376683*x_97 - 21.8833181167099*x_98 + 17.2967466927244*x_99 - 0.000267687622001861*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) + 0.056909609954289*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) - 0.0607154518915344*std::exp(0.785679876804352*x_1) + 1.67455682308037*std::exp(1.17999982833862*x_1) + 0.235014989750881*std::exp(1.20335984230042*x_1) - 0.731809989162076*std::exp(1.76671993732452*x_1) - 0.970415167171816*std::exp(0.52215987443924*x_10) + 0.0169752095460955*std::exp(0.591439843177795*x_10) + 0.963940082232672*std::exp(0.900879800319672*x_10) - 0.0105111271147756*std::exp(0.885119915008545*x_11) - 0.442298677978831*std::exp(0.925119876861572*x_11) - 1.45808617170868*std::exp(0.944479823112488*x_11) - 0.00743920462702442*std::exp(1.00215983390808*x_11) - 0.59804728887584*std::exp(1.00799977779388*x_11) - 0.095605340940892*std::exp(0.298719853162766*x_12) + 1.1333633785202*std::exp(0.684399843215942*x_12) - 0.000240918162547507*std::exp(1.34319984912872*x_12) - 2.63756534511634*std::exp(0.298239856958389*x_13) + 0.00165747367478494*std::exp(0.889039874076843*x_13) + 5.49631672193536e-5*std::exp(1.44815993309021*x_13) + 0.282037830615656*std::exp(0.24711985886097*x_15) + 0.560368233581235*std::exp(0.588559865951538*x_15) + 0.0741805848529676*std::exp(0.64167982339859*x_15) - 0.301685268305716*std::exp(0.977839827537537*x_15) - 1.34923093291089*std::exp(1.00783979892731*x_15) - 1.20171974759871*std::exp(0.590879797935486*x_16) + 4.10513334070174*std::exp(0.653999865055084*x_16) + 13.2180369056516*std::exp(0.721039831638336*x_16) - 0.0126437228740626*std::exp(0.929839789867401*x_16) + 0.0742528576305354*std::exp(0.602319836616516*x_17) - 1.631800900091*std::exp(0.615119874477386*x_17) - 17.7938945724076*std::exp(0.655999839305878*x_17) + 7.6422532066035*std::exp(0.666399836540222*x_17) - 30.4680950865477*std::exp(0.753679871559143*x_19) - 1.58650474157718*std::exp(0.754959881305695*x_19) - 3.82619588112987*std::exp(0.772639811038971*x_19) + 0.034206428061398*std::exp(0.822639882564545*x_19) - 0.0210344514162418*std::exp(0.812879860401154*x_2) - 0.93287216072065*std::exp(0.509519815444946*x_20) - 0.00994529002524731*std::exp(0.882799863815308*x_20) - 0.163579847585452*std::exp(0.894479870796204*x_20) - 0.00222488692655317*std::exp(0.971199810504913*x_20) + 4.98758125321566*std::exp(0.57015985250473*x_22) + 0.000408019801581675*std::exp(1.32799983024597*x_22) + 0.00312098038927443*std::exp(1.35727989673615*x_22) - 0.0810801407471104*std::exp(0.473199844360352*x_23) + 28.360661214224*std::exp(0.541199862957001*x_23) + 0.518742402378881*std::exp(0.599999845027924*x_23) - 0.963244552046142*std::exp(0.88975989818573*x_23) + 0.00550855008694549*std::exp(1.0971999168396*x_23) - 2.24154483030757*std::exp(0.481039851903915*x_24) + 0.0912985053530462*std::exp(0.518959879875183*x_24) + 12.3446613899997*std::exp(0.579039871692657*x_24) + 0.958020842029992*std::exp(0.539999842643738*x_25) + 0.0631680318565805*std::exp(0.599599838256836*x_25) + 0.0409384603202187*std::exp(0.719999849796295*x_25) - 0.24320528692103*std::exp(0.472639858722687*x_26) + 4.70027934912644*std::exp(0.830559849739075*x_26) - 0.0719939740893216*std::exp(0.873839855194092*x_26) + 0.000831695327265488*std::exp(0.995279788970947*x_26) + 0.256036883079497*std::exp(0.952159821987152*x_27) - 0.0678867734978655*std::exp(0.953839838504791*x_27) - 0.0117132563367991*std::exp(0.630799829959869*x_28) + 0.141731369482349*std::exp(0.639919817447662*x_28) + 0.252765795483429*std::exp(1.00135982036591*x_28) - 0.00190767332400909*std::exp(1.18399977684021*x_29) + 0.000352931104182118*std::exp(1.33479988574982*x_29) + 0.235658704764456*std::exp(0.598319828510284*x_3) - 1.84779168898262*std::exp(0.64167982339859*x_3) + 0.00613334091961217*std::exp(0.719519853591919*x_3) - 0.0657409859135177*std::exp(0.833439886569977*x_30) + 0.291669427831302*std::exp(0.888719916343689*x_30) - 0.00179780667881942*std::exp(1.12327992916107*x_30) + 4.19822280379552*std::exp(0.879999876022339*x_32) + 0.453004496498571*std::exp(0.414639860391617*x_33) - 2.48351549983188*std::exp(0.464239865541458*x_33) - 2.69424576469384*std::exp(0.618639826774597*x_4) - 0.797848861900914*std::exp(0.686719834804535*x_4) + 0.00549908208460907*std::exp(1.15263986587524*x_4) + 6.55472768810828*std::exp(0.735999822616577*x_41) + 0.55711826849763*std::exp(0.797439873218536*x_41) - 0.0309726688828049*std::exp(0.80103987455368*x_41) - 0.0159247258975856*std::exp(0.811199843883514*x_41) - 0.995925879718405*std::exp(0.823679864406586*x_41) + 1.0849619226049*std::exp(0.798799872398376*x_42) - 0.0285681876181145*std::exp(0.846959888935089*x_43) - 0.0118271672394388*std::exp(0.912319839000702*x_44) - 0.000571979210511285*std::exp(0.976159811019897*x_44) + 0.0492252670883262*std::exp(0.542799830436707*x_45) + 0.566588887566513*std::exp(0.54535984992981*x_45) - 1.34411625527825*std::exp(0.739759802818298*x_46) + 5.74132635596407*std::exp(0.763999879360199*x_46) + 0.0501260602009643*std::exp(0.56335985660553*x_47) + 3.98959522680375*std::exp(0.64167982339859*x_49) + 0.0646685095043657*std::exp(0.711119830608368*x_49) + 0.691494953036926*std::exp(0.730319857597351*x_49) - 0.12282102263317*std::exp(0.731119871139526*x_49) - 3.91499264375643*std::exp(0.733759820461273*x_49) + 0.0869508017891169*std::exp(0.500079810619354*x_50) + 0.66233534686763*std::exp(0.545759856700897*x_50) - 3.03300514247644*std::exp(0.560399830341339*x_50) + 39.2682026398989*std::exp(0.56335985660553*x_50) - 0.128216165313602*std::exp(0.596959829330444*x_50) + 22.8407602236668*std::exp(0.485359847545624*x_51) - 28.2074306911484*std::exp(0.49431985616684*x_51) + 0.605736710737409*std::exp(0.494879871606827*x_51) - 1.45604245900907*std::exp(0.500959813594818*x_51) + 81.0531676748765*std::exp(0.503039836883545*x_51) + 0.911739348192453*std::exp(0.511919856071472*x_52) - 2.11416036188476*std::exp(0.670159876346588*x_52) - 0.0160148029950655*std::exp(0.767999827861786*x_52) - 0.000323235985784851*std::exp(0.831919848918915*x_52) + 0.0244885768959499*std::exp(0.497679859399796*x_53) + 29.0728478894924*std::exp(0.447279840707779*x_54) + 13.9987747913604*std::exp(0.459519863128662*x_54) - 0.48356328193577*std::exp(0.508319854736328*x_54) + 0.110224709347279*std::exp(0.512159824371338*x_54) - 222.583233286737*std::exp(0.652319848537445*x_55) - 0.90274711960843*std::exp(0.652479827404022*x_55) + 36.0164376415026*std::exp(0.653519809246063*x_55) - 0.0733455991346344*std::exp(0.700159847736359*x_55) - 7.54953287785632*std::exp(0.471919864416122*x_56) + 0.22555463768447*std::exp(0.553919851779938*x_56) + 0.124908212185848*std::exp(0.583439826965332*x_56) - 12.3546928728512*std::exp(0.610639870166779*x_57) + 104.762534004119*std::exp(0.630239844322205*x_57) - 0.571150552346*std::exp(0.633599877357483*x_57) - 3.1837083794404*std::exp(0.638239860534668*x_57) - 0.0241518887247389*std::exp(0.663359880447388*x_57) + 0.113642440755444*std::exp(0.589439868927002*x_58) - 1.66146179425162*std::exp(0.592319846153259*x_58) + 41.9072819872908*std::exp(0.619999825954437*x_58) + 5.68722946240394*std::exp(0.620639801025391*x_58) + 0.021779025291581*std::exp(0.712479829788208*x_58) + 0.326310908253063*std::exp(0.610799849033356*x_59) - 0.00502492611228508*std::exp(0.726239860057831*x_59) + 0.296172926551939*std::exp(0.798399865627289*x_60) + 0.0633215840187713*std::exp(0.802639901638031*x_60) - 4.83126490202487*std::exp(0.808239877223969*x_60) - 0.0158479338564462*std::exp(0.813839852809906*x_60) - 1.84584447748407*std::exp(0.834959864616394*x_60) + 0.520249344259058*std::exp(1.13743984699249*x_61) - 1.03911742803123*std::exp(1.35527992248535*x_61) + 0.0170472666901315*std::exp(1.38071978092194*x_61) + 0.00066898749492337*std::exp(1.79559993743896*x_61) + 0.0449824687011826*std::exp(0.925839841365814*x_66) + 1.84087152216655*std::exp(1.02399981021881*x_66) + 0.810298337890254*std::exp(1.04943978786469*x_66) - 12.8819854812311*std::exp(0.33927983045578*x_8) + 0.0246539857578686*std::exp(0.773439824581146*x_8) + 0.94555899973634*std::log(5.44279956817627 - 0.804559826850891*x_5) - 1.33165541145268*std::log(9.53880023956299 - 1.21599996089935*x_21) + 8.56323975135808*std::sin(0.276399940252304*x_100 + 1.92679977416992) - 26.3343418161533*std::sin(0.231199979782104*x_101 + 1.96639978885651) + 1.9113665531143*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 132.689721785037*std::sin(0.222479999065399*x_110 - 1.2066398859024) - 37.9185072178161*std::sin(0.268559962511063*x_120 + 1.97511982917786) - 0.415928444146574*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 3773.64275116036*std::sin(0.0630401000380516*x_30 + 1.65183997154236) - 0.373551048706655*std::sin(0.320079833269119*x_31 + 5.15208005905151) - 29.3250494886056*std::sin(0.385919839143753*x_31 - 7.40183973312378) - 39.342494819547*std::sin(0.273439943790436*x_42 + 5.1384801864624) + 0.519732690087316*std::sin(0.328239858150482*x_91 + 2.00375986099243) + 17.059151919855*std::sin(0.307119935750961*x_92 + 8.21607971191406) + 0.386831358018454*std::sin(0.269759953022003*x_95 + 1.96215975284576) - 7.66788512658991*std::sin(0.273519963026047*x_95 - 1.20119988918304) + 0.842807814321578*std::sin(0.32551982998848*x_97 - 7.55847978591919) - 11.565474515204*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 4085.6238250563);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0163823237335072*x_1 - 0.208494320487214*x_10 + 18.1621351273903*x_100 + 5.29131034553457*x_101 + 17.0243606326443*x_102 - 24.3382705777896*x_103 - 24.6168521085181*x_104 + 19.5887564502749*x_105 + 44.3646503684388*x_106 + 2.55932443395328*x_107 - 9.29191244657286*x_108 + 12.8368255900197*x_109 + 5.47714245772998*x_110 + 22.8543942212289*x_111 + 2.23252714087936*x_112 + 27.479704558289*x_113 - 31.3418845765598*x_114 - 10.8820554614262*x_115 + 23.7166901600722*x_116 + 15.2370491283257*x_117 - 2.89994656486115*x_118 - 3.89221943753072*x_119 - 8.69400337711845*x_12 - 17.7271314898118*x_120 + 52.1801731282563*x_13 + 3.11500585944178*x_14 + 0.0691368468097704*x_17 + 52.5782308391444*x_18 - 0.117513037104323*x_19 - 11.4812895017204*x_2 + 1.82680963868945*x_20 - 1.42049100667908*x_21 - 0.458211829163702*x_22 - 9.44761667168217*x_24 - 35.7878955313858*x_25 - 3.45829568938114*x_26 + 10.6754190232358*x_27 + 26.6048976405531*x_28 - 54.4549726556091*x_29 - 3.57020455548176*x_3 - 0.311726528263611*x_30 + 0.56839382335087*x_31 + 0.755706781436211*x_32 - 46.8887847101863*x_33 + 222.093019684781*x_34 + 149.817895289127*x_35 - 88.0586582332345*x_36 + 265.450701676347*x_37 - 40.0782197631786*x_38 + 222.994212005908*x_39 + 6.67091774995433*x_4 + 412.1889165224*x_40 - 0.820832687446628*x_42 + 25.9266347798617*x_43 - 9.8498664649842*x_44 + 31.1086029807089*x_45 - 5.78413721274547*x_46 - 216.026291156864*x_47 + 104.099164032169*x_48 + 0.473331113443925*x_5 - 1.27905710445107*x_52 - 16.7463952291363*x_53 - 32.6305556028077*x_54 - 7.91570926484898*x_55 - 10.9915562457887*x_56 - 53.1473000259447*x_59 + 8.01756613756119*x_6 + 1.02849938209959*x_61 - 4.69681962998906*x_62 + 8.49091683411239*x_63 + 7.87610812554768*x_64 + 1.6744645366652*x_65 + 5.2715960324901*x_66 + 7.49622295718541*x_67 + 7.70026398433733*x_68 + 7.46546021318469*x_69 + 16.059732054253*x_7 - 2.67115812759296*x_70 + 14.4034964188151*x_71 - 3.02397683580047*x_72 + 12.3600678337181*x_73 - 16.3312158576676*x_74 - 19.5578564362306*x_75 - 11.9987566688066*x_76 - 9.85110204983687*x_77 - 1.42446089385569*x_78 - 59.3041810636588*x_79 + 26.8382992425527*x_8 + 7.21647570937922*x_80 - 12.3411721985748*x_81 + 8.65077941483984*x_82 - 36.5167012014038*x_83 + 5.69068927864186*x_84 + 37.6080292232308*x_85 + 106.695196506733*x_86 + 98.3731357398863*x_87 - 6.98349854819124*x_88 + 10.5703567353154*x_89 - 9.33065182954364*x_9 + 5.14480529143132*x_90 - 4.20212051399618*x_91 - 17.0679805988725*x_92 + 11.6169867680093*x_93 + 8.78764786773627*x_94 + 12.0189098779978*x_95 + 8.83010839304685*x_96 - 8.62703689458477*x_97 - 8.92709991268518*x_98 + 19.0138340884578*x_99 + 9.47438372201849e-5*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.0145193480944278*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) + 0.0758401517355248*std::exp(0.785679876804352*x_1) - 0.427229661874894*std::exp(1.17999982833862*x_1) - 0.98820617630357*std::exp(1.20335984230042*x_1) - 0.545681532574558*std::exp(1.76671993732452*x_1) + 4.0804642410017*std::exp(0.52215987443924*x_10) - 0.00600810929540335*std::exp(0.591439843177795*x_10) + 0.718771688242526*std::exp(0.900879800319672*x_10) + 0.00372024865742969*std::exp(0.885119915008545*x_11) + 1.85980598860055*std::exp(0.925119876861572*x_11) + 0.372001507227241*std::exp(0.944479823112488*x_11) + 0.00929236940726477*std::exp(1.00215983390808*x_11) - 0.445940019921689*std::exp(1.00799977779388*x_11) + 0.0338380116037685*std::exp(0.298719853162766*x_12) - 0.28915498495648*std::exp(0.684399843215942*x_12) + 0.000300932784558495*std::exp(1.34319984912872*x_12) + 11.0906047618967*std::exp(0.298239856958389*x_13) - 0.00058663682267488*std::exp(0.889039874076843*x_13) - 6.86549274018004e-5*std::exp(1.44815993309021*x_13) - 0.0998228685882161*std::exp(0.24711985886097*x_15) - 2.35627246592352*std::exp(0.588559865951538*x_15) - 0.0926595559418616*std::exp(0.64167982339859*x_15) + 0.0769689588280409*std::exp(0.977839827537537*x_15) - 1.00606771453178*std::exp(1.00783979892731*x_15) + 5.05306864903312*std::exp(0.590879797935486*x_16) - 1.04734261920904*std::exp(0.653999865055084*x_16) + 9.85616313404216*std::exp(0.721039831638336*x_16) + 0.0157933743618324*std::exp(0.929839789867401*x_16) - 0.0262806348828192*std::exp(0.602319836616516*x_17) + 6.86150159901284*std::exp(0.615119874477386*x_17) - 13.2681977624536*std::exp(0.655999839305878*x_17) - 1.94976796751127*std::exp(0.666399836540222*x_17) - 22.7188437814184*std::exp(0.753679871559143*x_19) + 6.67103739222488*std::exp(0.754959881305695*x_19) + 0.976177308546174*std::exp(0.772639811038971*x_19) - 0.0121068289519585*std::exp(0.822639882564545*x_19) + 0.00744481431787105*std::exp(0.812879860401154*x_2) + 0.238003663001442*std::exp(0.509519815444946*x_20) + 0.0124227405227255*std::exp(0.882799863815308*x_20) + 0.687831086323864*std::exp(0.894479870796204*x_20) + 0.000787463847697842*std::exp(0.971199810504913*x_20) + 3.71904049193306*std::exp(0.57015985250473*x_22) - 0.000509660765077292*std::exp(1.32799983024597*x_22) - 0.0131232994970771*std::exp(1.35727989673615*x_22) + 0.0286970447093759*std::exp(0.473199844360352*x_23) + 21.1474143635638*std::exp(0.541199862957001*x_23) - 2.18124148797807*std::exp(0.599999845027924*x_23) + 0.245752570830352*std::exp(0.88975989818573*x_23) - 0.0068807735332846*std::exp(1.0971999168396*x_23) + 9.42539217655576*std::exp(0.481039851903915*x_24) - 0.0323136746664927*std::exp(0.518959879875183*x_24) - 3.1494933100616*std::exp(0.579039871692657*x_24) - 4.02834778379509*std::exp(0.539999842643738*x_25) - 0.0223573345789508*std::exp(0.599599838256836*x_25) - 0.0511365549588711*std::exp(0.719999849796295*x_25) + 0.303789649724151*std::exp(0.472639858722687*x_26) + 3.5048109164192*std::exp(0.830559849739075*x_26) + 0.302724902471631*std::exp(0.873839855194092*x_26) - 0.000294365522447213*std::exp(0.995279788970947*x_26) - 0.0653226868613137*std::exp(0.952159821987152*x_27) + 0.285454680703663*std::exp(0.953839838504791*x_27) + 0.00414572344956721*std::exp(0.630799829959869*x_28) - 0.177037775926095*std::exp(0.639919817447662*x_28) - 0.0644881343227738*std::exp(1.00135982036591*x_28) + 0.00238288985500962*std::exp(1.18399977684021*x_29) - 0.000124914431360365*std::exp(1.33479988574982*x_29) - 0.294363154194452*std::exp(0.598319828510284*x_3) + 7.76971358937833*std::exp(0.64167982339859*x_3) - 0.00217079986499935*std::exp(0.719519853591919*x_3) + 0.0821175860772825*std::exp(0.833439886569977*x_30) - 1.2264304090873*std::exp(0.888719916343689*x_30) + 0.000636305489426943*std::exp(1.12327992916107*x_30) + 3.13044736692878*std::exp(0.879999876022339*x_32) - 0.565851503711149*std::exp(0.414639860391617*x_33) + 10.4428460434844*std::exp(0.464239865541458*x_33) + 0.687382889128015*std::exp(0.618639826774597*x_4) + 3.35484631819874*std::exp(0.686719834804535*x_4) - 0.00686894697659342*std::exp(1.15263986587524*x_4) + 4.8875991082757*std::exp(0.735999822616577*x_41) - 2.34260680327028*std::exp(0.797439873218536*x_41) + 0.0109622905869243*std::exp(0.80103987455368*x_41) + 0.0198917012192728*std::exp(0.811199843883514*x_41) + 0.254090557561288*std::exp(0.823679864406586*x_41) + 0.809012849619577*std::exp(0.798799872398376*x_42) + 0.120125356599362*std::exp(0.846959888935089*x_43) + 0.0497316351036918*std::exp(0.912319839000702*x_44) + 0.000202443074538704*std::exp(0.976159811019897*x_44) - 0.0614876709123353*std::exp(0.542799830436707*x_45) - 2.38242947274005*std::exp(0.54535984992981*x_45) + 0.342924363836602*std::exp(0.739759802818298*x_46) + 4.28107816418356*std::exp(0.763999879360199*x_46) - 0.0177413331727992*std::exp(0.56335985660553*x_47) + 2.97488210048504*std::exp(0.64167982339859*x_49) - 0.0228884051191243*std::exp(0.711119830608368*x_49) - 2.90764254738894*std::exp(0.730319857597351*x_49) + 0.153416711934424*std::exp(0.731119871139526*x_49) + 0.998832025513465*std::exp(0.733759820461273*x_49) - 0.0307748731497768*std::exp(0.500079810619354*x_50) - 2.78503035594693*std::exp(0.545759856700897*x_50) + 0.773810565055298*std::exp(0.560399830341339*x_50) + 29.2807331347353*std::exp(0.56335985660553*x_50) + 0.160155827378212*std::exp(0.596959829330444*x_50) - 5.82736287764322*std::exp(0.485359847545624*x_51) + 118.608422621023*std::exp(0.49431985616684*x_51) - 0.21439101252129*std::exp(0.494879871606827*x_51) + 1.81875416528047*std::exp(0.500959813594818*x_51) + 60.4381156473305*std::exp(0.503039836883545*x_51) - 3.83374037553023*std::exp(0.511919856071472*x_52) - 1.57644509294359*std::exp(0.670159876346588*x_52) + 0.0200042172350142*std::exp(0.767999827861786*x_52) + 0.000114404309739406*std::exp(0.831919848918915*x_52) - 0.00866734788046245*std::exp(0.497679859399796*x_53) + 21.6784635733247*std::exp(0.447279840707779*x_54) - 3.57150724200218*std::exp(0.459519863128662*x_54) + 0.604022724581757*std::exp(0.508319854736328*x_54) - 0.0390123078607206*std::exp(0.512159824371338*x_54) - 165.971442948433*std::exp(0.652319848537445*x_55) + 0.31951319045517*std::exp(0.652479827404022*x_55) - 9.18887329676411*std::exp(0.653519809246063*x_55) + 0.0916165686692227*std::exp(0.700159847736359*x_55) + 1.92611223116742*std::exp(0.471919864416122*x_56) - 0.28174208399537*std::exp(0.553919851779938*x_56) - 0.0442093034944964*std::exp(0.583439826965332*x_56) + 3.15205264215932*std::exp(0.610639870166779*x_57) + 78.1172448564389*std::exp(0.630239844322205*x_57) + 0.713428677614587*std::exp(0.633599877357483*x_57) + 13.3870621931282*std::exp(0.638239860534668*x_57) + 0.00854818238058382*std::exp(0.663359880447388*x_57) - 0.0402219603122458*std::exp(0.589439868927002*x_58) + 6.98622163851023*std::exp(0.592319846153259*x_58) + 31.248589387312*std::exp(0.619999825954437*x_58) - 1.45098278346757*std::exp(0.620639801025391*x_58) - 0.0272043529498236*std::exp(0.712479829788208*x_58) - 1.37209313870881*std::exp(0.610799849033356*x_59) + 0.00177849382076578*std::exp(0.726239860057831*x_59) - 1.24536701077142*std::exp(0.798399865627289*x_60) - 0.0790954920124211*std::exp(0.802639901638031*x_60) - 3.60248162098635*std::exp(0.808239877223969*x_60) + 0.00560912773755734*std::exp(0.813839852809906*x_60) + 0.470930279056472*std::exp(0.834959864616394*x_60) - 2.18757797432262*std::exp(1.13743984699249*x_61) - 0.774828437778309*std::exp(1.35527992248535*x_61) - 0.0212938758121274*std::exp(1.38071978092194*x_61) - 0.000236777635989902*std::exp(1.79559993743896*x_61) - 0.0561879578501803*std::exp(0.925839841365814*x_66) - 0.46966152902689*std::exp(1.02399981021881*x_66) - 3.40719467724363*std::exp(1.04943978786469*x_66) + 3.28658079891238*std::exp(0.33927983045578*x_8) - 0.0307954888337565*std::exp(0.773439824581146*x_8) - 1.18110523401859*std::log(5.44279956817627 - 0.804559826850891*x_5) + 1.66338131921383*std::log(9.53880023956299 - 1.21599996089935*x_21) - 36.0072624321981*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 6.71868030677935*std::sin(0.231199979782104*x_101 + 1.96639978885651) - 2.38750309672993*std::sin(0.231199979782104*x_102 + 1.9916797876358) + 98.9414353628267*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 9.67414828460008*std::sin(0.268559962511063*x_120 + 1.97511982917786) + 0.51953951313002*std::sin(0.299279928207397*x_120 - 7.47304010391235) + 2813.85494915129*std::sin(0.0630401000380516*x_30 + 1.65183997154236) + 0.466605572918864*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 7.48169951882261*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 10.0374502240842*std::sin(0.273439943790436*x_42 + 5.1384801864624) - 0.649202218712802*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 4.35230122151687*std::sin(0.307119935750961*x_92 + 8.21607971191406) - 0.136912894745312*std::sin(0.269759953022003*x_95 + 1.96215975284576) + 32.2424175977653*std::sin(0.273519963026047*x_95 - 1.20119988918304) - 1.05275791467751*std::sin(0.32551982998848*x_97 - 7.55847978591919) + 48.6312526699726*std::sin(0.267439961433411*x_98 + 1.9625598192215) - 2229.53997150988);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0141303183801057*x_1 - 0.0537987372134228*x_10 - 91.3241668992322*x_100 - 42.384452692861*x_101 - 71.562107795624*x_102 + 131.704198389132*x_103 - 404.557114641727*x_104 - 76.1852961855986*x_105 - 139.972547111085*x_106 - 39.4580691511566*x_107 + 43.9010068390762*x_108 - 98.1034096106804*x_109 - 2.21429047555268*x_110 - 79.754076443157*x_111 - 30.2127605495503*x_112 - 119.297401511909*x_113 + 114.17893571056*x_114 + 69.3705386126596*x_115 - 122.232085317225*x_116 - 65.9873179582187*x_117 + 6.24453077950061*x_118 + 17.4959651183185*x_119 - 5.63900521041985*x_12 + 114.945859258033*x_120 - 254.512200671398*x_13 - 53.8263991311896*x_14 - 0.200894697472041*x_17 - 300.949299617969*x_18 + 0.341464025732185*x_19 + 46.0174318634911*x_2 - 9.0424849315398*x_20 - 0.112515423782156*x_21 + 0.00959833919833755*x_22 + 46.7203308863603*x_24 + 181.974491035454*x_25 - 0.2077914301774*x_26 - 53.8768360875306*x_27 - 105.568870917583*x_28 + 265.499941546345*x_29 + 20.980097683605*x_3 - 0.0187300644450454*x_30 + 18.2493688145714*x_31 + 1.39096488092042*x_32 + 239.425776660335*x_33 - 718.715125649929*x_34 - 801.476223446573*x_35 + 391.583801300359*x_36 - 1512.28149275006*x_37 + 120.591662376916*x_38 - 1066.93604907187*x_39 - 32.9656775537236*x_4 - 688.502972831918*x_40 + 0.324657427043857*x_42 - 124.830825172653*x_43 + 40.8802317418859*x_44 - 129.990836106322*x_45 + 0.534898012261248*x_46 + 898.597751731088*x_47 - 547.048232934276*x_48 - 14.861672466823*x_5 - 0.0768520476223401*x_52 + 60.6509669737325*x_53 + 7.22857746119635*x_54 + 1.7535502085152*x_55 + 112.944884457004*x_56 + 278.927486176873*x_59 - 34.6252265269051*x_6 + 0.0617973061699912*x_61 + 5.19700772671356*x_62 - 47.0334725418125*x_63 - 13.8900123275322*x_64 + 24.1672457874662*x_65 - 26.0816428688589*x_66 - 42.6948391574385*x_67 - 24.3728732761504*x_68 - 35.3378857069308*x_69 - 115.253403819852*x_7 + 39.2657707614467*x_70 - 41.2553336346289*x_71 + 21.5339514752914*x_72 - 39.6557619569815*x_73 + 83.0939496939569*x_74 + 61.2650523989055*x_75 + 64.3757295815184*x_76 + 57.0204819409984*x_77 + 27.7549327290625*x_78 + 248.941696546854*x_79 - 124.591262477922*x_8 - 32.6309894805203*x_80 + 76.5649909498997*x_81 - 55.6256711191446*x_82 + 119.406674501509*x_83 - 48.2153512623225*x_84 - 147.784540784557*x_85 - 319.457283732713*x_86 - 514.962931628524*x_87 + 16.5030534637291*x_88 - 31.1133734539085*x_89 + 54.7306940633876*x_9 - 28.5965576911653*x_90 - 7.30739335137843*x_91 + 61.3524343010609*x_92 - 22.8396628773435*x_93 - 57.8212473264896*x_94 - 57.9581352127648*x_95 - 41.8865398930039*x_96 + 16.0592506819789*x_97 + 53.6275025912234*x_98 - 38.7647094682092*x_99 - 8.17198223067659e-5*std::pow(-8.8052806854248*x_16 - 4.81135988235474, 2) - 0.000872393912136688*std::pow(-8.56208038330078*x_18 - 4.06831979751587, 2) - 0.22037285531785*std::exp(0.785679876804352*x_1) - 0.0256700613333261*std::exp(1.17999982833862*x_1) + 0.218915208799827*std::exp(1.20335984230042*x_1) + 2.7010570402206*std::exp(1.76671993732452*x_1) - 0.90393654961807*std::exp(0.52215987443924*x_10) + 0.00518220116923223*std::exp(0.591439843177795*x_10) - 3.55783220238163*std::exp(0.900879800319672*x_10) - 0.00320884258166154*std::exp(0.885119915008545*x_11) - 0.411998858218619*std::exp(0.925119876861572*x_11) + 0.0223516819143737*std::exp(0.944479823112488*x_11) - 0.0270013433792744*std::exp(1.00215983390808*x_11) + 2.20734871609572*std::exp(1.00799977779388*x_11) - 0.0291864502917254*std::exp(0.298719853162766*x_12) - 0.017373855003643*std::exp(0.684399843215942*x_12) - 0.000874436765674914*std::exp(1.34319984912872*x_12) - 2.4568780436575*std::exp(0.298239856958389*x_13) + 0.000505994461636429*std::exp(0.889039874076843*x_13) + 0.000199494358027339*std::exp(1.44815993309021*x_13) + 0.0861006617688769*std::exp(0.24711985886097*x_15) + 0.521980019186272*std::exp(0.588559865951538*x_15) + 0.269245913254512*std::exp(0.64167982339859*x_15) + 0.0046246739638987*std::exp(0.977839827537537*x_15) + 4.97991249667849*std::exp(1.00783979892731*x_15) - 1.11939553193314*std::exp(0.590879797935486*x_16) - 0.0629295006206178*std::exp(0.653999865055084*x_16) - 48.7868055515144*std::exp(0.721039831638336*x_16) - 0.0458916671917793*std::exp(0.929839789867401*x_16) + 0.0226679526156602*std::exp(0.602319836616516*x_17) - 1.52001383035964*std::exp(0.615119874477386*x_17) + 65.6759608635242*std::exp(0.655999839305878*x_17) - 0.117151658178699*std::exp(0.666399836540222*x_17) + 112.455506148337*std::exp(0.753679871559143*x_19) - 1.47782070042612*std::exp(0.754959881305695*x_19) + 0.058653538409792*std::exp(0.772639811038971*x_19) + 0.0104425568953173*std::exp(0.822639882564545*x_19) - 0.00642140872708577*std::exp(0.812879860401154*x_2) + 0.0143004317630745*std::exp(0.509519815444946*x_20) - 0.0360974330511978*std::exp(0.882799863815308*x_20) - 0.152373755085036*std::exp(0.894479870796204*x_20) - 0.000679214686621959*std::exp(0.971199810504913*x_20) - 18.4087968969864*std::exp(0.57015985250473*x_22) + 0.00148094901544023*std::exp(1.32799983024597*x_22) + 0.00290717657755538*std::exp(1.35727989673615*x_22) - 0.0247521893052469*std::exp(0.473199844360352*x_23) - 104.677122166237*std::exp(0.541199862957001*x_23) + 0.483205779556753*std::exp(0.599999845027924*x_23) + 0.0147660242932407*std::exp(0.88975989818573*x_23) + 0.0199938380346771*std::exp(1.0971999168396*x_23) - 2.08798704746924*std::exp(0.481039851903915*x_24) + 0.0278716571895595*std::exp(0.518959879875183*x_24) - 0.189237062996474*std::exp(0.579039871692657*x_24) + 0.892391301890547*std::exp(0.539999842643738*x_25) + 0.0192839709964326*std::exp(0.599599838256836*x_25) + 0.148590270055142*std::exp(0.719999849796295*x_25) - 0.882738114227185*std::exp(0.472639858722687*x_26) - 17.3483866235525*std::exp(0.830559849739075*x_26) - 0.0670620026697004*std::exp(0.873839855194092*x_26) + 0.000253900400209879*std::exp(0.995279788970947*x_26) - 0.00392490860964286*std::exp(0.952159821987152*x_27) - 0.0632361672367585*std::exp(0.953839838504791*x_27) - 0.00357582924200422*std::exp(0.630799829959869*x_28) + 0.514428298034119*std::exp(0.639919817447662*x_28) - 0.00387476458463255*std::exp(1.00135982036591*x_28) - 0.00692409270339621*std::exp(1.18399977684021*x_29) + 0.000107742998740871*std::exp(1.33479988574982*x_29) + 0.855347033276228*std::exp(0.598319828510284*x_3) - 1.72120809758135*std::exp(0.64167982339859*x_3) + 0.00187238963964512*std::exp(0.719519853591919*x_3) - 0.238613537836362*std::exp(0.833439886569977*x_30) + 0.271688515536385*std::exp(0.888719916343689*x_30) - 0.00054883539715564*std::exp(1.12327992916107*x_30) - 15.4953327073199*std::exp(0.879999876022339*x_32) + 1.64422550199506*std::exp(0.414639860391617*x_33) - 2.31338143485916*std::exp(0.464239865541458*x_33) + 0.0413013479587522*std::exp(0.618639826774597*x_4) - 0.7431919571551*std::exp(0.686719834804535*x_4) + 0.0199594729654233*std::exp(1.15263986587524*x_4) - 24.1930195418153*std::exp(0.735999822616577*x_41) + 0.518952694054272*std::exp(0.797439873218536*x_41) - 0.00945535314087672*std::exp(0.80103987455368*x_41) - 0.0578003985290994*std::exp(0.811199843883514*x_41) + 0.015267011583871*std::exp(0.823679864406586*x_41) - 4.00451494626185*std::exp(0.798799872398376*x_42) - 0.0266111143126722*std::exp(0.846959888935089*x_43) - 0.0110169431680794*std::exp(0.912319839000702*x_44) - 0.00017461412334494*std::exp(0.976159811019897*x_44) + 0.178668070879512*std::exp(0.542799830436707*x_45) + 0.527774525177155*std::exp(0.54535984992981*x_45) + 0.0206045839929419*std::exp(0.739759802818298*x_46) - 21.1908148339668*std::exp(0.763999879360199*x_46) + 0.0153025108218586*std::exp(0.56335985660553*x_47) - 14.7253036096535*std::exp(0.64167982339859*x_49) + 0.0197420376258692*std::exp(0.711119830608368*x_49) + 0.64412385860395*std::exp(0.730319857597351*x_49) - 0.445791287184735*std::exp(0.731119871139526*x_49) + 0.06001474533416*std::exp(0.733759820461273*x_49) + 0.0265443878895083*std::exp(0.500079810619354*x_50) + 0.616961841066947*std::exp(0.545759856700897*x_50) + 0.0464943482111548*std::exp(0.560399830341339*x_50) - 144.936058222918*std::exp(0.56335985660553*x_50) - 0.465373501601224*std::exp(0.596959829330444*x_50) - 0.350136649745199*std::exp(0.485359847545624*x_51) - 26.2750711603759*std::exp(0.49431985616684*x_51) + 0.184919631307427*std::exp(0.494879871606827*x_51) - 5.28485293544511*std::exp(0.500959813594818*x_51) - 299.161302008299*std::exp(0.503039836883545*x_51) + 0.849280337361209*std::exp(0.511919856071472*x_52) + 7.80321096212784*std::exp(0.670159876346588*x_52) - 0.0581273424379723*std::exp(0.767999827861786*x_52) - 9.86776569045344e-5*std::exp(0.831919848918915*x_52) + 0.00747588602534894*std::exp(0.497679859399796*x_53) - 107.305750992946*std::exp(0.447279840707779*x_54) - 0.214593737598354*std::exp(0.459519863128662*x_54) - 1.75514169535341*std::exp(0.508319854736328*x_54) + 0.0336494590011784*std::exp(0.512159824371338*x_54) + 821.53840232844*std::exp(0.652319848537445*x_55) - 0.27559112987986*std::exp(0.652479827404022*x_55) - 0.552112744412325*std::exp(0.653519809246063*x_55) - 0.266215248388055*std::exp(0.700159847736359*x_55) + 0.115730305082178*std::exp(0.471919864416122*x_56) + 0.818673302893434*std::exp(0.553919851779938*x_56) + 0.0381320467048429*std::exp(0.583439826965332*x_56) + 0.189390840268474*std::exp(0.610639870166779*x_57) - 386.670835618376*std::exp(0.630239844322205*x_57) - 2.07304852579719*std::exp(0.633599877357483*x_57) - 2.96560736564823*std::exp(0.638239860534668*x_57) - 0.00737310167798768*std::exp(0.663359880447388*x_57) + 0.0346928258975587*std::exp(0.589439868927002*x_58) - 1.54764279498544*std::exp(0.592319846153259*x_58) - 154.676706692524*std::exp(0.619999825954437*x_58) - 0.0871821888062629*std::exp(0.620639801025391*x_58) + 0.0790491685398225*std::exp(0.712479829788208*x_58) + 0.30395686968564*std::exp(0.610799849033356*x_59) - 0.00153401216660556*std::exp(0.726239860057831*x_59) + 0.275883500561821*std::exp(0.798399865627289*x_60) + 0.229832074681659*std::exp(0.802639901638031*x_60) + 17.8318447001887*std::exp(0.808239877223969*x_60) - 0.00483806583581651*std::exp(0.813839852809906*x_60) + 0.0282958095513509*std::exp(0.834959864616394*x_60) + 0.484609487876371*std::exp(1.13743984699249*x_61) + 3.83530627644665*std::exp(1.35527992248535*x_61) + 0.0618747735350869*std::exp(1.38071978092194*x_61) + 0.000204228864979817*std::exp(1.79559993743896*x_61) + 0.163268406280405*std::exp(0.925839841365814*x_66) - 0.0282195768035283*std::exp(1.02399981021881*x_66) + 0.754788577602774*std::exp(1.04943978786469*x_66) + 0.197473954207135*std::exp(0.33927983045578*x_8) + 0.0894841274694468*std::exp(0.773439824581146*x_8) + 3.43200174175829*std::log(5.44279956817627 - 0.804559826850891*x_5) - 4.83337760288023*std::log(9.53880023956299 - 1.21599996089935*x_21) + 7.97661213082051*std::sin(0.276399940252304*x_100 + 1.92679977416992) + 0.403691388835592*std::sin(0.231199979782104*x_101 + 1.96639978885651) + 6.93749765086681*std::sin(0.231199979782104*x_102 + 1.9916797876358) - 489.748039108836*std::sin(0.222479999065399*x_110 - 1.2066398859024) + 0.581270454686024*std::sin(0.268559962511063*x_120 + 1.97511982917786) - 1.50965423115416*std::sin(0.299279928207397*x_120 - 7.47304010391235) - 13928.2388478599*std::sin(0.0630401000380516*x_30 + 1.65183997154236) - 1.35584120097673*std::sin(0.320079833269119*x_31 + 5.15208005905151) + 0.449537339432047*std::sin(0.385919839143753*x_31 - 7.40183973312378) + 0.603099423742498*std::sin(0.273439943790436*x_42 + 5.1384801864624) + 1.88642220964082*std::sin(0.328239858150482*x_91 + 2.00375986099243) - 0.261507683729517*std::sin(0.307119935750961*x_92 + 8.21607971191406) + 0.118092086602844*std::sin(0.269759953022003*x_95 + 1.96215975284576) - 7.14259407589225*std::sin(0.273519963026047*x_95 - 1.20119988918304) + 3.05905595264357*std::sin(0.32551982998848*x_97 - 7.55847978591919) - 10.773177791973*std::sin(0.267439961433411*x_98 + 1.9625598192215) + 14417.8424133096);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
