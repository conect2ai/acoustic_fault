
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.31062621755228e-6*x_1 + 1.09676353033743e-5*x_10 - 4.5038166970093e-5*x_100 - 3.41538107955584e-5*x_101 - 0.000117807627749194*x_102 + 4.48874154719484e-5*x_103 - 5.57829897645349e-5*x_104 + 1.82228957968994e-5*x_105 - 1.91009842239975e-5*x_106 - 5.35866221921647e-5*x_107 - 1.26236687032726e-5*x_108 - 1.34385997012346e-5*x_109 + 7.01011233358218e-6*x_11 + 6.86438741096599e-6*x_110 - 0.000107735301026256*x_111 - 1.95577693713798e-5*x_112 + 8.20732343899959e-6*x_113 - 3.42426941150609e-5*x_114 + 2.2478213875172e-5*x_115 + 2.30531116901621e-5*x_116 + 8.11892378047696e-6*x_117 - 7.86571678240937e-6*x_118 - 0.000127977831800286*x_119 + 2.00360739305239e-5*x_12 + 1.61064916395943e-5*x_120 - 2.70700079020535e-5*x_13 - 7.78554234365488e-6*x_14 - 3.51400730969886e-6*x_15 + 1.05985653348482e-5*x_16 + 1.5652554429648e-5*x_17 - 1.40039206859224e-5*x_18 + 1.73063850659011e-5*x_19 - 4.36316270100994e-5*x_2 + 2.96041945630686e-5*x_20 - 2.75740369040504e-5*x_21 - 4.03480429535079e-5*x_22 - 4.10487518655332e-6*x_23 - 2.86570799838916e-5*x_24 - 5.77211203312687e-6*x_25 - 2.31306555719955e-6*x_26 - 3.63981190145493e-5*x_27 + 2.42391257218184e-5*x_28 - 8.44696639834453e-6*x_29 - 2.41525176803422e-5*x_3 + 3.17786654890101e-5*x_30 - 2.47544514200055e-6*x_31 + 3.16318829925077e-5*x_32 + 2.09926157779997e-5*x_33 - 3.26666820271883e-5*x_34 - 6.38733302764014e-5*x_35 - 2.97642003885301e-5*x_36 + 2.33554848510205e-5*x_37 + 1.08072000614081e-5*x_38 + 1.50695849180182e-5*x_39 - 2.73448896672544e-7*x_4 - 4.21300982898645e-5*x_40 - 2.47944219147795e-5*x_41 - 5.2822771275553e-5*x_42 + 2.54934647763538e-5*x_43 - 3.50672051355862e-5*x_44 + 5.85768348335676e-5*x_45 - 9.09435570316211e-6*x_46 + 8.01837056328911e-5*x_47 + 2.37172915160405e-5*x_48 + 5.64556755825582e-6*x_49 + 2.27912139094622e-5*x_5 + 8.5119810276541e-5*x_50 - 2.19709405628393e-6*x_51 + 5.87724722390252e-5*x_52 - 2.2342335304372e-6*x_53 - 0.000232396225567685*x_54 - 1.42149389867899e-5*x_55 - 1.94091203156797e-5*x_56 + 8.26142213249995e-6*x_57 - 2.43568119045526e-5*x_58 + 1.11563458856948e-5*x_59 + 3.31363060350469e-5*x_6 - 1.50044905771937e-5*x_60 - 5.11833437813956e-5*x_61 + 7.73259463520948e-6*x_62 - 7.98812264341121e-5*x_63 - 3.91163650646994e-5*x_64 + 4.73158178773779e-5*x_65 - 7.65315780061894e-7*x_66 - 5.663669850181e-5*x_67 - 7.55087750138152e-5*x_68 + 2.18381189880072e-6*x_69 + 1.86670702296442e-5*x_7 + 6.09073945065286e-6*x_70 - 3.59577795751265e-5*x_71 - 0.000138705381900534*x_72 - 2.78441446924929e-5*x_73 + 1.30949642305744e-5*x_74 + 3.36977402511466e-6*x_75 + 1.28699808277486e-6*x_76 - 3.82723396086602e-5*x_77 + 2.63796344088646e-5*x_78 - 6.38739451528672e-5*x_79 + 2.76259592737462e-5*x_8 - 5.65643690297861e-6*x_80 - 1.73704714738101e-5*x_81 + 1.8063007616072e-5*x_82 + 2.58764940840184e-5*x_83 - 4.8856334904523e-5*x_84 - 5.66432684216187e-5*x_85 - 8.87594014422919e-5*x_86 - 2.83160530851063e-5*x_87 + 2.09044675217319e-5*x_88 - 1.61433953150819e-5*x_89 + 9.54272047235769e-5*x_9 - 4.80552845925937e-5*x_90 - 4.93848647803844e-5*x_91 - 3.2494251960402e-5*x_92 - 4.85992457390085e-6*x_93 + 3.66619421100008e-5*x_94 - 3.32001076223009e-5*x_95 - 5.48629896854858e-6*x_96 - 3.24167099179372e-5*x_97 - 1.25019842553776e-5*x_98 - 8.62449798075739e-6*x_99 - 2.46847616897944e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 2.66770912596971e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 5.16571700144888e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) + 4.14530541492435e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 2.53807113992756e-5*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 2.02646224264297e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) - 9.34624010662798e-6*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0263935958340312);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.30040090677647e-5*x_1 + 5.08139261663471e-6*x_10 + 2.18488866754984e-5*x_100 + 4.06805839319338e-5*x_101 + 3.94464496854318e-5*x_102 + 1.08354498542098e-5*x_103 + 2.25368050766186e-5*x_104 + 4.11767352200677e-6*x_105 + 1.02182980765697e-5*x_106 + 1.67087457779938e-5*x_107 + 3.90793061953072e-6*x_108 - 4.50685429039926e-6*x_109 + 1.22350659845785e-5*x_11 + 6.60219774352677e-6*x_110 - 1.95838524805659e-6*x_111 - 6.82636530427593e-6*x_112 + 2.07478289805611e-5*x_113 + 4.34982403717979e-6*x_114 - 1.0235006262582e-5*x_115 + 4.83377535468969e-5*x_116 - 1.07038275851038e-5*x_117 + 4.95962313413633e-6*x_118 + 6.13464196648419e-5*x_119 + 1.60719059849089e-7*x_12 + 9.83198896433395e-6*x_120 + 5.85690373342177e-5*x_13 + 1.10341232761155e-5*x_14 + 1.80783022247606e-5*x_15 + 1.65874748044572e-5*x_16 + 2.14415411132109e-6*x_17 - 5.85942425302427e-6*x_18 - 6.46777701236621e-6*x_19 - 3.16437467136278e-6*x_2 - 1.35453606950114e-5*x_20 + 8.88205216885746e-6*x_21 + 9.22784150223989e-7*x_22 + 2.39912352160775e-6*x_23 + 9.71957556317612e-6*x_24 + 7.79259684275097e-6*x_25 - 7.90626389149483e-6*x_26 + 2.05709290803618e-5*x_27 - 9.12527382498279e-6*x_28 - 1.71949850752842e-8*x_29 + 6.92836155568633e-6*x_3 + 1.83306662561864e-5*x_30 - 1.41718816903815e-5*x_31 - 3.37663325729807e-6*x_32 + 1.2180000215645e-5*x_33 + 6.65864250908497e-6*x_34 + 2.84932040505357e-5*x_35 - 1.48908386308356e-6*x_36 + 6.92173941366705e-6*x_37 + 1.11382855228272e-5*x_38 - 1.00362558679068e-5*x_39 + 3.75442279329531e-6*x_4 + 2.92998032435255e-5*x_40 - 6.98219921800943e-6*x_41 + 3.76923891849786e-5*x_42 - 1.42318837701715e-6*x_43 + 3.07148562235655e-6*x_44 - 2.70291796219207e-5*x_45 + 1.57731971515904e-5*x_46 - 1.05935478323661e-5*x_47 - 4.02312704682177e-5*x_48 + 2.24934274433393e-6*x_49 - 8.28903307825448e-6*x_5 - 2.30632345572933e-5*x_50 + 7.95803159154937e-6*x_51 + 1.5514573778642e-5*x_52 + 2.62078710121805e-6*x_53 + 2.73187715935425e-6*x_54 + 7.33521984029565e-6*x_55 + 5.61687532203045e-6*x_56 - 6.30684488150369e-6*x_57 - 4.42770002548689e-7*x_58 + 1.15274219375846e-5*x_59 - 2.67368333206901e-6*x_6 + 7.88488405596002e-6*x_60 + 4.82335774373744e-6*x_61 - 2.17307325211502e-6*x_62 + 5.55695526139236e-6*x_63 + 7.41518361016055e-6*x_64 - 2.24690954777031e-6*x_65 + 1.11261535099371e-5*x_66 + 2.44947199198932e-5*x_67 - 7.64994227832177e-6*x_68 + 1.18494447192461e-5*x_69 - 1.43295039092916e-5*x_7 + 1.36124094874751e-5*x_70 - 7.66068316478929e-7*x_71 + 4.74835687385306e-5*x_72 + 9.17248231293255e-6*x_73 + 2.76598464956649e-7*x_74 - 1.11821645252366e-6*x_75 + 1.87305083750479e-5*x_76 + 2.09560006986387e-5*x_77 - 2.13452890875929e-8*x_78 + 1.58090771582537e-5*x_79 + 4.60405096418888e-5*x_8 - 7.19283467483787e-6*x_80 + 7.94747892874377e-6*x_81 + 6.36466271713765e-6*x_82 + 2.67480846034134e-5*x_83 + 3.70628533541561e-6*x_84 + 1.27050049998774e-5*x_85 + 3.15989445747902e-5*x_86 + 1.34449275587431e-5*x_87 + 1.30304188750319e-5*x_88 - 4.95522246010739e-7*x_89 - 3.7028210463864e-5*x_9 + 1.29901517650429e-5*x_90 + 3.31012947139982e-5*x_91 - 2.1323651064319e-6*x_92 - 2.1411488051918e-5*x_93 - 2.61332604546764e-7*x_94 + 6.02282865929088e-6*x_95 + 7.66813824094561e-6*x_96 + 6.37047528696259e-6*x_97 + 6.65890464230119e-6*x_98 + 1.01735841443085e-6*x_99 + 1.03564882397157e-5*std::sin(1.98631978034973*x_29 - 3.61031985282898) - 2.63166391541077e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 3.29754019875395e-6*std::sin(2.5381600856781*x_43 + 2.6068799495697) - 9.58276711936887e-6*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 1.62018004642162e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) - 1.9990813496083e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 3.92121370123943e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0847336457831875);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.55628205917312e-5*x_1 - 8.7087666009903e-6*x_10 + 2.4817905500394e-6*x_100 - 1.81295104418239e-6*x_101 + 5.29424360161844e-5*x_102 - 1.54269229449441e-5*x_103 + 6.60515939643828e-6*x_104 - 1.24750043472315e-5*x_105 - 9.64691170241715e-6*x_106 + 4.1530866412196e-6*x_107 - 8.12092428729408e-6*x_108 + 1.16093640612048e-5*x_109 - 5.16297621161491e-6*x_11 + 3.46973961453472e-6*x_110 + 1.34659644891409e-5*x_111 - 2.36771105581955e-5*x_112 - 1.984323733933e-5*x_113 + 1.2339972558154e-5*x_114 - 6.10948104125965e-6*x_115 + 4.60772640241278e-6*x_116 - 1.36510246603313e-5*x_117 + 4.18354144495914e-6*x_118 + 2.96959204344856e-5*x_119 + 4.01597370572158e-6*x_12 - 1.53452552725971e-5*x_120 - 2.13440798342786e-5*x_13 - 1.97579348421054e-6*x_14 - 1.22260009436958e-5*x_15 + 2.64941852920357e-5*x_16 - 8.25998921630441e-6*x_17 + 1.341152147681e-5*x_18 - 7.61317570392497e-6*x_19 + 2.77338799164611e-5*x_2 - 2.32362836557864e-5*x_20 + 8.9618300212098e-6*x_21 + 6.70456529658547e-6*x_22 - 1.2634573948819e-5*x_23 + 6.45017982464884e-6*x_24 + 1.47947535632636e-6*x_25 + 3.24964277527188e-6*x_26 - 5.93510380719048e-6*x_27 - 8.45704511510169e-6*x_28 - 1.30784357809983e-5*x_29 - 3.37571423512855e-6*x_3 - 2.58967208168727e-5*x_30 - 3.91800754603002e-5*x_31 + 1.02060584851253e-6*x_32 + 2.53951496385319e-5*x_33 + 7.88993892729511e-6*x_34 + 2.92594987127721e-5*x_35 + 1.21782985768031e-5*x_36 - 1.486092795732e-5*x_37 + 1.65550638855137e-6*x_38 - 2.06442576999447e-5*x_39 - 1.61965068365602e-5*x_4 - 1.1886442813883e-6*x_40 + 8.29112261308191e-6*x_41 + 1.07895630722418e-5*x_42 - 1.20184140159125e-5*x_43 - 1.74577265690998e-5*x_44 - 1.17101523022744e-5*x_45 - 1.3691609343481e-5*x_46 - 7.16315187795727e-6*x_47 + 1.37588572852851e-5*x_48 - 2.46403085492432e-6*x_49 - 3.09861312312732e-6*x_5 - 3.16386206904221e-5*x_50 + 4.05698801970986e-6*x_51 - 6.12464934661226e-8*x_52 + 2.2641788492734e-6*x_53 + 1.67040870230905e-5*x_54 + 6.19693214367685e-6*x_55 + 1.05279656457291e-5*x_56 - 1.1955897263461e-5*x_57 - 1.8964497636969e-5*x_58 - 1.05262151337031e-5*x_59 - 1.26408954452581e-5*x_6 - 1.61526002097178e-5*x_60 + 9.51899272102914e-6*x_61 - 3.40607082465951e-5*x_62 + 1.82811483670298e-5*x_63 + 4.48288362062413e-6*x_64 - 3.86092566695696e-6*x_65 + 3.66171683947606e-6*x_66 + 8.21228653753189e-6*x_67 + 1.04298591438067e-6*x_68 - 6.91116143006794e-6*x_69 - 5.49155551464307e-6*x_7 - 3.07122166546605e-5*x_70 + 1.72612028404822e-5*x_71 + 1.52629948313069e-5*x_72 + 1.98622595775996e-5*x_73 - 1.2640888778972e-5*x_74 - 3.33061832197903e-6*x_75 - 1.20661286633534e-5*x_76 - 4.55279206558215e-7*x_77 - 1.30511679096297e-5*x_78 + 2.69737515501076e-5*x_79 + 6.17393881376373e-6*x_8 + 7.4990063407619e-6*x_80 + 2.66777447320123e-5*x_81 + 1.58714411042485e-5*x_82 - 2.12220815441497e-5*x_83 + 2.25060722315178e-5*x_84 + 1.87293522889499e-5*x_85 + 4.78020426925632e-5*x_86 - 4.07184049739527e-6*x_87 - 6.29281681130854e-6*x_88 - 3.97949814769631e-6*x_89 - 6.39010654362586e-5*x_9 + 1.65575499513386e-5*x_90 + 4.6567900117885e-5*x_91 - 1.23150267884301e-5*x_92 - 9.41959708555438e-6*x_93 - 8.90749411027464e-6*x_94 + 1.63520937976519e-5*x_95 - 5.11473235775941e-6*x_96 - 6.02751911553248e-6*x_97 - 3.91050736472199e-6*x_98 + 2.47848595240011e-6*x_99 - 3.08204809860848e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) - 1.91532567768432e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 1.29106259067005e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) - 1.68758094065785e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 6.34337634117525e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) - 1.4549319228276e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) - 1.1669369918074e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.00802785539476053);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.84821722225254e-5*x_1 + 1.8599060433111e-5*x_10 - 3.07465098862662e-6*x_100 + 3.59695382769417e-5*x_101 - 6.25684408945526e-8*x_102 + 5.08425663453349e-5*x_103 - 1.64727668033568e-6*x_104 + 8.94365775074503e-6*x_105 + 2.51254180616157e-6*x_106 - 1.21365831450201e-5*x_107 - 1.01722704941354e-5*x_108 - 1.31025718594549e-5*x_109 + 2.21894033695168e-5*x_11 + 2.52336971430416e-5*x_110 - 7.97818822381682e-5*x_111 - 1.15252043159719e-5*x_112 + 4.38720548750621e-5*x_113 + 4.66462023545381e-6*x_114 - 2.12428175366106e-7*x_115 + 0.000153092638558273*x_116 + 5.92109062307845e-6*x_117 + 4.55002247582216e-6*x_118 + 6.71592584259586e-6*x_119 + 1.48586573777344e-5*x_12 + 4.02283107130957e-5*x_120 + 8.72003016405444e-5*x_13 + 1.21224253241017e-5*x_14 + 2.84025708914379e-5*x_15 + 3.6925452495317e-5*x_16 + 1.38103866687391e-5*x_17 - 1.69429375438655e-5*x_18 + 3.67160094796119e-6*x_19 - 1.5414782890468e-5*x_2 - 5.62055277515744e-6*x_20 - 4.54804123338978e-6*x_21 - 2.32798372366726e-5*x_22 + 4.68508053566346e-6*x_23 + 2.71033005837248e-6*x_24 + 2.00552489419929e-5*x_25 - 4.46241799238768e-6*x_26 + 2.19136860690281e-5*x_27 - 5.83051727042579e-6*x_28 - 6.20446073021601e-6*x_29 + 8.64037245059075e-9*x_3 + 6.59812089526442e-5*x_30 - 2.30738508608782e-6*x_31 + 2.91241700288194e-5*x_32 + 4.33352610446227e-5*x_33 - 8.75715204908304e-6*x_34 - 5.74964530734343e-6*x_35 - 1.85282320835695e-5*x_36 + 3.74691315269019e-5*x_37 + 3.02263638534524e-5*x_38 + 4.8501769336172e-6*x_39 + 1.15441936430746e-5*x_4 + 2.94839663149385e-5*x_40 - 1.65282771021154e-5*x_41 - 9.4921539199888e-6*x_42 + 1.74526086615289e-5*x_43 + 4.86822690541684e-6*x_44 + 6.36870995004907e-6*x_45 + 1.27268266675839e-5*x_46 - 9.77018057587385e-7*x_47 - 3.74970611810614e-5*x_48 + 1.01328860996838e-5*x_49 + 5.91208314866571e-6*x_5 + 1.14344452441829e-5*x_50 + 1.99130854814457e-5*x_51 + 6.00211731842173e-5*x_52 - 4.36674831992097e-7*x_53 - 0.000144326219776284*x_54 - 2.78038339441617e-6*x_55 - 1.29523390843596e-5*x_56 + 6.57724959932042e-6*x_57 - 2.70156952203413e-6*x_58 + 2.46229622099324e-5*x_59 + 1.45253435774149e-5*x_6 + 6.34028635380095e-6*x_60 - 2.62899834476606e-5*x_61 + 2.73620053274807e-6*x_62 - 3.38078612309185e-5*x_63 - 2.13336547456497e-5*x_64 + 2.89030931166137e-5*x_65 + 1.39826442683977e-5*x_66 + 7.37689935131907e-6*x_67 - 1.26330910991059e-5*x_68 + 2.08116132729029e-5*x_69 + 7.71387403905062e-7*x_7 + 5.71108519590856e-5*x_70 - 9.69128866860967e-6*x_71 - 1.97074798891827e-6*x_72 + 2.89926006675974e-6*x_73 + 1.71323769608297e-5*x_74 + 5.16884120962525e-6*x_75 + 3.25173513843994e-5*x_76 + 1.55002518447336e-5*x_77 + 1.96658178208485e-5*x_78 - 3.33387357859305e-6*x_79 + 0.000108591604464138*x_8 + 4.6618038913765e-7*x_80 + 1.18354582122111e-5*x_81 + 2.9577806983267e-5*x_82 + 4.26457483811488e-5*x_83 - 1.50305877355916e-5*x_84 + 2.27752499332218e-6*x_85 - 6.16783097187096e-6*x_86 + 2.01701568140082e-5*x_87 + 3.63199209423816e-5*x_88 - 1.19704806856307e-5*x_89 - 2.60773801875225e-6*x_9 - 7.08732124044808e-6*x_90 + 3.66612912044762e-5*x_91 - 2.40446975267799e-5*x_92 - 1.60148582178556e-6*x_93 + 2.08670882029088e-5*x_94 - 1.47833335330827e-5*x_95 + 8.52420047569326e-6*x_96 - 1.71006732727956e-5*x_97 + 5.85409564867342e-6*x_98 + 2.23672523142054e-6*x_99 + 9.76857146051411e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 1.13236987850364e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 4.28332141755999e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) + 8.41056795976673e-6*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 2.10452381922847e-5*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 8.60178038585718e-6*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 3.69861437254487e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0854146540732336);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.73898447008146e-5*x_1 + 1.05182316068514e-5*x_10 + 2.36192499847687e-5*x_100 + 4.62098464533052e-5*x_101 + 4.5227332756994e-5*x_102 + 1.47674641649726e-5*x_103 + 2.97295162722069e-5*x_104 + 3.57877993669527e-7*x_105 + 1.86428238981463e-5*x_106 + 2.29697711097772e-5*x_107 + 4.76757405763859e-6*x_108 - 6.31579637180367e-6*x_109 + 1.279332904445e-5*x_11 + 1.10778905442805e-5*x_110 + 6.14176284205522e-6*x_111 + 1.89377084596892e-5*x_112 + 3.47477413754422e-5*x_113 + 1.97328790171869e-5*x_114 - 1.06586287533489e-5*x_115 + 9.17384705420431e-5*x_116 + 8.4652266130728e-6*x_117 + 5.77471865469006e-6*x_118 + 6.57153509178739e-5*x_119 - 4.75143749944166e-6*x_12 + 2.65541082310973e-5*x_120 + 8.65088889804693e-5*x_13 + 1.39961896967158e-5*x_14 + 2.79267341385212e-5*x_15 + 2.88717274253651e-6*x_16 + 3.79547100218664e-6*x_17 - 9.62236069369195e-6*x_18 - 3.53263722142472e-6*x_19 + 3.30665696085439e-6*x_2 - 9.70885908218321e-6*x_20 + 9.2846070798786e-6*x_21 + 6.30980221521105e-6*x_22 + 1.34701204640749e-5*x_23 + 1.67093995974978e-5*x_24 + 1.70710799517963e-5*x_25 - 2.11326386041326e-6*x_26 + 4.1382738937257e-5*x_27 - 1.49214143114068e-5*x_28 + 8.27317803962361e-6*x_29 + 1.76459208556707e-5*x_3 + 3.96639204643126e-5*x_30 + 2.53842461436843e-5*x_31 + 5.03243974632463e-7*x_32 + 2.47334463695646e-6*x_33 + 1.05583356155917e-5*x_34 + 1.86130176901893e-5*x_35 - 9.10395833863891e-8*x_36 + 1.90624858894064e-5*x_37 + 1.2472516979647e-5*x_38 + 6.84985092728134e-6*x_39 + 1.73223224732048e-5*x_4 + 4.72651984879422e-5*x_40 + 8.39184605952649e-7*x_41 + 1.73186597565694e-5*x_42 + 2.30200595007824e-6*x_43 + 3.69984956128878e-5*x_44 - 2.4465181397246e-5*x_45 + 2.08807471578158e-5*x_46 - 5.09866627188907e-5*x_47 - 4.51798105067414e-5*x_48 + 4.80716096213418e-6*x_49 - 8.03574752536187e-6*x_5 - 2.89458155429023e-5*x_50 + 1.32572254591666e-5*x_51 + 2.9448765656103e-6*x_52 - 6.06337264472159e-7*x_53 + 4.22281482250749e-5*x_54 + 2.9268635079043e-6*x_55 - 3.00387115811672e-6*x_56 + 6.96219365435964e-6*x_57 + 2.55748183255081e-5*x_58 + 1.46421682692049e-5*x_59 - 4.282367233673e-6*x_6 + 2.29549255461316e-5*x_60 + 9.38603830254356e-6*x_61 + 1.62593328974544e-5*x_62 + 1.77218030364432e-5*x_63 + 7.14415339546409e-6*x_64 - 8.01115044227651e-6*x_65 + 7.32762966018415e-6*x_66 + 3.61143713200107e-5*x_67 + 4.38410741158257e-5*x_68 + 1.57701932175395e-5*x_69 - 6.84772525630812e-6*x_7 + 5.36137839483859e-5*x_70 + 7.68294509073317e-6*x_71 + 7.82564220041755e-5*x_72 + 8.93766479628453e-6*x_73 + 1.09509099340806e-5*x_74 + 3.72201986959195e-6*x_75 + 2.74942949805497e-5*x_76 + 3.47661640015054e-5*x_77 + 3.90895949146479e-6*x_78 + 2.41256269832155e-5*x_79 + 5.32288683298107e-5*x_8 + 8.51439144747209e-7*x_80 + 4.6996486305062e-6*x_81 + 1.07100418403604e-7*x_82 + 2.25397371044998e-5*x_83 + 8.83191543843364e-6*x_84 + 2.84682332349816e-5*x_85 + 2.48266563402306e-5*x_86 + 3.46566536521797e-5*x_87 + 1.47308153501567e-5*x_88 + 4.68473093889808e-6*x_89 - 2.60278858457658e-5*x_9 + 1.64413624709452e-5*x_90 + 3.15032005082878e-5*x_91 + 1.15090167474401e-5*x_92 + 1.13065966027207e-5*x_93 - 4.17058642962461e-6*x_94 + 1.65649818598266e-6*x_95 + 1.18470940753359e-5*x_96 + 1.13912992852875e-5*x_97 + 1.38473163698199e-5*x_98 + 5.68129041822393e-6*x_99 + 9.41065809261164e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 5.90487769790798e-6*std::sin(2.08663988113403*x_29 + 4.18279981613159) - 1.07420678791677e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) - 1.12687385359398e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) - 5.27789897503317e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 4.48550090628245e-6*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 3.56309982653362e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0374447701429126);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.00599328626112e-5*x_1 + 9.3797524768094e-6*x_10 - 1.63609108526373e-5*x_100 - 1.61097067481593e-5*x_101 - 4.7132918244269e-5*x_102 + 1.7619868703143e-5*x_103 - 1.55434089292587e-5*x_104 + 4.06594610560972e-6*x_105 + 2.06227597606295e-6*x_106 - 1.58850710682368e-5*x_107 - 2.32563418898897e-6*x_108 - 7.41294773903865e-6*x_109 + 1.88516054878554e-6*x_11 + 6.09489386683743e-6*x_110 - 2.73829892704015e-5*x_111 + 2.31511471431682e-5*x_112 + 1.75484613571561e-5*x_113 + 2.70521275797108e-7*x_114 + 9.7828582931564e-6*x_115 + 3.26293453874504e-5*x_116 + 2.37979295511465e-5*x_117 - 3.37581434186673e-6*x_118 - 4.798042904828e-5*x_119 + 1.02307195821769e-6*x_12 + 2.1020985700326e-5*x_120 + 1.36499190705321e-5*x_13 - 1.74832550574783e-6*x_14 + 6.67326206073203e-6*x_15 - 1.49027348202135e-5*x_16 + 8.06668127502924e-6*x_17 - 9.49717679778748e-6*x_18 + 9.4082307421674e-6*x_19 - 1.10857887523613e-5*x_2 + 1.96762595924695e-5*x_20 - 1.20104650118774e-5*x_21 - 9.29743194173622e-6*x_22 + 8.99170795654087e-6*x_23 - 5.53062475514061e-6*x_24 + 5.52582650430946e-6*x_25 + 4.81906071116276e-6*x_26 + 6.49090361376996e-6*x_27 + 5.09368740810772e-6*x_28 + 7.57304978626367e-6*x_29 + 7.77992116224119e-7*x_3 + 3.10871145091287e-5*x_30 + 4.00166192734633e-5*x_31 + 1.34786493029642e-5*x_32 - 8.96041876369162e-6*x_33 - 9.80422039306661e-6*x_34 - 3.87693106699081e-5*x_35 - 9.85881474034123e-6*x_36 + 2.1735985598291e-5*x_37 + 3.70736420387472e-6*x_38 + 2.40532115895533e-5*x_39 + 1.47072081296717e-5*x_4 - 1.19314473542037e-6*x_40 + 1.82384857764585e-7*x_41 - 4.53322864389334e-5*x_42 + 1.49422327528802e-5*x_43 + 2.3254735812714e-5*x_44 + 2.70923505323545e-5*x_45 + 1.69435959226323e-6*x_46 - 6.86917410190651e-6*x_47 + 4.88475056671002e-6*x_48 + 4.23208117005537e-6*x_49 + 9.04703436173636e-6*x_5 + 3.18284346639182e-5*x_50 + 1.65935969916283e-6*x_51 + 2.9925628184578e-6*x_52 - 4.07891675008418e-6*x_53 - 4.57129304953436e-5*x_54 - 1.05009171522897e-5*x_55 - 1.78272725525731e-5*x_56 + 1.81797423853362e-5*x_57 + 1.89322448050615e-5*x_58 + 7.49205720938016e-6*x_59 + 1.13170376331196e-5*x_6 + 1.01906249653477e-5*x_60 - 1.50206461195251e-5*x_61 + 2.47297116262195e-5*x_62 - 1.57292500747218e-5*x_63 - 1.51182204027337e-5*x_64 + 1.02232719636641e-5*x_65 - 6.41753148647506e-6*x_66 - 1.28081765534039e-5*x_67 + 2.27838241997067e-5*x_68 + 5.12980397195978e-6*x_69 + 1.62021686214591e-5*x_7 + 4.3786400507342e-5*x_70 - 5.10516327753302e-6*x_71 - 2.74063449543608e-5*x_72 - 1.41336490587625e-5*x_73 + 1.62784052525322e-5*x_74 + 6.04234452160697e-6*x_75 + 7.25691609411137e-6*x_76 - 1.9162967894567e-6*x_77 + 1.46172923183613e-5*x_78 - 2.03407819739696e-5*x_79 + 4.0654960228564e-6*x_8 + 7.37906169676873e-6*x_80 - 1.36442086125061e-5*x_81 - 3.48894652733064e-6*x_82 + 9.93345195198827e-7*x_83 - 1.38125468042011e-5*x_84 - 9.07551264375922e-6*x_85 - 4.79764864377294e-5*x_86 + 1.02304547991311e-5*x_87 + 6.39350075619868e-6*x_88 - 9.39761271077953e-7*x_89 + 5.66940710955166e-5*x_9 - 1.70676832015026e-5*x_90 - 3.3706578607399e-5*x_91 + 4.04357682405173e-6*x_92 + 3.2780472613711e-5*x_93 + 8.54809240020485e-6*x_94 - 1.86443148916038e-5*x_95 + 1.67803511130371e-6*x_96 - 4.77533769895009e-6*x_97 + 3.39834352446206e-6*x_98 + 2.6607352201665e-6*x_99 - 3.98040415458564e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 4.36304837052939e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 5.88316824350594e-7*std::sin(2.5381600856781*x_43 + 2.6068799495697) + 1.60983017172158e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 2.89057637613378e-7*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 3.31428666627546e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) - 1.5070760422029e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0489223153811397);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.25292714446401e-5*x_1 + 1.39341597793715e-5*x_10 - 2.48110180638147e-5*x_100 - 6.92777186022869e-5*x_101 - 0.000137746185827627*x_102 + 1.95569164219522e-5*x_103 - 3.8120768342275e-5*x_104 + 2.93670859465208e-5*x_105 + 4.09763712985606e-6*x_106 - 4.60280073546141e-5*x_107 + 8.82347352397577e-6*x_108 - 2.2114558066725e-5*x_109 + 7.42476464127204e-6*x_11 + 5.24314216755341e-6*x_110 - 4.42464572128172e-5*x_111 + 2.3607429644917e-5*x_112 + 3.71979224981727e-5*x_113 - 4.45388785466442e-5*x_114 + 2.45532181297971e-5*x_115 - 0.000112013702251951*x_116 + 1.12871704509271e-5*x_117 - 1.29229838315346e-5*x_118 - 7.78046254467839e-5*x_119 + 1.41319085639289e-6*x_12 + 9.09312099531083e-6*x_120 + 7.39475661387292e-6*x_13 - 1.13160676754743e-5*x_14 + 2.58421208841306e-7*x_15 - 2.23507817951267e-5*x_16 + 2.12627003317418e-5*x_17 - 2.35102929933851e-5*x_18 + 6.71701862469751e-6*x_19 - 5.06869585181609e-5*x_2 + 5.57458428089931e-5*x_20 - 3.33906141073971e-5*x_21 - 2.82610765658122e-5*x_22 - 5.89401720740139e-6*x_23 - 2.96767482707669e-5*x_24 - 1.03328693867382e-5*x_25 - 1.1706716086608e-5*x_26 - 1.13946577882818e-5*x_27 + 2.6777058000363e-5*x_28 + 1.73198599829338e-5*x_29 - 2.05332921557355e-5*x_3 + 2.84680633623393e-5*x_30 - 3.93682641603016e-6*x_31 + 1.11160763899468e-6*x_32 - 3.80276549227857e-5*x_33 - 3.39214586793754e-5*x_34 - 6.96519086758628e-5*x_35 - 2.74608574474939e-5*x_36 + 3.74947260395916e-5*x_37 + 6.29663162083973e-6*x_38 + 1.65395324573728e-5*x_39 + 1.71745320568114e-5*x_4 - 3.29548866389576e-5*x_40 - 1.15627170041827e-5*x_41 - 5.39913583680006e-5*x_42 + 3.6696126825344e-5*x_43 + 9.89719786438966e-7*x_44 + 4.34057411779152e-5*x_45 + 1.06586589981301e-5*x_46 + 8.6329344664079e-5*x_47 - 1.81971439742173e-5*x_48 + 3.27538597593283e-6*x_49 + 1.20360885316606e-5*x_5 + 0.000101266227962396*x_50 - 1.97391277114139e-5*x_51 + 2.88360731208688e-6*x_52 + 9.03326116620189e-7*x_53 - 0.000173265923469559*x_54 - 1.11818525203912e-5*x_55 - 2.97820212829642e-5*x_56 + 1.84983175536132e-5*x_57 + 5.48092098226587e-7*x_58 + 2.51883550547261e-5*x_59 + 2.93603977933382e-5*x_6 + 4.53064689257299e-6*x_60 - 4.12863478793292e-5*x_61 + 3.77794894632215e-5*x_62 - 3.87916908342103e-5*x_63 - 2.65307287243619e-5*x_64 + 1.9649544657566e-5*x_65 - 1.09082339206243e-5*x_66 - 4.96852583150555e-5*x_67 - 7.2563306847554e-5*x_68 + 2.01792949801995e-5*x_69 + 1.6717718605903e-5*x_7 + 3.94066394082672e-5*x_70 - 3.03622914147042e-5*x_71 - 0.00012038809298089*x_72 - 4.63975565604913e-5*x_73 + 1.89961439430465e-5*x_74 + 1.26103938774722e-6*x_75 + 3.78088332054401e-6*x_76 - 2.00772543131424e-5*x_77 + 3.03587547180177e-5*x_78 - 8.06649832490665e-5*x_79 - 5.50701904307243e-5*x_8 + 2.78046040430201e-6*x_80 - 4.28188411007887e-5*x_81 - 1.64456245640968e-5*x_82 + 7.03004098713081e-6*x_83 - 4.16558899139627e-5*x_84 - 6.67184283253736e-5*x_85 - 0.000115748721026011*x_86 - 9.67481975175671e-6*x_87 + 1.84834562115669e-6*x_88 - 1.50756117374823e-5*x_89 + 0.000134184477603141*x_9 - 4.94849644634692e-5*x_90 - 0.000136541971828425*x_91 - 4.10557394353441e-6*x_92 - 7.93714604251677e-6*x_93 + 1.72617219868782e-5*x_94 - 3.92289533699629e-5*x_95 + 1.22597407429412e-7*x_96 + 3.50885596981609e-6*x_97 + 6.87829751970597e-6*x_98 + 7.02760142254019e-6*x_99 - 1.13288929035392e-5*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 7.7760553377631e-6*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 3.77969839358609e-7*std::sin(2.5381600856781*x_43 + 2.6068799495697) + 4.5447326687356e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 1.85707877680886e-7*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 5.90689681467852e-6*std::sin(2.07735991477966*x_77 + 6.80855989456177) - 4.28938932242264e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.00163540906109786);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.59107076097282e-5*x_1 + 1.35077470967395e-6*x_10 - 8.34403375797775e-6*x_100 - 1.79216736194772e-5*x_101 - 5.72722167368631e-5*x_102 + 9.65752396137713e-6*x_103 - 1.94682136548868e-5*x_104 + 1.68262308083887e-5*x_105 - 5.28779118117894e-6*x_106 - 2.01784810863625e-5*x_107 + 3.35367587678266e-6*x_108 - 8.33064769647308e-6*x_109 + 5.01925261026699e-6*x_11 - 3.48538880381748e-6*x_110 - 3.12871138471991e-5*x_111 - 1.84600683053249e-5*x_112 + 2.72749603903452e-6*x_113 - 3.32265483621334e-5*x_114 + 8.09465483208927e-6*x_115 - 6.74436113779282e-5*x_116 - 1.57189184440902e-5*x_117 - 5.02635057761434e-6*x_118 - 3.19363119746343e-5*x_119 + 5.99037854729474e-6*x_12 - 9.32641138234078e-6*x_120 - 1.61811597791429e-5*x_13 - 4.21516741351998e-6*x_14 - 4.72170688673833e-6*x_15 + 5.09037569681338e-6*x_16 + 7.05073327472023e-6*x_17 - 7.26041329057875e-6*x_18 + 8.78634733358803e-7*x_19 - 3.12373695177772e-5*x_2 + 1.59073440105296e-5*x_20 - 1.1563029624972e-5*x_21 - 1.73457730387972e-5*x_22 - 9.76067060416419e-6*x_23 - 1.72880636909255e-5*x_24 - 1.25500236056525e-5*x_25 - 1.1594781189056e-5*x_26 - 2.3650510981066e-5*x_27 + 1.5695225691952e-5*x_28 - 1.79182537008049e-6*x_29 - 1.63743976458784e-5*x_3 - 4.37532372586162e-6*x_30 - 3.53638510399263e-5*x_31 - 2.77294557088599e-6*x_32 - 2.61921011173021e-6*x_33 - 1.59689379868507e-5*x_34 - 1.43370971086851e-5*x_35 - 1.40311878754633e-5*x_36 + 2.29642740949198e-6*x_37 + 1.81997290265177e-6*x_38 - 9.14055982854919e-6*x_39 - 5.66551303914862e-6*x_4 - 2.60104785013739e-5*x_40 - 1.68529788390874e-5*x_41 + 9.08688062648773e-6*x_42 + 9.60601631278411e-6*x_43 - 3.44417758725729e-5*x_44 + 1.08273815947702e-5*x_45 + 2.75974475193897e-6*x_46 + 7.16421422365399e-5*x_47 - 7.33087086347099e-6*x_48 - 6.25940176694248e-7*x_49 + 3.80276256231416e-6*x_5 + 4.24169513429434e-5*x_50 - 1.07782614354301e-5*x_51 + 2.11984296089682e-5*x_52 + 3.36541269909332e-6*x_53 - 0.00010530995736277*x_54 + 5.43713479695113e-7*x_55 - 9.7867700045704e-7*x_56 - 7.27819798256396e-6*x_57 - 2.49348534948471e-5*x_58 + 8.11056228685406e-6*x_59 + 1.44656384537403e-5*x_6 - 1.06842581579753e-5*x_60 - 2.0474371881862e-5*x_61 - 1.06941833324008e-6*x_62 - 3.31103025245374e-5*x_63 - 8.81283472241119e-6*x_64 + 1.51661805577217e-5*x_65 + 2.20991671095363e-6*x_66 - 2.74021623857895e-5*x_67 - 8.14343612092579e-5*x_68 + 4.33307381878132e-6*x_69 - 3.69138211792905e-6*x_7 - 2.38417589769937e-5*x_70 - 2.45794982791945e-5*x_71 - 6.97441880197076e-5*x_72 - 1.72735713571176e-5*x_73 - 2.70983419373792e-6*x_74 - 4.04595604835065e-6*x_75 - 2.31102394735348e-6*x_76 - 1.95656960921524e-5*x_77 + 8.51088156515087e-6*x_78 - 3.85545938369788e-5*x_79 - 1.40124765201235e-5*x_8 - 1.22650546522965e-5*x_80 - 1.46755677054649e-5*x_81 + 4.19586102639283e-7*x_82 + 1.88477698515438e-5*x_83 - 2.53183863944697e-5*x_84 - 4.10880889788424e-5*x_85 - 3.55910859784723e-5*x_86 - 2.48006740191628e-5*x_87 + 3.87648175298549e-6*x_88 - 9.23562676737503e-6*x_89 + 3.98274476920394e-5*x_9 - 2.19132340366482e-5*x_90 - 4.29000374034852e-5*x_91 - 1.49706399412871e-5*x_92 - 3.92516593872663e-5*x_93 + 1.36882542008396e-5*x_94 - 1.06859489048097e-5*x_95 - 2.29842853773696e-6*x_96 - 4.21940345862129e-6*x_97 - 5.14822884068924e-6*x_98 - 4.86575570348444e-6*x_99 + 8.0322655361896e-7*std::sin(1.98631978034973*x_29 - 3.61031985282898) - 3.05486722317255e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 1.58603884781192e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) + 1.91466382855775e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 7.79268284597534e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) - 2.32055774888745e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 3.04120749654466e-6*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0491767756454172);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.99117056890357e-5*x_1 - 6.46106890748145e-6*x_10 + 1.07722246358899e-5*x_100 + 5.89766766868833e-5*x_101 + 8.63483102700043e-5*x_102 - 8.1684871176092e-6*x_103 + 2.55235597103651e-5*x_104 - 2.71598406253511e-5*x_105 + 1.64677655168927e-6*x_106 + 3.92087189994603e-5*x_107 - 6.73566834700179e-6*x_108 + 1.58671837087086e-5*x_109 - 9.98885680116091e-6*x_11 - 8.00112970767088e-6*x_110 + 3.54539521838777e-5*x_111 + 1.31836085300598e-5*x_112 - 2.66538205933197e-5*x_113 + 4.73785642912742e-5*x_114 - 1.55616803661233e-5*x_115 + 0.000135333202159727*x_116 + 1.96202981634983e-5*x_117 + 8.59762466779901e-6*x_118 + 2.13124556171286e-5*x_119 - 6.4157842922359e-6*x_12 + 1.11473866260752e-5*x_120 - 5.09227151725608e-6*x_13 + 9.90146253170389e-6*x_14 + 6.64388332125715e-6*x_15 - 1.36481781129576e-5*x_16 - 1.6060160932959e-5*x_17 + 1.52024151971034e-5*x_18 + 6.05672965986987e-6*x_19 + 3.84938137105614e-5*x_2 - 3.20515359072408e-5*x_20 + 2.36286736391946e-5*x_21 + 2.63501487677889e-5*x_22 + 2.3529569932028e-5*x_23 + 2.59463158551439e-5*x_24 + 1.3105893914328e-5*x_25 + 1.9570210600323e-5*x_26 + 1.86736963082057e-5*x_27 - 2.09525255673955e-5*x_28 - 4.12059740906317e-6*x_29 + 2.80772231142506e-5*x_3 - 2.11694224952385e-6*x_30 + 7.37002258336219e-5*x_31 + 6.48247013763732e-6*x_32 + 1.19558109198441e-5*x_33 + 2.84746150068138e-5*x_34 + 2.64109394241942e-5*x_35 + 2.05685591784628e-5*x_36 - 2.29985205845099e-5*x_37 - 1.23295548297974e-5*x_38 + 1.76404007069179e-5*x_39 + 1.50489772524702e-6*x_4 + 3.20164724242095e-5*x_40 + 1.40197541674969e-5*x_41 + 1.06757265333987e-5*x_42 - 2.61184498590693e-5*x_43 + 3.35494036897824e-5*x_44 - 1.71167956433906e-5*x_45 - 7.27300970515432e-6*x_46 - 0.000110424809529215*x_47 + 3.11024368892646e-5*x_48 - 4.10679363168322e-7*x_49 - 4.03762538582997e-6*x_5 - 7.38500693127674e-5*x_50 + 1.90643629309173e-5*x_51 - 1.50000529391874e-5*x_52 - 7.04116324357179e-6*x_53 + 0.000188909508145958*x_54 - 1.12668785607325e-6*x_55 + 1.38625832936832e-5*x_56 + 2.96689295729268e-6*x_57 + 3.2120702782371e-5*x_58 - 2.33165074138951e-5*x_59 - 1.98823010430301e-5*x_6 + 1.32047134291797e-5*x_60 + 3.50705176343881e-5*x_61 - 2.53745653841076e-7*x_62 + 2.77440578697313e-5*x_63 + 1.81842759286789e-5*x_64 - 1.74515528087338e-5*x_65 + 4.65575539425202e-7*x_66 + 3.98713361633391e-5*x_67 + 0.000118722621629564*x_68 - 2.09408790209475e-5*x_69 + 1.0155351646634e-6*x_7 + 3.49702319386062e-6*x_70 + 2.44300188870212e-5*x_71 + 0.000108625140279957*x_72 + 2.94004169001343e-5*x_73 - 2.1895958022067e-6*x_74 + 5.96713415952544e-6*x_75 + 1.81319087863287e-6*x_76 + 1.84151992399199e-5*x_77 - 1.8555848228125e-5*x_78 + 6.21841120074471e-5*x_79 + 4.19349781956913e-5*x_8 + 6.67993534434337e-7*x_80 + 1.94999417634108e-5*x_81 + 1.7619424486921e-7*x_82 - 6.67059924816383e-6*x_83 + 2.67517410696946e-5*x_84 + 6.10080748792836e-5*x_85 + 6.28067186107526e-5*x_86 + 2.04133594180829e-5*x_87 - 6.59074603759463e-7*x_88 + 2.28985282360107e-5*x_89 - 6.43767548300588e-5*x_9 + 3.40089579240563e-5*x_90 + 9.53904326793724e-5*x_91 + 2.25030485110054e-5*x_92 + 5.35074450133383e-5*x_93 - 1.16432745188605e-5*x_94 + 2.17468076203752e-5*x_95 + 2.29174034846875e-6*x_96 - 2.58935085613524e-6*x_97 - 4.25686358275784e-6*x_98 - 7.8362774219856e-6*x_99 + 8.66184135673764e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 4.89457906377056e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) - 1.74502480947372e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) - 3.03622318600354e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) - 8.57382838847073e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 3.71805140590671e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 3.27957993287253e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0754475621707614);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.2264408276412e-5*x_1 - 3.34629311026512e-6*x_10 - 1.14023502081076e-5*x_100 + 3.49091268027276e-5*x_101 + 3.79925783044689e-5*x_102 + 2.01365700147635e-5*x_103 - 8.83391151217655e-6*x_104 - 1.02095557588392e-5*x_105 - 2.02040720083367e-5*x_106 - 4.02266317439999e-6*x_107 - 1.93594082661514e-5*x_108 + 8.59580235781481e-6*x_109 + 2.18477734758464e-6*x_11 + 5.32715795192656e-6*x_110 - 5.31558184282533e-5*x_111 - 4.72648169190727e-5*x_112 - 2.28634937746639e-5*x_113 + 1.02031353800345e-5*x_114 - 5.19208928091566e-6*x_115 + 0.000118398960041245*x_116 - 1.15905575856401e-5*x_117 + 6.3153037263617e-6*x_118 - 1.76294801801404e-5*x_119 + 1.77689601059474e-5*x_12 + 2.84931730981217e-6*x_120 - 1.93190148665818e-5*x_13 + 4.48299690627307e-6*x_14 - 2.82015949524501e-6*x_15 + 4.26714758476383e-5*x_16 - 5.4501166117494e-6*x_17 + 9.55554229786098e-6*x_18 + 4.13605581021267e-6*x_19 + 1.12791952573702e-5*x_2 - 3.08176902942197e-5*x_20 + 8.2203266115329e-6*x_21 - 1.00934431533255e-5*x_22 - 4.09778014225639e-6*x_23 + 3.49502587265747e-6*x_24 + 5.58979624307428e-6*x_25 + 5.28636180925807e-6*x_26 - 1.88383632097241e-5*x_27 - 5.76687242109947e-6*x_28 - 2.58271790139801e-5*x_29 - 4.71088701756422e-6*x_3 - 2.00370486170479e-7*x_30 - 2.19818032578314e-5*x_31 + 2.49691299039482e-5*x_32 + 6.09761696860505e-5*x_33 + 3.00417770177567e-6*x_34 + 1.99597399343735e-5*x_35 - 8.79405848483288e-8*x_36 - 1.26651670091754e-5*x_37 + 8.70866827420564e-6*x_38 - 1.22778921331665e-5*x_39 - 1.91438758874801e-5*x_4 - 2.70295592603214e-6*x_40 - 1.13945590631219e-5*x_41 + 1.328009443829e-5*x_42 - 1.1449398431045e-5*x_43 - 3.80253520786219e-5*x_44 + 3.23988385199815e-6*x_45 - 1.64051363681904e-5*x_46 - 1.34018722154871e-6*x_47 + 2.63395104248765e-5*x_48 + 1.91073212524659e-6*x_49 + 6.23252993678208e-6*x_5 - 2.4100200756223e-5*x_50 + 1.68811113788368e-5*x_51 + 5.28892291294516e-5*x_52 - 6.04650409680515e-7*x_53 - 6.08125457158236e-5*x_54 + 1.5221948232728e-6*x_55 + 1.23852828317048e-5*x_56 - 1.44221417968297e-5*x_57 - 3.01405575678091e-5*x_58 - 1.00999795547292e-5*x_59 - 2.8156006856764e-8*x_6 - 2.08625764157766e-5*x_60 - 7.05848968209242e-6*x_61 - 3.7369090995176e-5*x_62 - 2.94347931098117e-5*x_63 - 8.92537390372014e-6*x_64 + 2.3128614327719e-5*x_65 + 1.27810692255784e-5*x_66 + 1.5818957668575e-7*x_67 - 1.3933200736187e-5*x_68 - 1.23384238421475e-5*x_69 - 3.99199078871902e-6*x_7 - 3.42789865354577e-5*x_70 - 1.05667046000411e-6*x_71 - 6.79894281270842e-6*x_72 + 2.23651875412612e-5*x_73 - 8.75578414668605e-6*x_74 - 7.11085601630988e-8*x_75 - 1.06574119060462e-6*x_76 - 1.12472983518079e-5*x_77 - 5.99160169842435e-6*x_78 + 2.22669623004287e-5*x_79 + 8.14313591747678e-5*x_8 - 6.33413462904009e-6*x_80 + 3.11319637620175e-5*x_81 + 3.64416147906052e-5*x_82 + 1.650596539442e-5*x_83 + 2.7455372097926e-7*x_84 + 1.32068426962488e-5*x_85 + 4.19153032366197e-5*x_86 - 1.48665923069389e-5*x_87 + 1.77496492019791e-5*x_88 - 4.46684537127774e-6*x_89 - 5.87235668967643e-5*x_9 + 7.34040548897561e-6*x_90 + 9.02304356673614e-5*x_91 - 3.07699108814125e-5*x_92 - 1.05272720692431e-5*x_93 + 1.43707894014792e-5*x_94 + 1.02003900670966e-5*x_95 - 4.53913388878768e-6*x_96 - 3.05616264273797e-5*x_97 - 1.53984011994522e-5*x_98 - 1.12831483990151e-5*x_99 + 8.44046997875062e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) - 1.3281206211859e-6*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 5.03119672692023e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) - 8.99852143779827e-6*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 2.471977308922e-5*std::sin(2.17719984054565*x_75 + 6.81143999099731) - 1.00887546783439e-6*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 3.19576344408475e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0802325746704869);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.06856954483191e-5*x_1 - 1.86224537550614e-6*x_10 - 1.89613480458772e-5*x_100 + 1.5490354559237e-5*x_101 - 3.16073956440331e-5*x_102 + 5.30743029382205e-6*x_103 - 1.4663057674312e-5*x_104 - 1.05412308288459e-5*x_105 - 3.7852661765469e-6*x_106 + 6.77969514426137e-6*x_107 - 3.12967138400702e-6*x_108 + 4.7940523883763e-6*x_109 - 1.32163028070673e-5*x_11 - 1.82492487026062e-5*x_110 - 9.91263513121987e-7*x_111 + 2.78550651064609e-5*x_112 - 2.67839858229642e-5*x_113 + 1.4119376606699e-5*x_114 + 4.39092935865508e-6*x_115 + 6.36045852321868e-5*x_116 + 3.39667854365676e-5*x_117 - 2.32026913042002e-6*x_118 - 8.68399056140208e-5*x_119 - 4.91496956729183e-6*x_12 + 1.31051422188897e-5*x_120 - 4.9350431102953e-5*x_13 - 4.72577848630341e-7*x_14 - 1.05876890000349e-6*x_15 - 4.73797982605734e-5*x_16 - 6.27122310096425e-6*x_17 + 4.23827916438139e-6*x_18 + 2.08281025597076e-5*x_19 - 1.87591807993286e-6*x_2 + 9.3991005794756e-6*x_20 + 4.42861057118009e-7*x_21 + 7.5676075678176e-6*x_22 + 2.7857571920047e-5*x_23 + 1.09069528288418e-6*x_24 - 1.53735217301977e-6*x_25 + 1.82046434258906e-5*x_26 - 9.68930356204389e-6*x_27 + 4.04645758078844e-6*x_28 + 4.90478492425179e-6*x_29 + 1.51077678036694e-5*x_3 + 5.13801592358542e-6*x_30 + 0.000104121877493223*x_31 + 1.08422984626889e-5*x_32 - 1.86029515963461e-5*x_33 + 5.45278623076458e-6*x_34 - 3.62532608478269e-5*x_35 + 1.81380685055719e-6*x_36 - 1.38410941030313e-5*x_37 - 2.18805813609778e-5*x_38 + 4.15824115158069e-5*x_39 + 9.05789641808602e-6*x_4 - 9.03317345179888e-6*x_40 + 1.93551475442357e-6*x_41 - 3.11735069729993e-5*x_42 - 8.18259981038234e-6*x_43 + 2.52258724033451e-5*x_44 + 2.73934847647713e-5*x_45 - 9.10297751591784e-6*x_46 - 5.40234886828856e-5*x_47 + 5.44320867859275e-5*x_48 + 4.72390235476503e-9*x_49 + 1.00513319099466e-5*x_5 + 9.54313729436824e-7*x_50 + 3.78056262679233e-6*x_51 - 1.12675237139208e-5*x_52 - 1.00544778702456e-5*x_53 + 0.000100853544609877*x_54 - 1.40421373664871e-5*x_55 - 1.7833258794228e-6*x_56 + 1.57086288848034e-5*x_57 + 3.43485205067187e-5*x_58 - 2.00119744962626e-5*x_59 + 3.4934479968138e-6*x_6 + 1.35169979654913e-5*x_60 + 8.16117478817787e-6*x_61 + 3.08874842677311e-5*x_62 - 1.76740848492823e-5*x_63 - 6.24675212153675e-9*x_64 + 1.4354901286563e-7*x_65 - 1.10896676646291e-5*x_66 - 6.93170784432076e-6*x_67 + 7.89215015434407e-5*x_68 - 2.38832457127553e-5*x_69 + 1.81222660148736e-5*x_7 + 5.88186267617609e-6*x_70 - 5.45112570626952e-6*x_71 + 8.10903725649841e-6*x_72 - 6.11464895686379e-6*x_73 + 8.17369280645032e-6*x_74 + 8.28775845393564e-6*x_75 - 5.03712551894721e-6*x_76 - 1.29519284255399e-5*x_77 - 1.00376029856993e-6*x_78 + 1.33190384333782e-6*x_79 - 5.10539306019334e-6*x_8 - 6.76165648318107e-6*x_80 - 1.87929577613757e-5*x_81 - 1.66186606723066e-5*x_82 + 1.04493897167377e-6*x_83 - 1.31205927155142e-5*x_84 + 9.19838702100153e-6*x_85 - 3.04549773035291e-5*x_86 - 3.04427978380844e-6*x_87 - 2.16982123485002e-6*x_88 + 2.12788165593589e-5*x_89 + 5.02101088147636e-5*x_9 - 6.42927660280793e-6*x_90 + 4.11360775585619e-6*x_91 + 2.44774976781696e-5*x_92 + 6.12577337681717e-5*x_93 + 6.91733289029161e-6*x_94 - 5.52208013889692e-6*x_95 - 1.66279971752362e-6*x_96 - 8.91229697269743e-6*x_97 - 1.1061224997357e-5*x_98 - 1.48605169301418e-5*x_99 + 3.0438607796736e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 7.71072465788879e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) - 1.80684737839856e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) + 5.40553797936952e-6*std::sin(2.41103982925415*x_53 - 8.78551959991455) - 8.87758114523292e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 5.85726990642128e-5*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 1.15247836116397e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0433740871244131);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.99850226296017e-5*x_1 + 7.17039616446701e-7*x_10 + 2.15892894065379e-5*x_100 + 5.67935576808136e-5*x_101 + 0.000129029498668389*x_102 + 1.78711615388078e-6*x_103 + 3.85334463431972e-5*x_104 - 2.41981156620613e-5*x_105 + 4.11107095258407e-6*x_106 + 3.1620273488773e-5*x_107 - 1.23389161720058e-5*x_108 + 1.19837421583387e-5*x_109 + 4.46864296562381e-6*x_11 + 1.85030974403502e-5*x_110 + 1.50272841290129e-5*x_111 - 6.48912273528816e-6*x_112 + 6.17551900478109e-6*x_113 + 5.22615519779912e-5*x_114 - 1.99277524874416e-5*x_115 + 0.00016779871846011*x_116 + 3.82934113069725e-6*x_117 + 1.35341781624846e-5*x_118 + 9.2386188495217e-5*x_119 + 2.12973526953991e-6*x_12 + 1.86081638520693e-5*x_120 + 6.21202015972693e-5*x_13 + 1.38966254699969e-5*x_14 + 1.57239485601191e-5*x_15 + 3.70025782556585e-5*x_16 - 8.97123366236063e-6*x_17 + 1.01143519338591e-5*x_18 - 8.33757837913961e-6*x_19 + 5.02174728621245e-5*x_2 - 4.68066937346135e-5*x_20 + 2.4006575950877e-5*x_21 + 1.72607126433366e-5*x_22 + 5.13372966564131e-6*x_23 + 3.12690238828336e-5*x_24 + 2.68227778176628e-5*x_25 + 1.05419622287765e-5*x_26 + 4.01063874606878e-5*x_27 - 3.16414179080737e-5*x_28 - 1.12732320743538e-5*x_29 + 2.02659723628465e-5*x_3 + 1.79899001766171e-5*x_30 + 3.78468325541647e-6*x_31 + 1.34885121186986e-5*x_32 + 4.65392558366466e-5*x_33 + 2.53972249438858e-5*x_34 + 5.28567925072202e-5*x_35 + 1.82281831397213e-5*x_36 + 1.40021485478446e-6*x_37 + 1.5424683271388e-5*x_38 - 8.72844404786802e-6*x_39 - 6.3513346239161e-7*x_4 + 5.48541436296318e-5*x_40 + 1.53740076954806e-5*x_41 + 1.59888054846381e-5*x_42 - 1.59611205738774e-5*x_43 + 2.79904876066014e-5*x_44 - 3.34721874655662e-5*x_45 - 1.48646541652944e-6*x_46 - 9.5192053885324e-5*x_47 - 1.34767636905961e-5*x_48 + 3.61945898489436e-6*x_49 - 8.76731096459038e-6*x_5 - 8.30004895920944e-5*x_50 + 2.76255823993567e-5*x_51 + 7.37475804917494e-6*x_52 - 1.1203488510934e-6*x_53 + 8.57625758233774e-5*x_54 + 6.98172430603808e-6*x_55 + 8.64176463312054e-6*x_56 - 2.51186621369037e-6*x_57 + 1.22383316901742e-5*x_58 - 3.63257750770078e-6*x_59 - 2.26247381429125e-5*x_6 + 5.7851048170971e-6*x_60 + 2.43766587077511e-5*x_61 - 2.60748463524203e-5*x_62 + 4.11993342297858e-5*x_63 + 1.00488046144281e-5*x_64 - 1.0511089074875e-5*x_65 + 1.16611107163523e-5*x_66 + 5.36768496320283e-5*x_67 + 8.66541575536719e-5*x_68 + 2.0680431635998e-6*x_69 - 7.54501783856331e-6*x_7 + 2.89143175095142e-5*x_70 + 3.71582310522903e-5*x_71 + 0.000117344958439434*x_72 + 4.20171818839269e-5*x_73 - 8.64776646435488e-7*x_74 + 3.42818203509217e-6*x_75 + 1.48178658384567e-5*x_76 + 3.80218447547811e-5*x_77 - 1.34128320362181e-5*x_78 + 7.35868653773127e-5*x_79 + 8.76749663173715e-5*x_8 + 1.51050027771412e-5*x_80 + 4.65968716718675e-5*x_81 + 2.66059486100651e-5*x_82 - 7.04153591705822e-6*x_83 + 4.25822278803168e-5*x_84 + 7.00514626965666e-5*x_85 + 9.41891458511494e-5*x_86 + 3.86119532129106e-5*x_87 + 1.1327560158523e-5*x_88 + 3.65415767239227e-6*x_89 - 0.000117571323072694*x_9 + 4.27777031925714e-5*x_90 + 0.000120596483491665*x_91 - 2.50112344352839e-6*x_92 + 2.61336752856652e-5*x_93 - 1.4479949864782e-5*x_94 + 2.34826096829526e-5*x_95 + 5.65468582251762e-6*x_96 - 3.86078536932922e-6*x_97 + 7.41823523574722e-6*x_98 + 7.61889322308755e-6*x_99 + 6.51329313571684e-6*std::sin(1.98631978034973*x_29 - 3.61031985282898) + 1.13901630392506e-5*std::sin(2.08663988113403*x_29 + 4.18279981613159) + 1.01967300339746e-5*std::sin(2.5381600856781*x_43 + 2.6068799495697) - 3.76070335324953e-5*std::sin(2.41103982925415*x_53 - 8.78551959991455) + 5.00995819430386e-6*std::sin(2.17719984054565*x_75 + 6.81143999099731) + 8.65226838709363e-6*std::sin(2.07735991477966*x_77 + 6.80855989456177) + 2.46608828135576e-5*std::sin(1.60463976860046*x_85 - 4.80663967132568) + 0.0444983577912534);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
