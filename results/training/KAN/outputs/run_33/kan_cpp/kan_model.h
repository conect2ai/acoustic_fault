
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-391.665152072078*x_1 - 9.18979874431491*x_10 - 222.265645421272*x_100 + 206.410269532321*x_101 - 108.24257916179*x_102 - 143.942294074555*x_103 - 38.5422626374809*x_104 + 55.8127379983493*x_105 - 8.56544267289379*x_106 - 34.3310789383113*x_107 - 27.3962594205656*x_108 - 231.637813931452*x_109 - 25.6570367476942*x_11 - 156.170924850219*x_110 + 75.7584067516264*x_111 - 36.7280482650513*x_112 + 401.98634499423*x_113 - 103.511939502169*x_114 - 9.05179769717681*x_115 + 793.159903761834*x_116 - 51.2019755288735*x_117 - 70.9516783234931*x_118 - 36.6300543101324*x_119 + 968.532437768165*x_12 - 33.357473516567*x_120 - 49.5435861934544*x_13 - 2.75420931070384*x_14 + 1.75490743575962*x_15 - 56.8239331790037*x_16 - 71.133096103511*x_17 - 182.120539404985*x_18 + 24.1695317478562*x_19 - 175.916037995789*x_2 + 179.050027109035*x_20 + 448.94899727568*x_21 + 78.401085185273*x_22 + 73.9138859051019*x_23 - 43.217971849212*x_24 - 147.858035864016*x_25 - 57.805977661042*x_26 - 158.598642569123*x_27 + 37.8770930846039*x_28 + 75.7195131173314*x_29 + 232.855214884994*x_3 + 115.47818194003*x_30 + 6507.03005239939*x_31 + 17.5131645458372*x_32 + 97.6722852551823*x_33 - 7.03976695599287*x_34 - 131.922888629457*x_35 - 8.78244435136562*x_36 + 1191.54696782631*x_37 - 59.9294106197865*x_38 - 137.459048356048*x_39 + 59.5238437421829*x_4 + 62.1134999124754*x_40 - 17.2894775862742*x_41 - 100401.961591181*x_42 + 90.9610938143704*x_43 + 52.7317440412702*x_44 - 4.83011587752579*x_45 - 57.1413990731015*x_46 - 351.364264260668*x_47 + 243.849159632188*x_48 - 375.432140406825*x_49 + 83.5795194420538*x_5 - 958.314113282588*x_50 + 254.904974695288*x_51 + 621.382657605234*x_52 - 27.31506729829*x_53 + 576.36640381018*x_54 - 98.7731487405867*x_55 - 132.106079912754*x_56 - 1580.91017047516*x_57 + 66.628621656171*x_58 + 60.308039350343*x_59 - 21.5748451996509*x_6 - 204.480721317476*x_60 + 23.1548493997696*x_61 - 100.674624485029*x_62 + 80.7669904376251*x_63 - 58.5621627269883*x_64 - 35.5559823462996*x_65 - 66.437419876072*x_66 - 39.1814906844424*x_67 + 66.9102394517775*x_68 - 142.053678342323*x_69 - 10.0759843775913*x_7 + 66.1988646449279*x_70 + 38.733004723435*x_72 + 83.0775227219225*x_73 + 83.7523543302237*x_74 + 107.47088125612*x_75 + 21.0578367088988*x_76 + 100.248911715208*x_77 - 12.8268137377902*x_78 + 85.0912624996825*x_79 - 220.831912623631*x_8 - 18.325408795092*x_80 - 302.977518139692*x_81 + 79.2902367945531*x_82 - 46.6899768161748*x_83 + 351.917135127698*x_84 + 48.4460567767649*x_85 + 104.151762956895*x_86 + 35.851924647783*x_87 + 176.066166800356*x_88 - 73.6861437967309*x_89 + 456.381227427254*x_9 + 234.966731490512*x_90 + 113.672812643569*x_91 - 49.650991075042*x_92 - 45.0899821812782*x_93 + 28.1394291821303*x_94 - 41.3163958655656*x_95 - 75.7724177659408*x_96 - 71.9005014076245*x_97 + 41.0854360776976*x_98 - 88.3866755987669*x_99 + 0.0457001977049778*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 0.168598254524226*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 7.23655203076039e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) - 1.20793339759815*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 0.0546745022686637*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) - 0.105530877522884*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.000945370347920429*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) - 0.0047689724222218*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 0.30247056875159*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) - 0.585742761792455*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00446952151913544*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 0.1158365639748*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.905527266862686*std::exp(0.925839841365814*x_38) + 0.00715698091097036*std::exp(1.08759987354279*x_38) + 9.46480344546196*std::exp(2.50039982795715*x_71) - 0.0716523540167261*std::exp(2.50919985771179*x_71) - 0.00746770028620012*std::exp(2.55495977401733*x_71) + 0.0476207257804753*std::exp(2.56535983085632*x_71) + 0.79424323783682*std::exp(2.59455990791321*x_71) + 0.000472638575138713*std::exp(2.59552001953125*x_71) - 0.000307504221979844*std::exp(2.60351991653442*x_71) - 0.723085054250232*std::exp(2.63032007217407*x_71) - 0.0504915930811255*std::exp(2.64359998703003*x_71) - 0.000565537526019303*std::exp(2.67215991020203*x_71) - 0.00222995684641156*std::exp(0.873279869556427*x_89) + 0.0753137496097998*std::exp(2.03023982048035*x_89) + 2.42863081133002*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 14.646899017275*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.0170666748145155*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.0462734078347093*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 6.20336939114773*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 6.20991233069004*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.0491109138921975*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.0265653097011101*std::sin(0.327919840812683*x_16 - 4.26919984817505) + 27.4218960591989*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 5.51031803793667*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.0360054912900412*std::sin(0.333359837532043*x_26 + 5.14448022842407) - 22.1811758049623*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.112917826350539*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 88.6976610685505*std::sin(0.330799847841263*x_28 - 4.27928018569946) + 4.0328450412122*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.0262386223357697*std::sin(0.34063982963562*x_28 + 5.15088033676147) + 804.765692825282*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.0120527249815369*std::sin(0.325119823217392*x_36 + 8.32335948944092) + 337.146301810096*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.719769567754299*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 6.32726380277334*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.0141391629845022*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.0264482389542062*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.0199682597380824*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 0.793483098147764*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 72.6418239006316*std::sin(0.412639856338501*x_41 - 7.39527988433838) - 21.9167932264544*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 54.3726756723744*std::sin(0.423359870910645*x_53 - 7.36495971679688) + 2.22525694272404*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.0156593717337858*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 120.427061796316*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 11.5364729297651*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.721361791048319*std::sin(0.501519858837128*x_75 - 4.09960031509399) + 5.39820720749576*std::sin(0.282399952411652*x_80 - 7.49272012710571) + 15.6096870371027*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.410474713450098*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 50.3145502308131*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.0106928026471592*std::sin(0.608239889144897*x_80 + 2.17871975898743) - 2.23067039337224*std::sin(0.374239832162857*x_83 - 4.23303985595703) + 15.1343076036558*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 0.813091560106548*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.0331045087892767*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 1.75498454043833*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 2.1883979452515*std::sin(0.400159865617752*x_96 + 5.19144010543823) - 1.90154201453463*std::sin(0.447679847478867*x_96 - 7.36935997009277) - 9.75060556504644*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 5.60918814060101*std::sin(0.439599871635437*x_97 + 1.99983978271484) - 2.48261427065387*std::sin(0.423839867115021*x_99 + 5.22488021850586) - 23.0942258693004*std::sin(0.449519872665405*x_99 - 1.14855980873108) - 212302.360072739 + 1.90689465527357e-6*std::exp(-3.94543981552124*x_74) - 0.00437455405882872*std::exp(-2.76799988746643*x_74) - 0.000588627184724022*std::exp(-2.69735980033875*x_74) - 0.012573403523903*std::exp(-2.53743982315063*x_74) + 0.051237476972187*std::exp(-3.83120012283325*x_45) + 0.00014065196495787*std::exp(-4.80536031723022*x_111) + 3.30284373027969e-6*std::exp(-4.45599985122681*x_111) + 7.45811383826503e-5*std::exp(-4.4312801361084*x_111) - 0.00447387298691409*std::exp(-3.27823972702026*x_111) - 0.0238026840601271*std::exp(-3.64696002006531*x_101));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5190.62231741081*x_1 - 217.248595931181*x_10 - 44.840939798488*x_100 + 146.638037829652*x_101 - 417.84587381803*x_102 - 308.9135371391*x_103 + 156.12772250087*x_104 + 8.06729906377241*x_105 - 4.9327654504172*x_106 + 12.9732886156939*x_107 + 216.36396404354*x_108 - 146.586484876487*x_109 + 194.541140414809*x_11 - 396.420779042771*x_110 + 95.9581747223039*x_111 - 36.1827870204318*x_112 - 277.241232702842*x_113 + 142.439960135939*x_114 - 5.90807823120701*x_115 + 1765.63506334676*x_116 - 55.7294872656342*x_117 - 330.197931706351*x_118 - 234.601889149456*x_119 - 250.658111070549*x_12 + 1206.4161019294*x_120 + 370.590286988498*x_13 + 136.499021477235*x_14 + 192.272462508503*x_15 + 23.423859002874*x_16 - 334.743010933083*x_17 - 70.0631467668678*x_18 + 46.6424395440904*x_19 - 617.927607535473*x_2 + 1112.58322585781*x_20 + 612.754724750951*x_21 + 1028.73819901082*x_22 - 353.993540825147*x_23 - 202.592768949496*x_24 + 540.461751855275*x_25 - 166.882185686242*x_26 - 0.0749025834034475*x_27 + 23.5176781181478*x_28 + 506.507487990961*x_29 - 959.739654991595*x_3 - 2150.34306950731*x_30 + 12846.6953735514*x_31 + 440.470318662783*x_32 + 155.454797971358*x_33 - 534.419820190283*x_34 - 853.520486793067*x_35 - 298.070274245268*x_36 - 1589.41203743049*x_37 - 34.7566818551235*x_38 - 109.102659770586*x_39 - 15.5055163628666*x_4 + 415.654523075282*x_40 - 8.86196419180003*x_41 - 77557.7769446515*x_42 + 391.20718229657*x_43 + 207.185847744191*x_44 - 326.544747932355*x_45 + 85.3669476124382*x_46 + 784.031360482588*x_47 + 405.286166866852*x_48 + 1383.85499390226*x_49 + 155.54485535013*x_5 + 996.575710209566*x_50 - 298.571825249553*x_51 + 981.867916324724*x_52 - 17.0523118664903*x_53 + 565.920565149473*x_54 + 298.056195714784*x_55 - 67.2072825538996*x_56 + 1683.32976280089*x_57 + 148.332197801997*x_58 - 216.510323025928*x_59 - 94.9642761484304*x_6 - 134.167002312653*x_60 - 198.911556778616*x_61 - 483.424404792945*x_62 + 237.335973524517*x_63 + 297.274751485412*x_64 - 197.4214953401*x_65 + 412.418202353427*x_66 - 22.5844610880729*x_67 + 158.30476082051*x_68 - 471.900202107109*x_69 + 239.514378191529*x_7 - 198.108446336427*x_70 - 99.3370452100874*x_72 + 718.75793710846*x_73 + 281.299132418371*x_74 + 37.8752101060171*x_75 + 740.781963180464*x_76 - 126.836456677602*x_77 - 267.541437310729*x_78 + 391.713961175845*x_79 - 1418.7810504829*x_8 - 11.424711701794*x_80 - 398.354183504317*x_81 + 113.676004011362*x_82 + 12.1547381106866*x_83 + 1065.00044229542*x_84 + 387.563298733807*x_85 + 355.80713994134*x_86 + 21.5170836586436*x_87 + 950.473455441274*x_88 - 164.515073219042*x_89 - 843.675478169547*x_9 + 2205.29793590426*x_90 + 355.396966239704*x_91 + 196.91887691103*x_92 + 261.40657046249*x_93 + 175.131318778718*x_94 + 163.309210004327*x_95 + 53.644434517502*x_96 + 866.895225368165*x_97 + 298.02547869544*x_98 + 139.738468866097*x_99 + 0.0477547562078537*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 6.31663849943728*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) + 8.04498412880798e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) - 0.75094389103565*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 2.04841424332888*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) - 0.110275263162751*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.00219910020411166*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) - 0.0124342954396747*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 11.3322480408506*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) - 0.364142550873259*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.000375843627297155*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 4.33988893722867*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.571438826437515*std::exp(0.925839841365814*x_38) + 0.00225823671276785*std::exp(1.08759987354279*x_38) + 5.88404653878717*std::exp(2.50039982795715*x_71) - 0.0452166804790564*std::exp(2.50919985771179*x_71) - 0.0173712040574913*std::exp(2.55495977401733*x_71) + 0.0040044434813056*std::exp(2.56535983085632*x_71) + 0.829950286812485*std::exp(2.59455990791321*x_71) + 0.00309597587579683*std::exp(2.59552001953125*x_71) + 0.000341857085370717*std::exp(2.60351991653442*x_71) - 27.0908314260657*std::exp(2.63032007217407*x_71) - 0.131648357341109*std::exp(2.64359998703003*x_71) - 0.000178443623029244*std::exp(2.67215991020203*x_71) + 0.00247907668749569*std::exp(0.873279869556427*x_89) + 0.0475272278003739*std::exp(2.03023982048035*x_89) + 6.33224735820665*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 548.755184275026*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.111793696674679*std::sin(0.404879868030548*x_106 + 5.1866397857666) + 0.0514428459898711*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 3.91467629364429*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 3.91880525787356*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.0154959290975535*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.174013638103006*std::sin(0.327919840812683*x_16 - 4.26919984817505) + 28.6547110696965*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 3.47732176393258*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.235850686536674*std::sin(0.333359837532043*x_26 + 5.14448022842407) - 23.1783820675712*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.0356288753823376*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 3323.11305533202*std::sin(0.330799847841263*x_28 - 4.27928018569946) + 10.5149668031625*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.171873702314386*std::sin(0.34063982963562*x_28 + 5.15088033676147) + 500.303975321712*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.0789502756297467*std::sin(0.325119823217392*x_36 + 8.32335948944092) + 209.595956393764*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.0605256746174498*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 3.99286066177137*std::sin(0.407759845256805*x_36 + 2.01279973983765) + 0.0157187209214327*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.00834519260808635*std::sin(0.416239857673645*x_36 - 7.38247966766357) - 0.0221990157729728*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 1.84578334505026*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 2721.57112666988*std::sin(0.412639856338501*x_41 - 7.39527988433838) - 22.9021135563549*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 2037.10612211698*std::sin(0.423359870910645*x_53 - 7.36495971679688) + 5.80198411844187*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.102575286208298*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 4511.87479409772*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 7.28016570395864*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.0606595652309594*std::sin(0.501519858837128*x_75 - 4.09960031509399) + 14.0749195675391*std::sin(0.282399952411652*x_80 - 7.49272012710571) + 16.3114567632721*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.954837464615254*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 1885.06592767933*std::sin(0.485199838876724*x_80 - 7.31383991241455) - 0.0118873501113807*std::sin(0.608239889144897*x_80 + 2.17871975898743) - 5.81609878272345*std::sin(0.374239832162857*x_83 - 4.23303985595703) + 15.814705543572*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 1.89139612822114*std::sin(0.407039850950241*x_94 - 7.38600015640259) + 0.0368027821356977*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 0.147577263629858*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 0.184023148382126*std::sin(0.400159865617752*x_96 + 5.19144010543823) - 4.95795175696619*std::sin(0.447679847478867*x_96 - 7.36935997009277) - 10.1889666789563*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 3.53971438037141*std::sin(0.439599871635437*x_97 + 1.99983978271484) - 6.47300017090079*std::sin(0.423839867115021*x_99 + 5.22488021850586) - 24.1324804176377*std::sin(0.449519872665405*x_99 - 1.14855980873108) - 130812.209265071 + 1.24909395063241e-5*std::exp(-3.94543981552124*x_74) - 0.0101759937201642*std::exp(-2.76799988746643*x_74) - 0.000185729085380045*std::exp(-2.69735980033875*x_74) - 0.0327830400884601*std::exp(-2.53743982315063*x_74) + 0.0318531389237602*std::exp(-3.83120012283325*x_45) + 8.8759330318259e-5*std::exp(-4.80536031723022*x_111) - 3.67182123158742e-6*std::exp(-4.45599985122681*x_111) + 0.000173489042681473*std::exp(-4.4312801361084*x_111) - 0.00467500633529454*std::exp(-3.27823972702026*x_111) - 0.0150208374094653*std::exp(-3.64696002006531*x_101));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (821.726321094841*x_1 + 26.4066917852126*x_10 + 399.25241495578*x_100 - 397.234031294112*x_101 + 218.224235057422*x_102 + 268.164303060539*x_103 + 61.8298331042341*x_104 - 105.777446076961*x_105 + 17.5882491071517*x_106 + 71.5187005649861*x_107 + 38.3167989915837*x_108 + 423.181606810642*x_109 + 27.3138321994791*x_11 + 295.285769671871*x_110 - 141.193296657174*x_111 + 60.1525047103518*x_112 - 685.563956421454*x_113 + 183.776705822328*x_114 + 24.0532445145694*x_115 - 1508.33141923459*x_116 + 104.8263495578*x_117 + 145.656257241731*x_118 + 80.7388117377031*x_119 - 1757.51430972525*x_12 - 11.2862041852017*x_120 + 41.4736197247545*x_13 + 4.01302368660082*x_14 - 20.7357328034732*x_15 + 99.0226420434396*x_16 + 139.591701870095*x_17 + 319.108312601436*x_18 - 47.3177884888257*x_19 + 342.973760832353*x_2 - 374.644733643877*x_20 - 858.410170863864*x_21 - 185.72388503961*x_22 - 103.198156712713*x_23 + 84.5479360343648*x_24 + 222.472651042518*x_25 + 106.18658253699*x_26 + 290.252708017293*x_27 - 66.3223127466344*x_28 - 170.928468268426*x_29 - 343.974682303357*x_3 - 45.6438717249948*x_30 - 12230.4411419874*x_31 - 56.7219917609176*x_32 - 189.057429088456*x_33 + 57.3597059717848*x_34 + 291.557988573235*x_35 + 31.5326202117518*x_36 - 2024.35384924155*x_37 + 112.598910213228*x_38 + 252.415696109374*x_39 - 101.103363401595*x_4 - 133.515656525045*x_40 + 42.4184476285669*x_41 + 175908.501893566*x_42 - 185.072321827491*x_43 - 124.91589136062*x_44 + 35.7273626066573*x_45 + 85.9937164148921*x_46 + 589.811672925481*x_47 - 401.263709046092*x_48 + 595.674400574812*x_49 - 156.053402429095*x_5 + 1621.29006060438*x_50 - 416.129994938206*x_51 - 1181.34969093677*x_52 + 49.710568289559*x_53 - 1026.9689549764*x_54 + 156.632091477519*x_55 + 232.598235705037*x_56 + 2724.15052705602*x_57 - 138.00898811866*x_58 - 102.100788571075*x_59 + 43.5732408588401*x_6 + 336.801135384271*x_60 - 25.18339219727*x_61 + 210.463381300492*x_62 - 168.060839889026*x_63 + 86.3558341865069*x_64 + 79.2407442073552*x_65 + 95.2472853321581*x_66 + 77.7687009055226*x_67 - 125.641073103826*x_68 + 274.126914743596*x_69 - 0.939941362377708*x_7 - 109.872749733876*x_70 - 59.7916227680171*x_72 - 180.567806739345*x_73 - 174.075276914162*x_74 - 198.86939049832*x_75 - 85.224189728062*x_76 - 161.60003024346*x_77 + 27.3752215540267*x_78 - 166.255583130826*x_79 + 521.690453604455*x_8 + 32.3986414272454*x_80 + 574.821524961176*x_81 - 135.255297396935*x_82 + 76.392336154662*x_83 - 637.675103495319*x_84 - 98.2311040732578*x_85 - 207.25242149141*x_86 - 71.3934149749191*x_87 - 353.099136235604*x_88 + 134.225883206343*x_89 - 747.590279305881*x_9 - 543.261325161689*x_90 - 236.058029674354*x_91 + 78.2528849465332*x_92 + 69.718907542602*x_93 - 68.4991708777828*x_94 + 57.7883121070887*x_95 + 132.987300455541*x_96 + 78.9871505174724*x_97 - 81.8459610736322*x_98 + 147.457515218451*x_99 - 0.000767827518882453*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) + 0.671875244033923*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 4.33548717085131e-6*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 2.17793550589282*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) + 0.217881523494144*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) + 0.00177306698708347*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) + 0.000786017192555001*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) - 0.00439377517602696*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) + 1.20536530918743*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 1.05610951792882*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00413513743498805*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) + 0.461616402306448*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.295080153645866*std::exp(0.925839841365814*x_38) + 0.000768726542732947*std::exp(1.08759987354279*x_38) - 17.0652881368762*std::exp(2.50039982795715*x_71) - 0.0233490347624724*std::exp(2.50919985771179*x_71) + 0.00620893264392427*std::exp(2.55495977401733*x_71) + 0.044058014938081*std::exp(2.56535983085632*x_71) - 0.0133444021103433*std::exp(2.59455990791321*x_71) - 0.00381445540009072*std::exp(2.59552001953125*x_71) - 1.84228705011624e-5*std::exp(2.60351991653442*x_71) + 2.88154197475307*std::exp(2.63032007217407*x_71) - 0.0465191845614715*std::exp(2.64359998703003*x_71) - 6.07440082027016e-5*std::exp(2.67215991020203*x_71) - 0.000133598836270006*std::exp(0.873279869556427*x_89) + 0.0245421575028905*std::exp(2.03023982048035*x_89) + 2.23755912716824*std::sin(0.414959847927094*x_103 - 4.18824005126953) + 58.3688655576078*std::sin(0.299919933080673*x_106 - 7.47904014587402) + 0.137737529969311*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.00277228388832399*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 2.02146446611586*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 2.02359658480084*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.00527497048216743*std::sin(0.336639851331711*x_14 - 1.25951993465424) + 0.214396780911804*std::sin(0.327919840812683*x_16 - 4.26919984817505) - 0.460726374754694*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 1.79562289593484*std::sin(0.474079847335815*x_16 + 8.26064014434814) + 0.290584281327247*std::sin(0.333359837532043*x_26 + 5.14448022842407) + 0.372674912571869*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.0121284283615059*std::sin(0.314639836549759*x_28 - 4.28416013717651) - 353.46607142429*std::sin(0.330799847841263*x_28 - 4.27928018569946) + 3.71556236061989*std::sin(0.331759840250015*x_28 - 4.27432012557983) - 0.211760232711102*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 1451.01359049574*std::sin(0.375119835138321*x_34 + 2.00247979164124) + 0.097272174363125*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 607.883599255312*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.665920517765333*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 2.06183738845205*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.000847090706531465*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.0028407876932405*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.00119631743889481*std::sin(0.559439837932587*x_38 + 8.55887985229492) + 0.659732303343245*std::sin(0.391199827194214*x_40 - 7.39615964889526) + 289.482493742503*std::sin(0.412639856338501*x_41 - 7.39527988433838) + 0.368232913861011*std::sin(0.300959914922714*x_53 + 5.12016010284424) - 216.678724457997*std::sin(0.423359870910645*x_53 - 7.36495971679688) + 2.05018562692117*std::sin(0.490639865398407*x_53 + 5.2628002166748) + 0.126379813696833*std::sin(0.549279868602753*x_53 - 1.03927981853485) - 479.909841065776*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 3.75933925925906*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.667393620002289*std::sin(0.501519858837128*x_75 - 4.09960031509399) + 4.97350513348001*std::sin(0.282399952411652*x_80 - 7.49272012710571) - 0.262264669960599*std::sin(0.360719859600067*x_80 + 5.14807987213135) - 0.34128443164162*std::sin(0.471119850873947*x_80 - 1.13295996189117) + 200.50682499757*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.000640615979822266*std::sin(0.608239889144897*x_80 + 2.17871975898743) - 2.05517317622295*std::sin(0.374239832162857*x_83 - 4.23303985595703) - 0.254277627688537*std::sin(0.331519842147827*x_92 - 7.40743970870972) - 0.676035531229617*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.00198332261750024*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 1.62368661610016*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 2.0246745042657*std::sin(0.400159865617752*x_96 + 5.19144010543823) - 1.75193885808677*std::sin(0.447679847478867*x_96 - 7.36935997009277) + 0.163823870674318*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 1.82784125771455*std::sin(0.439599871635437*x_97 + 1.99983978271484) - 2.28729545661062*std::sin(0.423839867115021*x_99 + 5.22488021850586) + 0.388015436261546*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 363622.517211379 - 1.53896973243829e-5*std::exp(-3.94543981552124*x_74) + 0.00363717214905713*std::exp(-2.76799988746643*x_74) - 6.32240530330232e-5*std::exp(-2.69735980033875*x_74) - 0.0115841953759417*std::exp(-2.53743982315063*x_74) - 0.0923825109496769*std::exp(-3.83120012283325*x_45) + 4.58336319061441e-5*std::exp(-4.80536031723022*x_111) + 1.97876510237012e-7*std::exp(-4.45599985122681*x_111) - 6.20096210316308e-5*std::exp(-4.4312801361084*x_111) + 7.51673508616638e-5*std::exp(-3.27823972702026*x_111) - 0.00775647506891845*std::exp(-3.64696002006531*x_101));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (390.827461323083*x_1 + 17.9412655405858*x_10 - 30.1990621029882*x_100 + 2.00374027700951*x_101 + 28.5761483772088*x_102 + 9.10118463111259*x_103 - 24.5451506022746*x_104 + 2.6142501672943*x_105 - 0.429529117301876*x_106 + 2.96771585903046*x_107 - 31.6919388958505*x_108 - 18.7834211476664*x_109 - 29.6242707930332*x_11 + 17.6801322985057*x_110 + 1.03118368633177*x_111 - 7.34111967161*x_112 + 95.3762793666979*x_113 - 24.3967040247154*x_114 + 5.00600871419164*x_115 - 78.7726853910163*x_116 + 5.71492510804332*x_117 + 28.8614210685626*x_118 + 22.8768363584158*x_119 + 134.892328312304*x_12 - 137.816050412344*x_120 - 57.97845496117*x_13 - 11.0620217278911*x_14 - 26.0522950018245*x_15 - 11.1114142250167*x_16 + 23.3631343073909*x_17 - 25.4421604203345*x_18 - 0.436750844590918*x_19 + 41.6226942491019*x_2 - 92.6003969801438*x_20 - 24.7552333887717*x_21 - 96.3820216422591*x_22 + 53.5536593067679*x_23 + 13.0738301512309*x_24 - 85.4173200943442*x_25 + 5.90706933842969*x_26 - 15.1310241296054*x_27 + 3.33065560249046*x_28 - 48.7400799061093*x_29 + 143.514571243422*x_3 + 279.077901541073*x_30 - 569.401239256453*x_31 - 50.0319401631904*x_32 - 9.27535400579987*x_33 + 67.5952262145621*x_34 + 79.2553341911794*x_35 + 30.7318613922943*x_36 + 360.175522083191*x_37 - 4.4961279837618*x_38 - 5.631298546627*x_39 + 11.4690054858006*x_4 - 38.364041760819*x_40 + 9.94322133928227*x_41 - 13153.1501854386*x_42 - 29.4543615411384*x_43 - 26.9655584091306*x_44 + 41.1269203760707*x_45 - 22.0012901158959*x_46 - 133.673347588012*x_47 + 20.4481043093577*x_48 - 202.437581132619*x_49 - 4.61840798034782*x_5 - 268.750452856774*x_50 + 82.7445218274467*x_51 - 36.2785581581225*x_52 - 2.14854201640774*x_53 + 40.7580194174496*x_54 - 49.5031539929231*x_55 - 16.9478627270915*x_56 - 408.077881144993*x_57 - 14.1408068506838*x_58 + 24.9229827062863*x_59 + 6.77409275996571*x_6 - 35.184876415883*x_60 + 26.5189911089822*x_61 + 41.4308298582313*x_62 - 21.7135736630945*x_63 - 39.5327361545974*x_64 + 17.8117739599767*x_65 - 53.7321412759512*x_66 + 0.77382967089103*x_67 - 7.27977914993242*x_68 + 28.2597431143386*x_69 - 29.186937854946*x_7 + 35.7947694297942*x_70 + 19.0576210061794*x_72 - 62.7254769596645*x_73 - 27.1641370417796*x_74 + 8.67998306949175*x_75 - 77.0721785293375*x_76 + 36.5671428965194*x_77 + 19.9557245715024*x_78 - 25.1618633924493*x_79 + 157.332139335404*x_8 - 1.55174013167232*x_80 + 14.7406828043205*x_81 + 8.72050561396627*x_82 - 13.2820327793647*x_83 - 27.7354051615715*x_84 - 28.6018036127235*x_85 - 22.7560308891175*x_86 - 0.180943456710912*x_87 - 69.6854847623834*x_88 + 0.176866468288162*x_89 + 173.725231497224*x_9 - 208.78375013351*x_90 - 39.6474944528671*x_91 - 28.4942267261974*x_92 - 32.8875304181262*x_93 - 18.8440959745089*x_94 - 29.6861812350572*x_95 - 17.1923333226369*x_96 - 107.618549320392*x_97 - 20.53476814009*x_98 - 28.6994840576993*x_99 + 0.0629182444798378*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) + 0.669958801106088*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 0.000283362552352083*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) - 0.0988664482022152*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) + 0.217260042782488*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) - 0.145290783970359*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) + 0.000644924129064934*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.00230385388838066*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) + 1.20192715032868*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) - 0.0479416386149474*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00385556142586716*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) + 0.46029969731184*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.270569038441491*std::exp(0.925839841365814*x_38) + 0.00250676916772433*std::exp(1.08759987354279*x_38) + 0.774671435896678*std::exp(2.50039982795715*x_71) - 0.0214095248567647*std::exp(2.50919985771179*x_71) + 0.00509440571495578*std::exp(2.55495977401733*x_71) + 0.0410792592909395*std::exp(2.56535983085632*x_71) + 1.09348302029844*std::exp(2.59455990791321*x_71) - 0.00163457964978952*std::exp(2.59552001953125*x_71) - 0.00120409804045994*std::exp(2.60351991653442*x_71) + 2.87332272454581*std::exp(2.63032007217407*x_71) + 0.0243921001741273*std::exp(2.64359998703003*x_71) - 0.000198082410872893*std::exp(2.67215991020203*x_71) - 0.00873186927901886*std::exp(0.873279869556427*x_89) + 0.0225035397155377*std::exp(2.03023982048035*x_89) - 1.17325286094168*std::sin(0.414959847927094*x_103 - 4.18824005126953) + 58.2023754233203*std::sin(0.299919933080673*x_106 - 7.47904014587402) + 0.059023619333642*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.181193348632558*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 1.85354958672353*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 1.85550459893059*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.0172013487635575*std::sin(0.336639851331711*x_14 - 1.25951993465424) + 0.0918738268772211*std::sin(0.327919840812683*x_16 - 4.26919984817505) + 37.7533937925492*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 1.64646776258523*std::sin(0.474079847335815*x_16 + 8.26064014434814) + 0.124521878744455*std::sin(0.333359837532043*x_26 + 5.14448022842407) - 30.5381751553094*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.0395500461861094*std::sin(0.314639836549759*x_28 - 4.28416013717651) - 352.457852177003*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 1.94823641381108*std::sin(0.331759840250015*x_28 - 4.27432012557983) - 0.0907440068681961*std::sin(0.34063982963562*x_28 + 5.15088033676147) + 65.8681396199789*std::sin(0.375119835138321*x_34 + 2.00247979164124) + 0.0416833073211342*std::sin(0.325119823217392*x_36 + 8.32335948944092) + 27.5946152749434*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.620897733474469*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 1.89056889364949*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.0553648933135586*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.00926363096056106*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.0781899587173673*std::sin(0.559439837932587*x_38 + 8.55887985229492) + 0.541307855832775*std::sin(0.391199827194214*x_40 - 7.39615964889526) + 288.656779917219*std::sin(0.412639856338501*x_41 - 7.39527988433838) - 30.1741835634534*std::sin(0.300959914922714*x_53 + 5.12016010284424) - 216.060674585216*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 1.07500450961979*std::sin(0.490639865398407*x_53 + 5.2628002166748) + 0.0541565832983971*std::sin(0.549279868602753*x_53 - 1.03927981853485) - 478.540956248132*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 3.44706614791111*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.622271239494633*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 2.6078323722995*std::sin(0.282399952411652*x_80 - 7.49272012710571) + 21.4908064860998*std::sin(0.360719859600067*x_80 + 5.14807987213135) - 0.280022583379423*std::sin(0.471119850873947*x_80 - 1.13295996189117) + 199.934903513393*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.0418699380176746*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 1.07761970598102*std::sin(0.374239832162857*x_83 - 4.23303985595703) + 20.8363226782314*std::sin(0.331519842147827*x_92 - 7.40743970870972) - 0.554684592557054*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.129627729684212*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 1.51390941248139*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 1.88778657089691*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 0.918620318224404*std::sin(0.447679847478867*x_96 - 7.36935997009277) - 13.4242523134913*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 1.67600987532711*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 1.19933185483395*std::sin(0.423839867115021*x_99 + 5.22488021850586) - 31.7952267667973*std::sin(0.449519872665405*x_99 - 1.14855980873108) - 30226.1512656897 - 6.59483030323493e-6*std::exp(-3.94543981552124*x_74) + 0.00298428597072419*std::exp(-2.76799988746643*x_74) - 0.000206169681923951*std::exp(-2.69735980033875*x_74) + 0.00607411451233085*std::exp(-2.53743982315063*x_74) + 0.00419366446292111*std::exp(-3.83120012283325*x_45) + 4.20264174323619e-5*std::exp(-4.80536031723022*x_111) + 1.29329855634823e-5*std::exp(-4.45599985122681*x_111) - 5.08786591645357e-5*std::exp(-4.4312801361084*x_111) - 0.0061594533174578*std::exp(-3.27823972702026*x_111) - 0.00711217604831305*std::exp(-3.64696002006531*x_101));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-678.68311807215*x_1 - 39.3371497014616*x_10 + 473.616847800162*x_100 - 429.606910283565*x_101 + 128.259984049746*x_102 + 229.559536410588*x_103 + 123.06554803608*x_104 - 126.089961460077*x_105 + 18.8787242817193*x_106 + 89.2136433577258*x_107 + 116.42266420628*x_108 + 469.158403748569*x_109 + 101.157936945687*x_11 + 233.619790737446*x_110 - 140.59868826578*x_111 + 63.8733496699457*x_112 - 941.435345250596*x_113 + 270.635685556116*x_114 + 26.4984191234859*x_115 - 1272.30646642011*x_116 + 106.814339159289*x_117 + 70.3492035684314*x_118 + 22.2171241466656*x_119 - 2227.51808008127*x_12 + 386.620332795109*x_120 + 183.445070743229*x_13 + 47.5530266581958*x_14 + 40.1498231522859*x_15 + 130.160578850692*x_16 + 62.5075269103809*x_17 + 372.484115473797*x_18 - 41.3049469400676*x_19 + 220.107017404358*x_2 - 93.8541911919713*x_20 - 846.736959282425*x_21 + 105.874074695771*x_22 - 247.68483559046*x_23 + 38.6760972481675*x_24 + 455.184760776013*x_25 + 77.9851615102075*x_26 + 355.14432514887*x_27 - 74.814591156512*x_28 - 40.0411439264147*x_29 - 747.156031485227*x_3 - 770.777301672432*x_30 - 10931.2419829107*x_31 + 74.2274838228985*x_32 - 180.576285208053*x_33 - 111.147287421774*x_34 + 73.5936817513271*x_35 - 59.3949302115313*x_36 - 3017.13593585481*x_37 + 123.830415990168*x_38 + 274.281917091471*x_39 - 132.305271348292*x_4 - 27.6584826081521*x_40 + 47.100616520526*x_41 + 192358.502621672*x_42 - 97.5231195624948*x_43 - 78.6852862847809*x_44 - 67.4903973942386*x_45 + 138.453676217021*x_46 + 981.147315434917*x_47 - 382.251661267709*x_48 + 1189.21475401674*x_49 - 141.586171051735*x_5 + 2331.32070667569*x_50 - 617.68096562807*x_51 - 1125.02172265776*x_52 + 55.3509351146962*x_53 - 1087.80096421803*x_54 + 291.487265966321*x_55 + 265.674147437335*x_56 + 3917.67104558109*x_57 - 116.562034019752*x_58 - 195.956202345681*x_59 + 22.0359348247191*x_6 + 383.001713692857*x_60 - 99.1511014684209*x_61 + 97.4586846843315*x_62 - 124.442086782062*x_63 + 205.246760774382*x_64 + 29.6719890189461*x_65 + 253.545653304828*x_66 + 85.5096725452224*x_67 - 102.467225235922*x_68 + 182.388822214432*x_69 + 80.6207550657029*x_7 - 196.175624404637*x_70 - 108.094913383535*x_72 + 12.4649296919558*x_73 - 118.539044545824*x_74 - 229.493447699395*x_75 + 143.596204583087*x_76 - 242.845400429995*x_77 - 50.7383098253407*x_78 - 77.8497777186039*x_79 + 155.695794107492*x_8 + 36.4074926062223*x_80 + 572.49537044304*x_81 - 132.254486659168*x_82 + 99.6206105489029*x_83 - 451.453528577976*x_84 + 3.56743559689835*x_85 - 135.458744859439*x_86 - 78.1024229359743*x_87 - 125.519282511106*x_88 + 111.156200452209*x_89 - 1204.99911701117*x_9 + 61.0722812787547*x_90 - 171.35684444745*x_91 + 161.276708587661*x_92 + 170.395686884437*x_93 - 23.2839362867656*x_94 + 127.070951095151*x_95 + 180.926183578229*x_96 + 382.968860828331*x_97 - 5.39944595208592*x_98 + 228.545935835783*x_99 - 0.0112592198390872*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 1.26794420663106*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 2.10894933778168e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 2.43537442581976*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 0.411179929457859*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) + 0.025999785767065*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.000526727374575904*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.00293161485921553*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 2.27473176639486*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 1.18094502976309*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00069891998840047*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 0.87114958943298*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) + 0.286216621722859*std::exp(0.925839841365814*x_38) - 0.00196903268659049*std::exp(1.08759987354279*x_38) - 19.0824595977907*std::exp(2.50039982795715*x_71) + 0.0226476832400757*std::exp(2.50919985771179*x_71) - 0.00416074205682722*std::exp(2.55495977401733*x_71) + 0.00744667566038474*std::exp(2.56535983085632*x_71) - 0.195678786298536*std::exp(2.59455990791321*x_71) - 0.000359509476046276*std::exp(2.59552001953125*x_71) - 8.96159970318517e-5*std::exp(2.60351991653442*x_71) - 5.43796558289014*std::exp(2.63032007217407*x_71) + 0.0310385322952088*std::exp(2.64359998703003*x_71) + 0.000155591008007111*std::exp(2.67215991020203*x_71) - 0.000649876625571257*std::exp(0.873279869556427*x_89) - 0.0238049673062655*std::exp(2.03023982048035*x_89) - 1.49294429568681*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 110.152093842677*std::sin(0.299919933080673*x_106 - 7.47904014587402) + 0.0129816558426657*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.0134854655083103*std::sin(0.360719859600067*x_114 + 5.16128015518188) - 1.96074430379635*std::sin(0.341119825839996*x_119 + 5.14807987213135) - 1.96281237851974*std::sin(0.211280003190041*x_14 + 1.80799984931946) + 0.0135114227528318*std::sin(0.336639851331711*x_14 - 1.25951993465424) + 0.0202067310499364*std::sin(0.327919840812683*x_16 - 4.26919984817505) - 6.75596981282841*std::sin(0.329199850559235*x_16 - 4.26480007171631) + 1.74168649708471*std::sin(0.474079847335815*x_16 + 8.26064014434814) + 0.027387344134305*std::sin(0.333359837532043*x_26 + 5.14448022842407) + 5.46480643890761*std::sin(0.29351994395256*x_28 + 5.11104011535645) + 0.031066017046679*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 667.051303769189*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 2.47909767576791*std::sin(0.331759840250015*x_28 - 4.27432012557983) - 0.0199582384178867*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 1622.5280226384*std::sin(0.375119835138321*x_34 + 2.00247979164124) + 0.00916782732296133*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 679.737378584483*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.112553734396866*std::sin(0.396159827709198*x_36 - 7.39479970932007) - 1.9999045160213*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.0041205781822894*std::sin(0.408159852027893*x_36 + 1.99183976650238) - 0.00727645464636668*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.00581935263814533*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 0.442101098238491*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 546.303281928019*std::sin(0.412639856338501*x_41 - 7.39527988433838) + 5.39967014360618*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 408.910040690314*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 1.36792494090856*std::sin(0.490639865398407*x_53 + 5.2628002166748) + 0.011911199854085*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 905.672456438748*std::sin(0.298639953136444*x_60 - 7.49128007888794) - 3.64641731882303*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.112802717801783*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 3.31842230600404*std::sin(0.282399952411652*x_80 - 7.49272012710571) - 3.84577981707387*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.228702189169534*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 378.390883431361*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.00311620492271747*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 1.37125273376514*std::sin(0.374239832162857*x_83 - 4.23303985595703) - 3.72865993976586*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 0.453026249116918*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.00964765147710782*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 0.274435142418428*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 0.342210024040035*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 1.1689287191632*std::sin(0.447679847478867*x_96 - 7.36935997009277) + 2.40226994924197*std::sin(0.447679847478867*x_96 + 2.02399969100952) + 1.77293709307397*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 1.52612937152584*std::sin(0.423839867115021*x_99 + 5.22488021850586) + 5.68975582457198*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 406883.412847902 - 1.45046708934336e-6*std::exp(-3.94543981552124*x_74) - 0.00243734889656298*std::exp(-2.76799988746643*x_74) + 0.000161943448131986*std::exp(-2.69735980033875*x_74) + 0.00772920732982856*std::exp(-2.53743982315063*x_74) - 0.103302418253945*std::exp(-3.83120012283325*x_45) - 4.44568945873917e-5*std::exp(-4.80536031723022*x_111) + 9.62548195350683e-7*std::exp(-4.45599985122681*x_111) + 4.155400822502e-5*std::exp(-4.4312801361084*x_111) + 0.00110223417012336*std::exp(-3.27823972702026*x_111) + 0.00752348832435455*std::exp(-3.64696002006531*x_101));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1476.8604835549*x_1 + 55.8919071432496*x_10 + 200.557271228202*x_100 - 230.680484625402*x_101 + 193.409901698412*x_102 + 193.877990630855*x_103 - 3.09910996133001*x_104 - 54.6123678290139*x_105 + 9.18661529876424*x_106 + 37.030725304466*x_107 - 31.7406233867286*x_108 + 234.53946429485*x_109 - 31.8774432252826*x_11 + 226.594083512558*x_110 - 88.6344762483333*x_111 + 33.5545896305436*x_112 - 266.28136136769*x_113 + 61.7970989613606*x_114 + 14.8136276552039*x_115 - 1111.01075211276*x_116 + 65.8140443345019*x_117 + 143.926534358632*x_118 + 90.4903062358336*x_119 - 817.159485247419*x_12 - 265.934675353736*x_120 - 61.1555051316384*x_13 - 24.9014644755532*x_14 - 54.3077639144517*x_15 + 42.5689781715176*x_16 + 139.102823205372*x_17 + 164.709951755523*x_18 - 31.0781123488139*x_19 + 298.965078070602*x_2 - 421.053804274306*x_20 - 560.542129574729*x_21 - 309.042141366373*x_22 + 28.5074577738958*x_23 + 82.3421755598693*x_24 - 9.87051130991237*x_25 + 84.8877438110811*x_26 + 145.291418887505*x_27 - 37.6102421716112*x_28 - 192.946140365153*x_29 + 41.7151359799617*x_3 + 445.957779984902*x_30 - 8659.60472366618*x_31 - 125.67179853328*x_32 - 128.549894075099*x_33 + 148.500589430126*x_34 + 326.33767437889*x_35 + 78.7794017444495*x_36 - 614.852219753611*x_37 + 62.3752769650322*x_38 + 146.875300456809*x_39 - 43.7898403988052*x_4 - 155.69134855807*x_40 + 28.6664498108088*x_41 + 96304.1617729819*x_42 - 173.020765244386*x_43 - 109.871944701069*x_44 + 91.7083526446427*x_45 + 21.9284244854898*x_46 + 114.963852859872*x_47 - 267.894625242551*x_48 - 9.87157832279247*x_49 - 108.128983564842*x_5 + 551.96631611*x_50 - 129.813731535519*x_51 - 792.117591626854*x_52 + 27.4366438172016*x_53 - 605.350750375915*x_54 + 10.1482285999478*x_55 + 123.322196838975*x_56 + 929.051982436213*x_57 - 103.01984222826*x_58 - 7.04354497493442*x_59 + 40.9818165647002*x_6 + 181.61820820914*x_60 + 31.1497687556791*x_61 + 208.2844742458*x_62 - 136.257972602918*x_63 - 20.2539574312211*x_64 + 81.3257465470031*x_65 - 41.7671731596627*x_66 + 44.4804647801396*x_67 - 96.6432564436416*x_68 + 233.494936188827*x_69 - 51.8520757676847*x_7 - 7.06838506013913*x_70 - 5.65800740090145*x_72 - 240.442340674754*x_73 - 150.126687830012*x_74 - 105.349291665775*x_75 - 198.192897390237*x_76 - 46.3282449384634*x_77 + 66.2419239311299*x_78 - 160.867436268325*x_79 + 576.856830906093*x_8 + 18.2598420096036*x_80 + 373.591972379491*x_81 - 83.8027199101668*x_82 + 30.7076144783256*x_83 - 509.215967186029*x_84 - 126.24235758748*x_85 - 175.043100855652*x_86 - 40.1381422781195*x_87 - 369.475469349482*x_88 + 96.3410871245747*x_89 - 167.810888160198*x_9 - 736.653355472545*x_90 - 203.604187003305*x_91 - 5.34747065377869*x_92 - 22.0369480101427*x_93 - 71.3078229064077*x_94 - 11.3088013000248*x_95 + 51.7042745649703*x_96 - 149.020730319664*x_97 - 99.3688479710591*x_98 + 41.4067871647285*x_99 + 0.0238727582814116*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) + 1.68057079007504*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 1.08886785437008e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 1.21014448978619*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) + 0.544990051847807*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) - 0.0551269634891458*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) + 0.00144044022307808*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 7.33193465843637e-5*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) + 3.01499682861939*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 0.586814949420825*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00342478514735026*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) + 1.15464745698619*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) + 0.618101643336517*std::exp(0.925839841365814*x_38) - 0.00233283303896081*std::exp(1.08759987354279*x_38) - 9.48212853391568*std::exp(2.50039982795715*x_71) + 0.0489090051590729*std::exp(2.50919985771179*x_71) + 0.0113783723910914*std::exp(2.55495977401733*x_71) + 0.0364895333115117*std::exp(2.56535983085632*x_71) + 0.414894853539306*std::exp(2.59455990791321*x_71) - 0.000268792932008565*std::exp(2.59552001953125*x_71) - 4.6269474878874e-5*std::exp(2.60351991653442*x_71) + 7.2076405793285*std::exp(2.63032007217407*x_71) + 0.000776270081886316*std::exp(2.64359998703003*x_71) + 0.000184338150664582*std::exp(2.67215991020203*x_71) - 0.000335536636283244*std::exp(0.873279869556427*x_89) - 0.0514082282258998*std::exp(2.03023982048035*x_89) - 0.0373383631558958*std::sin(0.414959847927094*x_103 - 4.18824005126953) + 145.998846328947*std::sin(0.299919933080673*x_106 - 7.47904014587402) + 0.00970593981179811*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.00696265653714607*std::sin(0.360719859600067*x_114 + 5.16128015518188) - 4.23434274726627*std::sin(0.341119825839996*x_119 + 5.14807987213135) - 4.23880887637287*std::sin(0.211280003190041*x_14 + 1.80799984931946) + 0.0160078060744393*std::sin(0.336639851331711*x_14 - 1.25951993465424) + 0.0151078812857823*std::sin(0.327919840812683*x_16 - 4.26919984817505) + 14.3245834616585*std::sin(0.329199850559235*x_16 - 4.26480007171631) + 3.76127451838729*std::sin(0.474079847335815*x_16 + 8.26064014434814) + 0.0204765799520673*std::sin(0.333359837532043*x_26 + 5.14448022842407) - 11.5869487438056*std::sin(0.29351994395256*x_28 + 5.11104011535645) + 0.0368058039101941*std::sin(0.314639836549759*x_28 - 4.28416013717651) - 884.129546657691*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 0.0620019444691847*std::sin(0.331759840250015*x_28 - 4.27432012557983) - 0.0149220918487812*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 806.238796508106*std::sin(0.375119835138321*x_34 + 2.00247979164124) + 0.00685447074549381*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 337.763439771213*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.551525731469454*std::sin(0.396159827709198*x_36 - 7.39479970932007) - 4.31891153081193*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.00212748833920926*std::sin(0.408159852027893*x_36 + 1.99183976650238) - 0.00862085932912418*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.0030045795351278*std::sin(0.559439837932587*x_38 + 8.55887985229492) + 1.20901292643553*std::sin(0.391199827194214*x_40 - 7.39615964889526) + 724.08654365775*std::sin(0.412639856338501*x_41 - 7.39527988433838) - 11.4488412145717*std::sin(0.300959914922714*x_53 + 5.12016010284424) - 541.981474073245*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 0.034211643636814*std::sin(0.490639865398407*x_53 + 5.2628002166748) + 0.00890559650257283*std::sin(0.549279868602753*x_53 - 1.03927981853485) - 1200.40508699555*std::sin(0.298639953136444*x_60 - 7.49128007888794) - 7.8746528538012*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.552745777656787*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 0.0829933558299331*std::sin(0.282399952411652*x_80 - 7.49272012710571) + 8.15415040194994*std::sin(0.360719859600067*x_80 + 5.14807987213135) - 0.62543138687457*std::sin(0.471119850873947*x_80 - 1.13295996189117) + 501.530479495668*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.00160892218091211*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 0.0342948713490236*std::sin(0.374239832162857*x_83 - 4.23303985595703) + 7.90582284809792*std::sin(0.331519842147827*x_92 - 7.40743970870972) - 1.23888991314265*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.00498116165020754*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 1.34476251253963*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 1.67686691904303*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 0.0292347712808622*std::sin(0.447679847478867*x_96 - 7.36935997009277) - 5.09349765299563*std::sin(0.447679847478867*x_96 + 2.02399969100952) + 3.82876202005625*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 0.0381683180420985*std::sin(0.423839867115021*x_99 + 5.22488021850586) - 12.063905618817*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 199313.593634779 - 1.08446460442213e-6*std::exp(-3.94543981552124*x_74) + 0.0066654128069783*std::exp(-2.76799988746643*x_74) + 0.000191864273670182*std::exp(-2.69735980033875*x_74) + 0.000193306576154328*std::exp(-2.53743982315063*x_74) - 0.0513312659056608*std::exp(-3.83120012283325*x_45) - 9.60072809073705e-5*std::exp(-4.80536031723022*x_111) + 4.96971534319421e-7*std::exp(-4.45599985122681*x_111) - 0.000113637657290224*std::exp(-4.4312801361084*x_111) - 0.00233705090485207*std::exp(-3.27823972702026*x_111) + 0.0162474159219498*std::exp(-3.64696002006531*x_101));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1517.25856000273*x_1 - 67.8476797002439*x_10 + 163.026148558055*x_100 - 141.106327264233*x_101 - 43.1241088716757*x_102 + 15.1456960989154*x_103 + 79.4934481197882*x_104 - 52.4445063234935*x_105 + 6.01799580028269*x_106 + 49.2538711070646*x_107 + 82.0358047671764*x_108 + 142.515814701451*x_109 + 73.9726183075352*x_11 - 1.52900446795253*x_110 - 31.2924803346596*x_111 + 8.82724773074923*x_112 - 406.02094135808*x_113 + 139.20771765824*x_114 + 15.382199102765*x_115 - 103.588694046988*x_116 + 36.6768399358403*x_117 - 38.447360251236*x_118 - 38.6271982311536*x_119 - 928.778563930376*x_12 + 402.176519362549*x_120 + 139.893505374595*x_13 + 52.2441578072849*x_14 + 49.3536465388391*x_15 + 53.6389289494831*x_16 - 49.2774909134044*x_17 + 116.559122774385*x_18 - 3.37032629172483*x_19 - 47.6458301838572*x_2 + 205.745943247333*x_20 - 219.828483857692*x_21 + 263.335049598823*x_22 - 163.636883253281*x_23 - 32.3373835979955*x_24 + 282.087647700173*x_25 - 11.2636745911834*x_26 + 144.010340985672*x_27 - 23.0358426225769*x_28 + 87.5571335965245*x_29 - 482.679049704795*x_3 - 708.883256537968*x_30 - 1614.13654757254*x_31 + 114.961739636753*x_32 - 42.1878921946093*x_33 - 141.536818266108*x_34 - 148.216122126914*x_35 - 86.6503195708339*x_36 - 1457.3562166835*x_37 + 38.6855665176553*x_38 + 82.9569454685084*x_39 - 52.5983560125307*x_4 + 74.6491368140163*x_40 + 32.3334482332985*x_41 + 45926.3387258692*x_42 + 47.7658651175892*x_43 - 0.0375844816518665*x_44 - 88.3606373486208*x_45 + 66.7950121408757*x_46 + 534.051014580188*x_47 - 25.8281534020669*x_48 + 745.336760038065*x_49 - 20.4789311321366*x_5 + 1062.90228144478*x_50 - 279.343286128796*x_51 - 242.073611953121*x_52 + 17.0127631883175*x_53 - 262.933194444611*x_54 + 169.183345075222*x_55 + 79.3355306298535*x_56 + 1861.00843226335*x_57 - 21.8516511806916*x_58 - 130.964870694545*x_59 - 12.6560783342406*x_6 + 91.7255688935391*x_60 - 78.1439012094964*x_61 - 62.6287812051565*x_62 - 7.15149829124615*x_63 + 143.623231354366*x_64 - 30.5145517428363*x_65 + 184.502318009674*x_66 + 31.8539703112258*x_67 - 3.49633293980307*x_68 - 35.5765595105654*x_69 + 79.9105715320691*x_7 - 106.834161662611*x_70 - 59.3201811266051*x_72 + 162.06933889135*x_73 + 3.52040001413656*x_74 - 81.1646629334357*x_75 + 213.837493681508*x_76 - 106.378883798386*x_77 - 85.0808041375933*x_78 + 60.3247451267013*x_79 - 199.867676392752*x_8 + 11.1740856293649*x_80 + 150.771472050626*x_81 - 12.6783898989476*x_82 + 33.3663481750542*x_83 + 112.860592425272*x_84 + 92.847061004231*x_85 + 26.4055675973432*x_86 - 27.1586862955722*x_87 + 164.614818010418*x_88 - 4.12770017900219*x_89 - 612.009282684455*x_9 + 490.391742738869*x_90 - 10.0503284419538*x_91 + 101.980427803349*x_92 + 122.381198697653*x_93 + 24.8841415314894*x_94 + 74.8701250391067*x_95 + 78.8986640420439*x_96 + 324.339627428734*x_97 + 69.6693390441393*x_98 + 114.717974888462*x_99 + 0.084895121055442*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 1.81931594689208*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) + 2.53267235616071e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 0.748687025762444*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 0.589983533023319*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) - 0.196039778213397*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.000996805394429208*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.0043405175693601*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 3.26391000160809*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 0.363048167275*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) - 0.00686627354851858*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 1.24997324952885*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) + 0.0765077734492156*std::exp(0.925839841365814*x_38) - 0.00373099444613669*std::exp(1.08759987354279*x_38) - 5.86636279375929*std::exp(2.50039982795715*x_71) + 0.00605388956116984*std::exp(2.50919985771179*x_71) - 0.00787399768317184*std::exp(2.55495977401733*x_71) - 0.0731570322209754*std::exp(2.56535983085632*x_71) + 1.47542853663144*std::exp(2.59455990791321*x_71) + 0.000995221807849016*std::exp(2.59552001953125*x_71) + 0.00010762134219454*std::exp(2.60351991653442*x_71) - 7.80269151581134*std::exp(2.63032007217407*x_71) + 0.0459553185613731*std::exp(2.64359998703003*x_71) + 0.000294819476942523*std::exp(2.67215991020203*x_71) + 0.000780447654674629*std::exp(0.873279869556427*x_89) - 0.00636323996374067*std::exp(2.03023982048035*x_89) - 2.21043733802009*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 158.052270646832*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.0359368190755241*std::sin(0.404879868030548*x_106 + 5.1866397857666) + 0.0161949199494672*std::sin(0.360719859600067*x_114 + 5.16128015518188) - 0.524121136234872*std::sin(0.341119825839996*x_119 + 5.14807987213135) - 0.524673947568681*std::sin(0.211280003190041*x_14 + 1.80799984931946) + 0.0256019331692814*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.0559378284750636*std::sin(0.327919840812683*x_16 - 4.26919984817505) + 50.9403744934318*std::sin(0.329199850559235*x_16 - 4.26480007171631) + 0.465565399858372*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.0758157544031403*std::sin(0.333359837532043*x_26 + 5.14448022842407) - 41.2049334506316*std::sin(0.29351994395256*x_28 + 5.11104011535645) + 0.0588650142042322*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 957.121826020187*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 3.67052547301859*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.0552499320412186*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 498.800376076244*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.0253790853658353*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 208.966042706421*std::sin(0.385119825601578*x_36 + 5.20032024383545) + 1.10574134679544*std::sin(0.396159827709198*x_36 - 7.39479970932007) - 0.534588944243698*std::sin(0.407759845256805*x_36 + 2.01279973983765) + 0.00494847091237411*std::sin(0.408159852027893*x_36 + 1.99183976650238) - 0.0137876897920719*std::sin(0.416239857673645*x_36 - 7.38247966766357) - 0.0069885574268391*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 0.836654369752524*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 783.865936255918*std::sin(0.412639856338501*x_41 - 7.39527988433838) - 40.7138022929007*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 586.7265720223*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 2.02533502001976*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.0329735004006057*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 1299.50855411683*std::sin(0.298639953136444*x_60 - 7.49128007888794) - 0.974713727143148*std::sin(0.271039962768555*x_66 + 1.87127995491028) + 1.10818738954078*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 4.91322053321195*std::sin(0.282399952411652*x_80 - 7.49272012710571) + 28.9973859458392*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.432807533623087*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 542.936009948241*std::sin(0.485199838876724*x_80 - 7.31383991241455) - 0.00374230235051548*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 2.03026211448981*std::sin(0.374239832162857*x_83 - 4.23303985595703) + 28.1142957935762*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 0.857329675150004*std::sin(0.407039850950241*x_94 - 7.38600015640259) + 0.0115860252117984*std::sin(0.426719844341278*x_94 + 1.9968798160553) - 2.69608365827976*std::sin(0.383279830217361*x_95 - 7.40383958816528) - 3.36191220039575*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 1.73070334491863*std::sin(0.447679847478867*x_96 - 7.36935997009277) - 18.1132441735218*std::sin(0.447679847478867*x_96 + 2.02399969100952) + 0.473918910230016*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 2.25957080596766*std::sin(0.423839867115021*x_99 + 5.22488021850586) - 42.9010638753194*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 107525.507486197 + 4.01529465859195e-6*std::exp(-3.94543981552124*x_74) - 0.00461256172636978*std::exp(-2.76799988746643*x_74) + 0.000306856310554647*std::exp(-2.69735980033875*x_74) + 0.0114437816096092*std::exp(-2.53743982315063*x_74) - 0.0317574084118834*std::exp(-3.83120012283325*x_45) - 1.18836495199823e-5*std::exp(-4.80536031723022*x_111) - 1.15594014619682e-6*std::exp(-4.45599985122681*x_111) + 7.86388966250445e-5*std::exp(-4.4312801361084*x_111) - 0.00831090471998928*std::exp(-3.27823972702026*x_111) + 0.0020110828532694*std::exp(-3.64696002006531*x_101));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (320.319463261105*x_1 + 7.855510903908*x_10 + 303.410106240586*x_100 - 284.177510957449*x_101 + 138.327823830413*x_102 + 186.878233697314*x_103 + 54.7894701243606*x_104 - 77.944006989548*x_105 + 12.7576090590151*x_106 + 49.623784247508*x_107 + 46.4226698959558*x_108 + 313.879173566104*x_109 + 38.658337501249*x_11 + 201.033384835251*x_110 - 101.056829711911*x_111 + 47.152759071481*x_112 - 552.204856665595*x_113 + 146.90449724325*x_114 + 15.8116909577265*x_115 - 1031.78107113861*x_116 + 71.8983967823413*x_117 + 86.6129457504485*x_118 + 44.9765962565136*x_119 - 1339.92989784775*x_12 + 76.8501097850804*x_120 + 64.1640193756219*x_13 + 9.22581212997394*x_14 + 0.987880147548335*x_15 + 78.0119156667628*x_16 + 84.3656168042289*x_17 + 244.926256337342*x_18 - 33.5604776323904*x_19 + 220.696814034625*x_2 - 210.069714759415*x_20 - 600.166396682176*x_21 - 75.1689677847541*x_22 - 107.636250485601*x_23 + 53.1616089644363*x_24 + 210.672041682179*x_25 + 72.9636390624714*x_26 + 217.571798332898*x_27 - 49.4444520954509*x_28 - 92.9088261321967*x_29 - 335.356501713406*x_3 - 195.107444244889*x_30 - 8529.08747297479*x_31 - 10.8656051992185*x_32 - 131.061774818019*x_33 - 1.05234318819489*x_34 + 160.806600274842*x_35 + 4.00308830129064*x_36 - 1678.09370183693*x_37 + 81.9822229050953*x_38 + 184.744474503208*x_39 - 81.0944677537608*x_4 - 72.3292235862825*x_40 + 25.2363950248488*x_41 + 134532.933410043*x_42 - 114.667014231044*x_43 - 73.6406191976876*x_44 - 0.154739114360978*x_45 + 75.0700731212472*x_46 + 507.139932172866*x_47 - 301.777564728601*x_48 + 552.448981441518*x_49 - 109.644450078467*x_5 + 1329.10096949186*x_50 - 349.516526527387*x_51 - 826.00620823521*x_52 + 37.0266724875325*x_53 - 764.534835132476*x_54 + 142.337983570606*x_55 + 177.185166829202*x_56 + 2218.7252540125*x_57 - 89.6658005910898*x_58 - 88.997408847823*x_59 + 27.0847801471962*x_6 + 263.778758306486*x_60 - 34.9952823048674*x_61 + 124.902611966572*x_62 - 106.535996825797*x_63 + 85.7915562452241*x_64 + 45.4094145186801*x_65 + 101.26473141118*x_66 + 55.0441794572219*x_67 - 84.6808306298541*x_68 + 178.574445701416*x_69 + 17.4471574468863*x_7 - 98.8294389716916*x_70 - 54.8677012473268*x_72 - 91.1278407213414*x_73 - 107.989810127908*x_74 - 147.523023920244*x_75 - 13.0851175864714*x_76 - 137.914154138341*x_77 + 7.88585797960578*x_78 - 104.27793014979*x_79 + 276.18397395455*x_8 + 24.1142481701408*x_80 + 403.661730673938*x_81 - 102.493902602918*x_82 + 63.0099722049828*x_83 - 448.152219663663*x_84 - 53.923214747275*x_85 - 134.128561051144*x_86 - 51.2422832399945*x_87 - 211.175263365916*x_88 + 95.1848008203002*x_89 - 644.299267902852*x_9 - 262.395436265385*x_90 - 146.163519215559*x_91 + 74.4002428280338*x_92 + 70.2175494618674*x_93 - 38.0870051646293*x_94 + 59.9028387914477*x_95 + 106.102752940391*x_96 + 121.41597134341*x_97 - 47.0093186949748*x_98 + 123.319291940407*x_99 - 0.0390594779127995*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) + 0.0719935609161609*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) + 4.50371503143742e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 1.62300483063497*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) + 0.0233466954966264*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) + 0.0901961301422213*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) + 0.000187078608106857*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.0020430582020103*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) + 0.129158711507505*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 0.787016348574284*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00241905070536941*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) + 0.0494636599196834*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.209223279016401*std::exp(0.925839841365814*x_38) - 0.00280297216080684*std::exp(1.08759987354279*x_38) - 12.7171098535233*std::exp(2.50039982795715*x_71) - 0.016555371666016*std::exp(2.50919985771179*x_71) + 0.00147777744285574*std::exp(2.55495977401733*x_71) + 0.0257738887252847*std::exp(2.56535983085632*x_71) - 0.678831334733996*std::exp(2.59455990791321*x_71) + 0.000221908265573667*std::exp(2.59552001953125*x_71) + 0.000191377244421688*std::exp(2.60351991653442*x_71) + 0.308766351393333*std::exp(2.63032007217407*x_71) + 0.0216309205094753*std::exp(2.64359998703003*x_71) + 0.000221488077311185*std::exp(2.67215991020203*x_71) + 0.00138782808801076*std::exp(0.873279869556427*x_89) + 0.017401341986063*std::exp(2.03023982048035*x_89) - 1.04044092929165*std::sin(0.414959847927094*x_103 - 4.18824005126953) + 6.25440885855391*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.00801296467620618*std::sin(0.404879868030548*x_106 + 5.1866397857666) + 0.0287985551040274*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 1.43329674595289*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 1.43480850083377*std::sin(0.211280003190041*x_14 + 1.80799984931946) + 0.0192338817364468*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.0124726632786385*std::sin(0.327919840812683*x_16 - 4.26919984817505) - 23.4372059037*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 1.27316630929807*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.0169049175069045*std::sin(0.333359837532043*x_26 + 5.14448022842407) + 18.958017469134*std::sin(0.29351994395256*x_28 + 5.11104011535645) + 0.0442233293139341*std::sin(0.314639836549759*x_28 - 4.28416013717651) - 37.8750093426509*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 1.72769653699246*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.0123192804816329*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 1081.30018557468*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.00565886797391497*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 452.996893335785*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.389562746957369*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 1.46192271449156*std::sin(0.407759845256805*x_36 + 2.01279973983765) + 0.00879959967047391*std::sin(0.408159852027893*x_36 + 1.99183976650238) - 0.0103582332289546*std::sin(0.416239857673645*x_36 - 7.38247966766357) - 0.0124273757933029*std::sin(0.559439837932587*x_38 + 8.55887985229492) + 0.157021757541199*std::sin(0.391199827194214*x_40 - 7.39615964889526) + 31.0189662924399*std::sin(0.412639856338501*x_41 - 7.39527988433838) + 18.7320524623211*std::sin(0.300959914922714*x_53 + 5.12016010284424) - 23.2178117694052*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 0.953314266869809*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.00735222261618799*std::sin(0.549279868602753*x_53 - 1.03927981853485) - 51.4238598368265*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 2.66551740955517*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.390424510093762*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 2.31262639725795*std::sin(0.282399952411652*x_80 - 7.49272012710571) - 13.3414351943824*std::sin(0.360719859600067*x_80 + 5.14807987213135) - 0.0812285240638505*std::sin(0.471119850873947*x_80 - 1.13295996189117) + 21.4849415092301*std::sin(0.485199838876724*x_80 - 7.31383991241455) - 0.00665473499057322*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 0.955633423654286*std::sin(0.374239832162857*x_83 - 4.23303985595703) - 12.9351333967231*std::sin(0.331519842147827*x_92 - 7.40743970870972) - 0.160902060935985*std::sin(0.407039850950241*x_94 - 7.38600015640259) + 0.0206028054809622*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 0.94985482725251*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 1.18443228663851*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 0.814632726991574*std::sin(0.447679847478867*x_96 - 7.36935997009277) + 8.33373993615933*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 1.29601037797839*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 1.06356778757051*std::sin(0.423839867115021*x_99 + 5.22488021850586) + 19.738391747852*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 278938.047215963 + 8.9530501284044e-7*std::exp(-3.94543981552124*x_74) + 0.000865677124540787*std::exp(-2.76799988746643*x_74) + 0.000230530950466352*std::exp(-2.69735980033875*x_74) + 0.00538652626234468*std::exp(-2.53743982315063*x_74) - 0.0688437564527648*std::exp(-3.83120012283325*x_45) + 3.24978235172766e-5*std::exp(-4.80536031723022*x_111) - 2.05554618985949e-6*std::exp(-4.45599985122681*x_111) - 1.47588038807681e-5*std::exp(-4.4312801361084*x_111) + 0.00382377214744537*std::exp(-3.27823972702026*x_111) - 0.00549964180063324*std::exp(-3.64696002006531*x_101));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (887.000726460692*x_1 + 39.6395856435413*x_10 - 117.987628793534*x_100 + 112.411537414456*x_101 + 11.9785085414431*x_102 - 24.8541946288229*x_103 - 44.6142055703419*x_104 + 38.8751763060242*x_105 - 4.56236134032234*x_106 - 36.7952087025553*x_107 - 47.8182987191151*x_108 - 108.406117867474*x_109 - 43.1419313672868*x_11 - 17.824857684484*x_110 + 26.4706164797059*x_111 - 6.06981490687941*x_112 + 277.906830553469*x_113 - 95.511377635263*x_114 - 13.9392483190171*x_115 + 156.73026267516*x_116 - 31.2500675631426*x_117 + 11.705950699323*x_118 + 15.2364341013711*x_119 + 661.081117305597*x_12 - 230.824731375852*x_120 - 78.4767087605486*x_13 - 31.6403249651512*x_14 - 24.7508453200819*x_15 - 37.2100109090836*x_16 + 22.2713447646305*x_17 - 85.5088869679805*x_18 + 4.45310667747846*x_19 + 5.25625119053298*x_2 - 96.1882058708058*x_20 + 191.397849463007*x_21 - 141.026376522767*x_22 + 100.239836089324*x_23 + 14.0410958599395*x_24 - 174.414686702786*x_25 + 0.989894427842435*x_26 - 105.306887991646*x_27 + 17.4396095664636*x_28 - 37.6262232701104*x_29 + 300.166785787924*x_3 + 398.893275151158*x_30 + 1837.7840723716*x_31 - 60.0812158725945*x_32 + 40.3618221050059*x_33 + 75.0182351294401*x_34 + 64.4584529641326*x_35 + 47.9205449994204*x_36 + 969.461050304728*x_37 - 28.760836393591*x_38 - 65.6579249351445*x_39 + 37.4763217403282*x_4 - 33.5079833744099*x_40 - 26.6666280401365*x_41 - 35476.4025504249*x_42 - 15.418121092264*x_43 + 13.3438693414836*x_44 + 46.0437466726933*x_45 - 42.1829539827029*x_46 - 351.465910979256*x_47 + 29.2008517198708*x_48 - 470.811152946644*x_49 + 22.1391431469341*x_5 - 712.33790498129*x_50 + 183.508819719928*x_51 + 223.102984074051*x_52 - 13.1254069249652*x_53 + 214.351976190729*x_54 - 106.522349665682*x_55 - 58.6189420865629*x_56 - 1253.58225033217*x_57 + 24.1116333385233*x_58 + 85.3958730385057*x_59 + 4.65182591849174*x_6 - 67.1368732641631*x_60 + 47.0131179718652*x_61 + 21.6088945359199*x_62 + 16.8435040413017*x_63 - 88.7748138487009*x_64 + 12.0939579688914*x_65 - 113.280007186176*x_66 - 24.9224504331488*x_67 + 10.1164745685628*x_68 + 3.82006827470585*x_69 - 45.7435037241499*x_7 + 65.7039784161496*x_70 + 36.7055445388807*x_72 - 83.1580002895958*x_73 + 12.6124870217031*x_74 + 60.7285588900443*x_75 - 119.785182955013*x_76 + 68.8217868661132*x_77 + 50.3454833587839*x_78 - 26.2929680137367*x_79 + 68.7051216031248*x_8 - 8.52224585281137*x_80 - 131.771974293517*x_81 + 12.5935651134219*x_82 - 22.1647591911993*x_83 - 30.4586899827442*x_84 - 48.8610330518013*x_85 - 2.76654997942911*x_86 + 21.9675155171327*x_87 - 75.6545536969428*x_88 - 3.01608610851811*x_89 + 395.469540348175*x_9 - 245.839704884131*x_90 + 30.5052184875412*x_91 - 64.9061444338745*x_92 - 76.1915919647194*x_93 - 8.11003971927487*x_94 - 44.6651198987126*x_95 - 53.8525165032327*x_96 - 189.852756086684*x_97 - 36.7563794901284*x_98 - 75.6304709925899*x_99 - 0.0737115040828285*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) + 1.0054044283314*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 6.43586321473008e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) - 0.572794961885174*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) + 0.326041256197176*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) + 0.170214574554132*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.00147322505470965*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) - 0.00779120810710353*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) + 1.80372715079959*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) - 0.277755796455792*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) - 0.00184561025155513*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) + 0.690769870136605*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) + 0.0606011438517942*std::exp(0.925839841365814*x_38) - 0.00260159108417536*std::exp(1.08759987354279*x_38) + 4.48815451213943*std::exp(2.50039982795715*x_71) + 0.00479523342033802*std::exp(2.50919985771179*x_71) - 0.0116373474024155*std::exp(2.55495977401733*x_71) - 0.0196641406268341*std::exp(2.56535983085632*x_71) - 1.28106368481182*std::exp(2.59455990791321*x_71) + 0.000206385183419616*std::exp(2.59552001953125*x_71) - 0.000273480395387459*std::exp(2.60351991653442*x_71) + 4.3119836421496*std::exp(2.63032007217407*x_71) - 0.082489575221943*std::exp(2.64359998703003*x_71) + 0.000205575144570132*std::exp(2.67215991020203*x_71) - 0.00198322311195317*std::exp(0.873279869556427*x_89) - 0.00504026719143907*std::exp(2.03023982048035*x_89) + 3.96772436305688*std::sin(0.414959847927094*x_103 - 4.18824005126953) + 87.3440663715482*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.00745243616842526*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.0411534833215752*std::sin(0.360719859600067*x_114 + 5.16128015518188) - 0.415151806682997*std::sin(0.341119825839996*x_119 + 5.14807987213135) - 0.415589683746369*std::sin(0.211280003190041*x_14 + 1.80799984931946) + 0.0178520129237457*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.0116001668159511*std::sin(0.327919840812683*x_16 - 4.26919984817505) - 44.2297693409403*std::sin(0.329199850559235*x_16 - 4.26480007171631) + 0.368770315711292*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.0157223728973617*std::sin(0.333359837532043*x_26 + 5.14448022842407) + 35.7768218304956*std::sin(0.29351994395256*x_28 + 5.11104011535645) + 0.0410460798949084*std::sin(0.314639836549759*x_28 - 4.28416013717651) - 528.93205491724*std::sin(0.330799847841263*x_28 - 4.27928018569946) + 6.58857552486039*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.0114575135596085*std::sin(0.34063982963562*x_28 + 5.15088033676147) + 381.615191089952*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.00526301488466242*std::sin(0.325119823217392*x_36 + 8.32335948944092) + 159.872807125816*std::sin(0.385119825601578*x_36 + 5.20032024383545) + 0.297216175672804*std::sin(0.396159827709198*x_36 - 7.39479970932007) - 0.423443266626959*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.012574734286747*std::sin(0.408159852027893*x_36 + 1.99183976650238) - 0.00961404026520912*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.0177588702139127*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 1.23653040657704*std::sin(0.391199827194214*x_40 - 7.39615964889526) + 433.186047138292*std::sin(0.412639856338501*x_41 - 7.39527988433838) + 35.3503895940112*std::sin(0.300959914922714*x_53 + 5.12016010284424) - 324.241369256746*std::sin(0.423359870910645*x_53 - 7.36495971679688) + 3.63546659480633*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.0068379147989874*std::sin(0.549279868602753*x_53 - 1.03927981853485) - 718.14445269692*std::sin(0.298639953136444*x_60 - 7.49128007888794) - 0.772062290273407*std::sin(0.271039962768555*x_66 + 1.87127995491028) + 0.297873656260295*std::sin(0.501519858837128*x_75 - 4.09960031509399) + 8.81920716565418*std::sin(0.282399952411652*x_80 - 7.49272012710571) - 25.1774295856436*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.639666384195021*std::sin(0.471119850873947*x_80 - 1.13295996189117) + 300.041490668538*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.00950969673495035*std::sin(0.608239889144897*x_80 + 2.17871975898743) - 3.64431070562171*std::sin(0.374239832162857*x_83 - 4.23303985595703) - 24.4106728797838*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 1.26708740205035*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.0294416580510964*std::sin(0.426719844341278*x_94 + 1.9968798160553) - 0.724689979740894*std::sin(0.383279830217361*x_95 - 7.40383958816528) - 0.903660417551723*std::sin(0.400159865617752*x_96 + 5.19144010543823) - 3.10660415870846*std::sin(0.447679847478867*x_96 - 7.36935997009277) + 15.7271048707013*std::sin(0.447679847478867*x_96 + 2.02399969100952) + 0.375387058832637*std::sin(0.439599871635437*x_97 + 1.99983978271484) - 4.05591870110205*std::sin(0.423839867115021*x_99 + 5.22488021850586) + 37.2495133488072*std::sin(0.449519872665405*x_99 - 1.14855980873108) - 89306.9709098154 + 8.32676010575347e-7*std::exp(-3.94543981552124*x_74) - 0.00681711950964505*std::exp(-2.76799988746643*x_74) + 0.000213968327529552*std::exp(-2.69735980033875*x_74) - 0.0205415328075389*std::exp(-2.53743982315063*x_74) + 0.0242965123141167*std::exp(-3.83120012283325*x_45) - 9.41293572636493e-6*std::exp(-4.80536031723022*x_111) + 2.93740034996685e-6*std::exp(-4.45599985122681*x_111) + 0.000116224082885384*std::exp(-4.4312801361084*x_111) + 0.00721607177872347*std::exp(-3.27823972702026*x_111) + 0.00159296128738805*std::exp(-3.64696002006531*x_101));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-797.78198294775*x_1 - 43.0214818612906*x_10 + 497.678977168047*x_100 - 443.355227371047*x_101 + 127.737756398062*x_102 + 235.580495428084*x_103 + 133.742373841971*x_104 - 131.197041155906*x_105 + 20.1461680521344*x_106 + 90.7008869383065*x_107 + 129.636034373012*x_108 + 490.502544372373*x_109 + 111.744284549182*x_11 + 237.232605721267*x_110 - 145.923063945133*x_111 + 68.4295538811403*x_112 - 995.200199174384*x_113 + 284.221141204534*x_114 + 26.3104681425796*x_115 - 1296.92934597824*x_116 + 108.970226290667*x_117 + 65.2908145541842*x_118 + 17.6620932037835*x_119 - 2329.75666384714*x_12 + 430.802795524511*x_120 + 199.786261484707*x_13 + 51.4917462154624*x_14 + 47.8774440009008*x_15 + 137.166675399462*x_16 + 59.2542630514486*x_17 + 391.885335194933*x_18 - 43.7752196686902*x_19 + 217.537322818998*x_2 - 74.8540667721682*x_20 - 867.156528028735*x_21 + 131.614723611174*x_22 - 267.786340953072*x_23 + 37.605410171797*x_24 + 488.891418609757*x_25 + 79.6466714655069*x_26 + 369.238966747217*x_27 - 77.4653590092647*x_28 - 31.0101614120931*x_29 - 802.525056028514*x_3 - 854.325002607067*x_30 - 11172.9114883055*x_31 + 89.6354698544776*x_32 - 183.504862688984*x_33 - 130.302214614502*x_34 + 58.892688111276*x_35 - 68.1664868852273*x_36 - 3210.34138780125*x_37 + 129.452697515121*x_38 + 284.29089170828*x_39 - 139.650543066206*x_4 - 19.1317940253875*x_40 + 44.9629332750388*x_41 + 203381.937628598*x_42 - 94.6450208164781*x_43 - 75.7441033427558*x_44 - 80.0681540009899*x_45 + 147.245872136943*x_46 + 1044.92690935934*x_47 - 398.808090110529*x_48 + 1275.72410863609*x_49 - 145.617565329669*x_5 + 2474.54076264996*x_50 - 657.468741275269*x_51 - 1154.24467259037*x_52 + 57.8169250769467*x_53 - 1134.86306336855*x_54 + 312.821934878268*x_55 + 279.492357929687*x_56 + 4160.76250516214*x_57 - 116.860498955462*x_58 - 207.137206105816*x_59 + 21.4740301151293*x_6 + 403.88904490943*x_60 - 107.761840838519*x_61 + 90.8690148247969*x_62 - 123.945911956933*x_63 + 219.953149682113*x_64 + 27.0845052102871*x_65 + 273.601039839865*x_66 + 88.1804392763886*x_67 - 102.703348549951*x_68 + 181.606462369044*x_69 + 88.9181428731778*x_7 - 213.016464406553*x_70 - 116.755834535809*x_72 + 27.3058132768219*x_73 - 115.14097169811*x_74 - 239.461781412117*x_75 + 163.018188946903*x_76 - 259.797079900261*x_77 - 55.9792728084067*x_78 - 75.9703194128764*x_79 + 123.537707670472*x_8 + 37.7752300647969*x_80 + 585.093221550366*x_81 - 139.757147062523*x_82 + 106.925556698131*x_83 - 465.689713617619*x_84 + 9.40000573650587*x_85 - 136.261517165561*x_86 - 80.9253630163966*x_87 - 115.433663162994*x_88 + 115.873244418161*x_89 - 1288.78878323916*x_9 + 109.714054424532*x_90 - 162.977571217551*x_91 + 173.434388968251*x_92 + 183.823080005523*x_93 - 20.8643063258419*x_94 + 139.188584104236*x_95 + 191.787628400598*x_96 + 420.676922473883*x_97 - 1.97754669724768*x_98 + 242.307715180122*x_99 - 0.0307414416286399*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 1.45568674854121*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) + 6.92818028250985e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 2.53972213055424*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 0.472062707055747*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) + 0.070988124216266*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.00212918436973518*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.000341814662482592*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 2.61154778854573*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 1.23154460162642*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) - 0.00100597556832347*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 1.00013936473128*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.291995112481287*std::exp(0.925839841365814*x_38) + 0.00248159659191092*std::exp(1.08759987354279*x_38) - 19.9000796066925*std::exp(2.50039982795715*x_71) - 0.0231049223323229*std::exp(2.50919985771179*x_71) - 0.0168189226182314*std::exp(2.55495977401733*x_71) - 0.0107182136781067*std::exp(2.56535983085632*x_71) - 0.534268632545611*std::exp(2.59455990791321*x_71) - 0.00172442433807902*std::exp(2.59552001953125*x_71) + 0.000294400520918445*std::exp(2.60351991653442*x_71) - 6.24315675456188*std::exp(2.63032007217407*x_71) + 0.00361896973167915*std::exp(2.64359998703003*x_71) - 0.000196093298923855*std::exp(2.67215991020203*x_71) + 0.00213493152380928*std::exp(0.873279869556427*x_89) + 0.0242855710628046*std::exp(2.03023982048035*x_89) - 0.174071382170594*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 126.462144384803*std::sin(0.299919933080673*x_106 - 7.47904014587402) + 0.0622678532144642*std::sin(0.404879868030548*x_106 + 5.1866397857666) + 0.0443015555477577*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 2.00033020475112*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 2.00244003229307*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.0170286155652166*std::sin(0.336639851331711*x_14 - 1.25951993465424) + 0.0969236727741837*std::sin(0.327919840812683*x_16 - 4.26919984817505) - 18.4460606164659*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 1.77684979146958*std::sin(0.474079847335815*x_16 + 8.26064014434814) + 0.131366225168602*std::sin(0.333359837532043*x_26 + 5.14448022842407) + 14.9207521084439*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.0391528909358925*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 765.820560885674*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 0.289052954087816*std::sin(0.331759840250015*x_28 - 4.27432012557983) - 0.0957317521960324*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 1692.04795897127*std::sin(0.375119835138321*x_34 + 2.00247979164124) + 0.0439744307629471*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 708.861867421001*std::sin(0.385119825601578*x_36 + 5.20032024383545) + 0.162001815380817*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 2.04028103117268*std::sin(0.407759845256805*x_36 + 2.01279973983765) + 0.0135366497447996*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.00917060705725773*std::sin(0.416239857673645*x_36 - 7.38247966766357) - 0.0191173507501032*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 1.78710048812263*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 627.193565795897*std::sin(0.412639856338501*x_41 - 7.39527988433838) + 14.7429082037567*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 469.456719361417*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 0.159494621371683*std::sin(0.490639865398407*x_53 + 5.2628002166748) + 0.0571333004904261*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 1039.77397937688*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 3.72003564556925*std::sin(0.271039962768555*x_66 + 1.87127995491028) + 0.162360184330657*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 0.386914876262088*std::sin(0.282399952411652*x_80 - 7.49272012710571) - 10.5002671102265*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.924480385884744*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 434.418637586081*std::sin(0.485199838876724*x_80 - 7.31383991241455) - 0.0102371494255716*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 0.159882628816968*std::sin(0.374239832162857*x_83 - 4.23303985595703) - 10.180490613873*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 1.8312631073639*std::sin(0.407039850950241*x_94 - 7.38600015640259) + 0.0316938238101691*std::sin(0.426719844341278*x_94 + 1.9968798160553) - 0.395002364997643*std::sin(0.383279830217361*x_95 - 7.40383958816528) - 0.492552694347053*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 0.136292451360372*std::sin(0.447679847478867*x_96 - 7.36935997009277) + 6.55900164276788*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 1.80873131266169*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 0.177940630363862*std::sin(0.423839867115021*x_99 + 5.22488021850586) + 15.5349392819453*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 420831.332906097 - 6.95731522282428e-6*std::exp(-3.94543981552124*x_74) - 0.00985246908484977*std::exp(-2.76799988746643*x_74) - 0.000204099358890033*std::exp(-2.69735980033875*x_74) + 0.000901194911875391*std::exp(-2.53743982315063*x_74) - 0.107728583743751*std::exp(-3.83120012283325*x_45) + 4.5354444677164e-5*std::exp(-4.80536031723022*x_111) - 3.16209939637933e-6*std::exp(-4.45599985122681*x_111) + 0.000167973318044836*std::exp(-4.4312801361084*x_111) + 0.00300946849659225*std::exp(-3.27823972702026*x_111) - 0.00767538169620604*std::exp(-3.64696002006531*x_101));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-412.183015355574*x_1 - 20.8035457109673*x_10 + 135.543617266275*x_100 - 115.033610986156*x_101 + 18.0826450962025*x_102 + 53.9520801997413*x_103 + 41.3994306582312*x_104 - 35.4321582729829*x_105 + 4.91551875462854*x_106 + 24.7966664542597*x_107 + 43.5473454452162*x_108 + 129.361388725574*x_109 + 39.4372072474169*x_11 + 51.1418656550725*x_110 - 36.3352332814592*x_111 + 17.9778001748245*x_112 - 288.807712045281*x_113 + 84.0705751394571*x_114 + 6.65838614204732*x_115 - 291.817113057307*x_116 + 26.9194987243926*x_117 + 5.45780998063444*x_118 - 4.0697778192522*x_119 - 653.266765024691*x_12 + 167.076371079868*x_120 + 73.7031720608361*x_13 + 18.8998425350535*x_14 + 21.3600207540759*x_15 + 39.1737774579053*x_16 + 3.74418930077049*x_17 + 106.789902729407*x_18 - 9.56308101433881*x_19 + 37.117628414001*x_2 + 21.769175262987*x_20 - 215.130930367975*x_21 + 74.8553378501563*x_22 - 89.4190753544967*x_23 + 2.90789761294475*x_24 + 157.941010538005*x_25 + 16.3241921895852*x_26 + 102.30699087025*x_27 - 21.1007370054297*x_28 + 12.2491438144876*x_29 - 262.739178003304*x_3 - 325.283217312983*x_30 - 2621.28422159551*x_31 + 41.1919725878022*x_32 - 45.1427835582396*x_33 - 58.7174011701591*x_34 - 18.0610174477143*x_35 - 30.5138426423559*x_36 - 950.314558366866*x_37 + 33.6290069213084*x_38 + 74.813861493391*x_39 - 39.9578990270372*x_4 + 10.4960120407855*x_40 + 11.5139949206494*x_41 + 53547.4819907462*x_42 - 10.680460050414*x_43 - 10.638745604607*x_44 - 35.6149110215417*x_45 + 45.7092577521568*x_46 + 319.973515750529*x_47 - 102.111629930311*x_48 + 407.717470380694*x_49 - 34.4751977921644*x_5 + 726.82539199936*x_50 - 196.529119382908*x_51 - 280.895216672743*x_52 + 15.2944385253211*x_53 - 296.585804131727*x_54 + 98.622837815933*x_55 + 75.214401719824*x_56 + 1213.85272675335*x_57 - 25.4670050950732*x_58 - 65.6514946147604*x_59 + 2.13774599152497*x_6 + 111.012727449832*x_60 - 38.6233056771092*x_61 + 6.17507938231114*x_62 - 23.6983864646128*x_63 + 73.188151844101*x_64 - 0.921301308983095*x_65 + 92.3146698809622*x_66 + 22.8412050859999*x_67 - 23.1886622970692*x_68 + 32.6753255091276*x_69 + 35.1520634329083*x_7 - 65.2855914273085*x_70 - 36.5564144945727*x_72 + 34.5668019926838*x_73 - 20.4533202153652*x_74 - 64.1654790579955*x_75 + 76.0580905087061*x_76 - 77.8834585199792*x_77 - 25.0479176225834*x_78 - 6.27820123647093*x_79 - 25.9378262836425*x_8 + 10.2096323877261*x_80 + 146.921668670059*x_81 - 35.2332193664852*x_82 + 30.3789247730764*x_83 - 92.7518838357008*x_84 + 16.7714274579971*x_85 - 22.9684394278013*x_86 - 20.8641612747533*x_87 + 3.90016304139343*x_88 + 25.9165544949606*x_89 - 391.866963254455*x_9 + 116.892260528542*x_90 - 32.7697298829681*x_91 + 55.7957556687266*x_92 + 60.5723881258007*x_93 + 2.30734725431575*x_94 + 45.3295030924379*x_95 + 54.9739652052823*x_96 + 150.529087206764*x_97 + 10.3341544332571*x_98 + 73.2707844249315*x_99 - 0.013864961078782*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 0.654585446248167*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) - 4.52697927676442e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 0.677595152617338*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 0.212274638114875*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) + 0.0320169623534281*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.000468140384551057*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.00344713104726808*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 1.17434686842945*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 0.328574784719461*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) - 3.46806342357462e-5*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 0.449737330527367*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) + 0.361080298176891*std::exp(0.925839841365814*x_38) + 0.00442048138456988*std::exp(1.08759987354279*x_38) - 5.30931999055004*std::exp(2.50039982795715*x_71) + 0.0285714790710536*std::exp(2.50919985771179*x_71) - 0.0036979497943678*std::exp(2.55495977401733*x_71) - 0.000369506437269127*std::exp(2.56535983085632*x_71) - 0.240965075266925*std::exp(2.59455990791321*x_71) + 0.0026890213740584*std::exp(2.59552001953125*x_71) - 0.000192365816552285*std::exp(2.60351991653442*x_71) - 2.80738940179097*std::exp(2.63032007217407*x_71) + 0.0364965704823442*std::exp(2.64359998703003*x_71) - 0.000349302050283809*std::exp(2.67215991020203*x_71) - 0.00139499700808803*std::exp(0.873279869556427*x_89) - 0.0300314658222765*std::exp(2.03023982048035*x_89) - 1.75547433092247*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 56.8668219990211*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.0970988314842215*std::sin(0.404879868030548*x_106 + 5.1866397857666) - 0.0289473159928329*std::sin(0.360719859600067*x_114 + 5.16128015518188) - 2.47360245397965*std::sin(0.341119825839996*x_119 + 5.14807987213135) - 2.47621146051909*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.0303331646877676*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.151140193273054*std::sin(0.327919840812683*x_16 - 4.26919984817505) - 8.31951590278976*std::sin(0.329199850559235*x_16 - 4.26480007171631) + 2.19724723152858*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.204848991925763*std::sin(0.333359837532043*x_26 + 5.14448022842407) + 6.72953629659956*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.0697432556517713*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 344.370101669013*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 2.91503999595515*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.149281544076303*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 451.436588751852*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.0685725558509237*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 189.123589333343*std::sin(0.385119825601578*x_36 + 5.20032024383545) + 0.00558495243986129*std::sin(0.396159827709198*x_36 - 7.39479970932007) - 2.52300552855212*std::sin(0.407759845256805*x_36 + 2.01279973983765) - 0.00884505459914596*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.0163356517791624*std::sin(0.416239857673645*x_36 - 7.38247966766357) + 0.0124915702454847*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 0.39292694499968*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 282.033054544128*std::sin(0.412639856338501*x_41 - 7.39527988433838) + 6.64932539281783*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 211.102791479932*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 1.60847067591957*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.0890921467510722*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 467.560012461282*std::sin(0.298639953136444*x_60 - 7.49128007888794) - 4.60018514938975*std::sin(0.271039962768555*x_66 + 1.87127995491028) + 0.00559730707635764*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 3.90195749043052*std::sin(0.282399952411652*x_80 - 7.49272012710571) - 4.73581546886443*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.203264033641118*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 195.347053909625*std::sin(0.485199838876724*x_80 - 7.31383991241455) + 0.00668911047532884*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 1.61238365174541*std::sin(0.374239832162857*x_83 - 4.23303985595703) - 4.59159033038815*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 0.402636909927216*std::sin(0.407039850950241*x_94 - 7.38600015640259) - 0.0207092306694538*std::sin(0.426719844341278*x_94 + 1.9968798160553) - 0.0136175598832566*std::sin(0.383279830217361*x_95 - 7.40383958816528) - 0.0169805712706819*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 1.37448153095697*std::sin(0.447679847478867*x_96 - 7.36935997009277) + 2.95823154916458*std::sin(0.447679847478867*x_96 + 2.02399969100952) + 2.23667182696291*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 1.79449490856455*std::sin(0.423839867115021*x_99 + 5.22488021850586) + 7.00654611801764*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 113856.199533196 + 1.08490520152813e-5*std::exp(-3.94543981552124*x_74) - 0.00216624672420108*std::exp(-2.76799988746643*x_74) - 0.000363563288052913*std::exp(-2.69735980033875*x_74) + 0.00908836659551984*std::exp(-2.53743982315063*x_74) - 0.028741871114525*std::exp(-3.83120012283325*x_45) - 5.60851730308575e-5*std::exp(-4.80536031723022*x_111) + 2.06616425306022e-6*std::exp(-4.45599985122681*x_111) + 3.69320265645229e-5*std::exp(-4.4312801361084*x_111) + 0.00135732618128743*std::exp(-3.27823972702026*x_111) + 0.00949135445431519*std::exp(-3.64696002006531*x_101));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1827.65675996057*x_1 - 88.5506447188311*x_10 + 661.340418346692*x_100 - 588.602367274604*x_101 + 120.266051426265*x_102 + 277.922128103633*x_103 + 191.292484797892*x_104 - 180.456809444098*x_105 + 26.496872275774*x_106 + 132.227633907662*x_107 + 195.48140006644*x_108 + 641.626310197829*x_109 + 171.257988053729*x_11 + 270.766069921401*x_110 - 183.825092670217*x_111 + 82.2137155048311*x_112 - 1373.83304379463*x_113 + 406.208858595917*x_114 + 41.4809903560828*x_115 - 1537.64567334868*x_116 + 146.783947979591*x_117 + 51.6557789576344*x_118 - 0.753806357239019*x_119 - 3193.9421470636*x_12 + 724.440500726997*x_120 + 305.429119866868*x_13 + 88.4182711947254*x_14 + 82.6946700601264*x_15 + 187.593799252418*x_16 + 35.9636312427905*x_17 + 515.238767035964*x_18 - 52.2666584785605*x_19 + 220.630227383884*x_2 + 35.6344772681021*x_20 - 1116.5007829638*x_21 + 302.043865928568*x_22 - 401.274520610766*x_23 + 24.7600437394135*x_24 + 719.120027129221*x_25 + 84.6207121432575*x_26 + 505.112425412336*x_27 - 101.408175081115*x_28 + 14.5551939860052*x_29 - 1196.28407595556*x_3 - 1377.12147789463*x_30 - 13818.2083657222*x_31 + 168.059616792045*x_32 - 235.743500804896*x_33 - 232.029654815097*x_34 - 17.7656149132404*x_35 - 127.500348046883*x_36 - 4517.4993454829*x_37 + 168.579004103109*x_38 + 373.164261009855*x_39 - 191.683525232853*x_4 + 21.4829158515559*x_40 + 71.2546447540593*x_41 + 259669.52967653*x_42 - 80.8461984710694*x_43 - 88.2264958405969*x_44 - 142.404870308277*x_45 + 205.669114881631*x_46 + 1508.78293287072*x_47 - 467.968629048748*x_48 + 1889.4136934132*x_49 - 178.671033145378*x_5 + 3444.0381307133*x_50 - 912.427371662836*x_51 - 1457.25460669046*x_52 + 76.0884949460842*x_53 - 1452.99586923704*x_54 + 454.612956800047*x_55 + 364.747557154647*x_56 + 5838.41970278693*x_57 - 145.499132071998*x_58 - 312.676062795821*x_59 + 17.3239821194769*x_6 + 513.39035492469*x_60 - 169.234156246546*x_61 + 66.7091134491722*x_62 - 144.209044662578*x_63 + 333.29024015465*x_64 + 13.176501603613*x_65 + 419.318392086357*x_66 + 119.190285138038*x_67 - 118.478847388255*x_68 + 186.106389829966*x_69 + 147.697853997759*x_7 - 303.531657576502*x_70 - 167.213975543139*x_72 + 125.159158266684*x_73 - 129.204768220193*x_74 - 320.360704448831*x_75 + 311.223530059516*x_76 - 358.174935925742*x_77 - 113.276693197514*x_78 - 51.7668643614014*x_79 + 24.8811979390679*x_8 + 49.4787372145408*x_80 + 756.791580377767*x_81 - 167.342151022688*x_82 + 141.481884658091*x_83 - 479.980749809628*x_84 + 62.8812702084257*x_85 - 139.855022564216*x_86 - 109.183572799995*x_87 - 36.3499359804838*x_88 + 129.015793856909*x_89 - 1826.279515774*x_9 + 406.87291448523*x_90 - 194.455367276113*x_91 + 258.687615126274*x_92 + 281.235767573997*x_93 - 10.693726574634*x_94 + 202.427463302674*x_95 + 264.701151593771*x_96 + 665.559752503493*x_97 + 37.0627828311107*x_98 + 342.841769410731*x_99 + 0.0162004144886818*std::pow(-6.13023996353149*x_109 - 7.71576023101807, 2) - 2.71320848229398*std::pow(-4.56559991836548*x_115 - 6.94360017776489, 2) + 8.93392132679101e-5*std::pow(-5.52792024612427*x_14 - 6.89896011352539, 2) + 3.3346328112545*std::pow(-6.14871978759766*x_15 - 8.92888069152832, 2) - 0.879862746735759*std::pow(-9.78495979309082*x_38 - 8.98983955383301, 2) - 0.0374099903957049*std::pow(-4.24336004257202*x_5 - 6.26535987854004, 2) - 0.000698409871346766*std::pow(-6.7599196434021*x_66 - 9.54776000976563, 2) + 0.0104413984328739*std::pow(-6.01983976364136*x_66 - 9.05136013031006, 2) - 4.8675813109511*std::pow(-4.25880002975464*x_67 - 4.87368011474609, 2) + 1.61700722598759*std::pow(-7.8076000213623*x_78 - 9.79096031188965, 2) + 0.00160444973873906*std::pow(-4.8089599609375*x_80 - 7.82367992401123, 2) - 1.86412812412039*std::pow(-5.89088010787964*x_87 - 8.32919979095459, 2) - 0.643220254768118*std::exp(0.925839841365814*x_38) + 0.00190066205555456*std::exp(1.08759987354279*x_38) - 26.1286294294612*std::exp(2.50039982795715*x_71) - 0.0508965848870046*std::exp(2.50919985771179*x_71) - 0.00551690203486286*std::exp(2.55495977401733*x_71) + 0.0170946846793182*std::exp(2.56535983085632*x_71) + 0.281553916699745*std::exp(2.59455990791321*x_71) + 0.00043089019449481*std::exp(2.59552001953125*x_71) + 0.000379630867731816*std::exp(2.60351991653442*x_71) - 11.6364223825925*std::exp(2.63032007217407*x_71) + 0.110548519512083*std::exp(2.64359998703003*x_71) - 0.000150188428622112*std::exp(2.67215991020203*x_71) + 0.00275300432350882*std::exp(0.873279869556427*x_89) + 0.0534973721767603*std::exp(2.03023982048035*x_89) - 5.31735135000769*std::sin(0.414959847927094*x_103 - 4.18824005126953) - 235.708790492037*std::sin(0.299919933080673*x_106 - 7.47904014587402) - 0.0155591676537363*std::sin(0.404879868030548*x_106 + 5.1866397857666) + 0.0571270659508226*std::sin(0.360719859600067*x_114 + 5.16128015518188) + 4.40641931636041*std::sin(0.341119825839996*x_119 + 5.14807987213135) + 4.41106694144399*std::sin(0.211280003190041*x_14 + 1.80799984931946) - 0.0130422662446156*std::sin(0.336639851331711*x_14 - 1.25951993465424) - 0.0242187837938677*std::sin(0.327919840812683*x_16 - 4.26919984817505) + 9.72087878246061*std::sin(0.329199850559235*x_16 - 4.26480007171631) - 3.91412639013602*std::sin(0.474079847335815*x_16 + 8.26064014434814) - 0.0328251098427457*std::sin(0.333359837532043*x_26 + 5.14448022842407) - 7.86307849708865*std::sin(0.29351994395256*x_28 + 5.11104011535645) - 0.0299873131715634*std::sin(0.314639836549759*x_28 - 4.28416013717651) + 1427.38871793153*std::sin(0.330799847841263*x_28 - 4.27928018569946) - 8.82968869711319*std::sin(0.331759840250015*x_28 - 4.27432012557983) + 0.0239209528723243*std::sin(0.34063982963562*x_28 + 5.15088033676147) - 2221.64408236679*std::sin(0.375119835138321*x_34 + 2.00247979164124) - 0.0109881022935183*std::sin(0.325119823217392*x_36 + 8.32335948944092) - 930.729394885951*std::sin(0.385119825601578*x_36 + 5.20032024383545) - 0.258379804189665*std::sin(0.396159827709198*x_36 - 7.39479970932007) + 4.49442483306481*std::sin(0.407759845256805*x_36 + 2.01279973983765) + 0.0174555740348827*std::sin(0.408159852027893*x_36 + 1.99183976650238) + 0.00702379464774681*std::sin(0.416239857673645*x_36 - 7.38247966766357) - 0.0246519144441516*std::sin(0.559439837932587*x_38 + 8.55887985229492) - 0.58620034964314*std::sin(0.391199827194214*x_40 - 7.39615964889526) - 1169.006247026*std::sin(0.412639856338501*x_41 - 7.39527988433838) - 7.76935664093685*std::sin(0.300959914922714*x_53 + 5.12016010284424) + 875.005528708532*std::sin(0.423359870910645*x_53 - 7.36495971679688) - 4.87207563755964*std::sin(0.490639865398407*x_53 + 5.2628002166748) - 0.0142761722951987*std::sin(0.549279868602753*x_53 - 1.03927981853485) + 1938.00182858096*std::sin(0.298639953136444*x_60 - 7.49128007888794) + 8.19466550435112*std::sin(0.271039962768555*x_66 + 1.87127995491028) - 0.258951373704918*std::sin(0.501519858837128*x_75 - 4.09960031509399) - 11.8190728078095*std::sin(0.282399952411652*x_80 - 7.49272012710571) + 5.53352967250123*std::sin(0.360719859600067*x_80 + 5.14807987213135) + 0.303245804612345*std::sin(0.471119850873947*x_80 - 1.13295996189117) - 809.699156460917*std::sin(0.485199838876724*x_80 - 7.31383991241455) - 0.0132008527274536*std::sin(0.608239889144897*x_80 + 2.17871975898743) + 4.88392808502844*std::sin(0.374239832162857*x_83 - 4.23303985595703) + 5.36501084221191*std::sin(0.331519842147827*x_92 - 7.40743970870972) + 0.600686464448907*std::sin(0.407039850950241*x_94 - 7.38600015640259) + 0.0408693360910422*std::sin(0.426719844341278*x_94 + 1.9968798160553) + 0.629996852088552*std::sin(0.383279830217361*x_95 - 7.40383958816528) + 0.785581744373174*std::sin(0.400159865617752*x_96 + 5.19144010543823) + 4.16331990474286*std::sin(0.447679847478867*x_96 - 7.36935997009277) - 3.45652447040058*std::sin(0.447679847478867*x_96 + 2.02399969100952) - 3.98435647039085*std::sin(0.439599871635437*x_97 + 1.99983978271484) + 5.43554511538967*std::sin(0.423839867115021*x_99 + 5.22488021850586) - 8.1867486393205*std::sin(0.449519872665405*x_99 - 1.14855980873108) + 553596.240271361 + 1.7384577817221e-6*std::exp(-3.94543981552124*x_74) - 0.00323178291359229*std::exp(-2.76799988746643*x_74) - 0.000156320293261921*std::exp(-2.69735980033875*x_74) + 0.0275287638986197*std::exp(-2.53743982315063*x_74) - 0.141446682587869*std::exp(-3.83120012283325*x_45) + 9.99088553647674e-5*std::exp(-4.80536031723022*x_111) - 4.07754216587912e-6*std::exp(-4.45599985122681*x_111) + 5.50981986872158e-5*std::exp(-4.4312801361084*x_111) - 0.00158595805702238*std::exp(-3.27823972702026*x_111) - 0.0169076835845757*std::exp(-3.64696002006531*x_101));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
