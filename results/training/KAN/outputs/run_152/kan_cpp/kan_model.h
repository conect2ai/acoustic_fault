
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.50978476147658e-5*x_1 - 0.000220767212491694*x_10 + 0.000331179527196015*x_100 - 0.000241547756054843*x_101 - 0.000172635466240701*x_102 - 0.000292391343899521*x_103 - 0.000207542807861122*x_104 + 0.000553916305366221*x_105 - 0.000653805987465727*x_106 + 0.000149418304032022*x_107 + 8.94889148780345e-6*x_108 + 1.76704564517839e-5*x_109 - 9.5525124928891e-5*x_11 + 0.000970099719404787*x_110 + 0.000257695548834684*x_111 - 0.000271938393084176*x_112 + 0.000129131742761328*x_113 + 8.15508302053431e-6*x_114 + 0.000419653887213733*x_115 + 0.00028955340331267*x_116 - 0.000133022113420805*x_117 - 0.000626084792491902*x_118 - 6.58234946420508e-5*x_119 + 0.000272105864784442*x_12 + 0.000109149386681267*x_120 + 2.90117006938628e-5*x_13 + 0.00178679599942125*x_14 + 2.32866195410339e-5*x_15 - 5.33950301175019e-6*x_16 - 7.07909826409422e-5*x_17 + 0.00017969946470715*x_18 + 0.000650030931857162*x_19 - 8.33439868619907e-6*x_2 + 0.000574954529163105*x_20 + 7.62187113949933e-5*x_21 + 0.00135114971033126*x_22 + 3.00711468496092e-5*x_23 + 0.000113361692857632*x_24 + 4.98617584111475e-5*x_25 - 0.000131074209398336*x_26 + 5.42494151772932e-5*x_27 + 3.636353253277e-5*x_28 + 9.22596038238606e-5*x_29 + 1.5456383059325e-5*x_3 + 0.000177528447057015*x_30 + 2.10099117787808e-5*x_31 + 1.82080997060957e-5*x_32 + 4.8841850361464e-5*x_33 + 8.03956918002555e-5*x_34 + 0.000713028673840966*x_35 + 0.00143457070145031*x_36 + 0.000328078715068737*x_37 - 0.000264522144921505*x_38 - 1.02275210471725e-5*x_39 + 5.36485339017495e-5*x_4 + 0.000119007803978097*x_40 + 0.00135987918168419*x_41 + 0.00146415159097086*x_42 - 0.000719991561260238*x_43 - 9.93576732127507e-5*x_44 + 0.000292417644630046*x_45 - 0.000550935145353593*x_46 - 6.39784485108627e-5*x_47 - 3.11239064163307e-5*x_48 - 0.000838735654751009*x_49 - 6.62195089070419e-6*x_5 - 0.000221687694898987*x_50 - 0.00104116518245026*x_51 - 1.24432480392805e-5*x_52 + 0.000452647541033213*x_53 + 0.00141830304073699*x_54 - 4.75863260825129e-5*x_55 + 0.000709635947181154*x_56 + 0.000295981085431111*x_57 - 0.000417847273879411*x_58 - 0.000410377874213856*x_59 + 0.00022545421948427*x_6 + 0.00078637416859166*x_60 - 2.87995658629193e-8*x_61 + 6.27960406373238e-6*x_62 - 6.7980606212366e-6*x_63 - 1.12723830638648e-5*x_64 + 6.47714780232716e-6*x_65 - 3.28422741990118e-5*x_66 + 2.76825833406602e-5*x_67 + 1.81195539558483e-5*x_68 - 3.38188732990201e-5*x_69 + 0.000605135883673726*x_7 + 9.98438111644271e-7*x_70 - 1.00846166870502e-5*x_71 + 8.3200725810428e-6*x_72 - 7.53352894622792e-6*x_73 - 3.50995151086058e-5*x_74 + 4.96075519016257e-6*x_75 + 1.65245937453015e-5*x_76 - 1.2250405440136e-5*x_77 + 1.0247498463502e-6*x_78 - 5.96269415464913e-6*x_79 + 4.85525205711494e-5*x_8 - 2.12802835281018e-5*x_80 + 2.92041809833327e-5*x_81 + 2.97866544536387e-5*x_82 + 0.00010151529646163*x_83 - 4.60777051439662e-5*x_84 - 6.66360527525255e-6*x_85 + 9.65762817126107e-6*x_86 - 2.7759608108298e-6*x_87 - 3.32804927952667e-5*x_88 - 1.71724387297148e-6*x_89 + 5.55770572159521e-5*x_9 + 5.21133068607453e-6*x_90 + 2.52153874221836e-5*x_91 - 0.000127275941581637*x_92 - 0.000808334400546846*x_93 - 8.85983511118162e-5*x_94 - 0.000549011725010323*x_95 + 6.53892108943003e-5*x_96 - 4.96936718954702e-5*x_97 - 0.000504659098687334*x_98 - 0.000321468009558417*x_99 + 6.39904330387591e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 2.27909520873296e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) - 2.65736443311683e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 1.81561356194962e-7*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) + 3.22295543774005e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.000720424594753323*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 0.000549837288415798*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.00157609462562991*std::sin(0.260159969329834*x_100 - 7.60351991653442) - 7.70094283452273e-7*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.000929778562605159*std::sin(0.267839968204498*x_102 + 7.99520015716553) - 0.00108235803781661*std::sin(0.242719978094101*x_103 - 4.42375993728638) - 0.00686669668748694*std::sin(0.307439923286438*x_107 + 1.73607993125916) - 0.000980031943619841*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.00209379500358216*std::sin(0.273919969797134*x_109 + 4.94927978515625) - 0.000465167936450629*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 0.000225397794692424*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 0.000161981280551552*std::sin(0.274239957332611*x_110 + 4.75271987915039) - 0.00135588411704313*std::sin(0.236399978399277*x_111 - 4.42143964767456) - 0.00654019029094781*std::sin(0.253679990768433*x_111 + 1.77215993404388) - 6.48057462707483e-5*std::sin(0.306399941444397*x_111 - 8.07583999633789) + 0.000898593650568127*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 0.000431398133157197*std::sin(0.335439831018448*x_113 + 8.03087997436523) + 0.00111591300513085*std::sin(0.239839985966682*x_114 + 8.16464042663574) - 0.00353322992707766*std::sin(0.298879951238632*x_114 - 7.8452000617981) - 8.12237998000988e-5*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.00026719853494906*std::sin(0.304879933595657*x_116 + 1.7325599193573) - 0.00649864143264397*std::sin(0.258879989385605*x_117 + 8.17216014862061) + 0.000817628863268679*std::sin(0.277439951896667*x_119 - 7.63727998733521) + 3.24186949546615e-6*std::sin(0.307279914617538*x_119 - 1.63255989551544) - 0.000163071855990034*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.000912448280896406*std::sin(0.305439919233322*x_12 - 1.25543987751007) + 0.000137791767986354*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.00158674321060828*std::sin(0.338559836149216*x_13 - 1.31959986686707) + 0.00017471929247106*std::sin(0.322799921035767*x_14 + 4.77503967285156) - 0.000565040865638106*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.0003018422276541*std::sin(0.349519848823547*x_14 - 7.55999994277954) - 0.000541440694042615*std::sin(0.404239863157272*x_14 - 7.99567985534668) + 0.00024304184414377*std::sin(0.222079992294312*x_15 - 1.59383988380432) + 0.0052329761418925*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.000371205537236704*std::sin(0.202719986438751*x_16 - 7.60552024841309) + 0.000135054326084169*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 0.000593360397705711*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 0.000900818241596794*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 0.000810540096816831*std::sin(0.331759840250015*x_19 + 4.80807971954346) - 0.000595767980132306*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 4.61392371682153e-5*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.00138583441601503*std::sin(0.385999828577042*x_20 - 4.40111970901489) + 0.000307784240504724*std::sin(0.411519855260849*x_20 + 4.79256010055542) - 0.00116739104874714*std::sin(0.303759932518005*x_21 + 1.98103988170624) - 0.000882998637126205*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.000185469413598639*std::sin(0.333439826965332*x_23 + 1.60327982902527) - 0.00063269152812648*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 0.000284671963161571*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 0.00025791508173818*std::sin(0.423679858446121*x_24 - 1.60191988945007) + 0.0054173284153512*std::sin(0.403359860181808*x_25 - 7.60167980194092) - 3.2315781168139e-5*std::sin(0.276479959487915*x_26 + 7.99839973449707) + 0.000687395049245762*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 0.000391299228363027*std::sin(0.411839872598648*x_26 + 4.99191999435425) - 0.0113492037130615*std::sin(0.239119976758957*x_28 + 1.82159984111786) - 0.000467679143181313*std::sin(0.348879843950272*x_28 + 5.00719976425171) - 0.000947614590636515*std::sin(0.399279862642288*x_28 + 8.19672012329102) - 0.000107157103854628*std::sin(0.438639879226685*x_28 + 8.16016006469727) - 0.00204331745074809*std::sin(0.192239999771118*x_29 + 1.77327990531921) - 0.000806723188463899*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.00895388190102556*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 0.000875080897497254*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 0.000655901383723949*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.00457019437864933*std::sin(0.296879917383194*x_32 - 1.34903991222382) + 0.00523434182233405*std::sin(0.26335996389389*x_33 + 4.99463987350464) + 0.000190796142610487*std::sin(0.277759939432144*x_33 - 7.6113600730896) - 0.00157498938383636*std::sin(0.290559947490692*x_36 + 4.96271991729736) + 0.00108954442941817*std::sin(0.253279983997345*x_38 - 1.40319991111755) - 0.000502148883426545*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.000364123719290647*std::sin(0.266479969024658*x_40 + 1.7739999294281) + 1.05092466339541e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) + 0.000204188217893785*std::sin(0.236239984631538*x_42 + 4.98647975921631) + 0.00233470035335326*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 0.00142163479619295*std::sin(0.240399971604347*x_48 - 7.60304021835327) + 0.00147159388321341*std::sin(0.267279952764511*x_48 + 4.96471977233887) + 0.00130733777121606*std::sin(0.267439961433411*x_49 + 8.15312004089355) - 0.000961304257793022*std::sin(0.318559914827347*x_5 + 8.2260799407959) - 0.000207246899864033*std::sin(0.36847984790802*x_5 - 7.57728004455566) - 0.000319359638287465*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.00263732863150289*std::sin(0.224639996886253*x_51 - 4.40959978103638) - 1.99756985841077e-5*std::sin(0.247039973735809*x_52 + 1.59447979927063) - 0.000492066797260112*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.00204396789705474*std::sin(0.252559989690781*x_54 + 4.95887994766235) - 4.71577790299836e-6*std::sin(0.313039928674698*x_57 + 1.52575981616974) + 0.00040078516362002*std::sin(0.320719927549362*x_57 + 1.70343995094299) - 0.000384153646675722*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 7.23710326788698e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 0.000755637056601991*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.000614087387023898*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 0.000155746676970241*std::sin(0.252239972352982*x_60 + 1.5759197473526) - 9.75129345873187e-5*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 0.000563645696898589*std::sin(0.424159854650497*x_60 + 4.95928001403809) + 0.0004167775860167*std::sin(0.425279855728149*x_60 - 7.63568019866943) - 7.55414226896037e-5*std::sin(0.428239852190018*x_60 + 4.95824003219604) - 0.000160667149916756*std::sin(0.301919937133789*x_7 + 7.77184009552002) - 0.000597109422774897*std::sin(0.338479846715927*x_7 - 4.58527994155884) + 0.000969085373102946*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 1.29403212013318e-5*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000980986313168881*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 0.000124812001339659*std::sin(0.37951985001564*x_7 - 1.59695994853973) + 1.96794430409299e-5*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 7.5676153241579e-6*std::sin(0.365359842777252*x_8 - 1.76943981647491) + 0.000496019206430512*std::sin(0.384799838066101*x_8 + 1.81071984767914) + 5.70364562672593e-6*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 0.000122198292161817*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.000177472594770256*std::sin(0.435199856758118*x_8 + 7.97311973571777) - 1.14733752994661e-5*std::sin(0.451999872922897*x_8 - 1.62583994865417) - 0.000160153479171747*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.000560725003369736*std::sin(0.348319828510284*x_9 - 4.58048009872437) + 8.73557250292065e-5*std::sin(0.295199930667877*x_91 + 5.05583953857422) + 0.000997887500813427*std::sin(0.351119846105576*x_91 + 1.97359979152679) - 0.000415133504014092*std::sin(0.284399926662445*x_93 + 7.97679996490479) - 0.000741103585652401*std::sin(0.288959950208664*x_94 - 4.41472005844116) - 0.000100121789391651*std::sin(0.314399927854538*x_94 - 7.61816024780273) + 0.00116530544322736*std::sin(0.278079956769943*x_95 + 4.98383951187134) + 0.000692752162042675*std::sin(0.305199921131134*x_96 - 4.61279964447021) - 0.000182888647163865*std::sin(0.286799937486649*x_97 - 4.41120004653931) + 0.000522209010204722*std::sin(0.308079928159714*x_98 + 7.96912002563477) - 0.000669633210455467*std::sin(0.319359838962555*x_98 - 4.56112003326416) + 0.135275691522886);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-5.30948739410502e-5*x_1 - 0.000283865520848424*x_10 + 0.000328924029726148*x_100 - 0.000129259520488612*x_101 + 0.00089671169526966*x_102 + 0.000209653929525337*x_103 - 2.66021562886725e-6*x_104 + 1.92108774953187e-5*x_105 + 0.000231989722298429*x_106 + 0.000323845224994082*x_107 + 0.000439432097624028*x_108 + 5.12117177596175e-5*x_109 + 1.002382540698e-5*x_11 + 9.91685116042475e-5*x_110 - 0.000136511358376697*x_111 - 0.000575033297463041*x_112 - 1.80971594959921e-5*x_113 + 1.04008540609276e-6*x_114 + 0.000351395491103586*x_115 + 0.00028836171205542*x_116 - 0.000328871729307994*x_117 + 0.00111518691274551*x_118 - 3.59246272145908e-5*x_119 + 0.000215454427355084*x_12 + 9.60869321334008e-6*x_120 + 1.50459569304144e-5*x_13 - 0.000515487132144957*x_14 + 2.79349025849969e-5*x_15 + 0.000262031587354887*x_16 - 4.30032494999514e-5*x_17 + 0.000179237556631398*x_18 - 0.000512004972987764*x_19 + 0.000262789905771053*x_2 - 0.000501607128135578*x_20 + 0.000248800459606591*x_21 - 0.000799098401684141*x_22 + 9.49198609880947e-5*x_23 + 0.000102898879678152*x_24 - 0.000175773083985778*x_25 - 0.000367831612484394*x_26 + 0.000490298856469837*x_27 - 1.59540950630216e-5*x_28 + 2.97923638513839e-5*x_29 - 3.59928721391122e-5*x_3 - 0.000181818749666013*x_30 - 2.31366980676527e-5*x_31 - 9.48096612655556e-5*x_32 - 0.000212358461466799*x_33 - 0.000196413475907614*x_34 - 0.00137702764639949*x_35 + 0.000545464813364237*x_36 + 0.00020449791586152*x_37 + 0.000657866402817842*x_38 - 0.000295502677765657*x_39 + 2.30365847762341e-6*x_4 - 0.000432525085739409*x_40 - 0.000819658735513754*x_41 - 0.000760773697125147*x_42 - 0.000555534855177791*x_43 - 5.85566564471953e-5*x_44 + 0.000275905135136858*x_45 - 0.000237633838473461*x_46 - 0.000474055461056779*x_47 - 0.000201720730868544*x_48 - 0.000673560733575454*x_49 - 0.000214082285673005*x_5 + 0.000168824923561871*x_50 + 3.43225162729591e-5*x_51 + 0.00103140828445194*x_52 - 0.000167933185651797*x_53 - 0.00141145138586712*x_54 - 0.000582059159041379*x_55 - 0.000259569193550522*x_56 - 0.000776542150230715*x_57 + 0.000286112724603854*x_58 + 0.000547594680941868*x_59 + 6.13169459426761e-6*x_6 - 0.000601207950570835*x_60 + 2.11082418736436e-5*x_61 - 3.4191956315406e-7*x_62 + 2.35892329544577e-5*x_63 - 1.39183047270415e-6*x_64 - 3.1775417211668e-5*x_65 + 2.71676722109536e-5*x_66 + 1.6103847429363e-6*x_67 + 2.40626918519521e-6*x_68 + 4.71270381783753e-5*x_69 - 0.000389648829811216*x_7 - 1.59260181149301e-5*x_70 - 4.56991174127944e-6*x_71 - 3.13876312253928e-6*x_72 + 1.81386127014374e-5*x_73 - 4.50544922362014e-6*x_74 - 2.19664192414688e-5*x_75 - 9.31757357691319e-6*x_76 + 4.80525867577749e-6*x_77 + 1.15075240229218e-5*x_78 + 5.67272250528507e-6*x_79 - 0.000122297690221161*x_8 - 1.84055283835611e-6*x_80 - 3.39151228608312e-5*x_81 - 2.87926752850833e-5*x_82 - 8.10227466577547e-5*x_83 - 2.3391600406896e-6*x_84 - 5.55592372905132e-5*x_85 - 3.5081729218316e-5*x_86 + 2.71939892740583e-5*x_87 + 2.74643872333704e-5*x_88 + 2.24390386455995e-5*x_89 - 3.77197079717878e-5*x_9 - 1.81663202966542e-5*x_90 + 4.66285355247481e-6*x_91 + 1.35185015665161e-5*x_92 - 0.000324180367068986*x_93 - 4.96923510899529e-5*x_94 + 0.000621639888535412*x_95 - 0.000142314891048212*x_96 + 3.29407940148685e-5*x_97 + 0.00030447145855947*x_98 - 9.5699380447657e-5*x_99 - 3.04274304061908e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 7.6335494699426e-9*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) - 7.45348738919842e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) - 5.23111613604683e-7*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 2.53353209627264e-8*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) - 0.00274299923330545*std::pow(-0.0109106293263339*x_1 - 0.0350548940703456*x_100 - 0.0154723480729254*x_101 + 0.15717985097626*x_102 - 0.0248328301690635*x_103 + 0.162656517605903*x_104 - 0.0619572662068887*x_105 + 0.00363476914223923*x_106 - 0.0274554450139179*x_107 + 0.0702590476213252*x_108 - 0.0238099674419506*x_109 + 0.233308768381215*x_11 - 0.0310707263012761*x_111 - 0.00213892710663181*x_113 - 0.211136562770174*x_115 + 0.00253414536716609*x_116 + 0.175862158471796*x_117 - 0.225594516821389*x_118 + 0.0153423300223808*x_119 + 6.89546256924688e-5*x_120 - 0.0538468675793818*x_13 - 0.0420326348115173*x_14 + 0.219198735891756*x_15 + 0.0309959453346973*x_16 - 0.0535921415577157*x_17 - 0.18524313625801*x_18 - 0.0244029211440914*x_2 - 0.00314089330484555*x_20 - 0.0444067043101878*x_22 - 0.0303137246317288*x_24 - 0.104698160204485*x_25 + 0.184332051422861*x_26 + 0.147031140941324*x_27 + 0.051069428158899*x_28 - 0.0237966085603062*x_29 - 0.0173774378294199*x_3 - 0.00365256351797848*x_30 - 0.00241634079163288*x_31 + 0.0182605613061159*x_32 - 0.0346978416309929*x_34 - 0.0423881365922285*x_35 + 0.00274972586261348*x_36 - 0.139805491601254*x_37 + 0.308663910436811*x_38 - 0.324843307607675*x_39 + 0.00327044655699421*x_40 + 0.0633684129519606*x_41 + 0.0654936487316974*x_42 + 0.109712646650934*x_43 - 0.0452636845175708*x_44 - 0.330971355862179*x_45 - 0.0341011511788568*x_46 - 0.0505632566650166*x_47 - 0.0469950728229552*x_50 + 0.100452351732248*x_51 - 0.0286003824117479*x_52 - 0.295278977164215*x_54 + 0.0440462124187115*x_55 - 0.328610259185087*x_56 - 0.359622566595502*x_58 + 0.0364917678392733*x_59 - 0.0525854707953753*x_60 + 0.00475701084221915*x_61 + 0.0139128172819752*x_62 + 0.00637252055982024*x_63 + 0.0080865384835325*x_64 - 0.000562445660477981*x_65 + 0.00189388687925166*x_66 + 0.0120117463681281*x_67 - 4.32330981887325e-5*x_68 + 0.00591150667226137*x_69 - 0.0354617815048558*x_7 + 0.0175777609881514*x_70 + 0.0532635936488606*x_71 + 0.0103712387816409*x_72 + 0.0167168453669367*x_73 + 0.0106509260373893*x_74 + 0.0122348603358663*x_75 + 0.00365297398645558*x_76 + 0.0114670629967152*x_77 + 0.00596824347170537*x_78 + 0.0132986877285924*x_79 - 0.0155235624771952*x_8 + 0.00772152129156661*x_80 + 0.012526410783513*x_81 + 0.00706984835791665*x_82 + 0.00775428560801291*x_83 + 0.015718613430003*x_84 + 0.0189101388645837*x_85 + 0.0110666823002952*x_86 + 0.00857878978897181*x_87 + 0.0166925446894007*x_88 + 0.0121725906847228*x_89 + 0.033384883206047*x_90 - 0.0383387199037079*x_92 + 0.0109477530142782*x_93 - 0.08863792811838*x_94 + 0.0144130062322483*x_97 + 0.170061292968777*x_99 + 0.864677640445976*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.354462015186186*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 1.41313412870137*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 1.75489193721224*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.256447844901304*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 1.41663253479742*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 1.83584663822415*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 1.3886093107056*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.300047235563024*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.789682549404503*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 2.2356719834149*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 2.05592775007678*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 1.51175323116783*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.773827396142195*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.630277314591012*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 1.18831967365962*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.251858386830101*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.137376172531575*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 1.83256680162934*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 1.08942648581507*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 1.05306947451522*std::sin(0.319359838962555*x_98 - 4.56112003326416) + 2.12958281030794, 2) + 0.000225926830643222*std::exp(0.00517232976838498*x_1 + 0.019154466398603*x_10 + 0.0196443713003131*x_100 - 0.0396368923078344*x_101 + 0.0121400461988688*x_102 + 0.00435365453550972*x_103 + 0.00882859928979454*x_104 + 0.00649581006666488*x_105 + 0.000683684637167103*x_106 + 0.010839081636169*x_107 + 0.00642625957565527*x_108 + 0.0612804685374603*x_109 - 0.128892698006866*x_11 + 0.0063591650717694*x_110 + 0.0399196920172332*x_111 + 0.0111014290513432*x_112 + 0.00891778360019096*x_113 + 0.00681192320958472*x_114 - 0.201563618047454*x_115 + 0.11634975381483*x_116 + 0.00888437969171283*x_117 - 0.0353196655094796*x_118 + 0.00603335236767849*x_119 + 0.00490671892354411*x_12 + 0.00998501255770269*x_120 + 0.0228054884495299*x_13 + 0.0087605803472912*x_14 + 0.0827454327207712*x_15 + 0.00152156246694541*x_16 + 0.00972083332424279*x_17 - 0.0552089979031278*x_18 + 0.0222983364362873*x_19 + 0.00555514959835948*x_2 + 0.017215772891986*x_20 + 0.00830940593710119*x_21 + 0.0241011161741729*x_22 - 0.0731885461970618*x_23 + 0.00384135008348973*x_24 + 0.0175349223219353*x_25 + 0.0121288747391079*x_27 - 0.0744456845998959*x_28 - 0.0203861012054285*x_29 - 0.0444645221716919*x_3 - 0.0606891040665564*x_30 + 0.0101387037474644*x_31 - 0.012481081981639*x_32 + 0.00868524679793287*x_33 + 0.00749537425459057*x_34 - 0.000759580399868448*x_35 - 0.0134366716148494*x_36 - 0.00692934088096214*x_37 - 0.0270777142018051*x_38 + 0.117419493153819*x_39 + 0.077097736837975*x_4 + 0.0466633409828311*x_40 + 0.00869642274384484*x_41 + 0.213634478667926*x_42 - 0.268758052398861*x_43 + 0.314959603259126*x_44 + 0.159892025910472*x_45 - 0.212499762165853*x_46 + 0.0349418874240427*x_47 - 0.178129111803297*x_48 - 0.0446312195561265*x_49 + 0.00623930509778969*x_5 + 0.116636206385341*x_50 + 0.00160386915060469*x_51 - 0.092208475337638*x_53 - 0.00270282497770026*x_54 - 0.0178723424056953*x_55 + 0.03503229476937*x_56 + 0.00244957518320617*x_57 + 0.206389861793147*x_58 - 0.231896800912785*x_59 + 0.0125640985724604*x_6 + 0.00285100740035928*x_60 + 0.00956618391449593*x_61 - 0.00716216701899749*x_62 + 0.000689184007653637*x_63 - 0.000371554421824184*x_64 - 0.00874683140495934*x_65 + 0.00427433120102155*x_66 - 0.000404109961865047*x_67 + 0.0011015817520859*x_68 + 0.00242317794535899*x_69 - 0.00193421398305053*x_70 - 0.00233031987067836*x_71 + 0.00136941399778484*x_72 + 0.00485074165954134*x_73 - 0.00205529434706776*x_74 + 0.00177445046528641*x_75 - 0.00255252756028388*x_76 + 0.00389619099612281*x_77 + 0.000150166999629212*x_78 + 0.00299755299441407*x_79 - 0.000288457762917783*x_80 + 0.00122866905145868*x_81 + 0.00364381093887476*x_82 + 0.00736427216137742*x_83 + 0.0189746878703707*x_84 - 0.00154535904501103*x_85 + 0.000492685000602473*x_86 - 0.000978894923561506*x_87 + 0.00300845868441283*x_88 + 0.0032099845152826*x_89 + 0.00689312944115612*x_9 - 0.00254398619575227*x_90 - 0.00312089410770527*x_91 + 0.00545488980120165*x_92 + 0.00385326265691521*x_93 + 0.00144715278172338*x_94 + 0.000328156107139153*x_95 - 0.0105055739676831*x_96 - 0.00664159650502876*x_97 - 0.00752452829616013*x_98 + 0.012530083773564*x_99 - 1.39327731859922*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 0.861241373544509*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.848468477024653*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.494668332148606*std::sin(0.451999872922897*x_8 - 1.62583994865417)) + 0.00592305410780483*std::sin(0.213359996676445*x_10 - 1.37991976737976) + 0.00225475972448457*std::sin(0.260159969329834*x_100 - 7.60351991653442) + 1.16028246363142e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.000256143857584222*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.000514660900173908*std::sin(0.242719978094101*x_103 - 4.42375993728638) + 0.00452913523960817*std::sin(0.307439923286438*x_107 + 1.73607993125916) - 0.00140203292318137*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.000576817697006697*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 0.000640927168857727*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 5.42536403725904e-5*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.000644722463203216*std::sin(0.236399978399277*x_111 - 4.42143964767456) + 0.00431377817727897*std::sin(0.253679990768433*x_111 + 1.77215993404388) - 0.000430853553524491*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.0035467896339255*std::sin(0.335439831018448*x_113 + 8.03087997436523) + 0.00233044750637183*std::sin(0.298879951238632*x_114 - 7.8452000617981) - 0.000227819925625609*std::sin(0.257839977741241*x_115 + 4.76639986038208) - 0.000769848054119616*std::sin(0.304879933595657*x_116 + 1.7325599193573) + 0.00428637338471658*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.000388782262500579*std::sin(0.277439951896667*x_119 - 7.63727998733521) - 4.88444649674397e-5*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000251369553907588*std::sin(0.305439919233322*x_12 - 1.25543987751007) + 0.000386484139029828*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.000437130455903375*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 0.000240735297283731*std::sin(0.322799921035767*x_14 + 4.77503967285156) - 0.000808347015344661*std::sin(0.345839858055115*x_14 + 4.82800006866455) + 0.000869662895625304*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 4.25620956629479e-5*std::sin(0.404239863157272*x_14 - 7.99567985534668) + 0.00161583575886934*std::sin(0.222079992294312*x_15 - 1.59383988380432) - 0.00345156597574257*std::sin(0.401519864797592*x_15 - 1.37799990177155) + 0.00106951133012231*std::sin(0.202719986438751*x_16 - 7.60552024841309) + 0.000378806046991594*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 0.000163464320773538*std::sin(0.437599837779999*x_16 + 4.97447967529297) + 0.00115955802124*std::sin(0.331759840250015*x_19 + 4.80807971954346) - 0.000852305201030028*std::sin(0.269519954919815*x_20 - 1.38383984565735) - 0.00146230657025404*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.000381782273293617*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 0.000146351307740132*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.000255547248321779*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.000300844618897867*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 7.84240223671873e-5*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 7.10527932376322e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) - 0.00357316103319505*std::sin(0.403359860181808*x_25 - 7.60167980194092) - 0.000947120659608628*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 0.000107798671483458*std::sin(0.411839872598648*x_26 + 4.99191999435425) + 0.00748570685697938*std::sin(0.239119976758957*x_28 + 1.82159984111786) - 0.000669061412226584*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.000450590434214112*std::sin(0.399279862642288*x_28 + 8.19672012329102) - 0.000300558746211074*std::sin(0.438639879226685*x_28 + 8.16016006469727) - 0.00292316832845107*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 0.00111153578894388*std::sin(0.368239849805832*x_29 - 4.39232015609741) + 0.0059058006920743*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 0.000241075247159034*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 0.000180693680601912*std::sin(0.316399931907654*x_31 - 4.54760026931763) + 0.00301440843454165*std::sin(0.296879917383194*x_32 - 1.34903991222382) - 0.00345246675113653*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.000433892404767523*std::sin(0.290559947490692*x_36 + 4.96271991729736) + 0.00155870139872266*std::sin(0.253279983997345*x_38 - 1.40319991111755) - 0.00104910731193995*std::sin(0.266479969024658*x_40 + 1.7739999294281) + 2.94767764180086e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) + 0.000572715690827986*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 0.000183528391709542*std::sin(0.268079966306686*x_44 - 7.61872005462646) + 0.00210526104506024*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 6.94148035826837e-5*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 0.000440026607114906*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.000726555285914182*std::sin(0.224639996886253*x_51 - 4.40959978103638) - 0.000563090872371771*std::sin(0.252559989690781*x_54 + 4.95887994766235) + 7.1051487081564e-5*std::sin(0.313039928674698*x_57 + 1.52575981616974) + 0.0011068172115264*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 2.42397884927375e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) + 0.000878512930035576*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 5.21654364800522e-5*std::sin(0.252239972352982*x_60 + 1.5759197473526) - 0.000648303534782555*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 0.000155278244649809*std::sin(0.424159854650497*x_60 + 4.95928001403809) + 0.00342658511504934*std::sin(0.425279855728149*x_60 - 7.63568019866943) - 0.000211881755608006*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 0.000221373687770321*std::sin(0.301919937133789*x_7 + 7.77184009552002) - 0.000854224267813225*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.000460799784397257*std::sin(0.339999854564667*x_7 + 5.0099196434021) - 3.72834420608904e-5*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000270251034599415*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 4.18042468352388e-5*std::sin(0.37951985001564*x_7 - 1.59695994853973) + 0.000239843011910361*std::sin(0.365359842777252*x_8 - 1.76943981647491) + 0.00070960468428939*std::sin(0.384799838066101*x_8 + 1.81071984767914) - 8.59354515630329e-5*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 4.09288170492146e-5*std::sin(0.401119858026505*x_8 - 1.60423982143402) + 0.000511331140979078*std::sin(0.435199856758118*x_8 + 7.97311973571777) - 0.000154473625423909*std::sin(0.348319828510284*x_9 - 4.58048009872437) + 0.000274907127539328*std::sin(0.351119846105576*x_91 + 1.97359979152679) - 0.000593889662405919*std::sin(0.284399926662445*x_93 + 7.97679996490479) - 0.00609306882257449*std::sin(0.288959950208664*x_94 - 4.41472005844116) - 0.000280825800674756*std::sin(0.314399927854538*x_94 - 7.61816024780273) - 0.000512973760119373*std::sin(0.286799937486649*x_97 - 4.41120004653931) + 0.000747071796848474*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.0631801883012684);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.18957728859814e-5*x_1 + 0.000769487218570782*x_10 - 1.63165904588472e-5*x_100 + 0.000275054577070311*x_101 + 0.000232491247621674*x_102 - 0.000666836984370521*x_103 + 0.000551011105981033*x_104 + 0.000753986812957172*x_105 + 0.000151030826221087*x_106 - 2.68066022882831e-6*x_107 + 0.000134011914406102*x_108 - 0.000382250249466083*x_109 + 1.91329665434469e-5*x_11 + 0.000854413154695761*x_110 - 0.00101343082829163*x_111 - 0.000114578801456974*x_112 - 0.000185002756385915*x_113 - 6.02900729733161e-5*x_114 + 0.000321482588669406*x_115 - 0.000445314305421595*x_116 - 0.000231764929164243*x_117 + 0.000738916374181919*x_118 - 5.0940082843968e-5*x_119 - 0.000287602093525085*x_12 + 1.00577570253298e-5*x_120 - 3.4226609777531e-5*x_13 + 4.87969366873595e-5*x_14 + 0.00076747019759916*x_15 - 7.01755790130401e-5*x_16 - 0.000133434563792329*x_17 + 0.000403578278172924*x_18 - 0.000275144535523244*x_19 + 0.000100720212242896*x_2 + 8.00377378001208e-5*x_20 - 2.46392740225727e-5*x_21 - 0.000676144137368724*x_22 - 0.000178456476394612*x_23 - 0.000315908598853723*x_24 + 0.000471333903511847*x_25 + 0.000528372637776134*x_26 + 0.000286237331098441*x_27 - 5.24331392546189e-5*x_28 - 8.81207214407101e-5*x_29 - 7.558669410383e-5*x_3 - 0.000375604998136132*x_30 - 5.57357256692303e-5*x_31 + 0.000517579947565727*x_32 + 0.000248110856079319*x_33 - 0.000393049320189951*x_34 + 5.86501337080943e-5*x_35 + 0.000299624179446145*x_36 + 9.88935525589833e-5*x_37 - 0.000574030417470625*x_38 - 0.00120707598354922*x_39 - 0.00023755178746698*x_4 + 4.6848747336913e-5*x_40 - 0.000109039850693501*x_41 - 0.00130644582302434*x_42 - 0.000374802752380367*x_43 + 0.000111796484206471*x_44 + 0.000924454260403722*x_45 - 0.000908776917942399*x_46 - 0.000231593955403823*x_47 - 0.000487822776034892*x_48 + 0.000330557742638431*x_49 - 0.000313308872919271*x_5 + 0.000434115834604326*x_50 + 0.000115985038022532*x_51 + 0.00052526153302337*x_52 - 0.000243467542998845*x_53 - 0.00071711846728012*x_54 + 0.000431828682494538*x_55 - 0.000478130449640358*x_56 + 0.000216617576225427*x_57 + 0.000841173369864707*x_58 - 0.00147683895394382*x_59 - 5.81307751152331e-5*x_6 - 0.00096396953988652*x_60 + 2.35457089133201e-5*x_61 - 7.16466217446507e-6*x_62 + 3.07412235649566e-5*x_63 + 2.42883671029376e-5*x_64 - 3.28740919271163e-6*x_65 + 6.28750420786102e-5*x_66 + 1.49713576818294e-5*x_67 - 3.81402329966545e-5*x_68 + 3.62966752726959e-5*x_69 - 0.000236082793100146*x_7 + 8.68510318066624e-5*x_70 - 4.01539904470349e-6*x_71 + 2.92026806221266e-5*x_72 - 2.35199300636255e-5*x_73 + 1.19969086435943e-5*x_74 + 0.000144863895549267*x_75 - 6.86473773447862e-7*x_76 + 1.27707193891536e-5*x_77 - 0.000111596973230683*x_78 - 1.98844570697924e-5*x_79 - 5.91375607293915e-5*x_8 + 1.65037048830086e-5*x_80 + 3.2100492184632e-5*x_81 - 1.65118785916081e-5*x_82 - 4.07281946468412e-5*x_83 - 7.33695250798769e-6*x_84 + 8.70846394284235e-5*x_85 + 0.000243519026197044*x_86 + 9.67527276361356e-5*x_87 + 4.17148599015632e-5*x_88 + 3.18863997378589e-5*x_89 - 0.000135891674073426*x_9 - 3.26401135887304e-5*x_90 - 2.99941003554878e-5*x_91 - 0.000474923250035303*x_92 - 7.50513300776271e-5*x_93 - 5.0119726099431e-5*x_94 + 0.000503671509905004*x_95 - 5.97832956868896e-5*x_96 - 0.000205986476521178*x_97 - 6.22827443832108e-5*x_98 - 8.02111414216788e-5*x_99 - 3.67653305823074e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) - 2.38026587388391e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 2.40622428812932e-7*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 2.49474471882817e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 4.05800557507717e-10*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.00385288391874371*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 8.41296036443529e-5*std::sin(0.260159969329834*x_100 - 7.60351991653442) - 5.76624826088546e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) + 6.43849868721127e-5*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.000621862506300624*std::sin(0.242719978094101*x_103 - 4.42375993728638) + 0.00332944249931285*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 5.23126579044008e-5*std::sin(0.273679971694946*x_108 - 7.62088012695313) + 0.00014499039797262*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 0.000898822250820028*std::sin(0.278079956769943*x_109 + 1.58247983455658) + 0.000169171745360836*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.000779015321934087*std::sin(0.236399978399277*x_111 - 4.42143964767456) + 0.00317112994781835*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 0.000719347621836252*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.00230714906448543*std::sin(0.335439831018448*x_113 + 8.03087997436523) + 0.0017131506478935*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.00073547563675305*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.00367144279990396*std::sin(0.304879933595657*x_116 + 1.7325599193573) + 0.00315098422987994*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.000469763901011602*std::sin(0.277439951896667*x_119 - 7.63727998733521) + 0.000242742021878778*std::sin(0.307279914617538*x_119 - 1.63255989551544) - 6.31849054708146e-5*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.00124769450023894*std::sin(0.363919854164124*x_12 - 1.37199985980988) + 0.000109878249395402*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 0.000337601918392733*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 3.0161046992973e-5*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.00414746463201562*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 6.81725018369864e-7*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 0.00269777886456394*std::sin(0.222079992294312*x_15 - 1.59383988380432) - 0.00253730344554995*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.00510055153270955*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.00122290716166282*std::sin(0.386159837245941*x_16 - 7.57615995407104) - 4.10888172229642e-5*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 4.32654334163484e-5*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 3.18012149889133e-5*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.00128899687215585*std::sin(0.33943983912468*x_20 + 1.81687986850739) - 9.59657861244336e-5*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 0.000176835642654998*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.000358373874736512*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.000363509232295802*std::sin(0.428079843521118*x_23 - 4.39831972122192) + 1.97128664266695e-5*std::sin(0.431919872760773*x_23 - 7.80887985229492) + 1.78600150828434e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) - 0.00262668999078893*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 9.79184162508485e-5*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 0.00132822130880295*std::sin(0.385359823703766*x_26 - 7.57872009277344) - 2.70965547007564e-5*std::sin(0.411839872598648*x_26 + 4.99191999435425) + 0.00550286737500489*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 2.4964022025549e-5*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.000544446443553008*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.000970299830641503*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.000109069268085552*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 0.00155879349203767*std::sin(0.368239849805832*x_29 - 4.39232015609741) + 0.00434145212638086*std::sin(0.194879993796349*x_3 - 4.60231971740723) + 6.05973017269098e-5*std::sin(0.326319932937622*x_3 + 8.03744029998779) + 4.54196339633188e-5*std::sin(0.316399931907654*x_31 - 4.54760026931763) + 0.00221594168009838*std::sin(0.296879917383194*x_32 - 1.34903991222382) - 0.00253796562049513*std::sin(0.26335996389389*x_33 + 4.99463987350464) + 0.000109064324432144*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 5.81582726755562e-5*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.00500324377795993*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 9.51604687163732e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.00184890955535817*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 2.9396084535024e-6*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 7.855150833391e-5*std::sin(0.267279952764511*x_48 + 4.96471977233887) + 0.00021644673786526*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 0.000617083694755207*std::sin(0.498079866170883*x_5 - 4.62080001831055) - 0.000182628828138373*std::sin(0.224639996886253*x_51 - 4.40959978103638) + 6.0527355309257e-5*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.000141539987596783*std::sin(0.252559989690781*x_54 + 4.95887994766235) - 0.000353104116160754*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.00527846509492768*std::sin(0.277679949998856*x_58 - 7.65583992004395) - 7.55836345419805e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 3.27790778759042e-5*std::sin(0.417759865522385*x_6 - 1.19479990005493) - 0.000162660383270773*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 0.00108239934928924*std::sin(0.353279858827591*x_60 - 4.75863981246948) + 3.90311438173581e-5*std::sin(0.424159854650497*x_60 + 4.95928001403809) + 0.00222895729900282*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.000684022122710392*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 0.00031044962045948*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 3.18728192162215e-5*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.000556782356559895*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 0.000177806547899417*std::sin(0.361119836568832*x_7 + 8.21175956726074) + 6.79310036124403e-5*std::sin(0.372319847345352*x_7 + 7.99711990356445) + 0.000130352495280399*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 5.96296863517104e-5*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.000211417289951166*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 2.64767727510697e-5*std::sin(0.384799838066101*x_8 + 1.81071984767914) + 0.000427072858252864*std::sin(0.39031982421875*x_8 - 4.58975982666016) + 0.000127622761684174*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.00243856307211321*std::sin(0.435199856758118*x_8 + 7.97311973571777) + 3.4764894975925e-5*std::sin(0.451999872922897*x_8 - 1.62583994865417) + 3.88288926340379e-5*std::sin(0.348319828510284*x_9 - 4.58048009872437) - 6.91013712552135e-5*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 2.21592134027097e-5*std::sin(0.284399926662445*x_93 + 7.97679996490479) - 0.00396347668871735*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.000906595566655451*std::sin(0.314399927854538*x_94 - 7.61816024780273) + 0.00165604348182174*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 2.78747458011758e-5*std::sin(0.308079928159714*x_98 + 7.96912002563477) - 0.175964862108231*std::sin(-0.00167848092765039*x_1 - 0.00539281184962139*x_100 - 0.00238025143826418*x_101 + 0.0241804000652666*x_102 - 0.00382025917769491*x_103 + 0.0250229252954811*x_104 - 0.00953144741216905*x_105 + 0.000559169457524839*x_106 - 0.00422371977249637*x_107 + 0.0108085856370029*x_108 - 0.00366290294023942*x_109 + 0.035892000934932*x_11 - 0.00477989123680192*x_111 - 0.000329050529234895*x_113 - 0.032481049730472*x_115 + 0.000389850533774032*x_116 + 0.027054468634352*x_117 - 0.0347052477489345*x_118 + 0.00236024958396575*x_119 + 1.06079145974406e-5*x_120 - 0.0082837513348167*x_13 - 0.00646626090575215*x_14 + 0.0337213268414658*x_15 + 0.00476838700341633*x_16 - 0.0082445645238313*x_17 - 0.028497629411418*x_18 - 0.00375412237866548*x_2 - 0.000483192064388416*x_20 - 0.00683148551885646*x_22 - 0.00466343481375509*x_24 - 0.0161066662432718*x_25 + 0.028357468979464*x_26 + 0.0226191320829715*x_27 + 0.00785647267328864*x_28 - 0.00366084782248369*x_29 - 0.0026733286500452*x_3 - 0.000561906927509791*x_30 - 0.000371727588954965*x_31 + 0.00280918753298029*x_32 - 0.00533788323902528*x_34 - 0.006520950964485*x_35 + 0.000423015233917269*x_36 - 0.0215075450017456*x_37 + 0.0474845649344647*x_38 - 0.0499735881392609*x_39 + 0.000503122414539874*x_40 + 0.00974853689682437*x_41 + 0.0100754811652396*x_42 + 0.0168780901099053*x_43 - 0.0069633225458916*x_44 - 0.0509163213044396*x_45 - 0.00524608894250342*x_46 - 0.00777860372795189*x_47 - 0.0072296776902214*x_50 + 0.0154534950713847*x_51 - 0.00439985586218765*x_52 - 0.0454254394208061*x_54 + 0.00677602778618883*x_55 - 0.0505530924179746*x_56 - 0.055323996547691*x_58 + 0.005613859155368*x_59 - 0.00808969924296859*x_60 + 0.000731814062459208*x_61 + 0.00214033469190607*x_62 + 0.000980342554109325*x_63 + 0.00124402545530167*x_64 - 8.65261100634634e-5*x_65 + 0.000291353771709461*x_66 + 0.00184787573508846*x_67 - 6.65093905975517e-6*x_68 + 0.000909420612349112*x_69 - 0.0054554070288818*x_7 + 0.0027041461758946*x_70 + 0.0081940210233293*x_71 + 0.00159550159486002*x_72 + 0.00257170372850639*x_73 + 0.00163852841856006*x_74 + 0.0018821993775054*x_75 + 0.000561970073593267*x_76 + 0.00176408215882624*x_77 + 0.00091814894807699*x_78 + 0.0020458575804922*x_79 - 0.00238813021392567*x_8 + 0.00118787155467372*x_80 + 0.00192705122346096*x_81 + 0.00108761880504017*x_82 + 0.00119291198622151*x_83 + 0.00241813666858707*x_84 + 0.00290911793207159*x_85 + 0.00170248797001823*x_86 + 0.00131975293197404*x_87 + 0.00256796533518799*x_88 + 0.00187261987308915*x_89 + 0.00513589895295385*x_90 - 0.00589799251942205*x_92 + 0.00168419200079887*x_93 - 0.013635975282751*x_94 + 0.00221728328837506*x_97 + 0.0261620689551526*x_99 + 0.133021192879438*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.0545301021848985*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 0.217395221878929*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 0.269970920888019*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.0394516946483525*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.217933413374007*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 0.282424915757424*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.213622347003541*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.0461589837967655*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.121484018788417*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.343933669855975*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 0.316281986484695*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.232566691611883*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.119044876960775*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.0969612677720022*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 0.182809978098634*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.0387456567461966*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.0211338208467335*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 0.28192034878832*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.167596343329556*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.162003214993148*std::sin(0.319359838962555*x_98 - 4.56112003326416) - 1.24129285704757) - 0.151969601322615);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000103245093620124*x_1 - 0.00132940490652261*x_10 - 0.000167260420717311*x_100 - 0.000557258394495412*x_101 - 0.000251614862687265*x_102 + 0.000864536284101735*x_103 - 0.00101764006076755*x_104 - 0.000722518702121252*x_105 - 0.00027241748733373*x_106 + 7.46940110305051e-5*x_107 - 0.000332948744270857*x_108 + 0.000550740033777989*x_109 + 0.000216191863790487*x_11 - 0.00154018562242312*x_110 + 0.00112228192357787*x_111 + 4.02507204178772e-5*x_112 - 6.31559049140705e-5*x_113 + 2.2785193009267e-5*x_114 - 0.00121809450978148*x_115 + 0.000245078202754189*x_116 + 0.000144965580885978*x_117 - 0.000763581655052709*x_118 + 4.78508239284122e-5*x_119 - 0.000125865579531039*x_12 - 5.73622246872132e-5*x_120 + 8.2126514532304e-5*x_13 + 0.000537329042196181*x_14 - 0.000715439673375381*x_15 - 0.000150387208120387*x_16 + 0.000340501594765052*x_17 - 0.000114551484459393*x_18 + 0.000249223157261018*x_19 - 9.10956396726753e-5*x_2 + 0.000221198125245068*x_20 - 0.000133966723724218*x_21 + 0.00085567850962441*x_22 + 8.82121619432157e-5*x_23 + 0.000164366370170792*x_24 - 0.000871918872855792*x_25 - 0.000457697155005081*x_26 - 0.000403923953098099*x_27 + 0.000182032555768533*x_28 + 0.00020377258297094*x_29 + 0.000105542690673006*x_3 + 0.000357346610008052*x_30 + 5.26370691645538e-5*x_31 - 0.000884087702555252*x_32 - 5.26454971135482e-5*x_33 + 0.000480363715123968*x_34 - 0.000556533681939778*x_35 - 0.000686608884121088*x_36 - 0.000171196064954483*x_37 + 0.000679536778958587*x_38 + 0.00214850778346924*x_39 + 1.0008551918548e-5*x_4 + 0.000596844885304523*x_40 + 0.000781951307886256*x_41 + 0.000804862383447851*x_42 + 0.000182579894076218*x_43 - 0.000317215127747609*x_44 - 0.00191188586425393*x_45 + 0.00242953977574657*x_46 + 9.4222996379069e-5*x_47 + 0.0012319094004799*x_48 - 0.00113250553911499*x_49 + 0.000377436477146523*x_5 - 0.00141570973429294*x_50 - 0.000407745577136744*x_51 - 0.000699900316215055*x_52 + 0.000459438450649066*x_53 + 0.00183383105854134*x_54 - 0.000898603637196666*x_55 - 0.000232434418893018*x_56 - 0.000950917698728407*x_57 - 0.000517986493435216*x_58 + 0.00150939844426011*x_59 + 0.000179072036858815*x_6 + 0.00129781413635095*x_60 - 3.48934558678633e-5*x_61 - 6.08685946288369e-6*x_62 - 1.20934587552316e-5*x_63 - 1.3425992948724e-6*x_64 + 6.9066969803261e-6*x_65 - 2.41323793820729e-5*x_66 - 6.06107724313615e-5*x_67 + 6.35495296663467e-5*x_68 - 6.81258780141005e-5*x_69 + 0.000398498369403013*x_7 - 4.62685282767836e-5*x_70 + 2.1520432484705e-5*x_71 + 2.6268205249915e-5*x_72 + 9.18721926989673e-6*x_73 + 1.61823081245724e-5*x_74 - 0.000227914232752677*x_75 - 1.3098674075504e-5*x_76 - 2.86525846754476e-5*x_77 + 0.000185088717056352*x_78 + 3.37297467313316e-6*x_79 - 4.62332967555484e-5*x_8 - 2.95255052094683e-6*x_80 + 6.28426040992641e-6*x_81 + 1.94445477282626e-5*x_82 + 9.99001326295794e-5*x_83 - 6.13354749497709e-6*x_84 + 3.23236055759334e-5*x_85 - 0.000386978650385699*x_86 - 0.000113812028490322*x_87 + 3.72500039181505e-5*x_88 - 1.81849345938234e-5*x_89 + 0.000152255016934032*x_9 + 2.46122306959605e-5*x_90 + 3.37101098274625e-6*x_91 + 0.00039874995562721*x_92 - 0.000293641051030332*x_93 - 4.43136920660339e-5*x_94 - 0.000595158775649683*x_95 - 4.95423196611137e-5*x_96 + 0.000310847184706861*x_97 + 0.000106686234965116*x_98 - 0.000371774360924453*x_99 + 3.25429980096368e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) - 3.77559709229379e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) - 4.06263102263198e-7*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) - 3.95582021280917e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 2.24492908704216e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.000795351923443377*std::pow(0.0105552840998203*x_1 + 0.0339132010569307*x_100 + 0.0149684335079424*x_101 - 0.152060704492774*x_102 + 0.0240240566879499*x_103 - 0.157359003102952*x_104 + 0.0599393973804491*x_105 - 0.00351638936545989*x_106 + 0.0265612563254658*x_107 - 0.0679708004043321*x_108 + 0.0230345072901223*x_109 - 0.225710200538027*x_11 + 0.0300587925305247*x_111 + 0.00206926498958347*x_113 + 0.204260115273073*x_115 - 0.00245161149743407*x_116 - 0.170134553155163*x_117 + 0.2182471922737*x_118 - 0.0148426499788208*x_119 - 6.6708861827436e-5*x_120 + 0.0520931440511836*x_13 + 0.0406636857168935*x_14 - 0.212059713739391*x_15 - 0.0299864470842732*x_16 + 0.0518467141298762*x_17 + 0.179210004506865*x_18 + 0.0236081492494391*x_2 + 0.00303859843170093*x_20 + 0.0429604348118978*x_22 + 0.0293264454360428*x_24 + 0.10128827518863*x_25 - 0.178328592538187*x_26 - 0.142242524948639*x_27 - 0.0494061622762205*x_28 + 0.0230215834901476*x_29 + 0.0168114769304627*x_3 + 0.00353360420116634*x_30 + 0.00233764366608171*x_31 - 0.0176658382063287*x_32 + 0.0335677773583356*x_34 + 0.0410076092598135*x_35 - 0.00266017081218736*x_36 + 0.135252205755406*x_37 - 0.298611122106261*x_38 + 0.314263577028371*x_39 - 0.00316393230031511*x_40 - 0.0613045848829535*x_41 - 0.0633606044546278*x_42 - 0.106139446232377*x_43 + 0.0437895042712569*x_44 + 0.320192042597958*x_45 + 0.0329905203501862*x_46 + 0.0489164761397606*x_47 + 0.0454645034765116*x_50 - 0.0971807472617374*x_51 + 0.0276689045782972*x_52 + 0.285662118971456*x_54 - 0.0426116836797309*x_55 + 0.317907843816345*x_56 + 0.347910120084481*x_58 - 0.0353032776870664*x_59 + 0.0508728293452617*x_60 - 0.00460208109025921*x_61 - 0.0134596946379337*x_62 - 0.00616497572495666*x_63 - 0.00782317027962826*x_64 + 0.000544127525506451*x_65 - 0.00183220540864442*x_66 - 0.0116205391695017*x_67 + 4.18250515390605e-5*x_68 - 0.00571897646940487*x_69 + 0.0343068366887027*x_7 - 0.0170052758204205*x_70 - 0.0515288666057194*x_71 - 0.0100334608144989*x_72 - 0.0161723991186191*x_73 - 0.0103040390144565*x_74 - 0.0118363866009996*x_75 - 0.00353400130121073*x_76 - 0.0110935954380494*x_77 - 0.00577386542394029*x_78 - 0.0128655664977351*x_79 + 0.0150179799246432*x_8 - 0.00747004123021409*x_80 - 0.0121184416238857*x_81 - 0.00683959244957076*x_82 - 0.00750173845482719*x_83 - 0.0152066783176734*x_84 - 0.0182942598554765*x_85 - 0.0107062546282396*x_86 - 0.00829938959035846*x_87 - 0.0161488898830344*x_88 - 0.01177614499266*x_89 - 0.032297580308097*x_90 + 0.0370900768877142*x_92 - 0.0105911987167838*x_93 + 0.0857511042970541*x_94 - 0.0139435930745693*x_97 - 0.16452261441379*x_99 - 0.836516196883423*std::sin(0.447439849376678*x_10 - 1.43487977981567) - 0.342917641226677*std::sin(0.273279964923859*x_110 + 1.57231986522675) + 1.36711015959398*std::sin(0.297439932823181*x_112 - 1.4184798002243) + 1.69773735388949*std::sin(0.239839985966682*x_114 + 8.16464042663574) - 0.248095666964563*std::sin(0.269519954919815*x_12 - 4.24232006072998) - 1.37049462708305*std::sin(0.331279844045639*x_19 - 7.56640005111694) - 1.77605546394886*std::sin(0.303759932518005*x_21 + 1.98103988170624) - 1.34338408351724*std::sin(0.200719982385635*x_23 - 1.610879778862) + 0.290275081299789*std::sin(0.277759939432144*x_33 - 7.6113600730896) - 0.763963599928815*std::sin(0.305199921131134*x_4 - 4.57615995407104) - 2.16285900960787*std::sin(0.240399971604347*x_48 - 7.60304021835327) + 1.98896881579392*std::sin(0.267439961433411*x_49 + 8.15312004089355) - 1.46251736417111*std::sin(0.318559914827347*x_5 + 8.2260799407959) - 0.74862482870634*std::sin(0.31279993057251*x_53 - 4.63367986679077) + 0.60974998950087*std::sin(0.320719927549362*x_57 + 1.70343995094299) - 1.14961762348659*std::sin(0.343759834766388*x_6 - 7.58983993530273) - 0.243655681666112*std::sin(0.312319934368134*x_9 + 8.1758394241333) + 0.132902006497176*std::sin(0.295199930667877*x_91 + 5.05583953857422) + 1.77288244743224*std::sin(0.278079956769943*x_95 + 4.98383951187134) + 1.05394526014118*std::sin(0.305199921131134*x_96 - 4.61279964447021) - 1.0187723501456*std::sin(0.319359838962555*x_98 - 4.56112003326416) - 2.29724689434334, 2) - 0.00403664516745928*std::sin(0.213359996676445*x_10 - 1.37991976737976) + 0.000353469324789896*std::sin(0.260159969329834*x_100 - 7.60351991653442) - 1.15075500164014e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.000848784111472094*std::sin(0.267839968204498*x_102 + 7.99520015716553) - 0.000550444399228326*std::sin(0.242719978094101*x_103 - 4.42375993728638) - 0.00485523158168635*std::sin(0.307439923286438*x_107 + 1.73607993125916) - 0.000219790882952466*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.00191140127681659*std::sin(0.273919969797134*x_109 + 4.94927978515625) - 8.52781786102552e-6*std::sin(0.278079956769943*x_109 + 1.58247983455658) + 0.000268341598680496*std::sin(0.274239957332611*x_110 + 4.75271987915039) - 0.000689548922031929*std::sin(0.236399978399277*x_111 - 4.42143964767456) - 0.00462436887720893*std::sin(0.253679990768433*x_111 + 1.77215993404388) - 4.75969288924466e-5*std::sin(0.306399941444397*x_111 - 8.07583999633789) + 0.00241718731168002*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.00249823900894988*std::sin(0.298879951238632*x_114 - 7.8452000617981) - 0.00124176543018186*std::sin(0.257839977741241*x_115 + 4.76639986038208) - 0.00582166484948199*std::sin(0.304879933595657*x_116 + 1.7325599193573) - 0.00459499094802394*std::sin(0.258879989385605*x_117 + 8.17216014862061) + 0.000415813633482644*std::sin(0.277439951896667*x_119 - 7.63727998733521) + 4.84433869557932e-5*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000832963497453515*std::sin(0.305439919233322*x_12 - 1.25543987751007) + 0.00210658765620673*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.00144851955112506*std::sin(0.338559836149216*x_13 - 1.31959986686707) + 3.20308900559527e-6*std::sin(0.322799921035767*x_14 + 4.77503967285156) - 0.000126721206968126*std::sin(0.345839858055115*x_14 + 4.82800006866455) + 0.0065764742578331*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 0.000377137067652687*std::sin(0.404239863157272*x_14 - 7.99567985534668) + 0.000178503389580156*std::sin(0.222079992294312*x_15 - 1.59383988380432) + 0.00370007766276133*std::sin(0.401519864797592*x_15 - 1.37799990177155) + 0.00808774729425811*std::sin(0.202719986438751*x_16 - 7.60552024841309) + 0.00206473710587997*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 0.000541671854143667*std::sin(0.437599837779999*x_16 + 4.97447967529297) + 0.000181779098842164*std::sin(0.331759840250015*x_19 + 4.80807971954346) - 0.000133612349312239*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.00155873923197579*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.00126511223290517*std::sin(0.385999828577042*x_20 - 4.40111970901489) + 0.000156526865821895*std::sin(0.411519855260849*x_20 + 4.79256010055542) - 3.40016852844343e-6*std::sin(0.333439826965332*x_23 + 1.60327982902527) - 0.000321761834742748*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 0.000259873747396475*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 0.000235447699369422*std::sin(0.423679858446121*x_24 - 1.60191988945007) + 0.00383042752689374*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 0.000599220373470917*std::sin(0.276479959487915*x_26 + 7.99839973449707) + 1.26018569191746e-5*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 0.000357212546324183*std::sin(0.411839872598648*x_26 + 4.99191999435425) - 0.0080246754447537*std::sin(0.239119976758957*x_28 + 1.82159984111786) - 0.000104885981000377*std::sin(0.348879843950272*x_28 + 5.00719976425171) - 0.000481919222492339*std::sin(0.399279862642288*x_28 + 8.19672012329102) - 0.00163823888432418*std::sin(0.438639879226685*x_28 + 8.16016006469727) - 0.000458252967748483*std::sin(0.192239999771118*x_29 + 1.77327990531921) - 1.47894725246525e-5*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.0063310165226563*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 0.000798851244717102*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 0.000598764797972511*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.00323144491325777*std::sin(0.296879917383194*x_32 - 1.34903991222382) + 0.00370104329370618*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.00143778961841394*std::sin(0.290559947490692*x_36 + 4.96271991729736) + 0.000244351149691353*std::sin(0.253279983997345*x_38 - 1.40319991111755) - 0.00793345015106888*std::sin(0.266479969024658*x_40 + 1.7739999294281) + 0.000160667429982554*std::sin(0.284799933433533*x_41 - 1.61207985877991) + 0.00312166964430338*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 0.00162622066423777*std::sin(0.268079966306686*x_44 - 7.61872005462646) + 0.000330033037233723*std::sin(0.267279952764511*x_48 + 4.96471977233887) + 0.000343329576366649*std::sin(0.36847984790802*x_5 - 7.57728004455566) - 5.85474753109418e-6*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.00240758684828993*std::sin(0.224639996886253*x_51 - 4.40959978103638) + 0.000370402482416637*std::sin(0.247039973735809*x_52 + 1.59447979927063) - 0.00186591468673797*std::sin(0.252559989690781*x_54 + 4.95887994766235) - 7.04680598870559e-5*std::sin(0.313039928674698*x_57 + 1.52575981616974) + 0.00836985794880475*std::sin(0.277679949998856*x_58 - 7.65583992004395) - 0.000119891375973076*std::sin(0.346799850463867*x_58 - 4.76103973388672) + 0.000137720826226774*std::sin(0.417759865522385*x_6 - 1.19479990005493) - 0.000258013223164194*std::sin(0.252239972352982*x_60 + 1.5759197473526) - 7.16188992601939e-5*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 0.000514545646962073*std::sin(0.424159854650497*x_60 + 4.95928001403809) - 0.00233526623154185*std::sin(0.425279855728149*x_60 - 7.63568019866943) - 0.00115489213104496*std::sin(0.428239852190018*x_60 + 4.95824003219604) - 2.94547427579543e-6*std::sin(0.301919937133789*x_7 + 7.77184009552002) - 0.000133913193447744*std::sin(0.338479846715927*x_7 - 4.58527994155884) + 0.000492838411469342*std::sin(0.339999854564667*x_7 + 5.0099196434021) - 0.000281940966080378*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000895531075545916*std::sin(0.372319847345352*x_7 + 7.99711990356445) + 0.000206766188413588*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 0.000364909118159026*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.000255659599556452*std::sin(0.365359842777252*x_8 - 1.76943981647491) + 0.000111241781507719*std::sin(0.384799838066101*x_8 + 1.81071984767914) + 8.52298072271635e-5*std::sin(0.39031982421875*x_8 - 4.58975982666016) + 0.000202436262777244*std::sin(0.401119858026505*x_8 - 1.60423982143402) + 0.00386673514851918*std::sin(0.435199856758118*x_8 + 7.97311973571777) + 0.000212746837099405*std::sin(0.451999872922897*x_8 - 1.62583994865417) - 0.00051187937957167*std::sin(0.348319828510284*x_9 - 4.58048009872437) + 0.000910959974549034*std::sin(0.351119846105576*x_91 + 1.97359979152679) - 9.31016177425764e-5*std::sin(0.284399926662445*x_93 + 7.97679996490479) + 0.00415251260075988*std::sin(0.288959950208664*x_94 - 4.41472005844116) - 0.00153068161278452*std::sin(0.314399927854538*x_94 - 7.61816024780273) - 0.00279603761680378*std::sin(0.286799937486649*x_97 - 4.41120004653931) + 0.000117115345255676*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.130288016950591);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.23273018616114e-5*x_1 + 0.000340896077426333*x_10 - 0.000405463171682269*x_100 + 0.000467646931636146*x_101 - 0.000484892195049026*x_102 - 0.000615349958270731*x_103 + 0.000528494332434798*x_104 - 0.000147933698918534*x_105 + 0.000257216889723889*x_106 - 0.000112715008369249*x_107 - 0.000204784765717242*x_108 - 0.000270789981057196*x_109 - 3.4683434368606e-5*x_11 + 0.000176763752556621*x_110 - 0.00112098662249137*x_111 + 0.000202203079887115*x_112 - 0.000326324584243342*x_113 - 4.83249301256101e-5*x_114 - 0.000738691764770497*x_115 - 0.000311971133946134*x_116 - 0.00016254498688867*x_117 - 0.000445938342180452*x_118 + 4.50245803653113e-5*x_119 - 0.000744830298490915*x_12 - 0.000252687575687758*x_120 - 3.1671828740776e-5*x_13 - 7.053370331221e-5*x_14 + 3.30664505747847e-5*x_15 - 0.000255508468728792*x_16 - 0.000124036111829883*x_17 + 8.46856252364733e-5*x_18 + 2.28534531174449e-5*x_19 - 5.98379574484726e-5*x_2 - 0.000138869469371563*x_20 - 7.03644398738499e-5*x_21 - 0.000193141263911314*x_22 - 0.00019551447399455*x_23 - 0.000367980531183002*x_24 + 0.00026304001219229*x_25 + 0.000635087507055205*x_26 + 1.77751284619032e-5*x_27 - 0.000160697712848825*x_28 - 6.59941333538903e-6*x_29 - 8.5194342689701e-5*x_3 - 0.000266645913731557*x_30 - 3.31813721026345e-5*x_31 + 0.000421899292812831*x_32 + 4.98546654708064e-6*x_33 - 0.000387334425580623*x_34 + 0.000404459959943349*x_35 - 0.00038804400180505*x_36 - 0.000377593151507164*x_37 - 0.000411073137341163*x_38 - 0.001139101646007*x_39 - 0.000239623307452415*x_4 + 0.000289314594283067*x_40 + 0.00025182978736283*x_41 - 0.000670477026406567*x_42 - 0.000113833707423941*x_43 + 0.000181767955942555*x_44 - 6.65959361094518e-5*x_45 - 0.00046870155454631*x_46 - 0.000629788287048321*x_47 - 0.000730830652153766*x_48 + 0.00051306652458105*x_49 - 0.000181105880916164*x_5 - 0.000440581629482688*x_50 - 0.000197184438062334*x_51 - 0.000292687406591898*x_52 - 0.000612667463765119*x_53 - 7.59542903968816e-6*x_54 + 0.000754285952744018*x_55 - 8.52600749296368e-5*x_56 + 2.63882144999898e-5*x_57 + 0.000173882746453217*x_58 - 0.000748082793438884*x_59 - 6.74288550779329e-5*x_6 - 0.000202381437513165*x_60 + 9.46143542891668e-6*x_61 + 3.35835356205326e-6*x_62 + 4.37510190832224e-6*x_63 + 1.43065466449749e-5*x_64 + 1.89310966224663e-5*x_65 + 3.826938531473e-5*x_66 - 1.71276439111493e-6*x_67 - 3.53406958992542e-5*x_68 - 8.01791084422373e-7*x_69 - 7.99948342858315e-5*x_7 + 7.81423926062868e-5*x_70 - 4.46534655078458e-6*x_71 + 3.19091059702413e-5*x_72 - 8.93738691982862e-6*x_73 - 1.27192661697321e-5*x_74 + 9.99357204877601e-5*x_75 + 1.13231237794114e-5*x_76 + 5.77601765175997e-6*x_77 - 0.000100149011301086*x_78 + 6.66236816027492e-7*x_79 - 9.3605787360436e-5*x_8 + 1.29784025233389e-5*x_80 + 1.71046165533269e-5*x_81 - 1.29095449446752e-6*x_82 + 0.000109514685151545*x_83 + 3.49385439812075e-5*x_84 + 4.57901270722099e-5*x_85 + 0.000169059531394227*x_86 + 4.69355931517546e-5*x_87 + 7.6609259265375e-5*x_88 + 2.42112169044746e-5*x_89 - 0.000199917206751974*x_9 + 1.40236105044756e-5*x_90 - 1.89653186839572e-5*x_91 - 0.000307466219563547*x_92 + 6.4196069993852e-5*x_93 + 0.000170492877534916*x_94 - 0.000470563864443784*x_95 + 9.31564174187809e-5*x_96 - 0.00027449084051704*x_97 - 0.000219781011667379*x_98 - 0.00016892427098151*x_99 + 1.3803382875947e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 3.95089630551018e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 6.68106385138072e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 1.96175765138922e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 4.52594229028788e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.000190124422530883*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 0.00393749256183279*std::sin(0.260159969329834*x_100 - 7.60351991653442) + 7.25028091190202e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.000145620217491813*std::sin(0.267839968204498*x_102 + 7.99520015716553) - 0.00023347556338292*std::sin(0.242719978094101*x_103 - 4.42375993728638) + 0.00244837361006761*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.000327926342967733*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 0.00144486602242171*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 0.000280800574035132*std::sin(0.274239957332611*x_110 + 4.75271987915039) - 0.000292477901995529*std::sin(0.236399978399277*x_111 - 4.42143964767456) + 0.000452557577685372*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.000113848585326958*std::sin(0.335439831018448*x_113 + 8.03087997436523) + 0.000204210377001146*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.00288706132935823*std::sin(0.304879933595657*x_116 + 1.7325599193573) + 0.000176370805981058*std::sin(0.277439951896667*x_119 - 7.63727998733521) - 0.000305215413578802*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000142905980475472*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.000346431821182953*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.000248512818778075*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 0.000542698559748623*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 0.00141161842024073*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.00326138398623191*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 0.000760336089712929*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 0.00169723264666018*std::sin(0.222079992294312*x_15 - 1.59383988380432) - 0.00401084965530984*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.000339549429024008*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 9.29310199654787e-5*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 0.00202493908067733*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 0.00148838271015077*std::sin(0.269519954919815*x_20 - 1.38383984565735) - 0.000151543585446424*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.000217046850921479*std::sin(0.385999828577042*x_20 - 4.40111970901489) + 6.6392170096676e-5*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.000576089693438263*std::sin(0.333439826965332*x_23 + 1.60327982902527) - 0.000136477954443722*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 4.45848020772373e-5*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 4.0394188259083e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) - 0.000451115296303207*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 0.00213512942920027*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 6.12845692838373e-5*std::sin(0.411839872598648*x_26 + 4.99191999435425) + 0.00116838362218561*std::sin(0.348879843950272*x_28 + 5.00719976425171) - 0.000204410040567577*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.000269411091704158*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.00510473618331656*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 0.00250577658770964*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.000137053569249257*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 0.000102726074780047*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.000246671955932096*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.00272196416183184*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.00393433111175752*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 2.64220243623124e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.000513363731540558*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 0.00327858056635154*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 0.00367642264300954*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.000359270208573892*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 0.000991968392781559*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.000413053585405073*std::sin(0.224639996886253*x_51 - 4.40959978103638) - 0.000278852710963331*std::sin(0.247039973735809*x_52 + 1.59447979927063) - 0.000320122512699608*std::sin(0.252559989690781*x_54 + 4.95887994766235) + 0.000443980889737345*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.00415075306479828*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 0.000125457876678993*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 0.00153414933304246*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 0.000269992656857589*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 0.000680961488900382*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 8.82771578866271e-5*std::sin(0.424159854650497*x_60 + 4.95928001403809) + 0.000109990134210191*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.00018992391940063*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 0.000499050961262231*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 0.0014917339812873*std::sin(0.338479846715927*x_7 - 4.58527994155884) + 0.000209041505256225*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 0.000139819258129397*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000153640281703083*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 0.000216366246169389*std::sin(0.37951985001564*x_7 - 1.59695994853973) + 0.000274717102839029*std::sin(0.396159827709198*x_7 - 7.5840802192688) + 2.48557113183531e-5*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 0.00123918443987192*std::sin(0.384799838066101*x_8 + 1.81071984767914) - 0.000536986624940547*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 0.000211835284103897*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.00191757887250299*std::sin(0.435199856758118*x_8 + 7.97311973571777) - 0.000160163700542679*std::sin(0.451999872922897*x_8 - 1.62583994865417) - 8.7819724209401e-5*std::sin(0.348319828510284*x_9 - 4.58048009872437) + 0.000156287314792093*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 0.0010371110069421*std::sin(0.284399926662445*x_93 + 7.97679996490479) - 0.000195581733721869*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.000251723120661902*std::sin(0.314399927854538*x_94 - 7.61816024780273) + 0.00045981300651385*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 0.00130461335250183*std::sin(0.308079928159714*x_98 + 7.96912002563477) - 0.0385672077536583*std::sin(-0.00333544962537539*x_1 + 0.000927796954396478*x_10 + 0.00142900712493614*x_100 + 0.000740774722994323*x_101 + 0.0138642221686084*x_102 + 0.000372973107733261*x_103 + 0.0032426371250766*x_104 + 0.000141345095881659*x_105 + 0.031624156695123*x_106 + 0.0043362646482789*x_108 - 0.000715631029415286*x_109 - 0.000967114477054815*x_11 - 0.0209134388954137*x_110 - 0.00320216066610323*x_112 + 7.06918872782079e-5*x_113 + 0.015934925555009*x_115 - 0.00374510025239202*x_116 + 0.0359357494455573*x_118 + 0.000646907909249029*x_119 - 0.000846826333164788*x_12 + 0.00198658411034552*x_120 + 0.000834484534940932*x_13 - 0.0746205197090183*x_14 + 0.00440158756356299*x_16 + 0.00145199332033346*x_17 + 0.000534740217921817*x_18 - 0.0216672709699*x_19 + 0.00526305055232109*x_2 - 0.0221248078329566*x_20 + 0.00324238191911509*x_21 - 0.0539077753200744*x_22 - 9.79156499608432e-5*x_23 - 0.00194339589372037*x_24 - 0.00135507559394312*x_26 - 0.00410537646237764*x_27 + 0.000501612708755099*x_29 - 0.00240729338946862*x_30 - 0.000923419069972578*x_31 + 0.00162110979966705*x_34 - 0.0416896472298273*x_35 - 0.0379608663698386*x_36 + 0.000412009809380583*x_37 + 0.0133565914530855*x_38 + 0.000796989895742299*x_39 + 0.000932209863437522*x_4 - 0.00322795519285895*x_40 - 0.0626693023619675*x_41 - 0.0541993921188791*x_42 + 0.0104481992381996*x_43 + 0.00111635451168266*x_44 + 0.00706231244261131*x_45 + 0.00601092871940311*x_46 - 0.00446017616326842*x_47 + 0.00349040351723222*x_48 + 0.011827218998797*x_49 - 0.00193868039656554*x_5 + 0.0187885884568601*x_50 + 0.0502725444994213*x_51 + 0.00908964769543297*x_52 - 0.000702289729477872*x_53 - 0.0638702982968088*x_54 + 0.00272995201092429*x_55 - 0.00909927254474031*x_56 + 0.000923573803675276*x_57 + 0.0338549117898377*x_58 + 0.0235009231206172*x_59 - 0.00208360552675568*x_6 - 0.0379254680462511*x_60 + 3.88413689091243e-5*x_61 - 0.000658839454185349*x_62 + 0.000300699031020117*x_63 - 0.00035144348176409*x_64 - 0.00044214958624095*x_65 + 0.000115277308101492*x_66 - 0.000279347098137635*x_67 - 0.000477036649185095*x_68 + 0.000235039242774774*x_69 - 0.0250744452385421*x_7 - 0.000186977119698292*x_70 - 0.000449105468043885*x_71 - 0.000620644806136495*x_72 - 0.000322205800075346*x_73 + 0.00135326693176335*x_74 - 0.000142316614336181*x_75 - 0.000556702305687493*x_76 + 1.8847133552855e-5*x_77 - 0.000469038924226144*x_78 - 9.88187866620523e-5*x_79 + 0.000138205248012418*x_8 + 0.000209983825641711*x_80 - 0.000632733829035237*x_81 - 0.00118327773259973*x_82 - 0.00579596628667397*x_83 + 0.000981221353236201*x_84 - 0.000551460806551369*x_85 + 0.000107374693417441*x_86 + 1.32113431952094e-5*x_87 - 0.000383283967446641*x_88 - 0.000451100232993421*x_89 - 0.000811326331749914*x_9 - 0.000334850945390524*x_90 - 0.000972914466604275*x_91 + 0.000134003819559797*x_92 + 0.0308213647776041*x_93 + 0.00238848730903401*x_94 + 0.0318513725850618*x_95 + 0.0024355170945699*x_96 - 0.000775089767099245*x_97 + 0.0198645958869169*x_98 - 2.12102885117579e-5*x_99 + 0.307082728194016*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.292481169455483*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 0.158008127448081*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.290623079992388*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.234021781267094*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.24226612373028*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 0.507543087695645*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 0.400422882680179*std::sin(0.194879993796349*x_3 - 4.60231971740723) + 0.204381789679168*std::sin(0.296879917383194*x_32 - 1.34903991222382) - 0.234082855302386*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 9.86531869292841) - 0.0432536564767361*std::sin(-0.0019982969033592*x_1 - 0.00642035249967515*x_100 - 0.00283378202274713*x_101 + 0.028787707847267*x_102 - 0.00454816730953491*x_103 + 0.0297907669412397*x_104 - 0.0113475592927534*x_105 + 0.000665713012890232*x_106 - 0.00502850285814779*x_107 + 0.0128680420803771*x_108 - 0.00436082858149124*x_109 + 0.0427308247249739*x_11 - 0.00569064664337049*x_111 - 0.00039174746807475*x_113 - 0.03866995449577*x_115 + 0.000464132240992522*x_116 + 0.0322093983931851*x_117 - 0.0413179488456213*x_118 + 0.00280996903634523*x_119 + 1.26291353937742e-5*x_120 - 0.00986212852816508*x_13 - 0.00769833540042978*x_14 + 0.0401465526920187*x_15 + 0.00567695040555733*x_16 - 0.0098154751037772*x_17 - 0.033927537494055*x_18 - 0.00446942887496502*x_2 - 0.000575258967849427*x_20 - 0.00813314952394715*x_22 - 0.00555200073699339*x_24 - 0.0191756133460662*x_25 + 0.0337606710420547*x_26 + 0.0269289575195516*x_27 + 0.00935343664365364*x_28 - 0.00435838188377806*x_29 - 0.0031827018556147*x_3 - 0.000668972077502677*x_30 - 0.000442556169489352*x_31 + 0.00334444714600835*x_32 - 0.00635495784987494*x_34 - 0.00776344604494772*x_35 + 0.000503616107925605*x_36 - 0.0256055698148505*x_37 + 0.056532223573567*x_38 - 0.0594955026198747*x_39 + 0.000598986825780036*x_40 + 0.0116060127775635*x_41 + 0.011995252660116*x_42 + 0.0200940234980535*x_43 - 0.00829010663828337*x_44 - 0.0606178631624563*x_45 - 0.00624567316545351*x_46 - 0.00926073063206249*x_47 - 0.00860721280930976*x_50 + 0.0183979876318601*x_51 - 0.00523819973155379*x_52 - 0.0540807544685043*x_54 + 0.0080671249337171*x_55 - 0.0601854250292154*x_56 - 0.0658653721716483*x_58 + 0.00668351792460953*x_59 - 0.00963110195655352*x_60 + 0.000871253137736907*x_61 + 0.00254815179400062*x_62 + 0.00116713598458949*x_63 + 0.00148106074610526*x_64 - 0.000103012703302847*x_65 + 0.000346868010352697*x_66 + 0.00219996801774146*x_67 - 7.91820193402151e-6*x_68 + 0.00108270065126816*x_69 - 0.00649487449800158*x_7 + 0.00321939132015348*x_70 + 0.00975530109829745*x_71 + 0.00189950677650926*x_72 + 0.00306171342931223*x_73 + 0.00195073188556159*x_74 + 0.00224083165057988*x_75 + 0.000669047255373924*x_76 + 0.00210020850233214*x_77 + 0.0010930920748281*x_78 + 0.00243567311398313*x_79 - 0.0028431620119667*x_8 + 0.00141420734081014*x_80 + 0.00229422951969264*x_81 + 0.00129485253859239*x_82 + 0.00142020817083901*x_83 + 0.00287888586467357*x_84 + 0.00346341817735343*x_85 + 0.00202687822211725*x_86 + 0.00157121725586403*x_87 + 0.00305726272649599*x_88 + 0.00222942687755245*x_89 + 0.00611448769216587*x_90 - 0.00702178975849033*x_92 + 0.00200509615832807*x_93 - 0.0162341595504144*x_94 + 0.0026397620944269*x_97 + 0.0311469618256162*x_99 + 0.15836690988454*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.0649202100189967*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 0.258817476880045*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 0.321410893815012*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.0469687787030348*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.259458214811774*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 0.336237859657764*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.254325722427522*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.0549540676118405*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.144631454878878*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.409466426524279*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 0.376546020731615*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.276879702364614*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.141727561554422*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.115436164893339*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 0.217642397431968*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.0461282130878464*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.0251606366557251*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 0.335637153033526*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.199529972830014*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.192871135752621*std::sin(0.319359838962555*x_98 - 4.56112003326416) - 1.16622136937492) - 0.0777559002672619);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-4.97173854497803e-6*x_1 - 0.000245635637875541*x_10 - 1.13590058017696e-5*x_100 - 0.000115672962414677*x_101 + 0.0003785738874391*x_102 + 0.00074337668942348*x_103 - 0.000426381988096341*x_104 - 0.000471556542002853*x_105 + 0.000319871232724622*x_106 - 0.000220775037637658*x_107 + 0.000491729765680666*x_108 + 0.000241970000649114*x_109 - 2.84039166338399e-5*x_11 - 8.61769844091584e-5*x_110 + 0.00056761486319699*x_111 - 0.000128435479248432*x_112 + 9.27748655335395e-5*x_113 - 7.28262972132674e-6*x_114 - 0.000196760869341694*x_115 - 3.57086247254743e-5*x_116 - 7.95703784603758e-5*x_117 + 0.00115772834775303*x_118 - 0.000101556233381654*x_119 - 6.44740026489957e-5*x_12 - 0.000115736744866357*x_120 - 1.65328277549302e-5*x_13 + 0.000289740840015651*x_14 - 4.64733796748702e-5*x_15 - 9.62479758820227e-5*x_16 + 0.000276339673169134*x_17 + 0.000122803145965244*x_18 - 0.000298682407013819*x_19 + 7.46556460658628e-5*x_2 - 0.000166804130105883*x_20 + 1.82129365639693e-5*x_21 + 7.02341346159434e-5*x_22 + 5.67213754457318e-5*x_23 + 0.000147592681013989*x_24 - 0.000325792834643508*x_25 - 0.000306814962168337*x_26 + 0.000373041732228911*x_27 + 9.85800624890048e-5*x_28 - 8.35415966365327e-5*x_29 + 1.10372400466216e-5*x_3 + 0.000267013269613998*x_30 + 2.16546603400641e-6*x_31 - 0.000452655373359539*x_32 - 7.26566427200517e-5*x_33 - 0.000345597801749736*x_34 - 0.000423502249776942*x_35 - 5.29690214921358e-5*x_36 - 9.46439461024517e-5*x_37 + 0.000158672566264426*x_38 + 0.000187379475184531*x_39 + 0.000130437546953788*x_4 - 4.20463735913294e-5*x_40 + 0.000358937267742845*x_41 - 0.000675197827655315*x_42 - 0.000234670446537612*x_43 - 9.93209034656605e-5*x_44 - 0.000688627659893314*x_45 + 0.000962670381426375*x_46 - 0.000118997819756916*x_47 + 2.06978831164725e-5*x_48 - 0.000427866223926656*x_49 - 0.000122852535696066*x_5 - 0.000152400832251932*x_50 - 0.000527410938182972*x_51 + 0.00107057789005413*x_52 + 0.000172263277733229*x_53 + 0.000200624126386697*x_54 - 0.000795091551572084*x_55 - 0.000347081915328445*x_56 - 0.000499801407320617*x_57 - 0.000435643709354392*x_58 + 0.000202290777140906*x_59 - 2.73983878311956e-5*x_6 + 0.000289219617519374*x_60 + 9.41879020533759e-6*x_61 - 1.4543215108388e-5*x_62 + 2.01299735695991e-6*x_63 - 3.35848861182287e-5*x_64 - 2.91636916026904e-5*x_65 + 3.1089937749933e-5*x_66 - 2.40715714502482e-5*x_67 + 8.43689960223464e-6*x_68 + 3.34787005077231e-5*x_69 - 6.88935139432221e-5*x_7 - 3.80294285846801e-5*x_70 - 6.25553503454079e-6*x_71 - 2.49980879923198e-5*x_72 + 1.37156575411819e-5*x_73 - 1.05123584919727e-6*x_74 - 0.000108171387078994*x_75 - 2.37069394972533e-5*x_76 - 1.66690480481565e-6*x_77 + 9.5042559029181e-5*x_78 + 5.57776618549214e-6*x_79 - 1.16593049259693e-5*x_8 + 7.17081856775366e-6*x_80 - 3.73303155506125e-5*x_81 - 2.29659689459251e-5*x_82 - 6.22561928189476e-5*x_83 - 2.09192831052332e-5*x_84 - 1.01327378671678e-5*x_85 - 0.000175593575920271*x_86 - 2.53593949852011e-5*x_87 - 4.52270512584698e-5*x_88 + 2.01940940692931e-6*x_89 + 1.58365171673838e-5*x_9 - 1.25956847256717e-5*x_90 + 2.67961167290406e-7*x_91 + 0.000192852913296709*x_92 - 0.000553886146358572*x_93 + 4.70840078856105e-5*x_94 + 0.000133128199759576*x_95 - 0.000129734714405009*x_96 + 0.000135236180533764*x_97 + 0.000219521754476964*x_98 + 0.000240368519140421*x_99 - 8.44156828310079e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 2.76920572927608e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 8.22426319379109e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) - 1.95283995241458e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 3.80629687131861e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.00160396203864366*std::pow(-0.0125634814412579*x_1 - 0.0403653627948913*x_100 - 0.0178162553279772*x_101 + 0.180991039253229*x_102 - 0.028594757610354*x_103 + 0.187297366551453*x_104 - 0.0713431774519713*x_105 + 0.00418540061218664*x_106 - 0.0316146725891692*x_107 + 0.0809025964011528*x_108 - 0.0274169413263729*x_109 + 0.268652732484043*x_11 - 0.0357776331297702*x_111 - 0.00246295334619361*x_113 - 0.243121657660179*x_115 + 0.00291804325283028*x_116 + 0.202503531015141*x_117 - 0.259769848334441*x_118 + 0.0176665408324894*x_119 + 7.94005674892913e-5*x_120 - 0.062004133883517*x_13 - 0.0484001620426333*x_14 + 0.252405170036933*x_15 + 0.0356915235885447*x_16 - 0.0617108193963239*x_17 - 0.213305633881333*x_18 - 0.0280997216325823*x_2 - 0.00361670748443045*x_20 - 0.0511338795207639*x_22 - 0.0349059532163665*x_24 - 0.120558892921796*x_25 + 0.212256528731167*x_26 + 0.169304900318155*x_27 + 0.0588059399416485*x_28 - 0.027401558706673*x_29 - 0.0200099472850379*x_3 - 0.00420589065933903*x_30 - 0.00278239245266657*x_31 + 0.0210268552083077*x_32 - 0.0399542204527592*x_34 - 0.0488095188167215*x_35 + 0.00316628205488667*x_36 - 0.160984636777911*x_37 + 0.355423431075537*x_38 - 0.374053846426214*x_39 + 0.00376588676917582*x_40 + 0.0729680989310477*x_41 + 0.0754152868501329*x_42 + 0.12633302432367*x_43 - 0.052120683728748*x_44 - 0.381110233204085*x_45 - 0.039267137315997*x_46 - 0.0582230884874124*x_47 - 0.0541143601878874*x_50 + 0.115669886582322*x_51 - 0.032933056645561*x_52 - 0.340010813184022*x_54 + 0.0507187766836292*x_55 - 0.378391453801319*x_56 - 0.414101818157748*x_58 + 0.0420199086867384*x_59 - 0.0605516479991622*x_60 + 0.0054776507976341*x_61 + 0.0160204710919677*x_62 + 0.00733789421239896*x_63 + 0.00931156884934843*x_64 - 0.000647650598859222*x_65 + 0.00218079195504253*x_66 + 0.0138314067923506*x_67 - 4.97824837134971e-5*x_68 + 0.00680704129390336*x_69 - 0.0408338896396088*x_7 + 0.0202406174152112*x_70 + 0.0613324997383091*x_71 + 0.0119423785795297*x_72 + 0.0192492816172371*x_73 + 0.0122644356801656*x_74 + 0.0140883203130215*x_75 + 0.00420636330971877*x_76 + 0.0132042092931567*x_77 + 0.0068723731556623*x_78 + 0.0153133070031071*x_79 - 0.0178752282064724*x_8 + 0.00889125517358869*x_80 + 0.0144240377614513*x_81 + 0.0081408602547621*x_82 + 0.00892898295897088*x_83 + 0.0180998274438222*x_84 + 0.0217748373233971*x_85 + 0.0127431748928064*x_86 + 0.00987839134467372*x_87 + 0.0192212996281051*x_88 + 0.0140166174274138*x_89 + 0.0384423618503285*x_90 - 0.0441466556680892*x_92 + 0.0126062289996773*x_93 - 0.102065694984159*x_94 + 0.0165964337065816*x_97 + 0.195823891930115*x_99 + 0.995667725801468*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.408159494400024*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 1.62720993161201*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 2.02074065804482*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.295297149568796*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 1.63123831152916*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 2.11395919322968*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 1.59896984696388*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.345501415431499*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.90931162238121*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 2.57435411214828*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 2.36738041043282*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 1.7407688498497*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.891054570674896*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.725758075714111*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 1.368338316679*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.290012434124947*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.158187299966812*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 2.11018249392509*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 1.25446379184723*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 1.21259905397892*std::sin(0.319359838962555*x_98 - 4.56112003326416) + 2.481938936362, 2) + 0.00371203604555792*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 0.000240634257131897*std::sin(0.260159969329834*x_100 - 7.60351991653442) - 2.27469433501618e-6*std::sin(0.232319980859756*x_102 - 4.39903974533081) + 0.000391115489839645*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.00142783832662262*std::sin(0.242719978094101*x_103 - 4.42375993728638) + 0.000647642944152001*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.000149628870553528*std::sin(0.273679971694946*x_108 - 7.62088012695313) + 0.000880764185566195*std::sin(0.273919969797134*x_109 + 4.94927978515625) - 0.00125093849555235*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 0.000196814722096759*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.00178867180834027*std::sin(0.236399978399277*x_111 - 4.42143964767456) + 0.000616847996659358*std::sin(0.253679990768433*x_111 + 1.77215993404388) - 0.000234895118822835*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.00222280781629093*std::sin(0.335439831018448*x_113 + 8.03087997436523) + 0.000333241955554613*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.000251379110381297*std::sin(0.257839977741241*x_115 + 4.76639986038208) - 0.00287393741273258*std::sin(0.304879933595657*x_116 + 1.7325599193573) + 0.000612929252881569*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.00107860965331115*std::sin(0.277439951896667*x_119 - 7.63727998733521) + 9.57579134744435e-6*std::sin(0.307279914617538*x_119 - 1.63255989551544) - 0.000383825429719754*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.000426451017306797*std::sin(0.363919854164124*x_12 - 1.37199985980988) + 0.00066747059249024*std::sin(0.338559836149216*x_13 - 1.31959986686707) + 0.000469858457002475*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 8.62690518328794e-5*std::sin(0.345839858055115*x_14 + 4.82800006866455) + 0.00324655848492223*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 0.000639439191620994*std::sin(0.404239863157272*x_14 - 7.99567985534668) + 0.000880930259186606*std::sin(0.222079992294312*x_15 - 1.59383988380432) - 0.000493556105570868*std::sin(0.401519864797592*x_15 - 1.37799990177155) + 0.00399261725548548*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.000417978922775572*std::sin(0.386159837245941*x_16 - 7.57615995407104) - 0.000249599691726457*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 0.000123751271593342*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 9.09603922193511e-5*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.00101287299574301*std::sin(0.33943983912468*x_20 + 1.81687986850739) - 0.000582957414007979*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 0.000406026582303204*std::sin(0.411519855260849*x_20 + 4.79256010055542) - 0.000498767887976909*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.000834641755523683*std::sin(0.428079843521118*x_23 - 4.39831972122192) + 0.00011974852808349*std::sin(0.431919872760773*x_23 - 7.80887985229492) + 0.000108493126845621*std::sin(0.423679858446121*x_24 - 1.60191988945007) - 0.000510943570690957*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 0.000163878015546096*std::sin(0.276479959487915*x_26 + 7.99839973449707) + 0.00184855588997564*std::sin(0.385359823703766*x_26 - 7.57872009277344) - 0.00016460176167782*std::sin(0.411839872598648*x_26 + 4.99191999435425) + 0.00107041741335425*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 7.14041031327919e-5*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.00125008581643377*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.000331639956568246*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.00031196869074336*std::sin(0.192239999771118*x_29 + 1.77327990531921) - 0.00216945540013876*std::sin(0.368239849805832*x_29 - 4.39232015609741) + 0.000844498992730634*std::sin(0.194879993796349*x_3 - 4.60231971740723) + 0.000368106673609444*std::sin(0.326319932937622*x_3 + 8.03744029998779) + 0.000275907835800075*std::sin(0.316399931907654*x_31 - 4.54760026931763) + 0.000431044835303279*std::sin(0.296879917383194*x_32 - 1.34903991222382) - 0.000493684911799276*std::sin(0.26335996389389*x_33 + 4.99463987350464) + 0.000662526292954545*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.000166348967962791*std::sin(0.253279983997345*x_38 - 1.40319991111755) - 0.00391644654762882*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 3.25250120792529e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.000631941040567024*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 0.00275727133747349*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 0.000224679340395171*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.000251814535996171*std::sin(0.36847984790802*x_5 - 7.57728004455566) - 0.000858828036402857*std::sin(0.498079866170883*x_5 - 4.62080001831055) - 0.00110940402485534*std::sin(0.224639996886253*x_51 - 4.40959978103638) + 0.000101299666131482*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.000859804191476674*std::sin(0.252559989690781*x_54 + 4.95887994766235) - 1.39294025571217e-5*std::sin(0.313039928674698*x_57 + 1.52575981616974) + 0.00413188469625961*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 8.79341405133174e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 9.37573542778274e-5*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 0.000189239391372981*std::sin(0.252239972352982*x_60 + 1.5759197473526) - 0.000353445700030314*std::sin(0.353279858827591*x_60 - 4.75863981246948) + 0.000237100070602635*std::sin(0.424159854650497*x_60 + 4.95928001403809) + 0.00214747446650449*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.000233792751378113*std::sin(0.428239852190018*x_60 + 4.95824003219604) - 0.000432069166966071*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 9.11652003879317e-5*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.00127840990609451*std::sin(0.339999854564667*x_7 + 5.0099196434021) - 0.000139183671947804*std::sin(0.361119836568832*x_7 + 8.21175956726074) + 0.000412656257986847*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 0.00015165233460534*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 9.97973112833076e-5*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.000166128303683592*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 7.57309943968976e-5*std::sin(0.384799838066101*x_8 + 1.81071984767914) + 1.68473532070536e-5*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 0.000148476557480186*std::sin(0.401119858026505*x_8 - 1.60423982143402) + 0.00190886200009369*std::sin(0.435199856758118*x_8 + 7.97311973571777) + 5.81831510093859e-5*std::sin(0.451999872922897*x_8 - 1.62583994865417) + 0.000235871467872746*std::sin(0.348319828510284*x_9 - 4.58048009872437) - 0.000419765817779178*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 6.3381563977523e-5*std::sin(0.284399926662445*x_93 + 7.97679996490479) - 0.00381858593316888*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.000309866398875694*std::sin(0.314399927854538*x_94 - 7.61816024780273) + 0.000566021111251131*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 7.97295893246091e-5*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.0890006303177918);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000308562750938247*x_1 + 0.00133930440168839*x_10 - 0.000323285139113271*x_100 + 0.000407501179513225*x_101 + 0.000684522975187663*x_102 - 0.000881240849293507*x_103 + 0.00130049488094285*x_104 + 0.000481015515523468*x_105 + 0.00215143958935178*x_106 - 2.40816307269229e-5*x_107 + 0.000234436830758097*x_108 - 0.000388541685385268*x_109 + 0.00026917958998361*x_11 - 0.000440397229003577*x_110 - 0.000741060380313149*x_111 + 0.000146364394382998*x_112 - 0.00039476807500078*x_113 - 6.52594802403455e-5*x_114 + 0.000210896847179827*x_115 - 0.00161557248488087*x_116 + 0.000776921990138813*x_117 + 0.00115754054337386*x_118 + 6.77711214023481e-5*x_119 - 0.000145595691276563*x_12 + 9.52442258255337e-5*x_120 - 0.000219130855291377*x_13 - 0.0042249510482824*x_14 + 0.00104739186798362*x_15 + 0.000291818112602871*x_16 - 0.000242019672580047*x_17 - 0.000121153607417276*x_18 - 0.00144390638771282*x_19 - 6.51040111612898e-6*x_2 - 0.000971757072698087*x_20 - 7.95292799520685e-5*x_21 - 0.00348400185826153*x_22 - 0.000497174096318796*x_23 - 0.000804489679475774*x_24 + 0.000151641068320182*x_25 + 0.00133718722657771*x_26 + 0.000201722196548113*x_27 - 1.60114487870149e-5*x_28 - 0.000546706388779531*x_29 - 0.000135140918537756*x_3 - 0.000641536591268105*x_30 - 0.000119012667201432*x_31 + 0.000502433033143558*x_32 + 3.86446995291638e-5*x_33 - 0.000576534432040561*x_34 - 0.00192849038999208*x_35 - 0.0022438122531634*x_36 + 0.000220045681709379*x_37 + 0.000637189768741408*x_38 - 0.00216545241970758*x_39 - 7.28313487997085e-5*x_4 - 0.000750734948536943*x_40 - 0.00381165361265607*x_41 - 0.00339338203538865*x_42 + 0.00106065223588745*x_43 + 0.000837030155214443*x_44 + 0.00078581273876354*x_45 - 0.00187348891268821*x_46 - 0.000141333850536475*x_47 - 0.00163952316847863*x_48 + 0.00158447555318407*x_49 - 0.00044904945494643*x_5 + 0.00178460180327885*x_50 + 0.00307192601838076*x_51 - 3.38057290326235e-5*x_52 - 0.00110156168377836*x_53 - 0.00429878211798381*x_54 + 0.0002119408562493*x_55 - 0.00114807215531816*x_56 + 0.000503411117430701*x_57 + 0.00180678591298403*x_58 - 0.000658399904537464*x_59 + 2.21836554076862e-5*x_6 - 0.00295514677677294*x_60 + 4.62882806620447e-5*x_61 - 2.67501817612873e-5*x_62 + 6.71879503711827e-5*x_63 + 9.37147809139185e-6*x_64 - 3.78216772537833e-5*x_65 + 6.03041221234257e-5*x_66 + 5.50025350050551e-5*x_67 - 9.05369281991727e-5*x_68 + 2.50186720537779e-5*x_69 - 0.0017065549677203*x_7 + 0.00015301242708067*x_70 + 0.00013129509383853*x_71 + 4.59127014709521e-5*x_72 + 1.20455805634544e-5*x_73 + 0.000157413802732675*x_74 + 0.000153374010865511*x_75 - 3.01024560596069e-5*x_76 + 4.94419961584108e-5*x_77 - 8.80882452422995e-5*x_78 + 3.32609731129583e-5*x_79 + 0.000171332702210108*x_8 + 6.04874809481792e-5*x_80 + 9.79783265548042e-5*x_81 - 7.83593785011689e-5*x_82 - 0.000442163237257017*x_83 + 0.000189373831505624*x_84 + 0.000156371998998408*x_85 + 0.000265277773427227*x_86 + 8.12092079191363e-5*x_87 + 2.82075721097127e-5*x_88 + 3.04976161879849e-5*x_89 - 0.000290343781219616*x_9 + 5.70360905058898e-5*x_90 - 9.71192720548813e-5*x_91 - 0.000725956823496489*x_92 + 0.00195641845338355*x_93 - 0.000224213694604796*x_94 + 0.00244407281387043*x_95 - 0.000371491457235042*x_96 - 0.000292079404933609*x_97 + 0.00104638699130793*x_98 + 0.000716078882000205*x_99 - 6.84826999525348e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 9.90669096474074e-9*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 1.15281169718923e-6*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 2.2677676532673e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 9.96139959130024e-8*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) - 0.000614668059433323*std::sin(0.213359996676445*x_10 - 1.37991976737976) + 0.00262151159008318*std::sin(0.447439849376678*x_10 - 1.43487977981567) - 0.000710017181905901*std::sin(0.260159969329834*x_100 - 7.60351991653442) + 2.5718999432488e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.000366222724102124*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.00115834191495645*std::sin(0.242719978094101*x_103 - 4.42375993728638) + 0.0192529660791075*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.0004414960291541*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.000824707452680758*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 3.35585690626656e-5*std::sin(0.278079956769943*x_109 + 1.58247983455658) + 0.00107465052591803*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 7.04094538195842e-5*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.00145107011702249*std::sin(0.236399978399277*x_111 - 4.42143964767456) + 0.0183375016479153*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 0.00159160921200978*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.00428431050307031*std::sin(0.297439932823181*x_112 - 1.4184798002243) + 0.000368069962189015*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.00532044468083229*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.00990653279613685*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.00352363211205791*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.00333740729446426*std::sin(0.304879933595657*x_116 + 1.7325599193573) + 0.0182210062213724*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.000875028179319332*std::sin(0.277439951896667*x_119 - 7.63727998733521) - 0.000108269391820854*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000777493213903254*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.000359396643966383*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.00597765063502187*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.000624989050523298*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 1.26047583754571e-5*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 0.000254546089148485*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.00377011966978855*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 0.000167346623698011*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 0.00596903299943439*std::sin(0.222079992294312*x_15 - 1.59383988380432) - 0.01467231140939*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.00463649274108288*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.00585889556304578*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 0.000233713778701505*std::sin(0.437599837779999*x_16 + 4.97447967529297) + 0.00429491689752139*std::sin(0.331279844045639*x_19 - 7.56640005111694) - 0.000365141398241629*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 0.00026838839207021*std::sin(0.269519954919815*x_20 - 1.38383984565735) - 0.000113831187365313*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.000545854760907225*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 0.000329391360421594*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.00556588145061508*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.00420995667267934*std::sin(0.200719982385635*x_23 - 1.610879778862) + 1.33803034077406e-5*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.000677107842932589*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 0.000112127065537434*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 0.000101588020653569*std::sin(0.423679858446121*x_24 - 1.60191988945007) - 0.0151892015865802*std::sin(0.403359860181808*x_25 - 7.60167980194092) - 0.00191715654192365*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 4.95906798939413e-5*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 0.000154125589805647*std::sin(0.411839872598648*x_26 + 4.99191999435425) + 0.0318210988568394*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 0.000210685463853447*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.00101413918611705*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.00464866471534901*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.000920497078365128*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 5.81993592273163e-5*std::sin(0.368239849805832*x_29 - 4.39232015609741) + 0.0251050530353147*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 0.000344678316945956*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 0.000258347526121382*std::sin(0.316399931907654*x_31 - 4.54760026931763) + 0.0128139921350255*std::sin(0.296879917383194*x_32 - 1.34903991222382) - 0.0146761405284574*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.000909676934857705*std::sin(0.277759939432144*x_33 - 7.6113600730896) - 0.000620359433717578*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.00049083046966649*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.00239414304119465*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.00454803824833747*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 0.000455909708780852*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.00885804608064572*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 0.000721601138922649*std::sin(0.268079966306686*x_44 - 7.61872005462646) + 0.0067780635719036*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 0.00066294048902778*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.0062331187636818*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.00458330183582419*std::sin(0.318559914827347*x_5 + 8.2260799407959) - 9.00853541566157e-5*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 2.30395339779299e-5*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.00103879538056383*std::sin(0.224639996886253*x_51 - 4.40959978103638) - 0.00118507242702134*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.00234607371906178*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.000805081469225651*std::sin(0.252559989690781*x_54 + 4.95887994766235) + 0.000157493818376684*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.00191086158341581*std::sin(0.320719927549362*x_57 + 1.70343995094299) - 0.0047982193572095*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 3.14579861693141e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) + 0.00360272273909597*std::sin(0.343759834766388*x_6 - 7.58983993530273) - 0.000276641128577168*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 6.76994182435784e-5*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 0.00239488770534131*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 0.000222009703007425*std::sin(0.424159854650497*x_60 + 4.95928001403809) - 0.000355595674936538*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.00327712054145125*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 1.15909959051001e-5*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 0.000268992700535763*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.00103711726398853*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 0.000161629338193297*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000386392517922755*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 5.42528421465206e-5*std::sin(0.37951985001564*x_7 - 1.59695994853973) + 0.00116749685768173*std::sin(0.396159827709198*x_7 - 7.5840802192688) + 1.86702401414269e-5*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 0.000223452420555167*std::sin(0.384799838066101*x_8 + 1.81071984767914) - 0.000190485842823385*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 5.3116724225805e-5*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.00221669752967273*std::sin(0.435199856758118*x_8 + 7.97311973571777) - 0.000680666093103868*std::sin(0.451999872922897*x_8 - 1.62583994865417) + 0.000763578990887547*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.000220859295390575*std::sin(0.348319828510284*x_9 - 4.58048009872437) - 0.000416494207375414*std::sin(0.295199930667877*x_91 + 5.05583953857422) + 0.000393049585775991*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 0.00018701410171804*std::sin(0.284399926662445*x_93 + 7.97679996490479) + 0.000632311425997353*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.00434346032918165*std::sin(0.314399927854538*x_94 - 7.61816024780273) - 0.00555593771060759*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.00330290044002385*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.0079340330255842*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 0.000235250703709011*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.00319267401338214*std::sin(0.319359838962555*x_98 - 4.56112003326416) - 0.120735925544264);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000182872348391513*x_1 + 0.000675104112504238*x_10 - 0.000810400827434652*x_100 + 0.000327752980011729*x_101 - 0.00124454475706991*x_102 - 0.00154554681832287*x_103 + 0.000986433082256565*x_104 + 0.00119647666587284*x_105 - 0.00212266333985661*x_106 - 2.65838468730699e-5*x_107 - 0.000643823490045639*x_108 - 0.000716629765903225*x_109 + 0.00103852581450204*x_11 + 0.00169118062272062*x_110 - 0.000919325537499844*x_111 + 0.000365559199801332*x_112 - 1.05051318656461e-5*x_113 - 3.94994367810763e-6*x_114 - 1.79090835858656e-5*x_115 - 0.000148553581943298*x_116 + 0.000644803937273161*x_117 - 0.00370019745247384*x_118 + 5.08271616961429e-5*x_119 - 0.000154332065454683*x_12 + 3.32130949601244e-6*x_120 - 0.000254904934522143*x_13 + 0.00405302010917993*x_14 + 0.00103486304481782*x_15 - 0.000313930365056278*x_16 - 0.000414557874532412*x_17 - 0.000605176918717115*x_18 + 0.00155424565100929*x_19 - 0.000652878078087168*x_2 + 0.00155340910925416*x_20 - 0.000638671213410092*x_21 + 0.00296979878585479*x_22 + 0.000150109353656585*x_23 - 7.70975016383278e-5*x_24 + 0.000452697490482841*x_25 + 0.000913143661709589*x_26 - 1.0023483299505e-5*x_27 + 0.000249632585836836*x_28 - 2.77191105903483e-5*x_29 + 7.38537178036551e-6*x_3 - 9.23907226256358e-5*x_30 + 2.65730043188295e-5*x_31 + 0.000941330653329795*x_32 + 0.000535419494214767*x_33 + 6.07382794195265e-5*x_34 + 0.0036090877782131*x_35 + 0.0015265318163769*x_36 - 0.00021564814961338*x_37 - 0.000645742440419595*x_38 - 0.00175055390020986*x_39 - 0.000370591853472667*x_4 + 0.000438300498661945*x_40 + 0.00378188853743054*x_41 + 0.00315815332993806*x_42 + 3.1723834796303e-5*x_43 - 0.0010533210070716*x_44 - 0.000405597384304073*x_45 - 0.00146256784988894*x_46 + 0.000496222678026129*x_47 - 0.000518373009993186*x_48 + 0.00026862532375595*x_49 + 0.000407581958666634*x_5 - 0.00127351291920253*x_50 - 0.00230874897276396*x_51 - 0.00195877406596487*x_52 + 0.000655188130368263*x_53 + 0.00290017557064032*x_54 + 0.00126656453930603*x_55 - 0.000181376122375663*x_56 + 0.00143144371430918*x_57 - 0.00322425903600121*x_58 - 0.00311666865943032*x_59 + 0.000125038087692274*x_6 + 0.00134751841020163*x_60 - 3.09113734484622e-5*x_61 + 0.000107152441010956*x_62 - 1.78836941345412e-5*x_63 + 0.000108544404493637*x_64 + 9.94893875066159e-5*x_65 + 1.57505027619079e-5*x_66 + 9.23963488553852e-5*x_67 + 2.33838766960803e-6*x_68 - 5.51267644680723e-5*x_69 + 0.00155693763368216*x_7 + 0.000105707791315186*x_70 + 0.000160044190874305*x_71 + 7.10906289104357e-5*x_72 + 2.97133130018923e-5*x_73 - 7.17373727410999e-5*x_74 + 0.000267385132458841*x_75 + 0.000102115656169662*x_76 + 5.54419539537036e-5*x_77 - 0.000131561773432552*x_78 + 1.61993990358058e-5*x_79 - 2.05229105778761e-6*x_8 + 1.87765658233675e-5*x_80 + 9.44420730282748e-5*x_81 + 0.000123854452243156*x_82 + 0.000425852106936805*x_83 - 7.62368711737606e-5*x_84 + 0.000131643497878762*x_85 + 0.000406626604604027*x_86 + 9.54984540585648e-5*x_87 + 7.14394824080775e-5*x_88 + 5.66326098387889e-5*x_89 - 3.69628658859369e-5*x_9 + 4.63087887601892e-5*x_90 + 7.77215763048087e-5*x_91 - 0.000752669546177611*x_92 - 0.00137860823515404*x_93 - 0.000423388821392363*x_94 - 0.00178779073173426*x_95 + 0.000229098936750321*x_96 - 0.000332163720875428*x_97 - 0.00167104632059166*x_98 + 0.000154798435400181*x_99 - 6.5026196107092e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) - 1.10125567033203e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) - 1.11076691266257e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 4.01557340666128e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) + 2.26994308257216e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) - 0.00538146952407712*std::sin(0.213359996676445*x_10 - 1.37991976737976) + 0.00196938422466693*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.000458844456363326*std::sin(0.260159969329834*x_100 - 7.60351991653442) - 5.28440982658766e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.000465570526805839*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.00109987732045069*std::sin(0.242719978094101*x_103 - 4.42375993728638) - 0.0192438667783431*std::sin(0.307439923286438*x_107 + 1.73607993125916) - 0.000285314229917647*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.00104843161807243*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 0.000682684294772901*std::sin(0.278079956769943*x_109 + 1.58247983455658) + 0.000807320402770309*std::sin(0.273279964923859*x_110 + 1.57231986522675) + 7.82691319833935e-5*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.00137783075229284*std::sin(0.236399978399277*x_111 - 4.42143964767456) - 0.0183288350122356*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 7.78617567179273e-5*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.00321854518982073*std::sin(0.297439932823181*x_112 - 1.4184798002243) + 0.00322248285696594*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.00399693057329253*std::sin(0.239839985966682*x_114 + 8.16464042663574) - 0.00990185078916326*std::sin(0.298879951238632*x_114 - 7.8452000617981) - 3.39511992462615e-5*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.00590960187633845*std::sin(0.304879933595657*x_116 + 1.7325599193573) - 0.018212394643543*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.000830863181899774*std::sin(0.277439951896667*x_119 - 7.63727998733521) + 0.000222458046845349*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000584083959818798*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.000456892688114623*std::sin(0.305439919233322*x_12 - 1.25543987751007) + 5.75963668396816e-5*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.00079453420650891*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 0.000256419472661752*std::sin(0.322799921035767*x_14 + 4.77503967285156) - 0.000164498923224969*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.00667581278184369*std::sin(0.349519848823547*x_14 - 7.55999994277954) - 0.000381339296123471*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 0.000292005972154668*std::sin(0.222079992294312*x_15 - 1.59383988380432) + 0.0146653770090553*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.00820991379978732*std::sin(0.202719986438751*x_16 - 7.60552024841309) + 5.64521278890921e-5*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 0.000297114951942469*std::sin(0.437599837779999*x_16 + 4.97447967529297) + 0.00322651313701255*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 0.000235970495702919*std::sin(0.331759840250015*x_19 + 4.80807971954346) - 0.000173444430630699*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.00222747219913799*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.000693932604040662*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 0.00031276610317061*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.00418131247890451*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.00316268762231293*std::sin(0.200719982385635*x_23 - 1.610879778862) + 0.000272196438969239*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.000642932410823485*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 0.00014254455973327*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 0.00012914651434807*std::sin(0.423679858446121*x_24 - 1.60191988945007) + 0.0151820228945782*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 0.00337420005833358*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 0.0010088266358284*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 0.000195936317758551*std::sin(0.411839872598648*x_26 + 4.99191999435425) - 0.0318060596287037*std::sin(0.239119976758957*x_28 + 1.82159984111786) - 0.000136154250332356*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.000962952886525217*std::sin(0.399279862642288*x_28 + 8.19672012329102) - 4.47912088892003e-5*std::sin(0.438639879226685*x_28 + 8.16016006469727) - 0.000594865859967955*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 0.00118395359576095*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.025093187932175*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 0.000438181617463829*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 0.000328431268513464*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.0128079360100653*std::sin(0.296879917383194*x_32 - 1.34903991222382) + 0.0146692043184116*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.000683385651175124*std::sin(0.277759939432144*x_33 - 7.6113600730896) - 0.000788648681135156*std::sin(0.290559947490692*x_36 + 4.96271991729736) + 0.000317196323920122*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.001798575888339*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.00805328597759555*std::sin(0.266479969024658*x_40 + 1.7739999294281) + 4.39281992809509e-6*std::sin(0.284799933433533*x_41 - 1.61207985877991) + 8.53497975533338e-5*std::sin(0.236239984631538*x_42 + 4.98647975921631) + 0.00164434073611925*std::sin(0.268079966306686*x_44 - 7.61872005462646) + 0.00509195210991723*std::sin(0.240399971604347*x_48 - 7.60304021835327) + 0.000428421418581253*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.00468256780176236*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.00344315942241275*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.000100141416979629*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 0.000468694835475503*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.00132059667722233*std::sin(0.224639996886253*x_51 - 4.40959978103638) + 0.00208573028072748*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.00176246429338859*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.0010234815566619*std::sin(0.252559989690781*x_54 + 4.95887994766235) - 0.000323598079171483*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.00143551555222449*std::sin(0.320719927549362*x_57 + 1.70343995094299) - 0.00849628577353504*std::sin(0.277679949998856*x_58 - 7.65583992004395) - 3.49695834557513e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) + 0.00270650923500181*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.000178777713391379*std::sin(0.417759865522385*x_6 - 1.19479990005493) - 7.52565801075957e-5*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 0.000117158258744041*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 0.000282235829681479*std::sin(0.424159854650497*x_60 + 4.95928001403809) - 0.00311326944388298*std::sin(0.425279855728149*x_60 - 7.63568019866943) - 3.15759900348528e-5*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 0.00023579643251214*std::sin(0.301919937133789*x_7 + 7.77184009552002) - 0.000173834961446599*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.000984771199746964*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 0.000286199722114462*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000491211921827568*std::sin(0.372319847345352*x_7 + 7.99711990356445) + 6.03089873885534e-5*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 0.00205479723702753*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.000365343117548216*std::sin(0.365359842777252*x_8 - 1.76943981647491) + 0.000144404821524859*std::sin(0.384799838066101*x_8 + 1.81071984767914) + 0.000391385855536119*std::sin(0.39031982421875*x_8 - 4.58975982666016) + 5.90460467085555e-5*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.00392514270055001*std::sin(0.435199856758118*x_8 + 7.97311973571777) + 0.00119797393735635*std::sin(0.451999872922897*x_8 - 1.62583994865417) + 0.000573631039675591*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.000280773342935112*std::sin(0.348319828510284*x_9 - 4.58048009872437) - 0.000312887085745927*std::sin(0.295199930667877*x_91 + 5.05583953857422) + 0.000499674899090958*std::sin(0.351119846105576*x_91 + 1.97359979152679) - 0.000120856770824544*std::sin(0.284399926662445*x_93 + 7.97679996490479) + 0.00553593865259176*std::sin(0.288959950208664*x_94 - 4.41472005844116) - 4.18504776788841e-5*std::sin(0.314399927854538*x_94 - 7.61816024780273) - 0.00417384234420093*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.00248127074731797*std::sin(0.305199921131134*x_96 - 4.61279964447021) - 7.64466685259909e-5*std::sin(0.286799937486649*x_97 - 4.41120004653931) + 0.000152029393095387*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.00239846425254955*std::sin(0.319359838962555*x_98 - 4.56112003326416) + 0.138271241498446);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (4.15481675199362e-5*x_1 + 0.000681430781628619*x_10 - 0.000428430724600044*x_100 + 0.000462265395299156*x_101 - 0.00137983866239817*x_102 - 9.75926597310856e-5*x_103 + 4.51265384861917e-5*x_104 - 0.000187979940230808*x_105 - 0.000577318237121434*x_106 + 0.000140693689141413*x_107 - 0.000851117986138962*x_108 + 0.000111150800790353*x_109 - 0.000262173475211849*x_11 - 0.000112761223681976*x_110 + 0.000351945905644845*x_111 + 0.00090535167874904*x_112 - 0.000358132935371812*x_113 + 5.49521917798232e-5*x_114 - 0.000273955382642697*x_115 - 0.000897703979637016*x_116 + 0.000810983498947153*x_117 - 0.00215280590775416*x_118 + 0.000122001951239908*x_119 + 0.000252943423121103*x_12 + 0.000203565546466492*x_120 - 9.99031811278457e-5*x_13 + 0.000941983163965487*x_14 - 0.00061638061938167*x_15 + 3.21497411476428e-5*x_16 + 5.43589156217485e-6*x_17 - 0.00048124153806951*x_18 + 0.000361667055095826*x_19 - 0.000641648373478681*x_2 + 0.000536939969707018*x_20 - 0.000541811282983378*x_21 + 0.00107060678465595*x_22 - 2.16962493510093e-5*x_23 + 9.67309040712593e-5*x_24 - 4.49996460310896e-6*x_25 - 7.95567864316585e-5*x_26 - 0.000699763063229276*x_27 - 6.60928368949701e-5*x_28 - 0.000603513763053976*x_29 + 7.7616836730462e-5*x_3 - 0.000259815698350393*x_30 + 5.53494575387453e-5*x_31 - 3.17526538104196e-5*x_32 - 0.000179882136383023*x_33 - 0.000331165123126982*x_34 + 0.00141746916266308*x_35 - 9.10669288902979e-5*x_36 + 0.000832481685487597*x_37 - 0.000224390778563751*x_38 + 0.000405777184209588*x_39 + 0.000158440533380973*x_4 - 0.000967806831552963*x_40 + 0.000164798550461798*x_41 + 0.00211537118129931*x_42 + 0.000906700337559553*x_43 + 0.00052865997831535*x_44 + 0.000522546427849573*x_45 - 0.00156229389799615*x_46 + 0.00116901777033819*x_47 - 0.00171658463787242*x_48 + 0.00090705917136533*x_49 + 0.000240245810807534*x_5 + 0.000270975074932852*x_50 - 0.000574896593899819*x_51 - 0.0022186824317834*x_52 - 0.00121633544974823*x_53 + 0.00213692497756571*x_54 - 0.000818958555170963*x_55 + 0.00117446747142346*x_56 + 0.000156209799630642*x_57 - 0.000640089015170715*x_58 - 0.00141668399529202*x_59 + 0.000272613333695578*x_6 + 0.000977063523697577*x_60 - 1.42727732148154e-5*x_61 + 1.40678898083415e-5*x_62 - 1.87966696813735e-5*x_63 + 3.57090526750495e-5*x_64 + 1.09305515343382e-5*x_65 - 1.83007213456201e-5*x_66 + 4.33260469879907e-5*x_67 - 1.38971260574086e-5*x_68 - 5.01528958214307e-5*x_69 + 0.000558928290555718*x_7 - 4.94067695586241e-5*x_70 + 8.40035589829077e-6*x_71 - 2.83587102527119e-6*x_72 + 2.12573640689352e-5*x_73 + 7.31748282507405e-7*x_74 - 1.16935431296268e-5*x_75 + 3.62431714918659e-5*x_76 + 1.98335584154419e-5*x_77 + 4.65522056718742e-5*x_78 + 2.42311808005829e-5*x_79 + 0.000424074059079159*x_8 + 5.27274742281895e-6*x_80 + 3.6575715273274e-5*x_81 + 9.3596042203888e-6*x_82 - 0.000112493608242506*x_83 + 5.82384518680965e-5*x_84 - 2.33459000297946e-5*x_85 + 4.08017095730417e-6*x_86 - 5.47279340724021e-5*x_87 - 2.56405673527775e-5*x_88 - 1.9706014588227e-5*x_89 - 9.43410933259636e-5*x_9 + 8.89762626947834e-6*x_90 + 5.22151069846045e-5*x_91 - 4.33268542371504e-5*x_92 + 0.000177379255980419*x_93 - 3.67990538429151e-5*x_94 - 7.73847275128207e-5*x_95 - 0.000679851064899588*x_96 - 5.02160562290731e-5*x_97 - 0.000267810710609058*x_98 + 0.000668821374283134*x_99 - 1.03466171277304e-7*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 2.34470214821689e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 1.26579247015415e-6*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) - 2.83531897810295e-7*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) + 3.2850711565541e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) - 0.00884307860321213*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 0.000377435811181701*std::sin(0.260159969329834*x_100 - 7.60351991653442) + 1.90985962767028e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 6.85192934853283e-5*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.00175006538956016*std::sin(0.242719978094101*x_103 - 4.42375993728638) - 0.00660172537312772*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.000234693492134902*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.000154300561573051*std::sin(0.273919969797134*x_109 + 4.94927978515625) - 0.0005507205853211*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 0.0001666441380004*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.00219232987845523*std::sin(0.236399978399277*x_111 - 4.42143964767456) - 0.0062878181684526*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 3.94948719047149e-6*std::sin(0.306399941444397*x_111 - 8.07583999633789) + 0.00529533226457142*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.0033968900506685*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.00386896403455224*std::sin(0.257839977741241*x_115 + 4.76639986038208) - 0.00041726559711796*std::sin(0.304879933595657*x_116 + 1.7325599193573) - 0.00624787259278901*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.00132202462135213*std::sin(0.277439951896667*x_119 - 7.63727998733521) - 8.03994497895835e-5*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 6.72421521246388e-5*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.00656348749884418*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.000116933781984486*std::sin(0.338559836149216*x_13 - 1.31959986686707) + 0.00020685327486402*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 0.000135313358731678*std::sin(0.345839858055115*x_14 + 4.82800006866455) + 0.000471366272204728*std::sin(0.349519848823547*x_14 - 7.55999994277954) - 0.000551875829915676*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 1.48118138503353e-5*std::sin(0.222079992294312*x_15 - 1.59383988380432) + 0.00503104665098394*std::sin(0.401519864797592*x_15 - 1.37799990177155) + 0.000579686187942966*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.00643309389140035*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 4.37272237370718e-5*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 0.000194104372898986*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 0.000142671745211649*std::sin(0.269519954919815*x_20 - 1.38383984565735) - 0.00183938407882844*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.000102127967767877*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 0.000497656531332236*std::sin(0.411519855260849*x_20 + 4.79256010055542) - 0.000219580534280966*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.00102299932827744*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 2.0978674466595e-5*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 1.90068473189949e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) + 0.00520828515978598*std::sin(0.403359860181808*x_25 - 7.60167980194092) - 0.000963769025686886*std::sin(0.276479959487915*x_26 + 7.99839973449707) + 0.000813819212811612*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 2.8836486177596e-5*std::sin(0.411839872598648*x_26 + 4.99191999435425) - 0.0109112619250893*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 0.000111997626226822*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.00153219862538331*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.00510425493366085*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.000489324160480912*std::sin(0.192239999771118*x_29 + 1.77327990531921) - 0.000955093917119322*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.00860837051994833*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 6.44883924523022e-5*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 4.8336132081698e-5*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.00439384023538354*std::sin(0.296879917383194*x_32 - 1.34903991222382) + 0.00503235963270323*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.000116067593046011*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.000260919032936613*std::sin(0.253279983997345*x_38 - 1.40319991111755) - 0.000568626999334371*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 0.000500590927253791*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.00972617475733276*std::sin(0.236239984631538*x_42 + 4.98647975921631) + 0.00237969681497534*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 0.000352410459377524*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.000213212791400952*std::sin(0.36847984790802*x_5 - 7.57728004455566) - 0.000378095550324489*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.000194355841043354*std::sin(0.224639996886253*x_51 - 4.40959978103638) - 0.000595744830108004*std::sin(0.247039973735809*x_52 + 1.59447979927063) - 0.000150628592490314*std::sin(0.252559989690781*x_54 + 4.95887994766235) + 0.000116952872181064*std::sin(0.313039928674698*x_57 + 1.52575981616974) + 0.000599906360997623*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 7.4454333957008e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 0.000147058791578064*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 0.000160230062645248*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 5.94277680946536e-6*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 4.153742243672e-5*std::sin(0.424159854650497*x_60 + 4.95928001403809) - 0.00511586775360529*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.00359829321238712*std::sin(0.428239852190018*x_60 + 4.95824003219604) - 0.000190216693607858*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 0.000142992987657202*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.00156691474700706*std::sin(0.339999854564667*x_7 + 5.0099196434021) - 2.02080106988659e-5*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 7.22930080349175e-5*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 0.000128404889160836*std::sin(0.37951985001564*x_7 - 1.59695994853973) + 0.000586909459094775*std::sin(0.396159827709198*x_7 - 7.5840802192688) + 0.000301690101446741*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 0.000118784372775829*std::sin(0.384799838066101*x_8 + 1.81071984767914) - 0.00014145232274922*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 0.000125715940712953*std::sin(0.401119858026505*x_8 - 1.60423982143402) + 0.00027714675996634*std::sin(0.435199856758118*x_8 + 7.97311973571777) - 0.000342175968953785*std::sin(0.451999872922897*x_8 - 1.62583994865417) - 4.1322184244388e-5*std::sin(0.348319828510284*x_9 - 4.58048009872437) + 7.35385276489883e-5*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 9.94142409270883e-5*std::sin(0.284399926662445*x_93 + 7.97679996490479) + 0.00909690939034436*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.00476913913390743*std::sin(0.314399927854538*x_94 - 7.61816024780273) + 0.00871160423356663*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 0.000125056185185733*std::sin(0.308079928159714*x_98 + 7.96912002563477) - 0.176406547427177*std::sin(-0.00213709833440999*x_1 - 0.00686630931085136*x_100 - 0.00303061613652776*x_101 + 0.0307872981179397*x_102 - 0.00486408239210377*x_103 + 0.0318600295601194*x_104 - 0.0121357592174593*x_105 + 0.000711953348199245*x_106 - 0.00537778198257648*x_107 + 0.0137618545326586*x_108 - 0.00466373114149653*x_109 + 0.045698901997093*x_11 - 0.00608591818503997*x_111 - 0.000418958193912281*x_113 - 0.0413559642742262*x_115 + 0.000496370803309399*x_116 + 0.0344466588236764*x_117 - 0.044187887951374*x_118 + 0.00300514910333*x_119 + 1.35063534201061e-5*x_120 - 0.0105471506340468*x_13 - 0.00823306073003035*x_14 + 0.0429351267803038*x_15 + 0.00607127060841161*x_16 - 0.0104972566691479*x_17 - 0.03628413963275*x_18 - 0.00477987479658056*x_2 - 0.000615216377495647*x_20 - 0.00869807698341332*x_22 - 0.00593764195286788*x_24 - 0.0205075488403544*x_25 + 0.0361056826596949*x_26 + 0.0287994392453332*x_27 + 0.0100031250804417*x_28 - 0.00466111449649304*x_29 - 0.00340377189351781*x_3 - 0.000715438786996293*x_30 - 0.000473296060814916*x_31 + 0.00357675198977771*x_32 - 0.00679637235757259*x_34 - 0.00830269395105858*x_35 + 0.000538597214268106*x_36 - 0.0273841292107027*x_37 + 0.0604589441321102*x_38 - 0.0636280521378377*x_39 + 0.00064059236921008*x_40 + 0.0124121648461633*x_41 + 0.0128284412780041*x_42 + 0.0214897516365544*x_43 - 0.00886593631755825*x_44 - 0.0648283716910165*x_45 - 0.00667949677383879*x_46 - 0.00990397972189758*x_47 - 0.0092050686400837*x_50 + 0.019675909349831*x_51 - 0.00560204437228122*x_52 - 0.0578371963165178*x_54 + 0.00862746633412816*x_55 - 0.0643658964638713*x_56 - 0.0704403719620942*x_58 + 0.00714775417039957*x_59 - 0.0103000769882009*x_60 + 0.000931770262155243*x_61 + 0.00272514607095083*x_62 + 0.00124820509129708*x_63 + 0.00158393502404013*x_64 - 0.00011016795165999*x_65 + 0.000370961415162442*x_66 + 0.00235277749696107*x_67 - 8.46819916313381e-6*x_68 + 0.00115790489121019*x_69 - 0.00694600759704326*x_7 + 0.00344300980327207*x_70 + 0.0104329029854338*x_71 + 0.00203144625878886*x_72 + 0.00327437962758414*x_73 + 0.00208622945694709*x_74 + 0.00239647951217718*x_75 + 0.000715519186712249*x_76 + 0.00224608869918311*x_77 + 0.00116901810163691*x_78 + 0.00260485463712138*x_79 - 0.00304064765852243*x_8 + 0.00151243799030821*x_80 + 0.00245358639001404*x_81 + 0.00138479281976594*x_82 + 0.00151885563717451*x_83 + 0.00307885288517829*x_84 + 0.00370398673277471*x_85 + 0.00216766490768065*x_86 + 0.00168035379270148*x_87 + 0.00326961977955578*x_88 + 0.00238428256516682*x_89 + 0.0065391991754236*x_90 - 0.00750952231984184*x_92 + 0.00214436986470399*x_93 - 0.0173617820642242*x_94 + 0.00282311961038167*x_97 + 0.0333104255566624*x_99 + 0.169367053900233*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.0694295589749032*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 0.276794903613537*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 0.343736050773339*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.0502312236819213*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.277480147114835*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 0.359592895646408*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.271991152507818*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.058771169671981*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.154677536058506*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.437907908805155*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 0.40270085610476*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.296111728823004*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.15157193869879*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.123454345202418*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 0.232759808748623*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.049332272493456*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.026908291054875*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 0.358950464021772*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.213389297597907*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.206267938603014*std::sin(0.319359838962555*x_98 - 4.56112003326416) - 1.13387129245549) - 0.119946728846207);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00011497021081353*x_1 - 0.000330268413741966*x_10 + 0.000587856165652922*x_100 + 0.000228765674433698*x_101 + 0.000811952361883524*x_102 + 0.00151905702327604*x_103 - 0.000755931044158604*x_104 - 0.00117037520811159*x_105 + 0.000696465652569391*x_106 - 0.000297671147462432*x_107 + 0.000291924758178714*x_108 + 0.000609388890206444*x_109 + 0.000303260682904611*x_11 - 0.000835578170006372*x_110 - 7.66829844962027e-5*x_111 + 0.000208955188604286*x_112 - 0.000884462380115477*x_113 - 6.20768800036323e-5*x_114 - 0.00166517961461335*x_115 - 0.00080654889010346*x_116 + 0.000104976314904884*x_117 + 0.00160308924857092*x_118 - 1.14503322476383e-5*x_119 - 0.000694348890686391*x_12 + 0.000113438633391111*x_120 - 9.68021517158616e-6*x_13 - 0.00038589097241017*x_14 - 0.000168448400186424*x_15 - 5.171214098407e-5*x_16 + 0.000340909263222884*x_17 + 9.17245166104269e-5*x_18 - 0.000817042458453564*x_19 + 0.000200192960565598*x_2 - 0.000521068180463207*x_20 + 0.00022579352831129*x_21 - 0.00117978148475814*x_22 + 3.27456668602235e-5*x_23 + 1.63978568384592e-5*x_24 - 0.00105907990570114*x_25 - 0.000168787617500604*x_26 + 0.000522171117671955*x_27 + 0.000171267135781721*x_28 - 0.000436338965854451*x_29 + 9.662091512025e-5*x_3 + 0.000262977868250439*x_30 - 1.04274812327836e-5*x_31 - 0.000979762518580593*x_32 - 0.000195727899777035*x_33 - 0.0016014542916256*x_34 - 0.00218425947203164*x_35 + 0.000391178725910886*x_36 + 0.000237425203254793*x_37 + 0.00158960246571612*x_38 + 0.000439301720157888*x_39 - 1.74371739977475e-5*x_4 - 0.000290845795443019*x_40 - 0.000342476781592196*x_41 - 0.00200399051312582*x_42 + 0.000278797723952441*x_43 + 0.000183882206688029*x_44 - 0.00146182951026876*x_45 + 0.0021196675865502*x_46 - 0.000168949430771122*x_47 + 0.000146867371377664*x_48 - 0.000680162414466692*x_49 - 0.000760847200685507*x_5 + 0.000310402553857133*x_50 + 0.000341036662673129*x_51 + 0.000632451769673286*x_52 - 0.00170586292647001*x_53 + 0.000356082769866891*x_54 - 0.00230621819626041*x_55 - 0.00140448855506936*x_56 - 0.00266402371644298*x_57 + 0.00103204699008907*x_58 + 0.00115725743156292*x_59 + 0.000178618559753865*x_6 + 7.41557771085754e-5*x_60 + 4.21634641850707e-5*x_61 - 7.38423915846773e-6*x_62 + 4.36771931229906e-5*x_63 - 3.37984557241615e-5*x_64 - 8.77688857745734e-5*x_65 + 3.33587510306335e-5*x_66 - 3.60180778555358e-5*x_67 - 2.13856602960241e-5*x_68 + 7.89764579915864e-5*x_69 - 0.000547823901579764*x_7 - 1.52048780733974e-5*x_70 + 7.59181888178253e-5*x_71 + 1.30364878879828e-5*x_72 + 1.77699088298919e-5*x_73 + 6.66869732226274e-5*x_74 - 0.000248861563298745*x_75 - 4.36770708815248e-5*x_76 - 3.08410063791624e-5*x_77 + 0.000199255949998949*x_78 + 1.19651795506656e-5*x_79 + 0.000161695129185533*x_8 + 2.00830519165731e-5*x_80 - 1.82264359538277e-5*x_81 - 9.55249610571159e-5*x_82 - 0.000385371459006093*x_83 + 4.00880970641152e-5*x_84 + 3.34194099318185e-5*x_85 - 0.000384817717287437*x_86 - 4.5241055541939e-5*x_87 + 0.000113909145334937*x_88 + 1.05711848852364e-5*x_89 - 0.000168280525328609*x_9 + 0.000153383876331012*x_90 - 1.09240983919057e-5*x_91 + 0.000351838288416658*x_92 + 0.000178688675898692*x_93 + 3.22873656403032e-5*x_94 + 0.00122856636642643*x_95 - 0.00120166365070642*x_96 + 0.000484545892642667*x_97 + 0.00101750594396007*x_98 + 0.000841546213506853*x_99 + 8.73440343485374e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 2.57102894129668e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 1.26285810747512e-6*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) - 4.44121806868201e-6*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 1.20385059203656e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.00512896626670296*std::sin(0.213359996676445*x_10 - 1.37991976737976) + 0.00113517758293341*std::sin(0.447439849376678*x_10 - 1.43487977981567) - 0.00179028061542449*std::sin(0.260159969329834*x_100 - 7.60351991653442) - 3.95535454095956e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) + 0.00030808938809286*std::sin(0.267839968204498*x_102 + 7.99520015716553) - 0.00147736955577731*std::sin(0.242719978094101*x_103 - 4.42375993728638) + 0.00657396731113011*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.00111321500792388*std::sin(0.273679971694946*x_108 - 7.62088012695313) + 0.000693795326532447*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 0.000743904966764062*std::sin(0.278079956769943*x_109 + 1.58247983455658) + 0.000465349530066752*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 0.000182729777435609*std::sin(0.274239957332611*x_110 + 4.75271987915039) - 0.00185072022906798*std::sin(0.236399978399277*x_111 - 4.42143964767456) + 0.00626137998196577*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 4.02513438562541e-5*std::sin(0.306399941444397*x_111 - 8.07583999633789) - 0.00185520951340035*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 0.00307128114253166*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.0023038805381465*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.00338260725650543*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.00385999499425757*std::sin(0.257839977741241*x_115 + 4.76639986038208) - 0.00653601066995145*std::sin(0.304879933595657*x_116 + 1.7325599193573) + 0.0062216023641773*std::sin(0.258879989385605*x_117 + 8.17216014862061) + 0.00111602625777574*std::sin(0.277439951896667*x_119 - 7.63727998733521) + 0.000166508744521605*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000336673265395642*std::sin(0.269519954919815*x_12 - 4.24232006072998) - 0.000302346863902835*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.00654827200877371*std::sin(0.363919854164124*x_12 - 1.37199985980988) + 0.000525779754963445*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 0.000279414248648497*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 0.000641828030008211*std::sin(0.345839858055115*x_14 + 4.82800006866455) + 0.00738343876385857*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 0.000202240990503096*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 0.000150955145230766*std::sin(0.222079992294312*x_15 - 1.59383988380432) - 0.00500989277120892*std::sin(0.401519864797592*x_15 - 1.37799990177155) + 0.00908015215198203*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.00641818068005589*std::sin(0.386159837245941*x_16 - 7.57615995407104) - 0.000196614601798816*std::sin(0.437599837779999*x_16 + 4.97447967529297) + 0.00185980233735053*std::sin(0.331279844045639*x_19 - 7.56640005111694) - 0.000920689785853124*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 0.000676730856623021*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.00121494638428944*std::sin(0.33943983912468*x_20 + 1.81687986850739) - 0.000459207056819842*std::sin(0.385999828577042*x_20 - 4.40111970901489) + 0.000420111507267031*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.00241016056381527*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.00182301251614718*std::sin(0.200719982385635*x_23 - 1.610879778862) + 0.000296606036545877*std::sin(0.333439826965332*x_23 + 1.60327982902527) - 0.000863595196038691*std::sin(0.428079843521118*x_23 - 4.39831972122192) + 9.43282782213232e-5*std::sin(0.431919872760773*x_23 - 7.80887985229492) + 8.54621765961059e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) - 0.00518638605096285*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 0.000112195425514765*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 0.00109929457985594*std::sin(0.385359823703766*x_26 - 7.57872009277344) - 0.000129660055282183*std::sin(0.411839872598648*x_26 + 4.99191999435425) + 0.0108653836935861*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 0.000531235175008105*std::sin(0.348879843950272*x_28 + 5.00719976425171) - 0.00129345087106377*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.00509242223949118*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.00232099746027043*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 0.00129012629563674*std::sin(0.368239849805832*x_29 - 4.39232015609741) + 0.00857217518174724*std::sin(0.194879993796349*x_3 - 4.60231971740723) + 0.000289964889582176*std::sin(0.326319932937622*x_3 + 8.03744029998779) + 0.000217338045947813*std::sin(0.316399931907654*x_31 - 4.54760026931763) + 0.00437536559689618*std::sin(0.296879917383194*x_32 - 1.34903991222382) - 0.00501120023227627*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.000393911996448309*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.000521885032667673*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.00123760987437635*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.00103672153157025*std::sin(0.305199921131134*x_4 - 4.57615995407104) - 0.00890692201931343*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 0.00049943045634799*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.0097036275192265*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 0.000872066169361345*std::sin(0.268079966306686*x_44 - 7.61872005462646) + 0.00293506458320805*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 0.00167157857152218*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.00269909037177619*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.00198467995317163*std::sin(0.318559914827347*x_5 + 8.2260799407959) - 0.000233793557856967*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 0.000510725702460867*std::sin(0.498079866170883*x_5 - 4.62080001831055) - 0.000873899439026491*std::sin(0.224639996886253*x_51 - 4.40959978103638) + 6.9352555364136e-5*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.00101590635870645*std::sin(0.31279993057251*x_53 - 4.63367986679077) + 0.000677284725645436*std::sin(0.252559989690781*x_54 + 4.95887994766235) - 0.000242211556994857*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.000827449034285386*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 0.00939687911856236*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 8.16411788397137e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) + 0.00156006561497462*std::sin(0.343759834766388*x_6 - 7.58983993530273) - 0.00069753980965843*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 0.000175696571370483*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 6.05660282671297e-5*std::sin(0.353279858827591*x_60 - 4.75863981246948) + 0.000186768403620856*std::sin(0.424159854650497*x_60 + 4.95928001403809) + 0.00296719211832223*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.00358995164174295*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 0.000256941808437792*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 0.000678254596835494*std::sin(0.338479846715927*x_7 - 4.58527994155884) + 0.00132275751382554*std::sin(0.339999854564667*x_7 + 5.0099196434021) - 0.000316536456536439*std::sin(0.361119836568832*x_7 + 8.21175956726074) + 0.000325057476163835*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 0.000140799413045944*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 6.83240016505494e-5*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.000199271757403756*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 0.000563426558095061*std::sin(0.384799838066101*x_8 + 1.81071984767914) + 0.000292950371330639*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 0.000137850908782228*std::sin(0.401119858026505*x_8 - 1.60423982143402) + 0.00434120184552474*std::sin(0.435199856758118*x_8 + 7.97311973571777) + 3.98337956652382e-5*std::sin(0.451999872922897*x_8 - 1.62583994865417) + 0.000330648072102156*std::sin(0.312319934368134*x_9 + 8.1758394241333) + 0.000185800609010073*std::sin(0.348319828510284*x_9 - 4.58048009872437) - 0.000180352011191829*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 0.000330657816684551*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 0.000471548759169609*std::sin(0.284399926662445*x_93 + 7.97679996490479) - 0.00527618756858972*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.0047580833058664*std::sin(0.314399927854538*x_94 - 7.61816024780273) - 0.00240585468518032*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.00143023534679738*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.00869140897491228*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 0.000593175468633982*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.00138250465239807*std::sin(0.319359838962555*x_98 - 4.56112003326416) + 0.0458429551506951);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.00287362715118e-5*x_1 + 0.000392557279484422*x_10 - 0.000162766953922518*x_100 - 2.72171701478243e-5*x_101 - 0.000456453011770173*x_102 - 0.00028732536538736*x_103 + 0.000170472073614421*x_104 + 0.000219504259500972*x_105 - 9.43072609451058e-5*x_106 - 0.000199217567068896*x_107 - 8.65241714152941e-5*x_108 - 0.000138989163594296*x_109 - 0.000104783836890946*x_11 + 0.000304051900686001*x_110 + 0.000396768574295057*x_111 + 0.000254696741111321*x_112 + 0.00033214280512833*x_113 + 1.75876478663688e-5*x_114 + 0.000546950929939922*x_115 - 0.000107604878582753*x_116 + 0.000283641219311975*x_117 - 0.000578699057868761*x_118 - 1.26129453059226e-5*x_119 + 0.000270009660799126*x_12 + 2.81985049640119e-5*x_120 - 4.57810722019371e-5*x_13 + 9.66577686762529e-5*x_14 + 8.17377989011244e-5*x_15 - 3.20545630649591e-5*x_16 - 4.72925189423266e-5*x_17 - 0.000131668689339853*x_18 + 0.000325922853130818*x_19 - 0.000171664912892146*x_2 + 0.000336855719635201*x_20 - 0.000130063305146287*x_21 + 0.000532695553294407*x_22 - 5.29070361509849e-5*x_23 - 3.02159122932595e-5*x_24 + 0.000323974450494398*x_25 + 0.000236728227041831*x_26 - 0.000259098606328108*x_27 + 1.44865970791263e-5*x_28 - 1.83244503863398e-5*x_29 + 8.39524975041728e-6*x_3 + 0.000146017411113724*x_30 + 7.89438084976329e-6*x_31 + 0.00020749774438032*x_32 + 0.000100598285335643*x_33 + 0.000427497618064354*x_34 + 0.00112539792559139*x_35 - 0.000305517859644419*x_36 - 5.90710551164552e-5*x_37 - 0.000677329011921853*x_38 - 0.000110951142091684*x_39 + 0.000113137716153917*x_4 + 2.16014207425434e-5*x_40 + 0.000185616560212654*x_41 + 0.000732291181295435*x_42 + 0.000469344849854424*x_43 + 2.75522483096631e-5*x_44 + 0.000328133893395234*x_45 - 0.000558191276482564*x_46 + 0.000451848740326139*x_47 - 6.69798632548435e-6*x_48 + 0.000664698351934746*x_49 + 0.000232150654537879*x_5 + 0.00029447992075945*x_50 + 0.000161005115227335*x_51 - 0.000387821013978279*x_52 + 0.000530271653192803*x_53 + 0.000262825008471716*x_54 + 0.000661917965055218*x_55 + 0.000508440243246881*x_56 + 0.00118629192921245*x_57 - 0.000468585903661174*x_58 - 0.00034558620202*x_59 - 5.51851140903209e-5*x_6 + 0.000168094439398082*x_60 - 1.54348676846294e-5*x_61 - 1.11638466461605e-6*x_62 - 2.00192228074616e-5*x_63 - 1.08803439051603e-5*x_64 + 2.42309066432496e-5*x_65 - 3.40661511839609e-5*x_66 + 2.18584391799763e-5*x_67 - 2.55384722858138e-6*x_68 - 2.98791726738267e-5*x_69 + 0.000197640790797455*x_7 + 9.894100286667e-7*x_70 - 4.55226383889344e-6*x_71 - 1.99166143872621e-5*x_72 - 1.0294689404781e-5*x_73 + 4.10620196469494e-6*x_74 + 5.3784537047708e-5*x_75 + 5.69644627182564e-6*x_76 + 6.5832489211635e-6*x_77 - 3.00004362991464e-5*x_78 + 7.53884862377674e-7*x_79 + 0.000108417794299555*x_8 - 4.14643072393248e-6*x_80 + 2.32843096062535e-5*x_81 + 2.56312656039863e-5*x_82 + 4.13097221213778e-5*x_83 - 1.90847829454349e-6*x_84 + 1.21339047592799e-5*x_85 + 8.55643747125094e-5*x_86 - 1.06038339992906e-5*x_87 - 9.1095045383287e-5*x_88 - 2.27704435174513e-5*x_89 + 7.24714173832405e-5*x_9 - 1.66723727776067e-5*x_90 - 3.46821417446639e-6*x_91 - 1.60811956982771e-5*x_92 + 0.000256725113015105*x_93 - 2.1292846966956e-5*x_94 - 0.00031454505249888*x_95 + 0.000290095585427416*x_96 - 7.50901247391922e-5*x_97 - 0.000246938313033596*x_98 + 0.00012902577920197*x_99 - 1.58401083342637e-8*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 1.08781119476853e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) - 6.77447205342903e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 9.72313274653581e-7*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) + 1.66782572360396e-7*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) + 0.00175775249954313*std::pow(-0.0100405332085643*x_1 - 0.0322593516385434*x_100 - 0.0142384659944151*x_101 + 0.144645140646036*x_102 - 0.0228524724392685*x_103 + 0.149685056449466*x_104 - 0.057016325113407*x_105 + 0.00334490515501552*x_106 - 0.0252659401371838*x_107 + 0.0646560596776367*x_108 - 0.0219111805236324*x_109 + 0.21470296228714*x_11 - 0.0285929115462857*x_111 - 0.00196835287887571*x_113 - 0.194298936076896*x_115 + 0.00233205344562008*x_116 + 0.161837579616426*x_117 - 0.207603903502446*x_118 + 0.0141188165667643*x_119 + 6.3455662220906e-5*x_120 - 0.0495527110249298*x_13 - 0.0386806345487225*x_14 + 0.2017181705261*x_15 + 0.028524094179675*x_16 - 0.0493182987831491*x_17 - 0.170470447269985*x_18 - 0.0224568476120667*x_2 - 0.00289041471290232*x_20 - 0.0408653777865216*x_22 - 0.0278962789163343*x_24 - 0.0963487369029652*x_25 + 0.169632019231645*x_26 + 0.135305765520907*x_27 + 0.0469967656342432*x_28 - 0.0218988869802659*x_29 - 0.0159916294823554*x_3 - 0.00336128047262478*x_30 - 0.00222364349809238*x_31 + 0.0168043260124838*x_32 - 0.0319307732616878*x_34 - 0.0390077859281869*x_35 + 0.00253044192156564*x_36 - 0.128656344118852*x_37 + 0.284048715278597*x_38 - 0.298937844927289*x_39 + 0.00300963640869731*x_40 + 0.0583149363421702*x_41 + 0.0602706897441279*x_42 + 0.100963330267249*x_43 - 0.0416540159093972*x_44 - 0.304577196257328*x_45 - 0.0313816674199702*x_46 - 0.0465309600843023*x_47 - 0.0432473302139326*x_50 + 0.092441521316435*x_51 - 0.0263195715658396*x_52 - 0.271731197837732*x_54 + 0.0405336342454731*x_55 - 0.30240439129018*x_56 - 0.330943542709881*x_58 + 0.0335816382236639*x_59 - 0.0483919075625278*x_60 + 0.00437765081245325*x_61 + 0.0128033039860678*x_62 + 0.00586432756437828*x_63 + 0.00744165673287731*x_64 - 0.000517591988796818*x_65 + 0.0017428540128748*x_66 + 0.0110538388478611*x_67 - 3.97853638951318e-5*x_68 + 0.00544007841163032*x_69 - 0.0326337907910574*x_7 + 0.0161759773570315*x_70 + 0.0490159517699019*x_71 + 0.00954415774621544*x_72 + 0.0153837176599932*x_73 + 0.00980154062444926*x_74 + 0.0112591600200287*x_75 + 0.00336165820724046*x_76 + 0.0105525926488334*x_77 + 0.00549229058949161*x_78 + 0.0122381497689579*x_79 - 0.0142855961746685*x_8 + 0.00710574877303263*x_80 + 0.0115274600294978*x_81 + 0.00650604516880126*x_82 + 0.00713590021503433*x_83 + 0.0144650922890037*x_84 + 0.0174021013426008*x_85 + 0.010184141337893*x_86 + 0.00789465219550324*x_87 + 0.0153613549023105*x_88 + 0.0112018562219167*x_89 + 0.0307225200736416*x_90 - 0.0352813003589014*x_92 + 0.0100746963728036*x_93 - 0.0815692692137285*x_94 + 0.0132636040856828*x_97 + 0.156499319010238*x_99 + 0.7957217043976*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.326194532707802*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 1.30044012338831*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 1.61494357896418*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.235996753806087*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 1.30365954011797*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 1.68944233972198*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 1.27787109990162*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.27611919924153*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.726707289228735*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 2.05738258734125*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 1.89197251887494*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 1.39119459260333*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.712116545826532*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.580014233686938*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 1.09355407363828*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.231773293839208*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.126420757328781*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 1.68642406210811*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 1.00254737668658*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.969089748496497*std::sin(0.319359838962555*x_98 - 4.56112003326416) + 1.94376254335101, 2) + 0.00423410855571203*std::exp(0.00309258551673673*x_1 + 0.0114526389495146*x_10 + 0.0117455577832804*x_100 - 0.023699277611593*x_101 + 0.00725864991760944*x_102 + 0.00260309175251921*x_103 + 0.00527870408874103*x_104 + 0.00388390706532871*x_105 + 0.000408781593904168*x_106 + 0.00648079074300976*x_107 + 0.00384232216049666*x_108 + 0.0366401791734492*x_109 - 0.0770661788630729*x_11 + 0.00380220571389298*x_110 + 0.0238683662669161*x_111 + 0.00663765077569371*x_112 + 0.00533202824226619*x_113 + 0.00407291414167939*x_114 - 0.120516818104822*x_115 + 0.0695666323757965*x_116 + 0.00531205572539511*x_117 - 0.0211179663520774*x_118 + 0.00360739917700138*x_119 + 0.00293377424819312*x_12 + 0.0059701346594588*x_120 + 0.0136356200086494*x_13 + 0.00523803491143232*x_14 + 0.0494742868818034*x_15 + 0.000909756774760874*x_16 + 0.00581217936507397*x_17 - 0.0330099887196622*x_18 + 0.01333238896168*x_19 + 0.00332147716029263*x_2 + 0.0102934755302365*x_20 + 0.00496827340956437*x_21 + 0.0144102882366507*x_22 - 0.0437601328792931*x_23 + 0.00229678001304722*x_24 + 0.0104842980316881*x_25 + 0.00725197039480165*x_27 - 0.0445117879730773*x_28 - 0.0121890451989342*x_29 - 0.0265857637533675*x_3 - 0.0362865966913328*x_30 + 0.00606202809409868*x_31 - 0.00746255847907252*x_32 + 0.00519299226061489*x_33 + 0.00448155606859265*x_34 - 0.000454160397465093*x_35 - 0.00803391467481891*x_36 - 0.00414311929219595*x_37 - 0.0161900247116274*x_38 + 0.0702062397741227*x_39 + 0.046097475411501*x_4 + 0.0279004585840842*x_40 + 0.00519967446573539*x_41 + 0.127734101302346*x_42 - 0.160693014091136*x_43 + 0.188317363937229*x_44 + 0.0956009739740193*x_45 - 0.127055643435765*x_46 + 0.0208920892158778*x_47 - 0.106505102331103*x_48 - 0.0266854337163949*x_49 + 0.00373054028725452*x_5 + 0.0697379051117711*x_50 + 0.000958968729375824*x_51 - 0.0551323307134368*x_53 - 0.00161604494581946*x_54 - 0.0106860447320765*x_55 + 0.0209461446337042*x_56 + 0.0014646244676906*x_57 + 0.123402475473268*x_58 - 0.138653318716062*x_59 + 0.00751219489398025*x_6 + 0.00170464463583755*x_60 + 0.0057197130015257*x_61 - 0.00428232827048016*x_62 + 0.000412069720199165*x_63 - 0.000222155948106098*x_64 - 0.00522981428710441*x_65 + 0.00255566357095259*x_66 - 0.00024162121736161*x_67 + 0.000658646282150344*x_68 + 0.00144884130631001*x_69 - 0.00115648506922625*x_70 - 0.00139332057392658*x_71 + 0.000818785747546852*x_72 + 0.00290030490581289*x_73 - 0.00122888017875884*x_74 + 0.00106096093150398*x_75 - 0.0015261806801754*x_76 + 0.00232956992005785*x_77 + 8.97862875997784e-5*x_78 + 0.00179226565035321*x_79 - 0.000172471659723343*x_80 + 0.000734632995875323*x_81 + 0.00217866946616003*x_82 + 0.00440316887117089*x_83 + 0.0113451476453001*x_84 - 0.000923984976745108*x_85 + 0.000294581081525354*x_86 - 0.000585290652099832*x_87 + 0.00179878626687429*x_88 + 0.00191928049166359*x_89 + 0.00412146812544924*x_9 - 0.00152107371650014*x_90 - 0.0018660124835335*x_91 + 0.00326153086713544*x_92 + 0.00230390265481454*x_93 + 0.000865266511160677*x_94 + 0.000196207680022716*x_95 - 0.00628138331319266*x_96 - 0.00397107417338446*x_97 - 0.00449898754932759*x_98 + 0.00749185711987604*x_99 - 0.833053855659927*std::sin(0.276479959487915*x_26 + 7.99839973449707) - 0.514944467485073*std::sin(0.247039973735809*x_52 + 1.59447979927063) + 0.507307430298169*std::sin(0.396159827709198*x_7 - 7.5840802192688) - 0.295766934456068*std::sin(0.451999872922897*x_8 - 1.62583994865417)) - 0.00384507465145988*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 0.000276996480533129*std::sin(0.260159969329834*x_100 - 7.60351991653442) + 4.16566696854895e-6*std::sin(0.232319980859756*x_102 - 4.39903974533081) + 0.000353965504296888*std::sin(0.267839968204498*x_102 + 7.99520015716553) + 0.000267925497005022*std::sin(0.242719978094101*x_103 - 4.42375993728638) - 0.00231045930666466*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.000172239277247863*std::sin(0.273679971694946*x_108 - 7.62088012695313) + 0.00079710506796444*std::sin(0.273919969797134*x_109 + 4.94927978515625) - 0.00147278689458677*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 7.73135978048409e-5*std::sin(0.274239957332611*x_110 + 4.75271987915039) + 0.000335633785907681*std::sin(0.236399978399277*x_111 - 4.42143964767456) - 0.00220059865941282*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 0.000241369006163256*std::sin(0.306399941444397*x_111 - 8.07583999633789) + 0.00230247278975507*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.00118883712782576*std::sin(0.298879951238632*x_114 - 7.8452000617981) - 0.000207065449872713*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.00143092499386259*std::sin(0.304879933595657*x_116 + 1.7325599193573) - 0.00218661858271534*std::sin(0.258879989385605*x_117 + 8.17216014862061) - 0.000202394782413054*std::sin(0.277439951896667*x_119 - 7.63727998733521) - 1.7536227659125e-5*std::sin(0.307279914617538*x_119 - 1.63255989551544) - 0.000347367888314585*std::sin(0.305439919233322*x_12 - 1.25543987751007) + 0.000351275297352146*std::sin(0.363919854164124*x_12 - 1.37199985980988) + 0.000604071101788926*std::sin(0.338559836149216*x_13 - 1.31959986686707) + 0.000553185772317654*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 9.93051613741747e-5*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.00161645193090507*std::sin(0.349519848823547*x_14 - 7.55999994277954) - 0.000280186535239054*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 0.000905209364181732*std::sin(0.222079992294312*x_15 - 1.59383988380432) + 0.00176075615086102*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.00198791240076767*std::sin(0.202719986438751*x_16 - 7.60552024841309) + 0.000344296682212601*std::sin(0.386159837245941*x_16 - 7.57615995407104) - 0.000225891541116221*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 0.000142451316372906*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 0.000104705409832246*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.000138528736542774*std::sin(0.33943983912468*x_20 + 1.81687986850739) - 0.000527585381794888*std::sin(0.385999828577042*x_20 - 4.40111970901489) - 7.61885094639211e-5*std::sin(0.411519855260849*x_20 + 4.79256010055542) - 0.000587222162772092*std::sin(0.333439826965332*x_23 + 1.60327982902527) + 0.00015661563567829*std::sin(0.428079843521118*x_23 - 4.39831972122192) + 0.000108374250657423*std::sin(0.431919872760773*x_23 - 7.80887985229492) + 9.81879402741149e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) + 0.00182278574752191*std::sin(0.403359860181808*x_25 - 7.60167980194092) + 0.00217638908575213*std::sin(0.385359823703766*x_26 - 7.57872009277344) - 0.000148967113535527*std::sin(0.411839872598648*x_26 + 4.99191999435425) - 0.00381870272351764*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 8.21939714617058e-5*std::sin(0.348879843950272*x_28 + 5.00719976425171) + 0.000234571279830527*std::sin(0.399279862642288*x_28 + 8.19672012329102) - 0.000273177738191566*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.000359110254717695*std::sin(0.192239999771118*x_29 + 1.77327990531921) - 0.00255419870207453*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.0030127411636951*std::sin(0.194879993796349*x_3 - 4.60231971740723) + 0.000333142173460421*std::sin(0.326319932937622*x_3 + 8.03744029998779) + 0.000249700814146934*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.00153774785984923*std::sin(0.296879917383194*x_32 - 1.34903991222382) + 0.00176121566570924*std::sin(0.26335996389389*x_33 + 4.99463987350464) + 0.000599596435037004*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.000191485947242976*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.00194998722912356*std::sin(0.266479969024658*x_40 + 1.7739999294281) + 2.67914316670563e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) + 0.000520541088953495*std::sin(0.236239984631538*x_42 + 4.98647975921631) + 0.0012081685215481*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 0.000258630617600946*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 9.89188590671043e-5*std::sin(0.36847984790802*x_5 - 7.57728004455566) - 0.00101113738302483*std::sin(0.498079866170883*x_5 - 4.62080001831055) - 0.00100402762183599*std::sin(0.224639996886253*x_51 - 4.40959978103638) + 0.000778135952522352*std::sin(0.252559989690781*x_54 + 4.95887994766235) + 2.5509032677751e-5*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.0020572532503464*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 3.45426637831426e-5*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 0.000107925020604281*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 7.43378241097772e-5*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 0.000363186931156868*std::sin(0.353279858827591*x_60 - 4.75863981246948) + 0.000214579192693438*std::sin(0.424159854650497*x_60 + 4.95928001403809) - 0.00222443950825717*std::sin(0.425279855728149*x_60 - 7.63568019866943) - 0.000192579252777442*std::sin(0.428239852190018*x_60 + 4.95824003219604) - 0.000508694719144987*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 0.000104941166546844*std::sin(0.338479846715927*x_7 - 4.58527994155884) - 0.000239886129318789*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 6.92991413262267e-5*std::sin(0.361119836568832*x_7 + 8.21175956726074) + 0.000373460229149879*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 5.95727163036014e-5*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 2.27210559566751e-5*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 8.71746989196001e-5*std::sin(0.384799838066101*x_8 + 1.81071984767914) - 3.08527003746203e-5*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 5.83251940006142e-5*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.000950416781404963*std::sin(0.435199856758118*x_8 + 7.97311973571777) + 0.000213467288419219*std::sin(0.348319828510284*x_9 - 4.58048009872437) - 0.000379894489573195*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 7.29591470545947e-5*std::sin(0.284399926662445*x_93 + 7.97679996490479) + 0.00395544326505648*std::sin(0.288959950208664*x_94 - 4.41472005844116) - 0.000255242470968689*std::sin(0.314399927854538*x_94 - 7.61816024780273) - 0.000466241669249652*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 9.17775212078938e-5*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.0819310199692853);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000111594518853164*x_1 - 4.58595479874536e-5*x_10 - 0.000129804805564599*x_100 + 8.16440176876902e-5*x_101 - 0.000577154860828982*x_102 - 8.11728171988594e-5*x_103 - 0.000129137530712303*x_104 - 9.98575029748977e-5*x_105 - 0.000790677259057071*x_106 - 0.000272206068073259*x_107 - 0.000175099721629982*x_108 - 1.05244824705069e-5*x_109 + 8.58262822475831e-5*x_11 + 0.000730457483992484*x_110 - 0.000432140575675082*x_111 + 0.000203945628881923*x_112 - 0.000196235280005674*x_113 - 2.45087003195264e-5*x_114 - 0.000859572529142449*x_115 - 1.40355136819468e-5*x_116 - 4.06448403730006e-5*x_117 - 0.00103971556879783*x_118 - 2.3329126128238e-5*x_119 - 0.00058209156461351*x_12 - 8.43440587478176e-5*x_120 - 4.65507879967483e-5*x_13 + 0.00202510777103549*x_14 - 6.30976764610125e-5*x_15 - 0.00038653072606343*x_16 + 0.00010091780353761*x_17 - 2.19016279318506e-5*x_18 + 0.000657134123170821*x_19 - 0.000187960613448033*x_2 + 0.000491528281081362*x_20 - 0.000179547776333176*x_21 + 0.00157300221858857*x_22 - 2.65138831537241e-5*x_23 - 6.42358824399597e-5*x_24 - 4.32959960286994e-5*x_25 + 0.000232989338861153*x_26 + 0.000152940512487235*x_27 + 2.80581810711763e-6*x_28 - 3.47875149114898e-5*x_29 - 2.41607746171333e-5*x_3 + 0.000274569940467684*x_30 + 2.20766309755407e-5*x_31 - 1.12426187576017e-6*x_32 + 0.000156975581482434*x_33 - 0.000436581064278735*x_34 + 0.00119545448108571*x_35 + 0.000917735245823258*x_36 - 0.000207662067848993*x_37 - 0.00038476255545937*x_38 - 0.000249548364013956*x_39 - 8.05681662307205e-5*x_4 + 0.000532909665475479*x_40 + 0.00237095862315145*x_41 + 0.00096541358980968*x_42 - 0.000705832287826099*x_43 - 0.000125559938170503*x_44 - 0.000687314855773571*x_45 + 5.71544212925459e-5*x_46 - 0.000146864949776443*x_47 - 0.000203774213545525*x_48 - 0.000512170921151545*x_49 - 1.32272829300813e-5*x_5 - 0.000891923085113335*x_50 - 0.00141257474861794*x_51 - 0.000419734238018896*x_52 - 0.000106635411612436*x_53 + 0.00234117470290123*x_54 + 1.25795831339778e-6*x_55 + 3.24526878647493e-6*x_56 - 0.000195876521913876*x_57 - 0.00126260281798377*x_58 - 0.00097252758421272*x_59 + 0.000100120992962908*x_6 + 0.00120713798912282*x_60 + 9.41060920661328e-7*x_61 + 3.42712810217566e-5*x_62 - 5.76775176201978e-6*x_63 + 1.11159629827364e-6*x_64 + 1.51754626912408e-5*x_65 + 2.69142949259979e-5*x_66 - 2.04775239133394e-6*x_67 - 1.8008957028868e-6*x_68 - 1.00821480123444e-5*x_69 + 0.000722310653460822*x_7 + 2.45405655630458e-5*x_70 + 1.72331894065886e-5*x_71 + 1.78203775796584e-5*x_72 + 1.61342416661884e-5*x_73 - 4.6857543568964e-5*x_74 + 1.25288045688248e-7*x_75 + 2.85373684321286e-5*x_76 - 3.3410154675929e-6*x_77 + 1.11333449484898e-5*x_78 + 1.01715144314085e-5*x_79 + 4.93039225097773e-6*x_8 - 8.30123883379839e-6*x_80 + 1.49934379360094e-5*x_81 + 2.90901964217635e-5*x_82 + 0.000198447654489879*x_83 - 1.24029292506336e-5*x_84 + 3.71329349328518e-5*x_85 + 8.1066758461598e-6*x_86 - 1.14620938234211e-6*x_87 + 4.11166846597708e-5*x_88 + 1.72441921323074e-5*x_89 - 6.007278160042e-5*x_9 + 3.17616489960809e-5*x_90 + 2.60711048341747e-5*x_91 - 9.28058226902943e-5*x_92 - 0.000923457864934844*x_93 + 5.00273739302773e-5*x_94 - 0.00112887596897852*x_95 - 5.48135472742142e-5*x_96 - 8.59949597385733e-5*x_97 - 0.000621707804749653*x_98 + 1.11294335292826e-5*x_99 + 6.45310598284223e-9*std::pow(2.03575968742371 - 8.57536029815674*x_18, 2) + 5.65593983668935e-8*std::pow(3.8724799156189 - 9.36935997009277*x_20, 2) + 9.15328468157662e-8*std::pow(-8.39992046356201*x_18 - 9.38560009002686, 2) + 1.3488299673757e-7*std::pow(-7.5798397064209*x_27 - 1.43911981582642, 2) - 4.21298549958658e-9*std::pow(-7.56376028060913*x_3 - 0.618559837341309, 2) - 0.000285856745904312*std::pow(-0.00620610622128221*x_1 - 0.0229828062797374*x_10 - 0.0235706268546984*x_100 + 0.0475589869477237*x_101 - 0.0145664371018978*x_102 - 0.00522380507586563*x_103 - 0.01059314224559*x_104 - 0.00779410615181717*x_105 - 0.000820330425575837*x_106 - 0.0130054530525841*x_107 - 0.00771065483407903*x_108 - 0.0735283932122856*x_109 + 0.154654055483401*x_11 - 0.00763015037349241*x_110 - 0.0478983089002032*x_111 - 0.0133202349784005*x_112 - 0.0107001515292932*x_113 - 0.00817339978365311*x_114 + 0.241849472087903*x_115 - 0.139604194498282*x_116 - 0.0106600712920492*x_117 + 0.0423788903004208*x_118 - 0.00723921856125749*x_119 - 0.00588740861489938*x_12 - 0.0119806840106579*x_120 - 0.0273635460389835*x_13 - 0.0105115285818953*x_14 - 0.0992834888312643*x_15 - 0.00182567212746141*x_16 - 0.0116637041470903*x_17 + 0.0662434378124236*x_18 - 0.0267550312293209*x_19 - 0.00666543898520549*x_2 - 0.0206566325105943*x_20 - 0.00997017943376511*x_21 - 0.0289181265940596*x_22 + 0.0878164989897794*x_23 - 0.00460910802651942*x_24 - 0.0210395692821114*x_25 - 0.0145530328394034*x_27 + 0.0893248974895288*x_28 + 0.02446060386405*x_29 + 0.0533514992340175*x_3 + 0.0728188346794259*x_30 - 0.012165092950468*x_31 + 0.0149756345792254*x_32 - 0.010421138365053*x_33 - 0.0089934499297746*x_34 + 0.000911395223483502*x_35 + 0.0161222147535811*x_36 + 0.00831428533686706*x_37 + 0.0324896474298845*x_38 - 0.140887739102771*x_39 - 0.0925070066416774*x_4 - 0.0559897886924147*x_40 - 0.0104345480103307*x_41 - 0.256332895718553*x_42 + 0.322473835911871*x_43 - 0.377909538016438*x_44 - 0.191849116582184*x_45 + 0.254971387180187*x_46 - 0.0419256069578496*x_47 + 0.213731188546993*x_48 + 0.053551513873636*x_49 - 0.00748633438272845*x_5 - 0.139947899397149*x_50 - 0.00192442917590662*x_51 + 0.110637878494461*x_53 + 0.00324302967140088*x_54 + 0.0214444284026199*x_55 - 0.0420340837204324*x_56 - 0.00293916367763633*x_57 - 0.247640321217178*x_58 + 0.278245247941654*x_59 - 0.0150752434216305*x_6 - 0.00342082882503759*x_60 - 0.0114781454710341*x_61 + 0.00859364566546991*x_62 - 0.000826928937062523*x_63 + 0.000445815775885454*x_64 + 0.0104950316839087*x_65 - 0.00512862764872846*x_66 + 0.000484878084097076*x_67 - 0.00132175125543202*x_68 - 0.00290749051112066*x_69 + 0.00232079893800914*x_70 + 0.00279607320000987*x_71 - 0.00164311424671925*x_72 - 0.00582024336018159*x_73 + 0.00246607923413324*x_74 - 0.00212910401407172*x_75 + 0.00306269280599609*x_76 - 0.00467490981107563*x_77 - 0.000180180381445618*x_78 - 0.00359666400254772*x_79 + 0.000346110862451869*x_80 - 0.00147423907322436*x_81 - 0.00437208738606545*x_82 - 0.00883614489456853*x_83 - 0.0227670960113522*x_84 + 0.00185422484892187*x_85 - 0.000591156323028909*x_86 + 0.00117454341605012*x_87 - 0.00360974937675615*x_88 - 0.00385155350926807*x_89 - 0.00827083643628935*x_9 + 0.0030524443071703*x_90 + 0.00374465689642993*x_91 - 0.00654514059381348*x_92 - 0.00462340152661665*x_93 - 0.0017363904244264*x_94 - 0.000393743583503948*x_95 + 0.0126052883088574*x_96 + 0.00796903044369797*x_97 + 0.00902843089325963*x_98 - 0.0150344301973197*x_99 + 1.67174705058102*std::sin(0.276479959487915*x_26 + 7.99839973449707) + 1.03337483991264*std::sin(0.247039973735809*x_52 + 1.59447979927063) - 1.01804906678808*std::sin(0.396159827709198*x_7 - 7.5840802192688) + 0.593536056494969*std::sin(0.451999872922897*x_8 - 1.62583994865417) - 2.89093855829524, 2) - 0.00026631225188749*std::sin(0.213359996676445*x_10 - 1.37991976737976) - 0.00242441958516906*std::sin(0.260159969329834*x_100 - 7.60351991653442) + 8.48941873752179e-5*std::sin(0.232319980859756*x_102 - 4.39903974533081) - 0.00010396919947032*std::sin(0.267839968204498*x_102 + 7.99520015716553) - 0.000109150240086376*std::sin(0.242719978094101*x_103 - 4.42375993728638) - 0.00931499974689158*std::sin(0.307439923286438*x_107 + 1.73607993125916) + 0.00150752917976205*std::sin(0.273679971694946*x_108 - 7.62088012695313) - 0.000234131221274283*std::sin(0.273919969797134*x_109 + 4.94927978515625) + 0.000330265868767104*std::sin(0.278079956769943*x_109 + 1.58247983455658) - 0.00040198249461408*std::sin(0.274239957332611*x_110 + 4.75271987915039) - 0.000136733938062774*std::sin(0.236399978399277*x_111 - 4.42143964767456) - 0.00887207833365037*std::sin(0.253679990768433*x_111 + 1.77215993404388) + 4.37134827108787e-6*std::sin(0.306399941444397*x_111 - 8.07583999633789) + 0.000159470691503099*std::sin(0.335439831018448*x_113 + 8.03087997436523) - 0.00479299397866418*std::sin(0.298879951238632*x_114 - 7.8452000617981) + 0.00027977516114253*std::sin(0.257839977741241*x_115 + 4.76639986038208) + 0.000198503359267249*std::sin(0.304879933595657*x_116 + 1.7325599193573) - 0.00881571533668136*std::sin(0.258879989385605*x_117 + 8.17216014862061) + 8.24536646924669e-5*std::sin(0.277439951896667*x_119 - 7.63727998733521) - 0.000357379456396346*std::sin(0.307279914617538*x_119 - 1.63255989551544) + 0.000102031302009224*std::sin(0.305439919233322*x_12 - 1.25543987751007) - 0.000474623376244083*std::sin(0.363919854164124*x_12 - 1.37199985980988) - 0.000177431947785147*std::sin(0.338559836149216*x_13 - 1.31959986686707) - 0.000124049433326437*std::sin(0.322799921035767*x_14 + 4.77503967285156) + 0.000869171253297308*std::sin(0.345839858055115*x_14 + 4.82800006866455) - 0.000224240361832341*std::sin(0.349519848823547*x_14 - 7.55999994277954) + 7.07760884986713e-6*std::sin(0.404239863157272*x_14 - 7.99567985534668) - 1.63939250195692e-5*std::sin(0.222079992294312*x_15 - 1.59383988380432) + 0.00709878033873926*std::sin(0.401519864797592*x_15 - 1.37799990177155) - 0.000275770771475739*std::sin(0.202719986438751*x_16 - 7.60552024841309) - 0.000465194264934503*std::sin(0.386159837245941*x_16 - 7.57615995407104) + 6.63504279707202e-5*std::sin(0.437599837779999*x_16 + 4.97447967529297) - 0.00124680920379522*std::sin(0.331759840250015*x_19 + 4.80807971954346) + 0.000916437081734289*std::sin(0.269519954919815*x_20 - 1.38383984565735) + 0.00183274502341046*std::sin(0.33943983912468*x_20 + 1.81687986850739) + 0.000154966032372042*std::sin(0.385999828577042*x_20 - 4.40111970901489) + 3.10384573053688e-5*std::sin(0.411519855260849*x_20 + 4.79256010055542) + 0.000131681941535498*std::sin(0.333439826965332*x_23 + 1.60327982902527) - 6.38036858255609e-5*std::sin(0.428079843521118*x_23 - 4.39831972122192) - 3.18324354980011e-5*std::sin(0.431919872760773*x_23 - 7.80887985229492) - 2.88404418623147e-5*std::sin(0.423679858446121*x_24 - 1.60191988945007) + 0.00734886294159196*std::sin(0.403359860181808*x_25 - 7.60167980194092) - 0.000488045510740944*std::sin(0.385359823703766*x_26 - 7.57872009277344) + 4.37556523267942e-5*std::sin(0.411839872598648*x_26 + 4.99191999435425) - 0.0153957331342793*std::sin(0.239119976758957*x_28 + 1.82159984111786) + 0.000719405076234365*std::sin(0.348879843950272*x_28 + 5.00719976425171) - 9.55620566055738e-5*std::sin(0.399279862642288*x_28 + 8.19672012329102) + 0.000369102357588286*std::sin(0.438639879226685*x_28 + 8.16016006469727) + 0.00314312273245111*std::sin(0.192239999771118*x_29 + 1.77327990531921) + 0.000572767626086963*std::sin(0.368239849805832*x_29 - 4.39232015609741) - 0.0121463654851303*std::sin(0.194879993796349*x_3 - 4.60231971740723) - 9.78528265156344e-5*std::sin(0.326319932937622*x_3 + 8.03744029998779) - 7.33438525471933e-5*std::sin(0.316399931907654*x_31 - 4.54760026931763) - 0.00619968544088177*std::sin(0.296879917383194*x_32 - 1.34903991222382) + 0.00710063294903302*std::sin(0.26335996389389*x_33 + 4.99463987350464) - 0.000176117617675444*std::sin(0.290559947490692*x_36 + 4.96271991729736) - 0.00167598620707023*std::sin(0.253279983997345*x_38 - 1.40319991111755) + 0.000270509647374594*std::sin(0.266479969024658*x_40 + 1.7739999294281) - 3.61990719190354e-5*std::sin(0.284799933433533*x_41 - 1.61207985877991) - 0.000703325770343611*std::sin(0.236239984631538*x_42 + 4.98647975921631) - 3.05187549892221e-5*std::sin(0.268079966306686*x_44 - 7.61872005462646) - 0.00226367184676597*std::sin(0.267279952764511*x_48 + 4.96471977233887) - 0.000514316379798373*std::sin(0.36847984790802*x_5 - 7.57728004455566) + 0.00022674303218952*std::sin(0.498079866170883*x_5 - 4.62080001831055) + 0.000294909946933195*std::sin(0.224639996886253*x_51 - 4.40959978103638) - 0.000228559481307442*std::sin(0.252559989690781*x_54 + 4.95887994766235) + 0.000519861192998801*std::sin(0.313039928674698*x_57 + 1.52575981616974) - 0.000285389997944534*std::sin(0.277679949998856*x_58 - 7.65583992004395) + 0.000179600310325924*std::sin(0.346799850463867*x_58 - 4.76103973388672) - 0.000944616816716196*std::sin(0.417759865522385*x_6 - 1.19479990005493) + 0.000386510327138856*std::sin(0.252239972352982*x_60 + 1.5759197473526) + 6.57754940798182e-6*std::sin(0.353279858827591*x_60 - 4.75863981246948) - 6.30276866431935e-5*std::sin(0.424159854650497*x_60 + 4.95928001403809) - 0.00015406605809501*std::sin(0.425279855728149*x_60 - 7.63568019866943) + 0.000260202228385456*std::sin(0.428239852190018*x_60 + 4.95824003219604) + 0.000114072513798947*std::sin(0.301919937133789*x_7 + 7.77184009552002) + 0.000918500549093541*std::sin(0.338479846715927*x_7 - 4.58527994155884) + 9.77272745641163e-5*std::sin(0.339999854564667*x_7 + 5.0099196434021) + 9.61344054132359e-6*std::sin(0.361119836568832*x_7 + 8.21175956726074) - 0.000109695325073677*std::sin(0.372319847345352*x_7 + 7.99711990356445) - 0.000309740974299338*std::sin(0.37951985001564*x_7 - 1.59695994853973) - 0.000300601184060962*std::sin(0.365359842777252*x_8 - 1.76943981647491) - 0.000762999035168669*std::sin(0.384799838066101*x_8 + 1.81071984767914) - 0.000628762439822893*std::sin(0.39031982421875*x_8 - 4.58975982666016) - 0.000303254636298262*std::sin(0.401119858026505*x_8 - 1.60423982143402) - 0.000131845431886396*std::sin(0.435199856758118*x_8 + 7.97311973571777) - 6.2701090418774e-5*std::sin(0.348319828510284*x_9 - 4.58048009872437) + 0.000111585240608595*std::sin(0.351119846105576*x_91 + 1.97359979152679) + 0.000638577012588554*std::sin(0.284399926662445*x_93 + 7.97679996490479) + 0.000273956450424298*std::sin(0.288959950208664*x_94 - 4.41472005844116) + 0.000344869235739617*std::sin(0.314399927854538*x_94 - 7.61816024780273) + 0.000629959455939507*std::sin(0.286799937486649*x_97 - 4.41120004653931) - 0.000803285368342702*std::sin(0.308079928159714*x_98 + 7.96912002563477) + 0.440814942121506*std::sin(-0.00150751703874549*x_1 - 0.00484351988522932*x_100 - 0.00213780778832246*x_101 + 0.0217174735211913*x_102 - 0.00343114163999514*x_103 + 0.0224741822327399*x_104 - 0.00856060926344009*x_105 + 0.00050221451484991*x_106 - 0.00379350722372387*x_107 + 0.00970766288976*x_108 - 0.00328981312966818*x_109 + 0.0322361738359586*x_11 - 0.00429302910990838*x_111 - 0.000295534653541888*x_113 - 0.0291726495656822*x_115 + 0.000350141793419765*x_116 + 0.0242988000451001*x_117 - 0.0311702989611209*x_118 + 0.00211984324927727*x_119 + 9.52743146362969e-6*x_120 - 0.00743999891583395*x_13 - 0.00580763137180288*x_14 + 0.0302865966155344*x_15 + 0.00428269665538907*x_16 - 0.00740480352917128*x_17 - 0.0255949657776008*x_18 - 0.00337174129186933*x_2 - 0.000433975899310228*x_20 - 0.00613565555018584*x_22 - 0.00418843450944414*x_24 - 0.0144661005073849*x_25 + 0.0254690815713236*x_26 + 0.0203152305486409*x_27 + 0.00705624128598254*x_28 - 0.00328796733864228*x_29 - 0.00240103323411075*x_3 - 0.000504673156218654*x_30 - 0.000333864785050517*x_31 + 0.0025230540313183*x_32 - 0.00479418610071968*x_34 - 0.00585675090246396*x_35 + 0.000379928459283643*x_36 - 0.0193168656358247*x_37 + 0.0426479619380175*x_38 - 0.0448834624011153*x_39 + 0.000451876217357659*x_40 + 0.00875558681228153*x_41 + 0.00904922974097786*x_42 + 0.0151589499785271*x_43 - 0.00625406414293121*x_44 - 0.0457301722362319*x_45 - 0.00471174163335235*x_46 - 0.00698630378478697*x_47 - 0.00649328933269656*x_50 + 0.0138794589467831*x_51 - 0.00395170273966536*x_52 - 0.0407985713696652*x_54 + 0.00608584653803121*x_55 - 0.045403940507119*x_56 - 0.0496888979035886*x_58 + 0.00504205212607419*x_59 - 0.00726571225576762*x_60 + 0.000657274175819889*x_61 + 0.00192232807862952*x_62 + 0.000880488470128692*x_63 + 0.0011173136016062*x_64 - 7.77128789897147e-5*x_65 + 0.000261677548978538*x_66 + 0.00165965791462984*x_67 - 5.97349888882814e-6*x_68 + 0.000816790376296847*x_69 - 0.00489973934993929*x_7 + 0.00242871180021455*x_70 + 0.00735940820358287*x_71 + 0.0014329896753513*x_72 + 0.00230975945300476*x_73 + 0.00147163394516836*x_74 + 0.00169048547717342*x_75 + 0.000504729870474504*x_76 + 0.00158439924360666*x_77 + 0.000824629675875953*x_78 + 0.0018374740580198*x_79 - 0.00214488406089636*x_8 + 0.00106687933059715*x_80 + 0.00173076887919684*x_81 + 0.000976837957017039*x_82 + 0.001071406362341*x_83 + 0.00217183416853787*x_84 + 0.00261280588779585*x_85 + 0.0015290788121462*x_86 + 0.00118532775625294*x_87 + 0.00230640183866898*x_88 + 0.00168188170581543*x_89 + 0.00461277519053569*x_90 - 0.00529724471154322*x_92 + 0.00151264640300518*x_93 - 0.0122470650336405*x_94 + 0.00199143897430526*x_97 + 0.0234972969123555*x_99 + 0.119472143815608*std::sin(0.447439849376678*x_10 - 1.43487977981567) + 0.0489758666983136*std::sin(0.273279964923859*x_110 + 1.57231986522675) - 0.195252144796848*std::sin(0.297439932823181*x_112 - 1.4184798002243) - 0.242472676632802*std::sin(0.239839985966682*x_114 + 8.16464042663574) + 0.0354332902507448*std::sin(0.269519954919815*x_12 - 4.24232006072998) + 0.195735518087288*std::sin(0.331279844045639*x_19 - 7.56640005111694) + 0.253658153427203*std::sin(0.303759932518005*x_21 + 1.98103988170624) + 0.191863561068546*std::sin(0.200719982385635*x_23 - 1.610879778862) - 0.0414573996156213*std::sin(0.277759939432144*x_33 - 7.6113600730896) + 0.109110103809867*std::sin(0.305199921131134*x_4 - 4.57615995407104) + 0.308901852243235*std::sin(0.240399971604347*x_48 - 7.60304021835327) - 0.284066667555999*std::sin(0.267439961433411*x_49 + 8.15312004089355) + 0.208878304468055*std::sin(0.318559914827347*x_5 + 8.2260799407959) + 0.106919403990457*std::sin(0.31279993057251*x_53 - 4.63367986679077) - 0.0870851499452385*std::sin(0.320719927549362*x_57 + 1.70343995094299) + 0.164189626641848*std::sin(0.343759834766388*x_6 - 7.58983993530273) + 0.0347991667704202*std::sin(0.312319934368134*x_9 + 8.1758394241333) - 0.0189812076475864*std::sin(0.295199930667877*x_91 + 5.05583953857422) - 0.253204979792292*std::sin(0.278079956769943*x_95 + 4.98383951187134) - 0.15052559670989*std::sin(0.305199921131134*x_96 - 4.61279964447021) + 0.145502163837866*std::sin(0.319359838962555*x_98 - 4.56112003326416) - 1.28618865062639) + 0.531944337732667);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
