
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.00425373017449e-6*x_1 + 0.000276912952993082*x_10 - 0.000793153116991469*x_100 + 0.000109827297000628*x_101 + 0.000219109289448905*x_102 - 0.000859582520486356*x_103 - 0.00120485355449357*x_104 + 0.000423032808094974*x_105 + 0.000465290144244927*x_106 + 0.000230685553796194*x_107 - 0.000411447349098107*x_108 - 0.00173978933380076*x_109 + 0.000535343343561327*x_11 - 4.22176715260188e-5*x_110 + 0.000246525833966326*x_111 - 0.000400797072491211*x_112 + 0.000130906865564879*x_113 - 0.00190086491757616*x_114 - 0.000689298921903624*x_115 - 4.8760547999678e-5*x_116 - 0.000942995800079906*x_117 - 0.000629253326375871*x_118 - 0.000478442738515061*x_119 - 0.00081707923761559*x_12 + 5.14976426497802e-5*x_120 - 0.000521896836901065*x_13 - 0.000227735627589176*x_14 + 0.000240564754856922*x_15 - 0.00042889654421121*x_16 + 1.80880677167476e-5*x_17 + 0.000466815812778733*x_18 - 0.000184382403817844*x_19 - 0.00118991604227278*x_2 - 1.82419633560439e-5*x_20 + 3.81960068740778e-5*x_21 + 0.000317217668557734*x_22 - 0.000250576407184298*x_23 + 8.068652271964e-5*x_24 - 0.000649851400506996*x_25 - 0.000317697911022854*x_26 + 4.50410850871242e-5*x_27 + 0.000855462492125156*x_28 + 0.000710177768544757*x_29 + 0.000191676921548597*x_3 + 0.00102186194356709*x_30 - 6.12795321161625e-5*x_31 + 0.00036059340793038*x_32 + 0.000204292245545101*x_33 - 0.000874933889850381*x_34 - 0.000400372283080846*x_35 + 0.000488578406947406*x_36 + 0.000688403839148416*x_37 - 0.000535606476495244*x_38 - 0.00202127374956569*x_39 + 8.56187067338108e-5*x_4 - 5.50214183057672e-5*x_40 + 0.0003365726127444*x_41 - 0.000633454749689662*x_42 - 0.00216978365216875*x_43 - 0.000128081792942374*x_44 - 0.00165261412999719*x_45 + 0.000844720669378819*x_46 + 0.000103335830940514*x_47 - 0.000249344654930652*x_48 - 0.000171548994122731*x_49 - 0.000667964602909685*x_5 + 0.0009437590398581*x_50 - 0.000401603632021717*x_51 + 0.000512574666573609*x_52 + 0.000149694649061916*x_53 + 0.000848810717187937*x_54 - 0.000685214929863873*x_55 + 0.00035284146386976*x_56 - 0.00108294200425538*x_57 + 0.000815026099347125*x_58 - 0.000303433820150286*x_59 - 0.00057198478792112*x_6 + 0.00112106649313658*x_60 - 0.00052242370649319*x_61 - 0.000175297331072682*x_62 - 0.000158674388501412*x_63 + 2.39944381860255e-5*x_64 - 0.000328978654888165*x_65 + 4.29393734757677e-5*x_66 + 8.02753177899597e-6*x_67 + 0.000289494776196067*x_68 - 0.000316991165891463*x_69 - 0.000268635476310723*x_7 + 0.000109437706622027*x_70 + 2.21518100262994e-5*x_71 + 7.53814522154457e-5*x_72 - 3.02754659303498e-5*x_73 + 0.000497256382892354*x_74 - 8.7996187469752e-5*x_75 + 0.00013140971470711*x_76 + 7.50439795758063e-5*x_77 - 4.39236805807526e-5*x_78 + 0.000153141040038377*x_79 - 0.00120586442393995*x_8 + 7.71049831313511e-6*x_80 - 0.000501826562705932*x_81 + 0.000169214347203174*x_82 + 0.000277001913840891*x_83 - 0.000333521387287673*x_84 - 0.000518668157309674*x_85 - 1.12181931175762e-5*x_86 + 0.000314448227361256*x_87 - 0.000488418108575408*x_88 - 0.000178490980996566*x_89 + 0.000290581850369515*x_9 + 0.000326149291485511*x_90 - 0.000157757318156188*x_91 + 0.000244823442683079*x_92 + 0.000317160997301327*x_93 + 0.000125575316698903*x_94 - 7.84975453012454e-5*x_95 - 9.56332116690747e-6*x_96 - 0.000233670839376509*x_97 + 2.15870177467937e-5*x_98 - 0.000125195310713978*x_99 - 0.00111445435322821*std::pow(-0.166617464919414*x_1 + 0.0220302551710618*x_10 - 0.0917037912061808*x_100 - 0.116402021531707*x_101 + 0.340989014323483*x_102 + 0.215898141809529*x_103 - 0.00942655987548405*x_104 - 0.112369234626118*x_105 + 0.0170618838115085*x_106 - 0.0729355415340142*x_107 - 0.309558620352042*x_108 + 0.219396243477123*x_109 - 0.199710553671701*x_11 + 0.381878145292467*x_110 - 0.101320816648363*x_114 + 0.461749004993634*x_115 + 0.174438079933416*x_116 + 0.33865825879916*x_118 + 0.276315259219628*x_119 - 0.442699921616479*x_12 - 0.211503655534512*x_13 - 0.193610187291193*x_14 - 0.331151838498029*x_15 - 0.0111756421374807*x_18 - 0.120383247303645*x_19 - 0.210398020662492*x_21 - 0.0115259558305915*x_24 + 0.00624941852150193*x_25 + 0.0679744569934165*x_26 + 0.394703163974017*x_30 + 0.100892972681067*x_31 - 0.0721849725235563*x_33 + 0.278663151840024*x_36 - 0.29649834012309*x_37 + 0.327658231128267*x_38 + 0.583477317819541*x_39 - 0.316984358315737*x_40 + 0.571136344459586*x_41 - 0.00570565302768483*x_42 - 0.0540660997386595*x_43 + 0.284629134063995*x_44 + 0.474331605446*x_45 - 0.234733065415945*x_47 + 0.276353930765283*x_48 - 0.17010136648961*x_49 - 0.0814571202447606*x_5 - 0.0960571049460872*x_50 - 0.176618141611941*x_51 - 0.372134332990764*x_52 - 0.063962211160164*x_54 - 0.408021182552337*x_55 - 0.250501115693292*x_56 + 0.12336557417721*x_57 - 0.0864652442015142*x_58 + 0.415741514938667*x_59 + 0.0711180124318704*x_6 - 0.517536008593114*x_60 + 0.212751813829669*x_61 + 0.0552584587440108*x_62 + 0.00780424017309192*x_63 - 0.183759785683891*x_64 + 0.119751703557865*x_65 - 0.133849253208828*x_66 + 0.218641974125409*x_67 - 0.103291469316204*x_68 + 0.0641849692925848*x_69 + 0.00369078426004026*x_70 - 0.00576045554609583*x_71 + 0.00797062667408871*x_72 - 0.159549575188633*x_73 + 0.222294420083883*x_74 - 0.0258876432619825*x_75 - 0.0418602674219102*x_76 + 0.00455700138212121*x_77 + 0.0893645514788738*x_78 - 0.13230015335288*x_79 + 0.169988752470107*x_80 - 0.000694733039195679*x_81 - 8.84963738543807e-6*x_82 + 0.00878321089633133*x_83 + 0.058962817644108*x_84 - 0.103669924518163*x_85 - 0.124904401589161*x_86 + 0.206420288651332*x_87 - 0.0273053934150792*x_88 - 0.140006888347272*x_89 - 0.165738832141426*x_90 - 0.254466561068984*x_92 - 0.417556036370912*x_93 - 0.0403445183591497*x_94 - 0.117589758160546*x_95 - 0.0658913842723263*x_96 - 0.200006925240506*x_98 - 0.0269382422097487*x_99 + 1.62563878865659*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.6413253789188*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 2.02586075679588*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 1.4475366378495*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 2.71466576797602*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 1.38334368060397*std::sin(0.304959923028946*x_16 + 5.18527984619141) + 1.70482100887372*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 0.920784683738461*std::sin(0.367199838161469*x_2 + 1.99895977973938) + 2.42849551175675*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 1.65378884165555*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 2.21648697892095*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 1.81169986636907*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 1.94675680205617*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 2.89507327569899*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 2.03569919439499*std::sin(0.361119836568832*x_3 + 1.96599984169006) - 1.03293079647229*std::sin(0.316159933805466*x_32 - 1.14583992958069) - 3.5580962487474*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 3.41361384832243*std::sin(0.231599986553192*x_35 + 1.97151982784271) + 0.738170533853882*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 2.65135343975598*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 2.48979207671974*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 1.64157919932985*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 1.56855785066115*std::sin(0.338799834251404*x_8 + 8.23480033874512) + 2.61296302688081*std::sin(0.302399933338165*x_9 - 7.42071962356567) + 1.4527034125187*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 2.63425078104675*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 3.60158309667109, 2) - 4.64770888597773e-6*std::sin(0.204080000519753*x_10 - 1.37511992454529) + 0.00244000622346748*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.000684070637206586*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 0.000630270462203243*std::sin(0.37255984544754*x_10 + 7.81288003921509) - 1.27493859101555e-5*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 0.00292162885908331*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.00129501951099665*std::sin(0.256079971790314*x_100 + 1.9599198102951) + 6.58416818433074e-6*std::sin(0.259679973125458*x_100 + 1.94807982444763) - 0.00146703475876783*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.00391168411685429*std::sin(0.242479979991913*x_101 - 1.2021598815918) + 0.00149271210475055*std::sin(0.228479996323586*x_103 - 1.22135984897614) + 0.00272767414087366*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.00705055532313451*std::sin(0.271919965744019*x_107 + 1.92799985408783) - 0.00249518831926144*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.000688011217344973*std::sin(0.260479986667633*x_108 + 1.96487975120544) + 0.00229086251790872*std::sin(0.267119973897934*x_108 + 1.96311986446381) - 1.50911232274107e-5*std::sin(0.26895996928215*x_108 - 1.21239984035492) + 7.28613610397822e-6*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.000659805311225081*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.00126247359196682*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.00491011449551185*std::sin(0.249359980225563*x_11 - 7.42104005813599) - 0.0018214127528006*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.00201575323577195*std::sin(0.280639946460724*x_113 - 7.41319990158081) + 0.00393824620625655*std::sin(0.295439928770065*x_113 - 4.42239999771118) + 9.46339200751239e-6*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.00372436949398007*std::sin(0.237919986248016*x_118 - 7.43095970153809) + 5.5747039140635e-6*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.00203292308514085*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.00140881058329462*std::sin(0.238479986786842*x_119 + 5.15775966644287) + 0.00117646391611343*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.00470594563109031*std::sin(0.265759944915771*x_12 - 4.24592018127441) + 0.00186474262052415*std::sin(0.319919914007187*x_12 + 8.1496000289917) - 0.000582125729092004*std::sin(0.285839945077896*x_120 + 8.15007972717285) - 1.25773255331408e-5*std::sin(0.287519931793213*x_120 - 1.24975991249084) + 0.000374800204425031*std::sin(0.300159931182861*x_120 + 1.77239990234375) + 0.00434982475748107*std::sin(0.302159935235977*x_13 - 7.44248008728027) + 3.6080931687944e-6*std::sin(0.349279850721359*x_13 - 1.33511984348297) - 0.000384355260820754*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.00481377770371262*std::sin(0.250879973173141*x_14 - 4.21776008605957) - 0.00153939538408266*std::sin(0.270719945430756*x_14 + 5.1691198348999) + 0.00270567896755299*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.000480483705612739*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.00384965936374885*std::sin(0.320319920778275*x_15 + 1.95847988128662) + 0.000982083846828681*std::sin(0.335039854049683*x_15 - 4.3471999168396) - 7.1400659808826e-6*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.0033318889067469*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.00297274918971549*std::sin(0.363839834928513*x_16 + 5.03007984161377) - 1.1044871232874e-5*std::sin(0.358959853649139*x_17 - 1.18831992149353) + 5.93121975730001e-6*std::sin(0.386799842119217*x_17 - 1.18543982505798) + 0.00245189586826123*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.00336807723746129*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 1.44308419981926e-5*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.000945690658041156*std::sin(0.172080010175705*x_19 + 4.98967981338501) + 5.38746938345726e-6*std::sin(0.424879848957062*x_2 + 5.19400024414063) - 0.00432469437123614*std::sin(0.276079952716827*x_20 - 1.17055988311768) - 0.00156579675026901*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.000632500027497876*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 0.00167707474483036*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 5.5060290369489e-6*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 0.00181028508878705*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.00499918768937678*std::sin(0.332959830760956*x_22 + 1.99087977409363) + 0.00136797080911286*std::sin(0.339119851589203*x_22 - 1.16015994548798) - 0.00208853014701961*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.00132950977709553*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.000473425742407821*std::sin(0.300559937953949*x_25 - 1.19079983234406) - 0.00147157560364998*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.000827874114270883*std::sin(0.267359972000122*x_26 - 1.1807998418808) + 0.00256592925784319*std::sin(0.319199919700623*x_26 - 1.19415986537933) - 2.66229824088779e-5*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 0.00250029764277838*std::sin(0.36711984872818*x_26 - 4.38271999359131) - 0.0144862867910624*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.00956516019032365*std::sin(0.203199997544289*x_27 - 1.20415985584259) - 8.59329774918163e-6*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.000559706768656888*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.0007325642817097*std::sin(0.284639924764633*x_28 - 1.18023991584778) + 0.00231616152652365*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 4.54069266062294e-6*std::sin(0.367439836263657*x_29 + 5.02615976333618) - 5.25326740658358e-6*std::sin(0.31415992975235*x_3 - 1.13303995132446) - 0.00221195307276567*std::sin(0.335119843482971*x_3 + 5.19600009918213) + 0.0013369844666925*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.00224502447211143*std::sin(0.33095982670784*x_30 + 2.03791975975037) + 0.00138719840874916*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.0045807562275751*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.000445615350635184*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.00545590644859466*std::sin(0.416479855775833*x_31 - 4.1956000328064) - 0.00145301992169765*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.000816572261898295*std::sin(0.306559920310974*x_32 + 1.85255992412567) + 0.00179823408791226*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.000569125789368702*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.00504987552555905*std::sin(0.22367998957634*x_33 + 5.18304014205933) - 4.47863142940478e-6*std::sin(0.23871998488903*x_34 + 1.98119986057281) - 0.000770180359933311*std::sin(0.246799975633621*x_35 - 1.19687986373901) + 0.00198571711059685*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 0.00183029058799609*std::sin(0.195119991898537*x_36 + 1.80503988265991) - 1.17233894872488e-5*std::sin(0.206160008907318*x_36 - 4.38503980636597) - 0.00157458192875371*std::sin(0.233519986271858*x_37 + 1.96423983573914) + 0.00215895424076871*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.00152186583852568*std::sin(0.236719980835915*x_39 + 1.96407985687256) + 0.00212998843643521*std::sin(0.310319930315018*x_4 + 2.00831985473633) + 8.5278567991186e-6*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.00102024073428104*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 0.0013611701572754*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 0.00185159538645224*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.00775140783074934*std::sin(0.226639986038208*x_41 + 1.97247982025146) + 0.00242806829571208*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.00109343642044436*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.00852828602590603*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.00392965532022742*std::sin(0.20168000459671*x_48 - 1.18839991092682) + 0.00342322036953255*std::sin(0.215120002627373*x_48 + 1.96871984004974) + 0.00352877721971668*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 0.0035597308355935*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.00478662167237737*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.000611847330117229*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.00209951023565545*std::sin(0.380479842424393*x_5 - 1.16351985931396) - 0.0029620267892568*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.0018602635266016*std::sin(0.218799993395805*x_52 - 7.39351987838745) - 0.000738004069790857*std::sin(0.242159977555275*x_52 + 8.19295978546143) + 0.00248570108991103*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.00571439079918398*std::sin(0.267039954662323*x_52 + 1.93775975704193) - 0.00289620609594941*std::sin(0.244799971580505*x_53 - 7.4125599861145) - 0.00269917515459656*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.00306555050934093*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.00599635716000711*std::sin(0.245999962091446*x_59 - 4.24624013900757) - 0.00397371186099816*std::sin(0.31007993221283*x_6 - 7.38839960098267) + 2.42227255611612e-5*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.00274064275712691*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.00371422749305221*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 5.94586773016102e-6*std::sin(0.466479867696762*x_7 - 7.62304019927979) - 6.30024592489564e-6*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.00290433949671518*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.000893289938285517*std::sin(0.31839993596077*x_9 - 7.44271993637085) - 2.91848978171274e-6*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 0.00316308524866307*std::sin(0.329679846763611*x_9 + 8.27055931091309) + 0.000891000612239244*std::sin(0.343599855899811*x_9 + 8.2553596496582) + 0.0006590540551805*std::sin(0.360399842262268*x_91 + 2.0033597946167) - 0.00171675602118899*std::sin(0.370799839496613*x_91 - 7.39167976379395) - 5.55593085392516e-6*std::sin(0.408639848232269*x_91 - 1.21063983440399) - 0.0010656180855444*std::sin(0.196879997849464*x_92 - 0.973359823226929) + 1.86319639768232e-6*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 0.00288693998079506*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.00538919821946319*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.000651301706672613*std::sin(0.350959837436676*x_92 - 7.59128046035767) - 1.70083332286087e-5*std::sin(0.251839965581894*x_94 - 1.18175983428955) - 8.28537664584804e-6*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.00260296466505038*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 0.00308705221102333*std::sin(0.304239928722382*x_94 - 1.20943987369537) - 0.00222613119999449*std::sin(0.278879970312119*x_95 + 1.96503984928131) - 0.000762663283010454*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.00499994230877305*std::sin(0.285359919071198*x_95 - 1.20247983932495) + 3.80869352495384e-6*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.00359511415507878*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 4.80169752307657e-6*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.00414822341671487*std::sin(0.293199926614761*x_97 - 1.21343982219696) + 0.00155031003728574*std::sin(0.253679990768433*x_98 + 1.97847986221313) + 0.00193536364893919*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.00651719187388869*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.00370022231992024*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 0.00286997439138866*std::sin(0.247679978609085*x_99 + 1.9799998998642) - 0.00164375072012572*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.00106510114951757*std::sin(0.258239984512329*x_99 - 1.22207987308502) - 1.44499635696411*std::sin(0.00455075759146022*x_1 + 0.0226194820658405*x_10 + 0.000832593526625643*x_100 + 0.00192969013156038*x_102 + 0.00530936571945569*x_103 - 0.00362035044284533*x_104 + 0.0015257634291407*x_105 + 0.0212545508794809*x_106 + 0.00666751977593579*x_107 + 0.0180311060830335*x_108 - 0.0037329136213381*x_11 + 0.0133176759331732*x_110 + 0.00979409907804985*x_111 - 0.0116640788626055*x_112 + 0.00744404126003253*x_113 - 0.0126017544005955*x_114 + 0.00125106205258557*x_115 + 0.00214999175404938*x_116 + 0.0190356898953808*x_117 + 0.0034087043862427*x_118 - 0.00196153594252637*x_119 + 0.0249429641646008*x_12 - 0.00137003757163949*x_120 + 0.00764504244894879*x_15 + 0.0034636952848768*x_16 + 0.018893001547413*x_17 - 0.000265682567946196*x_18 - 0.00754666488199606*x_23 - 0.0195713483652494*x_25 - 0.00770342471472137*x_26 + 0.0110836677950105*x_27 + 0.000994249027250724*x_28 - 0.0190164066623333*x_29 - 0.0132863586749613*x_3 - 0.0062456613181557*x_30 - 0.00989948787278916*x_31 - 0.0245436395691127*x_33 - 0.00349480139615287*x_34 - 0.0153904423218838*x_35 + 0.0127443602121137*x_36 - 0.00404876256455194*x_37 + 0.0142580593400441*x_39 + 0.00040336467928055*x_4 + 0.00188422484043775*x_40 + 0.0022294450277994*x_41 - 0.00227657270684538*x_43 - 0.0122682181548363*x_44 + 0.0187498280881785*x_45 + 1.21616612170655e-5*x_46 + 0.0064928940415429*x_47 - 0.0296982477618222*x_49 + 0.00230416822258143*x_50 - 0.0100175516558828*x_51 + 0.00674932667615857*x_53 - 0.0133968707171338*x_54 - 0.014590634149193*x_55 - 0.0110272591749654*x_56 + 0.00355218315836915*x_57 - 0.0155287289619399*x_58 + 0.0170425657110178*x_60 - 0.000204422373062482*x_61 - 0.000349862354153133*x_62 + 0.00820353859306116*x_63 - 0.000124040789106811*x_64 - 0.0117309424011497*x_65 - 0.0061812111581279*x_66 + 0.0100107177834523*x_67 + 0.00359292236351687*x_68 - 0.0118929703134699*x_69 + 0.0127228666358541*x_7 - 0.00740242557248807*x_70 + 0.000134378682401027*x_71 + 0.000185616176914564*x_72 - 8.15192593615122e-5*x_73 + 0.0052835527542356*x_74 - 7.27378829005838e-5*x_75 + 0.000560371923667676*x_76 - 0.00596279887039555*x_77 + 0.000744046959304919*x_78 + 0.000679539950711792*x_79 - 0.00131820366558116*x_80 - 0.00596329371433864*x_81 + 0.013694383340545*x_82 - 0.00177947771202563*x_83 + 0.00214877467756306*x_84 + 0.00983638637262924*x_85 + 0.00030763888156493*x_86 - 0.000706438340455936*x_87 - 0.00503559124946973*x_88 - 0.000144135702097133*x_89 + 0.00028352310100157*x_90 + 0.000173709255293401*x_91 + 0.00790932425444047*x_92 + 0.0189098499238456*x_93 - 0.00932784602941198*x_96 + 0.00240692521591169*x_97 + 0.00163569100983073*x_98 + 0.115006897977551*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.159785574540045*std::sin(0.241599977016449*x_109 + 1.95159983634949) + 0.175564086436122*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 0.166151491790616*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.0874338027353598*std::sin(0.295999944210052*x_19 + 2.15703988075256) + 0.0870506851741562*std::sin(0.36575984954834*x_2 + 5.18800020217896) - 0.123349109716118*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.119535253001954*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.0884810528201578*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.202916045608905*std::sin(0.187760010361671*x_24 - 1.41407978534698) - 0.112592340953682*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 0.139590394462832*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.0529889238609749*std::sin(0.285039931535721*x_42 + 8.16335964202881) - 0.134126793084873*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.0631826570643428*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.139838537148192*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.100568479457345*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 0.0290272133185288*std::sin(0.481119841337204*x_6 + 4.95983982086182) + 0.0104611769532168*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.133281374771443*std::sin(0.316079914569855*x_9 - 4.24240016937256) + 0.0930179056159597*std::sin(0.293039947748184*x_94 - 1.20255982875824) - 0.0814140758963076*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.0442246949455556*std::sin(0.254879981279373*x_99 + 4.98095989227295) - 1.95119068924328) - 1.36506373175133);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00116753356773319*x_1 - 0.00444740875796048*x_10 + 0.00125860453965175*x_100 + 0.00219761137160506*x_101 - 0.0033322172300772*x_102 - 0.00510281233048025*x_103 - 0.000564026217875746*x_104 + 0.00140379516617165*x_105 - 0.00292100254747061*x_106 + 0.000333106034709053*x_107 + 0.000246657059144258*x_108 - 0.00314933806671179*x_109 + 0.0036731314263532*x_11 - 0.00821749828458469*x_110 - 0.00247295522217456*x_111 + 0.0010338104447723*x_112 - 0.000690840698981389*x_113 + 0.0038443969953622*x_114 - 0.00689605510107368*x_115 - 0.00268074613292781*x_116 - 0.00305108050249455*x_117 - 0.00557563300619932*x_118 - 0.00352689838957868*x_119 + 0.00201148127343776*x_12 + 0.000846680568386238*x_120 + 0.00292819913998789*x_13 + 0.00313079854591441*x_14 + 0.00254441590304947*x_15 - 0.000976795019764541*x_16 - 0.00314609324629632*x_17 + 0.000964282138529604*x_18 + 0.000553658753495114*x_19 - 0.000179492235556203*x_2 + 2.13665735951208e-5*x_20 + 0.00271860217757621*x_21 + 0.00037097669290376*x_22 + 0.00144796811042007*x_23 + 0.000449026726423747*x_24 + 0.00326896855800805*x_25 - 0.000327391795986482*x_26 - 0.00172276181489189*x_27 + 0.00163891873053214*x_28 + 0.00407155508405348*x_29 + 0.00290822786644897*x_3 - 0.00481489497547809*x_30 + 0.000217213525934877*x_31 + 8.02523565419428e-5*x_32 + 0.00556010970755229*x_33 + 0.00264731126700482*x_34 + 0.00273006099255771*x_35 - 0.00629116679623957*x_36 + 0.00705954852279019*x_37 - 0.00409935895611544*x_38 - 0.0117658600019509*x_39 - 0.000241623636752315*x_4 + 0.00436000393547973*x_40 - 0.00916522829167749*x_41 - 0.000374433789193931*x_42 + 0.000445474180868628*x_43 - 0.00190580154468575*x_44 - 0.0116669759555117*x_45 + 0.00130257028896899*x_46 + 0.00247350624038403*x_47 - 0.00338016525588816*x_48 + 0.00996282654056917*x_49 - 5.38736641874566e-5*x_5 + 0.00323787573998434*x_50 + 0.00448176889691205*x_51 + 0.00526030772981315*x_52 - 0.000808105831787945*x_53 + 0.00358957579346425*x_54 + 0.00959571608412464*x_55 + 0.00653376055966651*x_56 - 0.00242386897625323*x_57 + 0.00427666541925411*x_58 - 0.00602442324259835*x_59 - 0.000921886420926246*x_6 + 0.00621859602797859*x_60 - 0.00390540469265753*x_61 - 0.000764003627208168*x_62 - 0.00168750825560799*x_63 + 0.00275386792151565*x_64 + 0.000355774380716238*x_65 + 0.00287046778144396*x_66 - 0.00502598541935752*x_67 + 0.000869989670699943*x_68 + 0.00108646711155821*x_69 - 0.00198839263393789*x_7 + 0.00144152182726458*x_70 - 0.000151792184899815*x_71 + 0.00056638772451577*x_72 + 0.00191965117515155*x_73 - 0.00364521235751095*x_74 - 0.000485991409381886*x_75 + 0.000877383225080297*x_76 + 0.000924923549948821*x_77 - 0.00187442375336568*x_78 + 0.00236389176561203*x_79 - 0.000341301203241894*x_8 - 0.00210852035704456*x_80 + 0.000401302719087708*x_81 - 0.00261845590262372*x_82 + 0.000416042777796875*x_83 - 0.00112755656006421*x_84 - 0.000675873223179859*x_85 + 0.00149986718627483*x_86 - 0.00263660092495788*x_87 + 0.000913084770482641*x_88 + 0.00204721289020924*x_89 - 0.000210322307715648*x_9 + 0.00301379446273853*x_90 - 9.63798175042822e-5*x_91 + 0.00235367354759465*x_92 + 0.00373615409705342*x_93 + 0.000559648723194813*x_94 + 0.00201695209625917*x_95 + 0.00358023836170835*x_96 - 0.00052267915199665*x_97 + 0.00216936128012193*x_98 + 0.00071103973475724*x_99 + 0.000972233141525234*std::sin(0.204080000519753*x_10 - 1.37511992454529) + 0.000140247433864279*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 4.19993068495402e-5*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 0.00140970542413362*std::sin(0.37255984544754*x_10 + 7.81288003921509) + 0.00166787046508105*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 0.000401761659984882*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 7.95092185809816e-5*std::sin(0.256079971790314*x_100 + 1.9599198102951) - 0.00137731227906623*std::sin(0.259679973125458*x_100 + 1.94807982444763) - 0.000932548817627509*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.00053790703060654*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.0211763165090318*std::sin(0.251679986715317*x_101 + 8.1866397857666) + 8.57985689445934e-5*std::sin(0.228479996323586*x_103 - 1.22135984897614) + 0.00173389845042344*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.000969542315969093*std::sin(0.271919965744019*x_107 + 1.92799985408783) + 0.000839821855846569*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 4.2241243318372e-5*std::sin(0.260479986667633*x_108 + 1.96487975120544) + 0.000131674905736912*std::sin(0.267119973897934*x_108 + 1.96311986446381) + 0.00197421576954916*std::sin(0.26895996928215*x_108 - 1.21239984035492) - 0.0015241537643038*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 4.05095091352822e-5*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.0294214517523806*std::sin(0.241599977016449*x_109 + 1.95159983634949) + 7.25648483564716e-5*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.0109822932416085*std::sin(0.249359980225563*x_11 - 7.42104005813599) + 0.00061304480568119*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.0240130800289196*std::sin(0.234959989786148*x_111 - 4.40944004058838) - 0.00947332073767809*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 0.000115862089162577*std::sin(0.280639946460724*x_113 - 7.41319990158081) + 0.0299249481618168*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 0.000541559660576204*std::sin(0.295439928770065*x_113 - 4.42239999771118) - 0.00197960405151603*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.0213822488562778*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 0.0083301759990276*std::sin(0.237919986248016*x_118 - 7.43095970153809) - 0.00116614702693514*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.00454697288200913*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 8.6495552889521e-5*std::sin(0.238479986786842*x_119 + 5.15775966644287) + 6.76211575535875e-5*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.010525635389346*std::sin(0.265759944915771*x_12 - 4.24592018127441) - 0.00062762862271988*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.0400996130216891*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 3.34596030560551e-5*std::sin(0.285839945077896*x_120 + 8.15007972717285) + 0.00164536158323719*std::sin(0.287519931793213*x_120 - 1.24975991249084) + 0.000238248947677745*std::sin(0.300159931182861*x_120 + 1.77239990234375) - 0.0323267623713843*std::sin(0.275919944047928*x_13 - 4.24416017532349) + 0.0097291114249844*std::sin(0.302159935235977*x_13 - 7.44248008728027) - 0.000754760644969863*std::sin(0.349279850721359*x_13 - 1.33511984348297) + 0.000129364964542004*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.0305936134308455*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.00066195653668639*std::sin(0.250879973173141*x_14 - 4.21776008605957) - 8.84818449410758e-5*std::sin(0.270719945430756*x_14 + 5.1691198348999) + 0.00171991679610263*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 2.94998520483774e-5*std::sin(0.319439917802811*x_14 + 8.14727973937988) - 0.00129570503608226*std::sin(0.320319920778275*x_15 + 1.95847988128662) + 0.000624280457363109*std::sin(0.335039854049683*x_15 - 4.3471999168396) + 0.00149359801777486*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.0204340242996383*std::sin(0.304959923028946*x_16 + 5.18527984619141) - 0.0011214356461748*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.000408791364948915*std::sin(0.363839834928513*x_16 + 5.03007984161377) + 0.00144488641647127*std::sin(0.358959853649139*x_17 - 1.18831992149353) - 0.00124072495915441*std::sin(0.386799842119217*x_17 - 1.18543982505798) + 0.00155859469533853*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.0251827180839471*std::sin(0.406719863414764*x_17 - 1.20767986774445) + 0.00113361578938321*std::sin(0.351359844207764*x_18 - 1.15703988075256) - 0.00188783799664144*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 5.80617701908748e-5*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.0160992593737607*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 0.0160287156161349*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 0.0136013464087476*std::sin(0.367199838161469*x_2 + 1.99895977973938) - 0.00112698028470597*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.0227123749478546*std::sin(0.199680000543594*x_20 + 5.20136022567749) + 0.00145559067617621*std::sin(0.276079952716827*x_20 - 1.17055988311768) - 8.99993508484516e-5*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 3.88330697041796e-5*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 0.000230619413313563*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.0358724567109268*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 0.00115178124087603*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 0.000248937554150928*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.022010126314777*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.0244288977863447*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 0.000687452801684805*std::sin(0.332959830760956*x_22 + 1.99087977409363) + 0.000869576915586248*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.0162920904095488*std::sin(0.413999855518341*x_22 - 4.39455986022949) - 0.000120045183020653*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.0327407783200544*std::sin(0.334719836711884*x_23 - 1.17023992538452) - 0.0373631015368666*std::sin(0.187760010361671*x_24 - 1.41407978534698) - 0.000845128421971395*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 2.90665202457048e-5*std::sin(0.300559937953949*x_25 - 1.19079983234406) - 0.000935435292880101*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 5.08282874120113e-5*std::sin(0.267359972000122*x_26 - 1.1807998418808) + 0.00163108220934538*std::sin(0.319199919700623*x_26 - 1.19415986537933) + 0.00348280978904012*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 0.000343823182159458*std::sin(0.36711984872818*x_26 - 4.38271999359131) + 0.00487574431287684*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.00131533292606217*std::sin(0.203199997544289*x_27 - 1.20415985584259) + 0.00179759298004978*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 3.43638435039072e-5*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.0267614762781682*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 4.49766301623134e-5*std::sin(0.284639924764633*x_28 - 1.18023991584778) + 0.0287564662032026*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 0.000318502090638996*std::sin(0.413119852542877*x_28 + 5.00263977050781) - 0.0427644977125556*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 0.000949846902730293*std::sin(0.367439836263657*x_29 + 5.02615976333618) + 0.00109890718185557*std::sin(0.31415992975235*x_3 - 1.13303995132446) - 0.00012713932419514*std::sin(0.335119843482971*x_3 + 5.19600009918213) + 0.0300702763805303*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 0.000183852612573426*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.00502137314921104*std::sin(0.33095982670784*x_30 + 2.03791975975037) - 0.000466898443323895*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.0102456283260885*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 2.73590691227703e-5*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.000750257523194567*std::sin(0.416479855775833*x_31 - 4.1956000328064) - 8.35171293465706e-5*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.0207317221006465*std::sin(0.297199934720993*x_32 + 8.2344799041748) + 0.00182640059439098*std::sin(0.306559920310974*x_32 + 1.85255992412567) + 0.000103359456173259*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.0152579097233047*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 3.49421351591566e-5*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.000694423033082376*std::sin(0.22367998957634*x_33 + 5.18304014205933) + 0.000936864595259144*std::sin(0.23871998488903*x_34 + 1.98119986057281) + 0.0525583238834855*std::sin(0.239839985966682*x_34 + 1.97279977798462) + 0.050424105957348*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 4.72861127301386e-5*std::sin(0.246799975633621*x_35 - 1.19687986373901) + 0.000114135663451643*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 0.000251688568382617*std::sin(0.195119991898537*x_36 + 1.80503988265991) + 0.00245236267376804*std::sin(0.206160008907318*x_36 - 4.38503980636597) - 9.05043080599002e-5*std::sin(0.233519986271858*x_37 + 1.96423983573914) + 0.00137238072411574*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.0257028963196845*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 9.34367108593936e-5*std::sin(0.236719980835915*x_39 + 1.96407985687256) - 0.0109038663620176*std::sin(0.306159913539886*x_4 - 1.14551985263824) + 0.000122428135427502*std::sin(0.310319930315018*x_4 + 2.00831985473633) - 0.00178390368452266*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 6.26388582244165e-5*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 0.00304448497740511*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 0.00414140312153926*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.00106591857744682*std::sin(0.226639986038208*x_41 + 1.97247982025146) - 0.000817230830429147*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 6.7132791914933e-5*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.00975689495922254*std::sin(0.285039931535721*x_42 + 8.16335964202881) - 0.0190749397127956*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.039164396653223*std::sin(0.204159989953041*x_46 - 1.17471981048584) + 0.0246968788190522*std::sin(0.193120002746582*x_48 - 7.40735960006714) - 0.00132262979847853*std::sin(0.20168000459671*x_48 - 1.18839991092682) + 0.000196760921247407*std::sin(0.215120002627373*x_48 + 1.96871984004974) + 0.0022431350070271*std::sin(0.221679985523224*x_48 - 1.18127989768982) - 0.00119812189468219*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.000658222232038512*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 3.7565073495334e-5*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.0116338755970733*std::sin(0.369519829750061*x_5 - 7.58495998382568) - 0.000120676299957965*std::sin(0.380479842424393*x_5 - 1.16351985931396) - 0.00188286921192136*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.025748587040302*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.000114213027756596*std::sin(0.218799993395805*x_52 - 7.39351987838745) - 4.24192266290509e-5*std::sin(0.242159977555275*x_52 + 8.19295978546143) + 0.00158008363368218*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.000785802456100749*std::sin(0.267039954662323*x_52 + 1.93775975704193) - 0.000166469031509992*std::sin(0.244799971580505*x_53 - 7.4125599861145) + 0.0367778972861793*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 0.00603715719569048*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.00685661702416879*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.000824576468354906*std::sin(0.245999962091446*x_59 - 4.24624013900757) + 0.0185177584064262*std::sin(0.267279952764511*x_59 + 5.12815999984741) - 0.00888787195390858*std::sin(0.31007993221283*x_6 - 7.38839960098267) - 0.00316880897887354*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.00534480511532736*std::sin(0.481119841337204*x_6 + 4.95983982086182) + 0.000922436061733432*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.00830749171572864*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.0242485433802261*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 0.00124378910215928*std::sin(0.466479867696762*x_7 - 7.62304019927979) + 0.00131791986938405*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.0231699104750343*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 0.00192622527964844*std::sin(0.418719857931137*x_8 - 1.58127987384796) - 0.00097753254426175*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.0385973136928831*std::sin(0.302399933338165*x_9 - 7.42071962356567) - 0.0245412112364762*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 5.48445674804342e-5*std::sin(0.31839993596077*x_9 - 7.44271993637085) + 0.000610505640218677*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 0.000434965028574949*std::sin(0.329679846763611*x_9 + 8.27055931091309) + 5.12132093091445e-5*std::sin(0.343599855899811*x_9 + 8.2553596496582) - 0.0214585697305635*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 4.046338490275e-5*std::sin(0.360399842262268*x_91 + 2.0033597946167) - 9.86762346042904e-5*std::sin(0.370799839496613*x_91 - 7.39167976379395) + 0.00116221997563264*std::sin(0.408639848232269*x_91 - 1.21063983440399) + 0.000358662050201669*std::sin(0.196879997849464*x_92 - 0.973359823226929) - 0.00038975360364381*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 0.000396991491699896*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.0120538442102315*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 3.99874205124104e-5*std::sin(0.350959837436676*x_92 - 7.59128046035767) + 0.00222502455037123*std::sin(0.251839965581894*x_94 - 1.18175983428955) + 0.00173318036106258*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.0171274649170635*std::sin(0.293039947748184*x_94 - 1.20255982875824) - 0.00582196632588882*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 0.000424509504999166*std::sin(0.304239928722382*x_94 - 1.20943987369537) - 0.00141508304832681*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.0149908420259024*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 4.68245931104925e-5*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.000687556571587118*std::sin(0.285359919071198*x_95 - 1.20247983932495) - 0.000796723323623937*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.00804107479046006*std::sin(0.260719984769821*x_97 + 8.19032001495361) - 0.0389117651860374*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 0.00100444532608298*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.000570434235924968*std::sin(0.293199926614761*x_97 - 1.21343982219696) + 0.000985484347651825*std::sin(0.253679990768433*x_98 + 1.97847986221313) + 0.000111241431578073*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.000896197960789257*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.00827616680092771*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 0.000394658504283871*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.00814313014394377*std::sin(0.254879981279373*x_99 + 4.98095989227295) - 9.44800132856155e-5*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 6.53931152301122e-5*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.176215037952042);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00107889136498546*x_1 - 0.00582349875293524*x_10 - 0.000233030747269944*x_100 + 1.94228979258034e-5*x_101 - 0.00050238043768518*x_102 - 0.00164366199227935*x_103 + 0.000871507142874072*x_104 - 0.000216646696671612*x_105 - 0.00547226981269355*x_106 - 0.00162268485983449*x_107 - 0.00456112067676209*x_108 - 0.000499663400937668*x_109 + 0.00106052198872516*x_11 - 0.00375955567313496*x_110 - 0.00266087147781198*x_111 + 0.00339974043306019*x_112 - 0.00183178860576309*x_113 + 0.00277215460872998*x_114 - 0.00079283423930424*x_115 - 0.000539616535594181*x_116 - 0.00510336047997796*x_117 - 0.000952284884210858*x_118 + 0.000286841697090058*x_119 - 0.00650912849699162*x_12 + 0.000460527776335038*x_120 - 8.22912444662459e-5*x_13 + 4.44669933283067e-5*x_14 - 0.00162612143987059*x_15 - 0.00100992501690918*x_16 - 0.00474296959355437*x_17 + 0.000171847676870418*x_18 + 0.000101568627773095*x_19 - 0.000251401581410092*x_2 - 9.65152213789602e-6*x_20 - 4.62534344550182e-5*x_21 - 2.86807373388582e-5*x_22 + 0.00169707312655005*x_23 - 0.00014666305336838*x_24 + 0.00510120431352947*x_25 + 0.00192154350845194*x_26 - 0.00288948573220001*x_27 - 0.000328331725728446*x_28 + 0.00498169847064708*x_29 + 0.00341611922946355*x_3 + 0.00156918852500474*x_30 + 0.00253632317229171*x_31 + 0.000145269484231465*x_32 + 0.00677872064625633*x_33 + 0.000769648141086212*x_34 + 0.00392732048869762*x_35 - 0.00333720399573951*x_36 + 0.00112547377164035*x_37 - 0.000317714567556307*x_38 - 0.00438148975369664*x_39 - 7.79073786677877e-5*x_4 - 0.000452417225643846*x_40 - 0.000525095727875394*x_41 - 0.000264349158417099*x_42 + 0.000167189677118918*x_43 + 0.00289069622268799*x_44 - 0.00570485322495094*x_45 + 0.000233433774018507*x_46 - 0.00133489637871087*x_47 - 0.000371333549840286*x_48 + 0.00786317945551502*x_49 - 8.40877244827417e-5*x_5 - 0.000116772322562693*x_50 + 0.00240426305174232*x_51 + 0.000242288513689066*x_52 - 0.00164327367023687*x_53 + 0.00355646780959053*x_54 + 0.00384493464170142*x_55 + 0.0034387334419821*x_56 - 0.00143612538246596*x_57 + 0.00404321688368401*x_58 - 0.000405108233582113*x_59 - 7.71661972544456e-5*x_6 - 0.00420886228533326*x_60 - 8.91961616523024e-5*x_61 - 2.0850346889849e-5*x_62 - 0.00214242796143235*x_63 + 0.000196068845341768*x_64 + 0.0028883517663142*x_65 + 0.00161419444492839*x_66 - 0.00267226966922801*x_67 - 0.000768012182108015*x_68 + 0.00304747004679055*x_69 - 0.00339024574232899*x_7 + 0.00193949770676264*x_70 - 0.000162127598611867*x_71 - 7.70141588518989e-5*x_72 + 0.000120143263996908*x_73 - 0.00138388043072583*x_74 + 2.46750755476499e-6*x_75 - 0.000150148824114897*x_76 + 0.00153507366785668*x_77 - 0.000139695881303708*x_78 - 0.000151131943702108*x_79 - 0.00035698810920963*x_8 + 0.000197367196318079*x_80 + 0.00150086237314068*x_81 - 0.00355532591739583*x_82 + 0.000653311627408749*x_83 - 0.000649762030343309*x_84 - 0.00261207338203948*x_85 - 0.000120651278141219*x_86 + 0.000188101470439765*x_87 + 0.00115145736595657*x_88 + 9.34400961703576e-5*x_89 + 0.000186682688424807*x_9 - 9.92695884324218e-6*x_90 - 9.93160308418929e-5*x_91 - 0.00192547164973952*x_92 - 0.00475173559423091*x_93 - 1.05055400009176e-5*x_94 + 6.24027621890284e-5*x_95 + 0.00206636555769664*x_96 - 0.000813731302722062*x_97 - 0.000217286580688378*x_98 + 7.167178749271e-6*x_99 + 0.000323575274341752*std::sin(0.204080000519753*x_10 - 1.37511992454529) - 0.000326304822508813*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.00120026129506819*std::sin(0.336399853229523*x_10 - 1.13703989982605) + 4.61417563365496e-6*std::sin(0.37255984544754*x_10 + 7.81288003921509) - 2.92200219106628e-5*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 0.000953168087576718*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.00227222411088229*std::sin(0.256079971790314*x_100 + 1.9599198102951) - 0.000458392313035085*std::sin(0.259679973125458*x_100 + 1.94807982444763) - 0.000507562282402588*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.0012761690990539*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.0299481366256899*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.000199622096744164*std::sin(0.228479996323586*x_103 - 1.22135984897614) + 0.000943716230524197*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.0023002115114014*std::sin(0.271919965744019*x_107 + 1.92799985408783) - 0.00021685960665264*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.00120717538487554*std::sin(0.260479986667633*x_108 + 1.96487975120544) - 0.00030635966421266*std::sin(0.267119973897934*x_108 + 1.96311986446381) - 3.45869953634554e-5*std::sin(0.26895996928215*x_108 - 1.21239984035492) - 0.000507263588700463*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.00115768567494401*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.041608636536512*std::sin(0.241599977016449*x_109 + 1.95159983634949) - 0.000168832037142666*std::sin(0.255759954452515*x_109 + 8.17471981048584) - 3.59466800719925e-5*std::sin(0.249359980225563*x_11 - 7.42104005813599) - 0.000158301018835065*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.000647813235153545*std::sin(0.234959989786148*x_111 - 4.40944004058838) - 0.000255566655644821*std::sin(0.312399923801422*x_112 - 7.64192008972168) + 0.000269568985314066*std::sin(0.280639946460724*x_113 - 7.41319990158081) + 0.000807300748473826*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 0.00128483485955216*std::sin(0.295439928770065*x_113 - 4.42239999771118) - 0.000658844979355928*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.00057683994680239*std::sin(0.266079962253571*x_117 - 1.24495995044708) + 2.72659056713165e-5*std::sin(0.237919986248016*x_118 - 7.43095970153809) - 0.000388113023560783*std::sin(0.194319993257523*x_119 + 2.19599986076355) - 1.48829188849512e-5*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.00247188042175873*std::sin(0.238479986786842*x_119 + 5.15775966644287) - 0.000157329864835295*std::sin(0.261599957942963*x_119 - 1.24623990058899) + 3.44519709655691e-5*std::sin(0.265759944915771*x_12 - 4.24592018127441) + 0.000162066866085273*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.00108178792594289*std::sin(0.257359951734543*x_120 - 7.41495990753174) + 7.784833943548e-5*std::sin(0.285839945077896*x_120 + 8.15007972717285) - 2.88256807226436e-5*std::sin(0.287519931793213*x_120 - 1.24975991249084) + 0.000129672760693621*std::sin(0.300159931182861*x_120 + 1.77239990234375) - 0.0457174077347927*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 3.18448294982385e-5*std::sin(0.302159935235977*x_13 - 7.44248008728027) - 0.000251196829574588*std::sin(0.349279850721359*x_13 - 1.33511984348297) - 3.34047454587047e-5*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.0432663402301213*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.00157047301665375*std::sin(0.250879973173141*x_14 - 4.21776008605957) + 0.00020586510507344*std::sin(0.270719945430756*x_14 + 5.1691198348999) + 0.000936106376493297*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.000843050356777331*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.000334578199538996*std::sin(0.320319920778275*x_15 + 1.95847988128662) + 0.000339779760382599*std::sin(0.335039854049683*x_15 - 4.3471999168396) + 0.000497094130734539*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.000551259204267536*std::sin(0.304959923028946*x_16 + 5.18527984619141) + 0.000289578190211029*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.000969845862248021*std::sin(0.363839834928513*x_16 + 5.03007984161377) - 2.53134842493045e-5*std::sin(0.358959853649139*x_17 - 1.18831992149353) - 0.000412933793237316*std::sin(0.386799842119217*x_17 - 1.18543982505798) + 0.000848302915571949*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.00067936716374053*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 0.000292723358494944*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 3.30737121260577e-5*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.00165929632441098*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.0227680210149942*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 0.0226682560681223*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 0.000366930531563771*std::sin(0.367199838161469*x_2 + 1.99895977973938) - 0.000375077683763587*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.0321204732533225*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.0003758640231679*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 0.000209395789964556*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.0011097761851544*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 0.000547137985128859*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.000967749751669676*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 0.000383331852289538*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 0.000590597252174323*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.0311273336768697*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.000659030965088542*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 0.00163096217868529*std::sin(0.332959830760956*x_22 + 1.99087977409363) + 0.000473288299396948*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.0230407280366801*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.000279301524878517*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.000883264849799186*std::sin(0.334719836711884*x_23 - 1.17023992538452) - 0.0528399388585059*std::sin(0.187760010361671*x_24 - 1.41407978534698) - 0.000459981614550111*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.000830666547860359*std::sin(0.300559937953949*x_25 - 1.19079983234406) - 0.000509133316475669*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.00145257697451516*std::sin(0.267359972000122*x_26 - 1.1807998418808) + 0.00088775600087917*std::sin(0.319199919700623*x_26 - 1.19415986537933) - 6.10165959989451e-5*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 0.000815710700258965*std::sin(0.36711984872818*x_26 - 4.38271999359131) - 0.00125901938187054*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.0031205898783586*std::sin(0.203199997544289*x_27 - 1.20415985584259) + 0.00059826868354016*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.00098205409568496*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.00072195813716384*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 0.00128534760251674*std::sin(0.284639924764633*x_28 - 1.18023991584778) + 0.000775778008495582*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 0.000755637132311188*std::sin(0.413119852542877*x_28 + 5.00263977050781) - 0.00115367989360478*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 0.000316124763707863*std::sin(0.367439836263657*x_29 + 5.02615976333618) + 0.000365734490687291*std::sin(0.31415992975235*x_3 - 1.13303995132446) + 0.00029580701387758*std::sin(0.335119843482971*x_3 + 5.19600009918213) + 0.000811221342725398*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 0.000436185083288409*std::sin(0.473119854927063*x_3 + 5.00575971603394) - 1.64357015557477e-5*std::sin(0.33095982670784*x_30 + 2.03791975975037) + 0.000120562964706229*std::sin(0.354239851236343*x_31 - 4.42335987091064) - 3.35354661792391e-5*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.000781870802172915*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.00177996459044977*std::sin(0.416479855775833*x_31 - 4.1956000328064) + 0.000194314015714903*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.0293193788301753*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 5.97808093496634e-6*std::sin(0.306559920310974*x_32 + 1.85255992412567) - 0.000240479900928961*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.00041162049381549*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 0.000998580584884966*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.00164749885401524*std::sin(0.22367998957634*x_33 + 5.18304014205933) + 0.000311804036999271*std::sin(0.23871998488903*x_34 + 1.98119986057281) + 0.00141789298949588*std::sin(0.239839985966682*x_34 + 1.97279977798462) + 0.00136031709262681*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 0.00135134827599751*std::sin(0.246799975633621*x_35 - 1.19687986373901) - 0.000265552219946891*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 0.000597123955031468*std::sin(0.195119991898537*x_36 + 1.80503988265991) + 0.000816186870265593*std::sin(0.206160008907318*x_36 - 4.38503980636597) + 0.000210570641929517*std::sin(0.233519986271858*x_37 + 1.96423983573914) + 0.000746951451216931*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.036349751871604*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.00267024567773874*std::sin(0.236719980835915*x_39 + 1.96407985687256) - 0.000294159222188639*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 0.000284845789331274*std::sin(0.310319930315018*x_4 + 2.00831985473633) - 0.000593712659509972*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.00179010090245939*std::sin(0.33095982670784*x_4 + 2.00415992736816) - 9.96505238561082e-6*std::sin(0.366239845752716*x_4 + 4.79080009460449) - 1.35554287054639e-5*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.00252886144490671*std::sin(0.226639986038208*x_41 + 1.97247982025146) + 0.000211026130360262*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.00191852908558759*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.0137984726076736*std::sin(0.285039931535721*x_42 + 8.16335964202881) + 6.2435116251547e-5*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.0010565581120042*std::sin(0.204159989953041*x_46 - 1.17471981048584) + 0.0349270139018573*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.000341530737558604*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.000457791174606715*std::sin(0.215120002627373*x_48 + 1.96871984004974) + 0.00122088056129903*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 0.00030938018699309*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.00156161348530926*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.0010735392354061*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.0164529509047918*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.000280769904687958*std::sin(0.380479842424393*x_5 - 1.16351985931396) - 0.00102479717587299*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.0364143689613133*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.00326399378684727*std::sin(0.218799993395805*x_52 - 7.39351987838745) + 9.86941281902419e-5*std::sin(0.242159977555275*x_52 + 8.19295978546143) + 0.000859998790775418*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.0018642939306922*std::sin(0.267039954662323*x_52 + 1.93775975704193) + 0.000387312953138585*std::sin(0.244799971580505*x_53 - 7.4125599861145) + 0.000992176288689801*std::sin(0.258399993181229*x_53 + 5.15200042724609) + 1.97605139002851e-5*std::sin(0.259919971227646*x_53 - 1.20503985881805) - 2.24427278639914e-5*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.00195628416965468*std::sin(0.245999962091446*x_59 - 4.24624013900757) + 0.026188329708835*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 2.9091327523248e-5*std::sin(0.31007993221283*x_6 - 7.38839960098267) + 5.55155029913491e-5*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.00755877226160845*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 0.000238192326285764*std::sin(0.261199980974197*x_60 - 7.43887996673584) - 2.71916566363954e-5*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.000654165451328492*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 0.000413953590723203*std::sin(0.466479867696762*x_7 - 7.62304019927979) + 0.000438625536491568*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.000625066615568403*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 0.00272412144114703*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.00025241939294979*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.00104125962273519*std::sin(0.302399933338165*x_9 - 7.42071962356567) - 0.0347068644708083*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 0.0015673547143848*std::sin(0.31839993596077*x_9 - 7.44271993637085) + 0.000203186377406389*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 0.00103194213321684*std::sin(0.329679846763611*x_9 + 8.27055931091309) - 0.000119154530769518*std::sin(0.343599855899811*x_9 + 8.2553596496582) - 0.000578898894360189*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 0.00115636753102151*std::sin(0.360399842262268*x_91 + 2.0033597946167) + 0.000229583745892637*std::sin(0.370799839496613*x_91 - 7.39167976379395) + 0.000386806035917295*std::sin(0.408639848232269*x_91 - 1.21063983440399) - 9.26140592632697e-5*std::sin(0.196879997849464*x_92 - 0.973359823226929) - 0.000129716447463295*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 0.00094185099927668*std::sin(0.296559929847717*x_92 + 1.81431996822357) - 3.94540258514685e-5*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.0011427653628333*std::sin(0.350959837436676*x_92 - 7.59128046035767) - 3.89810045053172e-5*std::sin(0.251839965581894*x_94 - 1.18175983428955) + 0.000576831098284469*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.0242221379326834*std::sin(0.293039947748184*x_94 - 1.20255982875824) + 1.90561621605349e-5*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 0.00100713670152951*std::sin(0.304239928722382*x_94 - 1.20943987369537) - 0.000770193225514181*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.0212004663291835*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.00133815891222158*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.00163120836982095*std::sin(0.285359919071198*x_95 - 1.20247983932495) - 0.000265162703270588*std::sin(0.271519958972931*x_96 + 8.18879985809326) - 2.63196343940727e-5*std::sin(0.260719984769821*x_97 + 8.19032001495361) - 0.00104974274271955*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 0.000334296022288143*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.0013533389666036*std::sin(0.293199926614761*x_97 - 1.21343982219696) + 0.000536373726834728*std::sin(0.253679990768433*x_98 + 1.97847986221313) - 0.000258818393938219*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.00212620411914814*std::sin(0.262879967689514*x_98 + 1.95375978946686) - 2.70891255287425e-5*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 0.000936316053125379*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.0115162414581209*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 0.00021982066349697*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.00186881239387638*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.15597661433795);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00198048263122252*x_1 + 0.00751006878745183*x_10 + 0.00108214257795214*x_100 + 0.00160975015729824*x_101 - 0.00318051469540049*x_102 - 0.00149649965424904*x_103 - 0.00239456127794138*x_104 - 8.79896572454737e-5*x_105 + 0.00671364251472434*x_106 + 0.0030447637035329*x_107 + 0.00893360400516339*x_108 - 0.00213789471988266*x_109 + 0.00133830804606054*x_11 + 0.000469153068744272*x_110 + 0.0042150032493727*x_111 - 0.00511258071552977*x_112 + 0.00228212154588064*x_113 - 0.00404498873667564*x_114 - 0.00242602213366621*x_115 - 0.00213850544365343*x_116 + 0.00641565003442623*x_117 - 0.00441419251428117*x_118 - 0.00335962547201089*x_119 + 0.0107383876210313*x_12 + 0.000684873798003459*x_120 + 0.00307230140204808*x_13 + 0.0013904922166483*x_14 + 0.00565371321090899*x_15 + 0.00130039998292316*x_16 + 0.00641544559652728*x_17 + 0.000188531958401607*x_18 - 0.00165346489856815*x_19 + 0.00130572248926364*x_2 + 7.77139259155614e-5*x_20 + 0.00130864416834466*x_21 + 0.000324366904726904*x_22 - 0.00214135341436796*x_23 + 0.000347253647193991*x_24 - 0.00733937463639392*x_25 - 0.00413351193268205*x_26 + 0.00374767646287568*x_27 + 0.00220763165756758*x_28 - 0.00821025575642909*x_29 - 0.00423139249188692*x_3 - 0.00660456931377849*x_30 - 0.00389042336961273*x_31 + 0.000421996295115917*x_32 - 0.00919200386897599*x_33 - 0.00137035603746574*x_34 - 0.00422412785880633*x_35 + 0.00181226406535716*x_36 + 0.00289629983156702*x_37 - 0.00542578127760941*x_38 - 0.00110141515945267*x_39 + 0.000450269048351308*x_4 + 0.00387203031353685*x_40 - 0.00490154019239606*x_41 + 0.00030853276346383*x_42 + 0.000569004817762011*x_43 - 0.00703441476036625*x_44 - 0.000283908453795432*x_45 - 0.000951795187996577*x_46 + 0.00315038715841545*x_47 - 0.00336549472047659*x_48 - 0.00889072160732689*x_49 + 0.000730895104879332*x_5 + 0.00335574616342396*x_50 - 0.00162587635714236*x_51 + 0.00428264055109473*x_52 + 0.00167731156968853*x_53 - 0.00528200582028019*x_54 - 0.000829909808871284*x_55 - 0.00125571461605085*x_56 - 0.00100728193355021*x_57 - 0.00289328456197472*x_58 - 0.00545810702074226*x_59 + 0.00030260284452278*x_6 + 0.00921776898948671*x_60 - 0.00199662573511224*x_61 - 0.000315275527859988*x_62 + 0.00216580046788651*x_63 + 0.00185076443163921*x_64 - 0.00558533182777751*x_65 - 0.000276787995209038*x_66 + 0.00144911053188502*x_67 + 0.00264742511401019*x_68 - 0.00499158842517164*x_69 + 0.00332756990077085*x_7 - 0.00260911341738422*x_70 - 0.000155740666779924*x_71 + 3.20455684326306e-6*x_72 + 0.00154840689430188*x_73 - 4.70828535749366e-5*x_74 - 0.000113452686962933*x_75 + 0.000816130544057638*x_76 - 0.00167474199656474*x_77 - 0.000568393619463604*x_78 + 0.00175366017092655*x_79 - 0.000171321132621645*x_8 - 0.00280350609121323*x_80 - 0.00199823009430364*x_81 + 0.00474316663994128*x_82 - 0.00111583355399291*x_83 + 0.000991848961106099*x_84 + 0.00388471919060189*x_85 + 0.000889184981692659*x_86 - 0.00207052291598244*x_87 - 0.00255800873858676*x_88 + 0.00118315964474717*x_89 - 0.00175455989549765*x_9 + 0.00159801052550128*x_90 - 1.26108416354181e-5*x_91 + 0.0049899538870309*x_92 + 0.011023707762486*x_93 + 0.000221964980227294*x_94 + 0.00141504990882623*x_95 - 0.00250546159556592*x_96 + 0.000230223061060601*x_97 + 0.00235397837256819*x_98 - 0.00119598927124717*x_99 + 0.00380291635411903*std::sin(0.204080000519753*x_10 - 1.37511992454529) + 0.00490394197052344*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.00154775579335123*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 0.000454176934031617*std::sin(0.37255984544754*x_10 + 7.81288003921509) - 0.000675007015493616*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 0.000569809490464394*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.00293006868242852*std::sin(0.256079971790314*x_100 + 1.9599198102951) - 0.00538739440888931*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.00434203121446636*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.000762901395416032*std::sin(0.242479979991913*x_101 - 1.2021598815918) + 0.0389967181776131*std::sin(0.251679986715317*x_101 + 8.1866397857666) + 0.00300006347114638*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.00807318721780912*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.00137507997419865*std::sin(0.271919965744019*x_107 + 1.92799985408783) - 6.67996630462434e-5*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.00155667162076235*std::sin(0.260479986667633*x_108 + 1.96487975120544) + 0.0046041918837021*std::sin(0.267119973897934*x_108 + 1.96311986446381) - 0.000798988603997525*std::sin(0.26895996928215*x_108 - 1.21239984035492) - 0.00596176886890516*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.00149285386243545*std::sin(0.239599987864494*x_109 + 8.18639945983887) - 0.0541803416035307*std::sin(0.241599977016449*x_109 + 1.95159983634949) + 0.00253732846038623*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.00353825997099741*std::sin(0.249359980225563*x_11 - 7.42104005813599) - 4.87617536584269e-5*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.0157827661502723*std::sin(0.234959989786148*x_111 - 4.40944004058838) - 0.0062264068453207*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 0.0040512752795658*std::sin(0.280639946460724*x_113 - 7.41319990158081) + 0.0196683831615176*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 0.000768081838024586*std::sin(0.295439928770065*x_113 - 4.42239999771118) - 0.00774327504448191*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.0140536338137022*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 0.00268380452427309*std::sin(0.237919986248016*x_118 - 7.43095970153809) - 0.00456141578663089*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.00146493740275207*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.00318752863144787*std::sin(0.238479986786842*x_119 + 5.15775966644287) + 0.00236446559830338*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.00339113457891805*std::sin(0.265759944915771*x_12 - 4.24592018127441) + 4.99217545054286e-5*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.0263557533758908*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 0.00116996045647745*std::sin(0.285839945077896*x_120 + 8.15007972717285) - 0.000665897403282343*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 0.00110930854028892*std::sin(0.300159931182861*x_120 + 1.77239990234375) + 0.0595305440043774*std::sin(0.275919944047928*x_13 - 4.24416017532349) + 0.00313451159526259*std::sin(0.302159935235977*x_13 - 7.44248008728027) - 0.00295226677389173*std::sin(0.349279850721359*x_13 - 1.33511984348297) - 1.02897251140054e-5*std::sin(0.375919848680496*x_13 - 7.79184007644653) - 0.0563389067446494*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.000938838008816074*std::sin(0.250879973173141*x_14 - 4.21776008605957) - 0.00309388786005022*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.00800808737708949*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.00108712667745801*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.000103060737482674*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00290670598816273*std::sin(0.335039854049683*x_15 - 4.3471999168396) + 0.00584224923598571*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.0134304065385104*std::sin(0.304959923028946*x_16 + 5.18527984619141) + 8.9199301936492e-5*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.000579779562282152*std::sin(0.363839834928513*x_16 + 5.03007984161377) - 0.000584762718765535*std::sin(0.358959853649139*x_17 - 1.18831992149353) - 0.00485312939520846*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.00725695715863824*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.0165515190083283*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 9.01681139012109e-5*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 0.000764030491892222*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.00213968867407958*std::sin(0.172080010175705*x_19 + 4.98967981338501) + 0.0296471900766629*std::sin(0.295999944210052*x_19 + 2.15703988075256) + 0.0295172819770108*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 0.008939580821768*std::sin(0.367199838161469*x_2 + 1.99895977973938) - 0.0044082140100208*std::sin(0.424879848957062*x_2 + 5.19400024414063) - 0.0418254083333146*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.000115778085584365*std::sin(0.276079952716827*x_20 - 1.17055988311768) - 0.00314694951476042*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.0014310738228032*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 0.000327082306450904*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.0235774250875971*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 0.00450522362406146*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 0.000353062511971726*std::sin(0.304159939289093*x_21 + 1.8031998872757) - 0.0405321998556712*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.0160560653030119*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 0.000974998785750435*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.00404882837175289*std::sin(0.339119851589203*x_22 - 1.16015994548798) - 0.0300022932673109*std::sin(0.413999855518341*x_22 - 4.39455986022949) - 0.00419754283664*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.0215191073856832*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 0.0688050889423237*std::sin(0.187760010361671*x_24 - 1.41407978534698) + 0.00393499398537466*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.00107115756133825*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.00435547090299487*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.00187312082530055*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.00759446554696856*std::sin(0.319199919700623*x_26 - 1.19415986537933) - 0.00140953454746719*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 0.000487636655631848*std::sin(0.36711984872818*x_26 - 4.38271999359131) - 0.000387818053236416*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.00186550698844367*std::sin(0.203199997544289*x_27 - 1.20415985584259) + 0.00703133379217712*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.00126637418221034*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.0175891689623204*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 0.00165747592331749*std::sin(0.284639924764633*x_28 - 1.18023991584778) + 0.0189003901559802*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 0.000451724323285801*std::sin(0.413119852542877*x_28 + 5.00263977050781) - 0.0281072676274043*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 0.00371535197271259*std::sin(0.367439836263657*x_29 + 5.02615976333618) + 0.00429840530531733*std::sin(0.31415992975235*x_3 - 1.13303995132446) - 0.0044455991161157*std::sin(0.335119843482971*x_3 + 5.19600009918213) + 0.0197639011578858*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 0.000260754008968784*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.00161777902141433*std::sin(0.33095982670784*x_30 + 2.03791975975037) + 3.71372315137149e-5*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.00330092229249259*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.00100823468080469*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.00106407330411932*std::sin(0.416479855775833*x_31 - 4.1956000328064) - 0.00292028983757826*std::sin(0.419359862804413*x_31 + 5.2006402015686) - 0.0381779864194366*std::sin(0.297199934720993*x_32 + 8.2344799041748) + 0.000588427204771396*std::sin(0.306559920310974*x_32 + 1.85255992412567) + 0.00361410373945974*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.0100283687396564*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 0.00128768534962711*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.000984884507551809*std::sin(0.22367998957634*x_33 + 5.18304014205933) + 0.00366457132423688*std::sin(0.23871998488903*x_34 + 1.98119986057281) + 0.0345443289284139*std::sin(0.239839985966682*x_34 + 1.97279977798462) + 0.0331415991494192*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 0.00174258482849063*std::sin(0.246799975633621*x_35 - 1.19687986373901) + 0.00399090846022681*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 0.000356964213337849*std::sin(0.195119991898537*x_36 + 1.80503988265991) + 0.00959248324293162*std::sin(0.206160008907318*x_36 - 4.38503980636597) - 0.0031646060293526*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.00638992815132459*std::sin(0.266079962253571*x_37 - 1.21983981132507) - 0.0473325284734788*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.00344332374489874*std::sin(0.236719980835915*x_39 + 1.96407985687256) - 0.00716664304280366*std::sin(0.306159913539886*x_4 - 1.14551985263824) + 0.00428086600341551*std::sin(0.310319930315018*x_4 + 2.00831985473633) - 0.00697778774070762*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.00230836323211387*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 0.000980867938131809*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 0.00133427150107311*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.00151176824964921*std::sin(0.226639986038208*x_41 + 1.97247982025146) + 6.50027666267859e-5*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.00247397339157081*std::sin(0.257199972867966*x_42 - 7.44295978546143) + 0.017967566873639*std::sin(0.285039931535721*x_42 + 8.16335964202881) - 0.00614553756216113*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.0257410758240886*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 0.0454799220044938*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.000105202340541883*std::sin(0.20168000459671*x_48 - 1.18839991092682) + 0.00688001279793668*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.0104442384512939*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 9.52989473850024e-5*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.000933541728855645*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.00138434570690312*std::sin(0.366639852523804*x_5 - 1.15799987316132) + 0.021424073812789*std::sin(0.369519829750061*x_5 - 7.58495998382568) - 0.00421961069736245*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.00876680848914633*std::sin(0.22495998442173*x_51 + 1.95727980136871) + 0.0474166690819029*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.00420897125801951*std::sin(0.218799993395805*x_52 - 7.39351987838745) - 0.00148324586120168*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.0073570115893449*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.00111448587984549*std::sin(0.267039954662323*x_52 + 1.93775975704193) - 0.00582081573916175*std::sin(0.244799971580505*x_53 - 7.4125599861145) + 0.0241725322893791*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 0.00194504291355108*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.00220905534202641*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.00116947818589738*std::sin(0.245999962091446*x_59 - 4.24624013900757) - 0.0341009167268791*std::sin(0.267279952764511*x_59 + 5.12815999984741) - 0.00286348223180929*std::sin(0.31007993221283*x_6 - 7.38839960098267) + 0.00128245468474967*std::sin(0.445759862661362*x_6 + 5.1659197807312) + 0.00984259272417796*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 7.33708198667723e-5*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.00267649613341139*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.0159375260980239*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 0.00486511487384201*std::sin(0.466479867696762*x_7 - 7.62304019927979) + 0.00515507938439159*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.0152285870163181*std::sin(0.338799834251404*x_8 + 8.23480033874512) + 0.00354719218259732*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 7.77532093489023e-5*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.0253683565502566*std::sin(0.302399933338165*x_9 - 7.42071962356567) + 0.0451932562453889*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 0.00202112852375833*std::sin(0.31839993596077*x_9 - 7.44271993637085) + 0.00238800940258758*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 0.000616901078394212*std::sin(0.329679846763611*x_9 + 8.27055931091309) + 0.00179073940717772*std::sin(0.343599855899811*x_9 + 8.2553596496582) - 0.0141037962464174*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 0.00149115409514235*std::sin(0.360399842262268*x_91 + 2.0033597946167) - 0.00345034853783837*std::sin(0.370799839496613*x_91 - 7.39167976379395) + 0.00454605501874106*std::sin(0.408639848232269*x_91 - 1.21063983440399) - 2.8528078823092e-5*std::sin(0.196879997849464*x_92 - 0.973359823226929) - 0.00152453181245046*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 0.000563044068497551*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.00388349077259335*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.0014736138856047*std::sin(0.350959837436676*x_92 - 7.59128046035767) - 0.000900493900809688*std::sin(0.251839965581894*x_94 - 1.18175983428955) + 0.0067793820825555*std::sin(0.285679936408997*x_94 + 1.97303986549377) + 0.0315406563829366*std::sin(0.293039947748184*x_94 - 1.20255982875824) - 0.00187571301823754*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 0.000602072245395365*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.00658875401561173*std::sin(0.278879970312119*x_95 + 1.96503984928131) - 0.027606011719739*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.00172557693672681*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.000975145960259732*std::sin(0.285359919071198*x_95 - 1.20247983932495) - 0.00311640493180915*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.00259066229875265*std::sin(0.260719984769821*x_97 + 8.19032001495361) - 0.0255750320111338*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 0.0039289151894029*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.000809033996245643*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.00458850380590094*std::sin(0.253679990768433*x_98 + 1.97847986221313) + 0.00388970771261838*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.00127105733138342*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.00266640391590302*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 0.000559735245124919*std::sin(0.247679978609085*x_99 + 1.9799998998642) - 0.0149957784759952*std::sin(0.254879981279373*x_99 + 4.98095989227295) - 0.00330362196127819*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.00240986293667365*std::sin(0.258239984512329*x_99 - 1.22207987308502) - 0.240657413716439);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00108557094457797*x_1 + 0.00350004373030725*x_10 + 0.000181955516744139*x_100 - 0.00045884702221287*x_101 - 0.00111084229995213*x_102 + 0.000787375631468596*x_103 + 0.00142636510070362*x_104 + 0.000477385722385399*x_105 + 0.00263204598583722*x_106 + 0.00110548450379308*x_107 + 0.00337887244633504*x_108 + 0.000790748369076048*x_109 - 0.00121167992800425*x_11 + 0.00155926576962902*x_110 + 0.00220141608815849*x_111 - 0.0023601208365137*x_112 + 0.000220761147016875*x_113 - 0.00169479012975498*x_114 + 3.37759715131926e-5*x_115 + 0.000472483212049207*x_116 + 0.00276435366089867*x_117 + 0.00132509207822921*x_118 - 0.000131553716656072*x_119 + 0.00549565273384151*x_12 - 0.000933778132205824*x_120 + 0.000848763884726778*x_13 + 9.12690695961931e-5*x_14 + 0.000553898572283616*x_15 + 0.000899927441848035*x_16 + 0.00323448754673269*x_17 - 0.000664097503522375*x_18 + 0.000729785863258795*x_19 + 0.00079558741635895*x_2 + 2.85281182290079e-5*x_20 + 0.00123019576567118*x_21 - 0.000406466437849289*x_22 - 0.000646616366009309*x_23 - 0.000310417364563363*x_24 - 0.0030360544573748*x_25 - 0.000624342190957586*x_26 + 0.00173401002239631*x_27 - 0.000526207525170094*x_28 - 0.00397981315689335*x_29 - 0.00242892106376251*x_3 - 0.00132252168805549*x_30 - 0.00162932683185984*x_31 - 0.000544249782607464*x_32 - 0.00412800877461631*x_33 - 0.000338910563543284*x_34 - 0.00230212319059832*x_35 + 0.0021976922963944*x_36 - 0.00221006924490324*x_37 + 0.00060910123457854*x_38 + 0.00392826701954677*x_39 + 4.79641273878784e-5*x_4 - 0.000527960676619318*x_40 + 0.000390524567085544*x_41 + 0.000848373444305928*x_42 + 0.00219458533947217*x_43 - 0.00228299517013469*x_44 + 0.00468555356201908*x_45 - 0.000278520440313519*x_46 + 0.000522716934995738*x_47 + 0.00097205159992513*x_48 - 0.00559323282914599*x_49 + 0.00105547060945028*x_5 - 0.00095259922410448*x_50 - 0.000686457561087807*x_51 - 7.35345826972115e-5*x_52 - 0.000113771544620525*x_53 - 0.00218391379079698*x_54 - 0.00383766812562405*x_55 - 0.00406385423010441*x_56 + 0.00104638168426266*x_57 - 0.00315336801830707*x_58 - 0.000207309402641561*x_59 - 0.000263251759598147*x_6 + 0.00198504750936444*x_60 + 0.000546415814925863*x_61 + 6.41561714392612e-6*x_62 + 0.00153000601741383*x_63 + 0.000110059528273702*x_64 - 0.00199390837746883*x_65 - 0.000857440676538414*x_66 + 0.00155282345177999*x_67 + 0.000655954783853224*x_68 - 0.0018465594338087*x_69 + 0.00106346180509942*x_7 - 0.00147650843299059*x_70 + 0.000119320776345027*x_71 - 0.000166798894451869*x_72 + 0.00019674529087438*x_73 + 0.000393602381094608*x_74 + 0.00054448550586261*x_75 - 0.000172192705001071*x_76 - 0.000446050295476241*x_77 - 3.97604285066657e-5*x_78 - 5.7243785889807e-6*x_79 + 0.000750497181140154*x_8 - 0.000588777723936605*x_80 - 0.000518384570548602*x_81 + 0.00251630450827638*x_82 - 0.000861524241941677*x_83 + 0.000221436845138859*x_84 + 0.00199506888839201*x_85 + 0.000221603861547495*x_86 - 6.841822557862e-5*x_87 - 0.000826170201545227*x_88 + 0.000144876255984292*x_89 - 0.000557900925939671*x_9 - 0.000382437996899609*x_90 + 0.000247589219361458*x_91 + 0.0010499973564486*x_92 + 0.0023895784414573*x_93 - 2.07033698609291e-5*x_94 - 0.000289525190887764*x_95 - 0.00224531911847497*x_96 + 0.000110277495107173*x_97 + 0.000778503917748273*x_98 - 0.000197029341165906*x_99 - 0.000670071342028677*std::pow(-0.213750734403509*x_1 + 0.0282622426417824*x_10 - 0.117645246417521*x_100 - 0.14933018936814*x_101 + 0.437449052957476*x_102 + 0.276972083271461*x_103 - 0.0120931746096239*x_104 - 0.144156595092296*x_105 + 0.0218884028560941*x_106 - 0.0935677755903525*x_107 - 0.397127530857517*x_108 + 0.281459738877241*x_109 - 0.256205299583114*x_11 + 0.489905029154021*x_110 - 0.129982766088931*x_114 + 0.592370007401177*x_115 + 0.223783669447494*x_116 + 0.434458966022231*x_118 + 0.354480183776998*x_119 - 0.567932259752394*x_12 - 0.271334470977544*x_13 - 0.248379242485229*x_14 - 0.424829106073971*x_15 - 0.0143370427312207*x_18 - 0.154437636735614*x_19 - 0.269916070655641*x_21 - 0.0147864542572587*x_24 + 0.008017273574604*x_25 + 0.0872032839417516*x_26 + 0.506358029223647*x_30 + 0.129433892282312*x_31 - 0.0926048832712099*x_33 + 0.357492255603639*x_36 - 0.380372717718305*x_37 + 0.420347216127048*x_38 + 0.748533205999969*x_39 - 0.406653884796436*x_40 + 0.732701179506106*x_41 - 0.00731968599755793*x_42 - 0.0693604870957634*x_43 + 0.365145913534571*x_44 + 0.608512013214914*x_45 - 0.301135088963887*x_47 + 0.354529794850412*x_48 - 0.218220172943935*x_49 - 0.104499965133509*x_5 - 0.123230039160851*x_50 - 0.226580433790626*x_51 - 0.477404856759811*x_52 - 0.0820560414610193*x_54 - 0.523443490542437*x_55 - 0.321363654609899*x_56 + 0.158263613560817*x_57 - 0.110924802855399*x_58 + 0.533347774695455*x_59 + 0.0912360981724365*x_6 - 0.663938213023123*x_60 + 0.272935712194188*x_61 + 0.0708901443450183*x_62 + 0.0100119280368753*x_63 - 0.235742328469351*x_64 + 0.15362743992021*x_65 - 0.171712948499042*x_66 + 0.280492099452737*x_67 - 0.132510883145621*x_68 + 0.0823418141104971*x_69 + 0.00473484485248938*x_70 - 0.00738999122374283*x_71 + 0.0102253824715595*x_72 - 0.20468345792461*x_73 + 0.28517776074503*x_74 - 0.0332108207377968*x_75 - 0.0537018307659895*x_76 + 0.00584610018269889*x_77 + 0.114644275241423*x_78 - 0.169725634431856*x_79 + 0.218075702318454*x_80 - 0.000891261293732209*x_81 - 1.13530504815748e-5*x_82 + 0.011267833059516*x_83 + 0.0756424038741915*x_84 - 0.132996396938529*x_85 - 0.160237749282927*x_86 + 0.264813105374918*x_87 - 0.0350296284874627*x_88 - 0.179612474720184*x_89 - 0.212623551237825*x_90 - 0.326450857573293*x_92 - 0.535675593624405*x_93 - 0.0517573018686546*x_94 - 0.15085391664856*x_95 - 0.084530945095615*x_96 - 0.256585509668047*x_98 - 0.0345586164010977*x_99 + 2.08550457251428*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.822745507512096*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 2.59894258248261*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 1.85702032836693*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 3.48259890909748*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 1.77466826664639*std::sin(0.304959923028946*x_16 + 5.18527984619141) + 2.18708610678681*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 1.1812591343398*std::sin(0.367199838161469*x_2 + 1.99895977973938) + 3.11547591595331*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 2.12161780052995*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 2.84349374640476*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 2.32419918969734*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 2.4974614536705*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 3.71404065673386*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 2.61156414807425*std::sin(0.361119836568832*x_3 + 1.96599984169006) - 1.32512949012121*std::sin(0.316159933805466*x_32 - 1.14583992958069) - 4.56462164165066*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 4.37926760800144*std::sin(0.231599986553192*x_35 + 1.97151982784271) + 0.946986522707036*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 3.40137659149485*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 3.1941122448855*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 2.10595425640398*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 2.01227640028836*std::sin(0.338799834251404*x_8 + 8.23480033874512) + 3.35212617857991*std::sin(0.302399933338165*x_9 - 7.42071962356567) + 1.86364869641091*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 3.37943587921046*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 5.2547519792099, 2) - 0.00227395523025518*std::sin(0.204080000519753*x_10 - 1.37511992454529) - 0.00102779353904369*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.00140586249043813*std::sin(0.336399853229523*x_10 - 1.13703989982605) + 0.000622816872886293*std::sin(0.37255984544754*x_10 + 7.81288003921509) - 0.00025908768472324*std::sin(0.252959966659546*x_100 - 1.23215985298157) - 0.00294486799586583*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.00266144935314027*std::sin(0.256079971790314*x_100 + 1.9599198102951) + 0.00322139446487492*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.00219550032400397*std::sin(0.225839987397194*x_101 - 7.42223978042603) - 0.00394279832287637*std::sin(0.242479979991913*x_101 - 1.2021598815918) + 0.0187824063259659*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.000628768829423181*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.00408211831674339*std::sin(0.253919988870621*x_107 - 7.43423986434937) - 0.00710663664880928*std::sin(0.271919965744019*x_107 + 1.92799985408783) - 0.0011593077104751*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.00141396094329637*std::sin(0.260479986667633*x_108 + 1.96487975120544) - 0.00096497036445994*std::sin(0.267119973897934*x_108 + 1.96311986446381) - 0.000306675490444484*std::sin(0.26895996928215*x_108 - 1.21239984035492) + 0.00356484188413339*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.0013559937930256*std::sin(0.239599987864494*x_109 + 8.18639945983887) - 0.026095457218791*std::sin(0.241599977016449*x_109 + 1.95159983634949) - 0.000531786430934923*std::sin(0.255759954452515*x_109 + 8.17471981048584) - 0.00485204739710967*std::sin(0.249359980225563*x_11 - 7.42104005813599) - 0.000846259912319735*std::sin(0.290559947490692*x_11 - 1.21591985225677) + 0.0008490872408877*std::sin(0.280639946460724*x_113 - 7.41319990158081) - 0.00396957169169112*std::sin(0.295439928770065*x_113 - 4.42239999771118) + 0.00463009415593181*std::sin(0.279519945383072*x_116 - 1.23175990581512) + 0.00368032503634253*std::sin(0.237919986248016*x_118 - 7.43095970153809) + 0.00272750024442246*std::sin(0.194319993257523*x_119 + 2.19599986076355) - 0.00200888170180104*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.00289530619714064*std::sin(0.238479986786842*x_119 + 5.15775966644287) - 0.00049555693762989*std::sin(0.261599957942963*x_119 - 1.24623990058899) + 0.00465029303718733*std::sin(0.265759944915771*x_12 - 4.24592018127441) + 0.000866391719349297*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.000245206367720493*std::sin(0.285839945077896*x_120 + 8.15007972717285) - 0.000255591145750501*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 0.000560909661706343*std::sin(0.300159931182861*x_120 + 1.77239990234375) + 0.0286723324050868*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 0.00429838365514918*std::sin(0.302159935235977*x_13 - 7.44248008728027) + 0.00176530900142684*std::sin(0.349279850721359*x_13 - 1.33511984348297) - 0.000178578111315887*std::sin(0.375919848680496*x_13 - 7.79184007644653) - 0.0271351100269299*std::sin(0.202239990234375*x_14 - 1.01215982437134) - 0.00485206731676509*std::sin(0.250879973173141*x_14 - 4.21776008605957) + 0.000648433030447525*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.00404920129834049*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.000987462379245009*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.00178861841755404*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00146974391099118*std::sin(0.335039854049683*x_15 - 4.3471999168396) - 0.00349337507574541*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.00154805329530457*std::sin(0.31399992108345*x_16 - 4.2368803024292) - 0.00299639494637111*std::sin(0.363839834928513*x_16 + 5.03007984161377) - 0.00022444925080762*std::sin(0.358959853649139*x_17 - 1.18831992149353) + 0.00290193050377937*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.00366940056533687*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.00156486702054629*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 0.000293257531638478*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.00194352885708834*std::sin(0.172080010175705*x_19 + 4.98967981338501) + 0.014279293142229*std::sin(0.295999944210052*x_19 + 2.15703988075256) + 0.0142167241152256*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 0.00263589318584765*std::sin(0.424879848957062*x_2 + 5.19400024414063) - 0.0201448186098065*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.00200932790976929*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 0.000659553966667797*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.00129987754991421*std::sin(0.290639936923981*x_20 - 1.18799984455109) - 0.00169041448484164*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.0026939001201821*std::sin(0.364559859037399*x_20 - 4.37727975845337) + 0.00182468440670962*std::sin(0.304159939289093*x_21 + 1.8031998872757) - 0.0195219567838278*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.00503895208523894*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.00204724553163131*std::sin(0.339119851589203*x_22 - 1.16015994548798) - 0.0144503252886784*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.000879742752522256*std::sin(0.298639953136444*x_23 - 1.17119991779327) + 0.0331393306463116*std::sin(0.187760010361671*x_24 - 1.41407978534698) + 0.00198968642626525*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.000972957260637368*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.00220229595468036*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.00170139909646003*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.00384005796951778*std::sin(0.319199919700623*x_26 - 1.19415986537933) - 0.000541021106534187*std::sin(0.346879839897156*x_26 - 1.15215992927551) + 0.00252018543884012*std::sin(0.36711984872818*x_26 - 4.38271999359131) - 0.0067305797495891*std::sin(0.121280059218407*x_27 + 4.92423963546753) + 0.00964124311417572*std::sin(0.203199997544289*x_27 - 1.20415985584259) - 0.00420438862271402*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.00115027704582125*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.0015055238296676*std::sin(0.284639924764633*x_28 - 1.18023991584778) - 0.00233458467235134*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 0.00222159607624235*std::sin(0.367439836263657*x_29 + 5.02615976333618) - 0.00257023303055195*std::sin(0.31415992975235*x_3 - 1.13303995132446) + 0.000931731671415831*std::sin(0.335119843482971*x_3 + 5.19600009918213) - 0.00134761907033183*std::sin(0.473119854927063*x_3 + 5.00575971603394) - 0.00221847477412444*std::sin(0.33095982670784*x_30 + 2.03791975975037) + 0.000644516407361876*std::sin(0.354239851236343*x_31 - 4.42335987091064) - 0.00452658412570942*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.000915802948624802*std::sin(0.413679867982864*x_31 - 1.18167984485626) - 0.00549930366376021*std::sin(0.416479855775833*x_31 - 4.1956000328064) + 0.000612049458423241*std::sin(0.419359862804413*x_31 + 5.2006402015686) - 0.0183880717954548*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 0.000806915464296633*std::sin(0.306559920310974*x_32 + 1.85255992412567) - 0.000757462566885528*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.00116963447354168*std::sin(0.337119847536087*x_32 + 1.98447978496552) - 0.00509004310115932*std::sin(0.22367998957634*x_33 + 5.18304014205933) - 0.00219123176884126*std::sin(0.23871998488903*x_34 + 1.98119986057281) - 0.00158283022251017*std::sin(0.246799975633621*x_35 - 1.19687986373901) - 0.000836435250455887*std::sin(0.251999974250793*x_35 + 1.95895981788635) + 0.00184484903308879*std::sin(0.195119991898537*x_36 + 1.80503988265991) - 0.00573582887716514*std::sin(0.206160008907318*x_36 - 4.38503980636597) + 0.000663254510379154*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.0032309968845582*std::sin(0.266079962253571*x_37 - 1.21983981132507) - 0.0227972717646428*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.00312765083237493*std::sin(0.236719980835915*x_39 + 1.96407985687256) - 0.000897206053062777*std::sin(0.310319930315018*x_4 + 2.00831985473633) + 0.00417237074157743*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.00209673987089963*std::sin(0.33095982670784*x_4 + 2.00415992736816) - 0.00134507293560433*std::sin(0.366239845752716*x_4 + 4.79080009460449) - 0.00182969838759316*std::sin(0.216800004243851*x_40 + 2.00239968299866) - 0.00781306385741263*std::sin(0.226639986038208*x_41 + 1.97247982025146) + 0.00112812258499685*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.00224716742039817*std::sin(0.257199972867966*x_42 - 7.44295978546143) + 0.00865391134127253*std::sin(0.285039931535721*x_42 + 8.16335964202881) + 0.00842743036880864*std::sin(0.130480051040649*x_44 + 8.17927932739258) - 0.0219049811030516*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.0018257859244859*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.00144194869041291*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.0052810142928944*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 0.00165391260173142*std::sin(0.161120027303696*x_5 + 4.78815984725952) + 0.0048246952817014*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.00125743331828868*std::sin(0.366639852523804*x_5 - 1.15799987316132) + 0.0103187057350968*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.000884367848986973*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.00443284028320075*std::sin(0.22495998442173*x_51 + 1.95727980136871) + 0.0228377973055034*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.00382310622929067*std::sin(0.218799993395805*x_52 - 7.39351987838745) + 0.000310866344283773*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.00371999198768839*std::sin(0.254639983177185*x_52 - 1.21143984794617) - 0.00575984404318454*std::sin(0.267039954662323*x_52 + 1.93775975704193) + 0.0012199566888504*std::sin(0.244799971580505*x_53 - 7.4125599861145) + 0.00266725466283411*std::sin(0.259919971227646*x_53 - 1.20503985881805) - 0.00302929725633726*std::sin(0.248719975352287*x_57 - 7.43688011169434) + 0.00604405321277746*std::sin(0.245999962091446*x_59 - 4.24624013900757) - 0.0164243891276949*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 0.00392671867624342*std::sin(0.31007993221283*x_6 - 7.38839960098267) + 0.0004922440914059*std::sin(0.445759862661362*x_6 + 5.1659197807312) + 0.00474059317003332*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 0.00127335009364561*std::sin(0.261199980974197*x_60 - 7.43887996673584) - 0.00367030297489193*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.00290909722512898*std::sin(0.466479867696762*x_7 - 7.62304019927979) - 0.00308248161067783*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.00170847209722587*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.00134940643413075*std::sin(0.293359935283661*x_9 + 1.99279975891113) + 0.0217669112084844*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 0.00183583792230822*std::sin(0.31839993596077*x_9 - 7.44271993637085) - 0.0014279110990782*std::sin(0.322079926729202*x_9 - 7.60824012756348) + 0.00318824497095973*std::sin(0.329679846763611*x_9 + 8.27055931091309) - 0.000375312433114239*std::sin(0.343599855899811*x_9 + 8.2553596496582) + 0.00135444985496373*std::sin(0.360399842262268*x_91 + 2.0033597946167) + 0.000723141904197652*std::sin(0.370799839496613*x_91 - 7.39167976379395) - 0.00271831526762276*std::sin(0.408639848232269*x_91 - 1.21063983440399) - 0.000495104619341519*std::sin(0.196879997849464*x_92 - 0.973359823226929) + 0.000911594357014257*std::sin(0.272479951381683*x_92 + 1.9845597743988) - 0.00290990319629317*std::sin(0.296559929847717*x_92 + 1.81431996822357) - 0.00532546546870871*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.00133851767575991*std::sin(0.350959837436676*x_92 - 7.59128046035767) - 0.000345636229717656*std::sin(0.251839965581894*x_94 - 1.18175983428955) - 0.00405373400543713*std::sin(0.285679936408997*x_94 + 1.97303986549377) + 0.015191263564124*std::sin(0.293039947748184*x_94 - 1.20255982875824) + 0.00257218196019063*std::sin(0.303999930620193*x_94 + 1.95023989677429) - 0.00311160715350472*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.00333153099587652*std::sin(0.278879970312119*x_95 + 1.96503984928131) - 0.0132961785860528*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.00156738155988852*std::sin(0.283679932355881*x_95 - 1.21423995494843) - 0.00503971270700725*std::sin(0.285359919071198*x_95 - 1.20247983932495) + 0.00186345547321987*std::sin(0.271519958972931*x_96 + 8.18879985809326) - 0.00355259827330029*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 0.00234929628007592*std::sin(0.265839964151382*x_97 + 8.19623947143555) - 0.00418121909687656*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.0023201264788206*std::sin(0.253679990768433*x_98 + 1.97847986221313) - 0.000815225073997124*std::sin(0.259759962558746*x_98 + 1.97319984436035) - 0.00656903073525685*std::sin(0.262879967689514*x_98 + 1.95375978946686) - 0.00365646342717809*std::sin(0.240079984068871*x_99 - 7.41871976852417) + 0.00289280265968032*std::sin(0.247679978609085*x_99 + 1.9799998998642) - 0.00722257712116934*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 0.000692390188883523*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.00218893440704295*std::sin(0.258239984512329*x_99 - 1.22207987308502) - 0.0224009711810123);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.76263957137813e-6*x_1 - 5.96505466444129e-5*x_10 + 8.19448355393557e-5*x_100 + 0.000471106371833688*x_101 - 0.000995480460042865*x_102 - 0.000339419719480686*x_103 - 0.0008239368360776*x_104 - 0.000753268060906013*x_105 - 0.00012947505411808*x_106 + 0.000123254555967475*x_107 + 0.000590926600429093*x_108 - 0.000160660053614076*x_109 + 0.00074002454680595*x_11 - 0.000658658117672561*x_110 + 0.000230483055983409*x_111 - 5.97949187239643e-5*x_112 + 0.000247195057308433*x_113 + 0.00029714482613186*x_114 - 0.000192130255978691*x_115 - 0.00134827328395797*x_116 + 0.000292236656260989*x_117 - 0.00103526836389192*x_118 - 0.000455043898493015*x_119 + 0.000349185005826228*x_12 + 0.000335951210467017*x_120 + 0.000610851021249881*x_13 + 0.000394983008107095*x_14 + 0.000625213318402506*x_15 - 0.000168409770188118*x_16 - 0.00021720654861245*x_17 - 0.000272734144917787*x_18 - 0.000228146113835011*x_19 + 0.000184604070258375*x_2 + 4.57400122133589e-6*x_20 - 0.000176402744494459*x_21 - 9.40083052521827e-5*x_22 - 0.00010534821814335*x_23 + 0.000331222822338043*x_24 - 0.00031879894695913*x_25 - 0.000328579412997467*x_26 - 3.46266560997372e-5*x_27 + 0.000305130454598549*x_28 - 0.000331093357635475*x_29 + 2.42145911767754e-5*x_3 - 0.00122221929922595*x_30 - 0.000136398720189549*x_31 + 0.0001018594752806*x_32 - 0.000265336300568181*x_33 - 4.29268708952589e-5*x_34 + 0.000146286184381745*x_35 - 0.000736198171663405*x_36 + 0.000925723432960522*x_37 - 0.00181545994904026*x_38 - 0.00145373038120412*x_39 + 4.52274707315903e-6*x_4 + 0.000541927552430193*x_40 - 0.000811151495790727*x_41 + 0.000168983429888958*x_42 - 0.000514854143339207*x_43 - 0.000513822603860082*x_44 - 0.00152406010367368*x_45 - 0.000200748187028574*x_46 - 0.000219119904636546*x_47 - 0.000824981118285244*x_48 + 0.000103424194178286*x_49 + 3.23601532857083e-5*x_5 + 0.000216128454546326*x_50 + 0.000187443312252002*x_51 + 0.000667893412449306*x_52 + 0.000236627354839407*x_53 - 0.000359047284606342*x_54 + 0.00100385208076311*x_55 + 0.000827011794086184*x_56 - 0.000686774142841384*x_57 + 0.00014331997121634*x_58 - 0.00165326551811026*x_59 + 8.57832329911069e-5*x_6 + 0.000965272422781184*x_60 - 0.0004762200964127*x_61 - 6.27481912076942e-5*x_62 - 0.000253106710396509*x_63 + 0.000371928827139336*x_64 - 0.000444591439682143*x_65 + 0.000532033322576234*x_66 - 0.000391097814004382*x_67 + 0.000300844792229564*x_68 - 0.000277263931349716*x_69 + 0.000336905017320756*x_7 + 0.000253612914370795*x_70 - 0.000162955914551395*x_71 - 6.43132022013992e-5*x_72 + 0.000263527880210552*x_73 - 0.000412704596559189*x_74 - 5.40525168474532e-5*x_75 + 0.000140277586863982*x_76 + 0.000133959775600031*x_77 + 9.58140416229199e-5*x_78 + 0.000265338650239446*x_79 + 9.65155383897463e-5*x_8 - 0.000489253783650487*x_80 + 0.000156497022275341*x_81 - 5.78493915188859e-5*x_82 - 1.75368396317823e-5*x_83 + 0.000351640341455663*x_84 + 9.40910484769382e-5*x_85 + 0.000167404698911579*x_86 - 0.000451118114408107*x_87 - 0.000203981275173554*x_88 + 3.82879778750937e-5*x_89 - 7.68042967435036e-5*x_9 + 0.000335869693749943*x_90 - 2.48374379586636e-5*x_91 + 0.000652023051592467*x_92 + 0.000978041708120859*x_93 - 1.40090224225741e-5*x_94 + 0.000323846427249511*x_95 + 0.000451252344277944*x_96 - 0.000155280071216809*x_97 + 0.000272578116715157*x_98 + 8.81196819604608e-6*x_99 + 0.00111046447594648*std::sin(0.204080000519753*x_10 - 1.37511992454529) + 0.00375645617845864*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 9.39306718646498e-6*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 3.29275576444745e-5*std::sin(0.37255984544754*x_10 + 7.81288003921509) + 8.11486654387047e-5*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 8.49808784875721e-5*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 1.7782089469952e-5*std::sin(0.256079971790314*x_100 + 1.9599198102951) - 0.00157313744292705*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.000175313893396665*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.000113778432733739*std::sin(0.242479979991913*x_101 - 1.2021598815918) + 0.00229807102728685*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.000325963083489314*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.000205078199211515*std::sin(0.271919965744019*x_107 + 1.92799985408783) + 0.00107658937561374*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 9.44717582960842e-6*std::sin(0.260479986667633*x_108 + 1.96487975120544) + 0.0035268453730287*std::sin(0.267119973897934*x_108 + 1.96311986446381) + 9.60536074839449e-5*std::sin(0.26895996928215*x_108 - 1.21239984035492) - 0.00174085673368865*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 9.05987668705034e-6*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.0019436125527357*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.000256521743898257*std::sin(0.249359980225563*x_11 - 7.42104005813599) + 0.000785878004932673*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.00320316428665053*std::sin(0.234959989786148*x_111 - 4.40944004058838) - 0.00126366974275568*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 0.00310330712435761*std::sin(0.280639946460724*x_113 - 7.41319990158081) + 0.00399176303566056*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 0.000114551039317512*std::sin(0.295439928770065*x_113 - 4.42239999771118) - 0.00226106258031857*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.00285223119325875*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 0.000194574232106097*std::sin(0.237919986248016*x_118 - 7.43095970153809) - 0.00133194888327973*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.000106207090585775*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 1.93445701980818e-5*std::sin(0.238479986786842*x_119 + 5.15775966644287) + 0.00181119830921482*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.000245855240459485*std::sin(0.265759944915771*x_12 - 4.24592018127441) - 0.000804573377493466*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.00534898680989237*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 0.000896198448453073*std::sin(0.285839945077896*x_120 + 8.15007972717285) + 8.00535170081831e-5*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 4.47894521182349e-5*std::sin(0.300159931182861*x_120 + 1.77239990234375) + 0.000227250226743346*std::sin(0.302159935235977*x_13 - 7.44248008728027) - 0.000862071912881539*std::sin(0.349279850721359*x_13 - 1.33511984348297) + 0.000165836296630048*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.000140017462119997*std::sin(0.250879973173141*x_14 - 4.21776008605957) - 0.00236994120999016*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.000323334611704488*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 6.5975872714723e-6*std::sin(0.319439917802811*x_14 + 8.14727973937988) - 0.00166099782479372*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00011736118847935*std::sin(0.335039854049683*x_15 - 4.3471999168396) + 0.00170595659543253*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.00272574516847998*std::sin(0.304959923028946*x_16 + 5.18527984619141) - 0.00143759738294652*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 8.64678060937914e-5*std::sin(0.363839834928513*x_16 + 5.03007984161377) + 7.0299586725674e-5*std::sin(0.358959853649139*x_17 - 1.18831992149353) - 0.0014171302465576*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.000293006970897612*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.00335918520698476*std::sin(0.406719863414764*x_17 - 1.20767986774445) + 0.00145321142380571*std::sin(0.351359844207764*x_18 - 1.15703988075256) - 9.18509783578943e-5*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 1.29854073621205e-5*std::sin(0.172080010175705*x_19 + 4.98967981338501) + 0.00181431732265888*std::sin(0.367199838161469*x_2 + 1.99895977973938) - 0.0012872134448068*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.00186595936543478*std::sin(0.276079952716827*x_20 - 1.17055988311768) - 0.00241058683383184*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 8.68494411335815e-6*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 4.87807630534296e-5*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.00478511594816134*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 0.00131554058119011*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 5.26554277008151e-5*std::sin(0.304159939289093*x_21 + 1.8031998872757) - 0.0032586312483537*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 0.00014541044809531*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.000163475532645178*std::sin(0.339119851589203*x_22 - 1.16015994548798) - 0.00321534916559343*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.00436737360245489*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 0.000158879354383747*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 6.50067341641471e-6*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.000175856534387849*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 1.13676523363671e-5*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.000306634212778114*std::sin(0.319199919700623*x_26 - 1.19415986537933) + 0.00016945282758738*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 7.2725695292584e-5*std::sin(0.36711984872818*x_26 - 4.38271999359131) + 0.00625034284224594*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.000278220046095485*std::sin(0.203199997544289*x_27 - 1.20415985584259) + 0.002053173319544*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 7.6854099514955e-6*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.00356977967711918*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 1.00589400308168e-5*std::sin(0.284639924764633*x_28 - 1.18023991584778) + 0.0038358963298935*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 6.73697621212754e-5*std::sin(0.413119852542877*x_28 + 5.00263977050781) - 0.00570446238651749*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 0.00108489537953321*std::sin(0.367439836263657*x_29 + 5.02615976333618) + 0.0012551489305319*std::sin(0.31415992975235*x_3 - 1.13303995132446) - 0.00340536212847979*std::sin(0.335119843482971*x_3 + 5.19600009918213) + 0.0040111487271031*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 3.88886200074762e-5*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.000117288017052697*std::sin(0.33095982670784*x_30 + 2.03791975975037) - 0.000598529200060411*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.000239314903337681*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 6.11880513528367e-6*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.00015869494220873*std::sin(0.416479855775833*x_31 - 4.1956000328064) - 0.00223696382812008*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 4.26606224422184e-5*std::sin(0.306559920310974*x_32 + 1.85255992412567) + 0.00276843045926886*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.00203529041071648*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 7.81474380908959e-6*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.000146884795815423*std::sin(0.22367998957634*x_33 + 5.18304014205933) + 0.0010700672579163*std::sin(0.23871998488903*x_34 + 1.98119986057281) + 0.00701088514372335*std::sin(0.239839985966682*x_34 + 1.97279977798462) + 0.00672619652265933*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 1.05754515295248e-5*std::sin(0.246799975633621*x_35 - 1.19687986373901) + 0.00305706568984577*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 5.32373239577887e-5*std::sin(0.195119991898537*x_36 + 1.80503988265991) + 0.00280103764729137*std::sin(0.206160008907318*x_36 - 4.38503980636597) - 0.00242411185589135*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.000257999799495073*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 2.08969473217436e-5*std::sin(0.236719980835915*x_39 + 1.96407985687256) - 0.00145449377069336*std::sin(0.306159913539886*x_4 - 1.14551985263824) + 0.0032791753337096*std::sin(0.310319930315018*x_4 + 2.00831985473633) - 0.0020375376908719*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 1.40090646232139e-5*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 7.11123422489871e-5*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 9.67338904135231e-5*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.000225463766530293*std::sin(0.226639986038208*x_41 + 1.97247982025146) - 0.00104762935536742*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 1.50141245695069e-5*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.000445547818860077*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.00522423597958848*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 0.00169551337465105*std::sin(0.20168000459671*x_48 - 1.18839991092682) + 0.00527014119213265*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.000421696670525783*std::sin(0.221679985523224*x_48 - 1.18127989768982) - 0.00153590346991482*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.000139227579657024*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 8.40135910981185e-6*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.0032322533117384*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.000353968742503402*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 2.55435321142459e-5*std::sin(0.218799993395805*x_52 - 7.39351987838745) - 0.00113617740849604*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.000297046769538472*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.000166213428726988*std::sin(0.267039954662323*x_52 + 1.93775975704193) - 0.0044587883336453*std::sin(0.244799971580505*x_53 - 7.4125599861145) + 0.00490589491157796*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 0.000141014454627657*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.00016015519869916*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.000174414932135676*std::sin(0.245999962091446*x_59 - 4.24624013900757) - 0.000207600759058506*std::sin(0.31007993221283*x_6 - 7.38839960098267) - 0.000154175414128025*std::sin(0.445759862661362*x_6 + 5.1659197807312) + 0.00118249466459065*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.000194044378114503*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.00323457332692407*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 0.00142063004697665*std::sin(0.466479867696762*x_7 - 7.62304019927979) + 0.00150530066769692*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.00309069180917809*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 0.00125312427170404*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.00514859137739912*std::sin(0.302399933338165*x_9 - 7.42071962356567) - 1.22658859347811e-5*std::sin(0.31839993596077*x_9 - 7.44271993637085) + 0.000697306846343715*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 9.20040758519914e-5*std::sin(0.329679846763611*x_9 + 8.27055931091309) + 0.00137171976147673*std::sin(0.343599855899811*x_9 + 8.2553596496582) - 0.00286241182392102*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 9.04956108787508e-6*std::sin(0.360399842262268*x_91 + 2.0033597946167) - 0.00264299275168935*std::sin(0.370799839496613*x_91 - 7.39167976379395) + 0.00132746348694793*std::sin(0.408639848232269*x_91 - 1.21063983440399) + 0.000459778166041801*std::sin(0.196879997849464*x_92 - 0.973359823226929) - 0.000445168460868954*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 8.39718894979137e-5*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.000281550771725124*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 8.94311253354913e-6*std::sin(0.350959837436676*x_92 - 7.59128046035767) + 0.000108256472316754*std::sin(0.251839965581894*x_94 - 1.18175983428955) + 0.00197960256564463*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.000135988078443914*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 8.97925169427839e-5*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.000266027594472686*std::sin(0.278879970312119*x_95 + 1.96503984928131) - 1.04722335214101e-5*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.000145432397570179*std::sin(0.285359919071198*x_95 - 1.20247983932495) - 0.00091000081179544*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.000187821476142173*std::sin(0.260719984769821*x_97 + 8.19032001495361) - 0.00519053684176866*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 0.00114725656327226*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.000120658607618544*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.000185265473080385*std::sin(0.253679990768433*x_98 + 1.97847986221313) + 0.00297954516127847*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.000189564355168952*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.000193312698346405*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 8.34784145353656e-5*std::sin(0.247679978609085*x_99 + 1.9799998998642) - 0.00253059909809873*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 1.46250491011476e-5*std::sin(0.258239984512329*x_99 - 1.22207987308502) - 0.112629279494286*std::sin(0.0151420735822591*x_1 + 0.0752634819477707*x_10 + 0.00277035025287575*x_100 + 0.00642080123491499*x_102 + 0.0176662467255975*x_103 - 0.0120462608032563*x_104 + 0.00507678593044004*x_105 + 0.07072184507892*x_106 + 0.0221853335470659*x_107 + 0.0599962378991945*x_108 - 0.0124208006237444*x_11 + 0.0443128918365619*x_110 + 0.032588632976203*x_111 - 0.0388107555406335*x_112 + 0.0247691111300474*x_113 - 0.0419307529712095*x_114 + 0.00416275164640097*x_115 + 0.00715382717861266*x_116 + 0.0633388641983089*x_117 + 0.0113420351665215*x_118 - 0.00652676416597476*x_119 + 0.0829945764302611*x_12 - 0.00455862772369031*x_120 + 0.0254379173082546*x_15 + 0.0115250104660704*x_16 + 0.0628640866649341*x_17 - 0.000884025332598297*x_18 - 0.0251105783261833*x_23 - 0.0651212003923816*x_25 - 0.0256321769554584*x_26 + 0.0368795107057135*x_27 + 0.00330823860140817*x_28 - 0.0632747016654027*x_29 - 0.0442086875983206*x_3 - 0.020781652581727*x_30 - 0.0329393009370021*x_31 - 0.0816658740578401*x_33 - 0.0116285121394366*x_34 - 0.0512097613238724*x_35 + 0.0424052558749278*x_36 - 0.0134717482611219*x_37 + 0.0474418993602972*x_39 + 0.00134214524315952*x_4 + 0.00626952119641994*x_40 + 0.00741819795497127*x_41 - 0.00757500938021934*x_43 - 0.0408209530589675*x_44 + 0.0623876949848273*x_45 + 4.0466398249137e-5*x_46 + 0.0216042883768079*x_47 - 0.0988171845754979*x_49 + 0.00766682998841868*x_50 - 0.0333321433275434*x_51 + 0.0224575357195205*x_53 - 0.044576402520654*x_54 - 0.0485485002131284*x_55 - 0.0366918181164621*x_56 + 0.0118194427368802*x_57 - 0.0516698927277298*x_58 + 0.0567069941301603*x_60 - 0.000680189738205523*x_61 - 0.00116412298475104*x_62 + 0.0272962429913072*x_63 - 0.00041273012638191*x_64 - 0.0390332355563801*x_65 - 0.0205672027794873*x_66 + 0.033309404476459*x_67 + 0.0119549973186464*x_68 - 0.0395723630579936*x_69 + 0.0423337387029564*x_7 - 0.0246306401633326*x_70 + 0.000447128166224839*x_71 + 0.000617614485590761*x_72 - 0.000271245083662477*x_73 + 0.0175803573300664*x_74 - 0.000242026157834738*x_75 + 0.0018645671036249*x_76 - 0.0198404633595896*x_77 + 0.00247572268573333*x_78 + 0.00226108372704181*x_79 - 0.00438615691991381*x_80 - 0.0198421098905787*x_81 + 0.0455663383598637*x_82 - 0.00592098829962864*x_83 + 0.00714977750966398*x_84 + 0.0327293386308653*x_85 + 0.00102362968973817*x_86 - 0.00235058473617365*x_87 - 0.0167552966065996*x_88 - 0.000479593422220728*x_89 + 0.000943387462714422*x_90 + 0.000577995701310933*x_91 + 0.0263172817799453*x_92 + 0.0629201475186615*x_93 - 0.031037234592849*x_96 + 0.00800874096100449*x_97 + 0.00544255613069235*x_98 + 0.382670989751546*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.531666404646387*std::sin(0.241599977016449*x_109 + 1.95159983634949) + 0.584167418674753*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 0.552848193719839*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.290924982925915*std::sin(0.295999944210052*x_19 + 2.15703988075256) + 0.289650207421879*std::sin(0.36575984954834*x_2 + 5.18800020217896) - 0.410428650194987*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.39773852160927*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.294409575880898*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.675177623039502*std::sin(0.187760010361671*x_24 - 1.41407978534698) - 0.37463685490934*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 0.46446948268553*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.176313980259746*std::sin(0.285039931535721*x_42 + 8.16335964202881) - 0.446290036202939*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.210232345529953*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.465295146264637*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.334628967901232*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 0.0965844018547379*std::sin(0.481119841337204*x_6 + 4.95983982086182) + 0.0348082507141001*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.443477013084816*std::sin(0.316079914569855*x_9 - 4.24240016937256) + 0.309505383004272*std::sin(0.293039947748184*x_94 - 1.20255982875824) - 0.270895098909882*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.147152110733213*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 6.92809489816318) + 0.148213770321675);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00117636900408446*x_1 - 0.00474418058126786*x_10 + 0.00088625415768703*x_100 + 0.0010169365140447*x_101 - 0.0062099447778088*x_102 - 0.00291964297309385*x_103 + 0.00251246739871249*x_104 + 0.00158489802927378*x_105 - 0.00596366887458803*x_106 - 0.000947555679223806*x_107 + 0.000662481668126687*x_108 - 0.00305392390368607*x_109 + 0.00288504931312391*x_11 - 0.00728212441915037*x_110 - 0.00108479353944165*x_111 + 0.00334412046461529*x_112 - 0.00239797974198427*x_113 + 0.00262596116882678*x_114 - 0.00579400094421398*x_115 - 0.00192540017897625*x_116 - 0.00520860433811591*x_117 - 0.00503291224077063*x_118 - 0.00262451988845109*x_119 - 0.000180773343606104*x_12 - 0.000396816190572533*x_120 + 0.00275239188286411*x_13 + 0.00263293271272614*x_14 + 0.00313488281632594*x_15 - 3.89571238983121e-5*x_16 - 0.0039234840581888*x_17 + 3.29189430300198e-5*x_18 + 0.00253548971661637*x_19 + 0.000344032442279918*x_2 + 5.30945382546422e-5*x_20 + 0.0034849221118915*x_21 - 0.000159572035756436*x_22 + 0.00189197104313949*x_23 - 0.000139296437990945*x_24 + 0.00428263990812986*x_25 + 0.00155567872865288*x_26 - 0.00231651148744166*x_27 - 0.0015813686856212*x_28 + 0.00297964833979544*x_29 + 0.00212264155980933*x_3 - 0.00205686666449672*x_30 + 0.000924720145774519*x_31 - 6.87853370398292e-5*x_32 + 0.00566116482225386*x_33 - 0.000491804454396917*x_34 + 0.0036993710137811*x_35 - 0.00557576025864357*x_36 + 0.00205929554606678*x_37 - 0.00370330157587934*x_38 - 0.00866650989966253*x_39 + 4.1372077897224e-5*x_4 + 0.0028055410563379*x_40 - 0.00676987318185419*x_41 + 0.000301255972913975*x_42 + 0.00454210298907863*x_43 - 0.000697497664293812*x_44 - 0.00880324750668984*x_45 - 0.00117860687591441*x_46 + 0.00143268660054726*x_47 - 0.00371063976059274*x_48 + 0.00648784402842746*x_49 + 0.00241730308662786*x_5 - 0.000825890610930772*x_50 + 0.00389504986134664*x_51 + 0.00414387269142074*x_52 - 0.0024172213972412*x_53 + 0.00410037418907154*x_54 + 0.00628350348824222*x_55 + 0.00385673051864412*x_56 - 0.00259472928956243*x_57 + 0.00473218342055734*x_58 - 0.00428009782440426*x_59 - 0.000728630841624739*x_6 + 0.000392061563411865*x_60 - 0.00114151224451018*x_61 - 0.000372522033464507*x_62 - 0.00158413132917906*x_63 + 0.00210169804756726*x_64 + 0.0012167769605835*x_65 + 0.00267027156861474*x_66 - 0.00445159113709907*x_67 + 0.000463686519902406*x_68 + 0.00167639359224981*x_69 - 0.00411133516841532*x_7 + 0.0010820059260148*x_70 + 0.00035664943663754*x_71 - 0.000900334463185742*x_72 + 0.00229188436657588*x_73 - 0.00401270474854469*x_74 + 0.00122497709038335*x_75 - 4.33524933070172e-5*x_76 + 0.00120954193990242*x_77 - 0.000596859143896123*x_78 + 0.000699239631831728*x_79 - 0.000772629860327049*x_8 - 0.001952370132057*x_80 + 0.00182514463677617*x_81 - 0.00261540095368268*x_82 - 0.000170216977693138*x_83 - 0.0012627013941332*x_84 - 0.00044768271788424*x_85 + 0.00153960090672764*x_86 - 0.00221560009957198*x_87 + 0.00146839920607934*x_88 + 0.00188284622990457*x_89 - 0.000700947708902118*x_9 + 0.00103503121710583*x_90 + 4.02809887277033e-5*x_91 + 0.000701772064764653*x_92 - 0.000351104886533285*x_93 + 0.000502531911487926*x_94 + 0.000923370539883188*x_95 + 0.00147261463621498*x_96 - 0.000737746051253033*x_97 + 0.00229170225276817*x_98 - 0.000274456979085554*x_99 - 0.00129646042997029*std::sin(0.204080000519753*x_10 - 1.37511992454529) - 0.0026434962940538*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.000803927899267131*std::sin(0.336399853229523*x_10 - 1.13703989982605) + 0.00126194686935128*std::sin(0.37255984544754*x_10 + 7.81288003921509) + 0.000967920566459412*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 0.000538051468559296*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.00152192223779235*std::sin(0.256079971790314*x_100 + 1.9599198102951) + 0.00183662826667303*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.00325683127475989*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.000720381501254027*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.0235884931517581*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.00161720034934572*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.00605546282816945*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.00129844064004809*std::sin(0.271919965744019*x_107 + 1.92799985408783) - 0.00228132105656893*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.000808558915627493*std::sin(0.260479986667633*x_108 + 1.96487975120544) - 0.00248191439760857*std::sin(0.267119973897934*x_108 + 1.96311986446381) + 0.00114570291037696*std::sin(0.26895996928215*x_108 - 1.21239984035492) + 0.00203243950469554*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.000775411001332433*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.0327728249093659*std::sin(0.241599977016449*x_109 + 1.95159983634949) - 0.00136776055307039*std::sin(0.255759954452515*x_109 + 8.17471981048584) - 0.00983118198829602*std::sin(0.249359980225563*x_11 - 7.42104005813599) - 0.00166529605544847*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.017670250938467*std::sin(0.234959989786148*x_111 - 4.40944004058838) - 0.00697103222301161*std::sin(0.312399923801422*x_112 - 7.64192008972168) + 0.00218386172840068*std::sin(0.280639946460724*x_113 - 7.41319990158081) + 0.022020554743627*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 0.000725273214712586*std::sin(0.295439928770065*x_113 - 4.42239999771118) + 0.00263977662371509*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.0157343290600018*std::sin(0.266079962253571*x_117 - 1.24495995044708) + 0.00745704694268217*std::sin(0.237919986248016*x_118 - 7.43095970153809) + 0.00155504211014357*std::sin(0.194319993257523*x_119 + 2.19599986076355) - 0.00407038101382287*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.00165565085108501*std::sin(0.238479986786842*x_119 + 5.15775966644287) - 0.00127457789755728*std::sin(0.261599957942963*x_119 - 1.24623990058899) + 0.00942238881976469*std::sin(0.265759944915771*x_12 - 4.24592018127441) + 0.00170491203908107*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.0295076776396578*std::sin(0.257359951734543*x_120 - 7.41495990753174) + 0.000630673476455822*std::sin(0.285839945077896*x_120 + 8.15007972717285) + 0.000954857915539683*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 0.000832060058742628*std::sin(0.300159931182861*x_120 + 1.77239990234375) - 0.0360090770503304*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 0.00870935267336045*std::sin(0.302159935235977*x_13 - 7.44248008728027) + 0.00100646364386138*std::sin(0.349279850721359*x_13 - 1.33511984348297) - 0.00035141145177089*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.0340785065520363*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.000886512383237216*std::sin(0.250879973173141*x_14 - 4.21776008605957) + 0.00166777689079951*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.00600663333184267*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.000564670130650094*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.00351969785179882*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00218023558587975*std::sin(0.335039854049683*x_15 - 4.3471999168396) - 0.00199169380843094*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.0150365690957799*std::sin(0.304959923028946*x_16 + 5.18527984619141) + 0.00304630647011044*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.000547465863849228*std::sin(0.363839834928513*x_16 + 5.03007984161377) + 0.000838515525024548*std::sin(0.358959853649139*x_17 - 1.18831992149353) + 0.00165449082665163*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.00544323241046769*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.0185309401093116*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 0.00307939303124233*std::sin(0.351359844207764*x_18 - 1.15703988075256) - 0.00109557502297037*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.00111138684037096*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.017933112650841*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 0.017854533312317*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 0.0100086787639961*std::sin(0.367199838161469*x_2 + 1.99895977973938) + 0.00150281376150766*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.0252995227328195*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.00395401671936586*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 0.00169638006115224*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.000743321509119548*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 0.000308852552073573*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.026397084884487*std::sin(0.319999933242798*x_20 + 1.95359981060028) - 0.00153588551860644*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 0.000333384764976096*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.0245172815406313*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.0179762343487386*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 0.000920657758945018*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.00303690835370482*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.0181479089099164*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.0022627080417115*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.0240926098667615*std::sin(0.334719836711884*x_23 - 1.17023992538452) - 0.0416191014313054*std::sin(0.187760010361671*x_24 - 1.41407978534698) + 0.00295152449269881*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.000556375528859255*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.0032669119940732*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.00097292744541882*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.00569638763214039*std::sin(0.319199919700623*x_26 - 1.19415986537933) + 0.00202119007108521*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 0.000460458491964086*std::sin(0.36711984872818*x_26 - 4.38271999359131) - 0.0132446400269015*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.00176153397150634*std::sin(0.203199997544289*x_27 - 1.20415985584259) - 0.00239706719333886*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.000657774010838064*std::sin(0.323919922113419*x_27 + 1.99407982826233) - 0.0196926841850175*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 0.000860918203532189*std::sin(0.284639924764633*x_28 - 1.18023991584778) + 0.0211607162972087*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 0.000426547713920653*std::sin(0.413119852542877*x_28 + 5.00263977050781) - 0.0314686581200035*std::sin(0.277119934558868*x_29 + 8.20456027984619) + 0.00126660866753399*std::sin(0.367439836263657*x_29 + 5.02615976333618) - 0.00146537863876031*std::sin(0.31415992975235*x_3 - 1.13303995132446) + 0.00239642411328255*std::sin(0.335119843482971*x_3 + 5.19600009918213) + 0.0221274958811244*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 0.000246221026160927*std::sin(0.473119854927063*x_3 + 5.00575971603394) - 0.0044950569225382*std::sin(0.33095982670784*x_30 + 2.03791975975037) + 0.00126829903582392*std::sin(0.354239851236343*x_31 - 4.42335987091064) - 0.00917173075260775*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.000523692427700477*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.00100476775750002*std::sin(0.416479855775833*x_31 - 4.1956000328064) + 0.00157419794312474*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.0230932553632111*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 0.00163496605235064*std::sin(0.306559920310974*x_32 + 1.85255992412567) - 0.00194820205846931*std::sin(0.31399992108345*x_32 + 8.25504016876221) + 0.0112276764697644*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 0.000668843355321148*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.000929992505420833*std::sin(0.22367998957634*x_33 + 5.18304014205933) - 0.0012492969269574*std::sin(0.23871998488903*x_34 + 1.98119986057281) + 0.0386755372825115*std::sin(0.239839985966682*x_34 + 1.97279977798462) + 0.0371050529353637*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 0.000905125063321499*std::sin(0.246799975633621*x_35 - 1.19687986373901) - 0.00215132066976548*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 0.00033706900713958*std::sin(0.195119991898537*x_36 + 1.80503988265991) - 0.00327019418561334*std::sin(0.206160008907318*x_36 - 4.38503980636597) + 0.00170589790030508*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.00479289917985084*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.0286306919127621*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.00178851472346252*std::sin(0.236719980835915*x_39 + 1.96407985687256) - 0.00802371268426696*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 0.00230762384289835*std::sin(0.310319930315018*x_4 + 2.00831985473633) + 0.00237881269325338*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.00119899897122703*std::sin(0.33095982670784*x_4 + 2.00415992736816) - 0.00272537667816991*std::sin(0.366239845752716*x_4 + 4.79080009460449) - 0.00370732112856844*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.00142751066884152*std::sin(0.226639986038208*x_41 + 1.97247982025146) + 0.0022199540159097*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.00128501940685482*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.0108682947683505*std::sin(0.285039931535721*x_42 + 8.16335964202881) + 0.0170755961079038*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.02881948987313*std::sin(0.204159989953041*x_46 - 1.17471981048584) + 0.0275100797933648*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.00359283720506774*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.00370870790146137*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.00783391936840421*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 0.00325461964063734*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.000881511288558559*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.000719050215021583*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.0129590807132547*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.00227460384072138*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.00657572796164049*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.0286815872254538*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.00218620368669976*std::sin(0.218799993395805*x_52 - 7.39351987838745) + 0.000799551658813526*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.00551828032767706*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.0010523706157487*std::sin(0.267039954662323*x_52 + 1.93775975704193) + 0.00313774203025524*std::sin(0.244799971580505*x_53 - 7.4125599861145) + 0.0270633618533437*std::sin(0.258399993181229*x_53 + 5.15200042724609) + 0.00540437136188606*std::sin(0.259919971227646*x_53 - 1.20503985881805) - 0.0061379393452418*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.00110429795554531*std::sin(0.245999962091446*x_59 - 4.24624013900757) + 0.0206271009015943*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 0.00795628788498362*std::sin(0.31007993221283*x_6 - 7.38839960098267) - 0.00183896498322122*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.0059536274312206*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 0.00250573713499003*std::sin(0.261199980974197*x_60 - 7.43887996673584) - 0.00743674031705491*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.0178435188615901*std::sin(0.320879906415939*x_7 + 5.20904016494751) + 0.00165857682206561*std::sin(0.466479867696762*x_7 - 7.62304019927979) - 0.00175742924978626*std::sin(0.334319829940796*x_8 - 4.33663988113403) + 0.0170497966867473*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 0.00214564000298879*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.00265540312053173*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.0284021965396605*std::sin(0.302399933338165*x_9 - 7.42071962356567) - 0.0273366802456211*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 0.00104980489508347*std::sin(0.31839993596077*x_9 - 7.44271993637085) - 0.000814101444408178*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 0.000582518432459419*std::sin(0.329679846763611*x_9 + 8.27055931091309) - 0.000965307708562694*std::sin(0.343599855899811*x_9 + 8.2553596496582) - 0.0157904904936391*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 0.000774528116348219*std::sin(0.360399842262268*x_91 + 2.0033597946167) + 0.00185992893631164*std::sin(0.370799839496613*x_91 - 7.39167976379395) - 0.00154980543757738*std::sin(0.408639848232269*x_91 - 1.21063983440399) - 0.000974281964229727*std::sin(0.196879997849464*x_92 - 0.973359823226929) + 0.00051973143372773*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 0.000531663113704559*std::sin(0.296559929847717*x_92 + 1.81431996822357) - 0.0107904181287366*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.000765417464740979*std::sin(0.350959837436676*x_92 - 7.59128046035767) + 0.00129125556706633*std::sin(0.251839965581894*x_94 - 1.18175983428955) - 0.00231117379170409*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.0190784402344391*std::sin(0.293039947748184*x_94 - 1.20255982875824) + 0.00521173576595928*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 0.000568516076399067*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.00494203267545633*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.0166984364025854*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.00089629090566214*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.000920796730763121*std::sin(0.285359919071198*x_95 - 1.20247983932495) + 0.00106242033787535*std::sin(0.271519958972931*x_96 + 8.18879985809326) - 0.00719824793486698*std::sin(0.260719984769821*x_97 + 8.19032001495361) - 0.0286335886303595*std::sin(0.26199996471405*x_97 - 1.21223986148834) + 0.00133941496511039*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.000763942926678167*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.00344170319403141*std::sin(0.253679990768433*x_98 + 1.97847986221313) - 0.00209676786247975*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.00120021564262914*std::sin(0.262879967689514*x_98 + 1.95375978946686) - 0.0074086987294374*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 0.000528538705802198*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.00907070734196706*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 0.00178083518607817*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.00125171946150947*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.0533810162472911);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00172418901906603*x_1 - 0.00537451139645897*x_10 - 0.00160856273827484*x_100 - 0.00211967885085344*x_101 + 0.00253180534402624*x_102 + 0.00255098048662558*x_103 + 0.00182189736491755*x_104 - 0.000523041056042953*x_105 - 0.00539014779556517*x_106 - 0.00236044096246549*x_107 - 0.00778778789789392*x_108 + 0.00267472578863455*x_109 - 0.00190175597473741*x_11 + 0.00151297693104516*x_110 - 0.00257102489545575*x_111 + 0.00394143738026734*x_112 - 0.00218608225379281*x_113 + 0.00191021483768615*x_114 + 0.00355161207860225*x_115 + 0.00139469085635014*x_116 - 0.00546048163268334*x_117 + 0.00601964445621626*x_118 + 0.00380428403442602*x_119 - 0.00917621899397579*x_12 - 0.00127744613711386*x_120 - 0.00304771920347512*x_13 - 0.00181215330662495*x_14 - 0.00606277458470933*x_15 - 0.00122471856835776*x_16 - 0.00475162929063559*x_17 - 0.000884291011478727*x_18 + 0.00193673746737873*x_19 - 0.00109287918946209*x_2 - 7.09110579849198e-5*x_20 - 0.00124153142358325*x_21 - 0.000976477076149847*x_22 + 0.00142427745005294*x_23 - 0.00032508108767112*x_24 + 0.00504385437640478*x_25 + 0.00397315434566558*x_26 - 0.00284053220226364*x_27 - 0.0022012775336313*x_28 + 0.00562754342808235*x_29 + 0.00287712499335477*x_3 + 0.00685973070483979*x_30 + 0.00316619551524517*x_31 - 0.000572881073008105*x_32 + 0.00650130218580599*x_33 + 0.00060176016704152*x_34 + 0.00297504053935427*x_35 + 2.05179610829872e-5*x_36 - 0.00495466742240959*x_37 + 0.00520450713439356*x_38 + 0.00343987237616173*x_39 - 0.000352068614134116*x_4 - 0.00559269724234062*x_40 + 0.007248517185217*x_41 + 0.00067614105755217*x_42 - 0.00151285127811131*x_43 + 0.00620427892277151*x_44 + 0.00297424951446978*x_45 + 0.00167279592665694*x_46 - 0.00414877810536468*x_47 + 0.00442403129810073*x_48 + 0.00486263465903791*x_49 - 0.000416100495180499*x_5 - 0.00409515606567678*x_50 + 0.000196793491988183*x_51 - 0.0053492291911262*x_52 - 0.00144467676864196*x_53 + 0.0040453634221496*x_54 - 0.00308161883925823*x_55 - 0.0012377586232355*x_56 + 3.4644679485925e-5*x_57 + 0.00102700180186522*x_58 + 0.0047852727749774*x_59 - 0.000500125556504059*x_6 - 0.00867101701834121*x_60 + 0.00257904155813433*x_61 + 0.000374041722290468*x_62 - 0.00149098576538736*x_63 - 0.0020757365097848*x_64 + 0.00422623804296092*x_65 - 4.51241461864557e-5*x_66 - 7.83197027388739e-5*x_67 - 0.0022605983478145*x_68 + 0.003888336396997*x_69 - 0.00242791591422132*x_7 + 0.00218213156810327*x_70 - 6.63018369415965e-5*x_71 - 0.000272498024235218*x_72 - 0.00191508832871052*x_73 + 0.000919359771397037*x_74 + 0.000383487151554599*x_75 - 0.00102342360525663*x_76 + 0.00168869624244448*x_77 + 0.00121681031014309*x_78 - 0.00207392742883092*x_79 + 0.000173487553859488*x_8 + 0.00253279555404798*x_80 + 0.00192460576615191*x_81 - 0.00333490585043567*x_82 + 0.000801055021448225*x_83 - 0.000451627581595851*x_84 - 0.00335292062994922*x_85 - 0.00105598790642044*x_86 + 0.00263397428294367*x_87 + 0.00138487473516856*x_88 - 0.00181270808493713*x_89 + 0.00157855269244289*x_9 - 0.00215292382502551*x_90 + 3.66765873906454e-5*x_91 - 0.00467361826227024*x_92 - 0.0106831930368784*x_93 - 0.000451430200156281*x_94 - 0.00191256456037056*x_95 + 0.00110744954676241*x_96 - 0.000626658624307012*x_97 - 0.00220804845491823*x_98 + 0.00125846210848989*x_99 - 0.00557868162913203*std::sin(0.204080000519753*x_10 - 1.37511992454529) + 0.000349471101127629*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.000595110218926139*std::sin(0.336399853229523*x_10 - 1.13703989982605) + 0.000698322518016024*std::sin(0.37255984544754*x_10 + 7.81288003921509) + 0.000374162021586054*std::sin(0.252959966659546*x_100 - 1.23215985298157) - 0.000627938037677999*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.00112660784250282*std::sin(0.256079971790314*x_100 + 1.9599198102951) + 0.00790302899647177*std::sin(0.259679973125458*x_100 + 1.94807982444763) - 0.00359700738578062*std::sin(0.225839987397194*x_101 - 7.42223978042603) - 0.000840728020849427*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.0283698781773045*std::sin(0.251679986715317*x_101 + 8.1866397857666) + 0.000213794431299601*std::sin(0.228479996323586*x_103 - 1.22135984897614) + 0.00668795607744566*std::sin(0.253919988870621*x_107 - 7.43423986434937) - 0.00151535738715915*std::sin(0.271919965744019*x_107 + 1.92799985408783) + 0.000598538343715162*std::sin(0.260479986667633*x_108 + 1.96487975120544) + 0.000328109919952524*std::sin(0.267119973897934*x_108 + 1.96311986446381) + 0.000442886050713587*std::sin(0.26895996928215*x_108 - 1.21239984035492) + 0.00874560662636427*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.000574000493304621*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.0394158729946489*std::sin(0.241599977016449*x_109 + 1.95159983634949) + 0.000180818406152347*std::sin(0.255759954452515*x_109 + 8.17471981048584) - 0.00544027322217604*std::sin(0.249359980225563*x_11 - 7.42104005813599) + 0.0195476705839803*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.00771168683457108*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 0.000288707256617452*std::sin(0.280639946460724*x_113 - 7.41319990158081) - 0.0243601832087094*std::sin(0.287039935588837*x_113 - 7.43591976165771) - 0.000846436941147099*std::sin(0.295439928770065*x_113 - 4.42239999771118) + 0.0113589840579007*std::sin(0.279519945383072*x_116 - 1.23175990581512) + 0.0174060618831001*std::sin(0.266079962253571*x_117 - 1.24495995044708) + 0.0041265000329645*std::sin(0.237919986248016*x_118 - 7.43095970153809) + 0.00669136107191751*std::sin(0.194319993257523*x_119 + 2.19599986076355) - 0.00225242344815879*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.00122560087957223*std::sin(0.238479986786842*x_119 + 5.15775966644287) + 0.00016849962768407*std::sin(0.261599957942963*x_119 - 1.24623990058899) + 0.00521405967727197*std::sin(0.265759944915771*x_12 - 4.24592018127441) - 0.0326427940501198*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 8.33752461710547e-5*std::sin(0.285839945077896*x_120 + 8.15007972717285) + 0.000369112487518112*std::sin(0.287519931793213*x_120 - 1.24975991249084) + 0.000918968753433793*std::sin(0.300159931182861*x_120 + 1.77239990234375) - 0.0433081130966141*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 0.00481948744187396*std::sin(0.302159935235977*x_13 - 7.44248008728027) + 0.0043308226850606*std::sin(0.349279850721359*x_13 - 1.33511984348297) + 0.0409862161658972*std::sin(0.202239990234375*x_14 - 1.01215982437134) - 0.00103461263250111*std::sin(0.250879973173141*x_14 - 4.21776008605957) - 0.000220480667127827*std::sin(0.270719945430756*x_14 + 5.1691198348999) + 0.00663402633896256*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.000417998884450418*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.00240796124930647*std::sin(0.335039854049683*x_15 - 4.3471999168396) - 0.0085702775056577*std::sin(0.190400004386902*x_16 + 5.19712018966675) - 0.0166341666805477*std::sin(0.304959923028946*x_16 + 5.18527984619141) - 0.000638925196434602*std::sin(0.363839834928513*x_16 + 5.03007984161377) + 0.000324138854825782*std::sin(0.358959853649139*x_17 - 1.18831992149353) + 0.00711928985015027*std::sin(0.386799842119217*x_17 - 1.18543982505798) + 0.0060117781767544*std::sin(0.389279842376709*x_17 - 1.1684798002243) + 0.0204998058108913*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 0.000423508477450016*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.000822707691184407*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.0215681526569373*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 0.0214736452949436*std::sin(0.36575984954834*x_2 + 5.18800020217896) - 0.0110720756677861*std::sin(0.367199838161469*x_2 + 1.99895977973938) + 0.00646662198824049*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.0304277332704714*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.00022426201588984*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.000550246143252274*std::sin(0.290639936923981*x_20 - 1.18799984455109) - 0.000360449281925059*std::sin(0.295519918203354*x_20 + 4.99823999404907) + 0.0292017086512347*std::sin(0.319999933242798*x_20 + 1.95359981060028) - 0.00660893007532519*std::sin(0.364559859037399*x_20 - 4.37727975845337) + 0.000389079832216385*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.0294869318727358*std::sin(0.318879932165146*x_21 + 1.80535984039307) + 0.0198861639607286*std::sin(0.302559942007065*x_22 + 8.23855972290039) - 0.00107446231505127*std::sin(0.332959830760956*x_22 + 1.99087977409363) + 0.00335411350992398*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.0218264880946316*std::sin(0.413999855518341*x_22 - 4.39455986022949) - 0.00029913076581418*std::sin(0.298639953136444*x_23 - 1.17119991779327) + 0.0266523889685443*std::sin(0.334719836711884*x_23 - 1.17023992538452) - 0.0500552888164038*std::sin(0.187760010361671*x_24 - 1.41407978534698) - 0.00325981130242393*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.000411858778736769*std::sin(0.300559937953949*x_25 - 1.19079983234406) - 0.00360814103648736*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.000720212677741703*std::sin(0.267359972000122*x_26 - 1.1807998418808) + 0.0062913754678891*std::sin(0.319199919700623*x_26 - 1.19415986537933) + 0.000781316762152521*std::sin(0.346879839897156*x_26 - 1.15215992927551) + 0.000537382423005568*std::sin(0.36711984872818*x_26 - 4.38271999359131) + 0.00205581482443054*std::sin(0.203199997544289*x_27 - 1.20415985584259) - 0.0103146030577895*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.000486919331883633*std::sin(0.323919922113419*x_27 + 1.99407982826233) + 0.0217849822678567*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 0.000637297475368866*std::sin(0.284639924764633*x_28 - 1.18023991584778) - 0.0234089890935519*std::sin(0.341039836406708*x_28 + 8.24183940887451) - 0.000497806529870763*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 0.0348121237662001*std::sin(0.277119934558868*x_29 + 8.20456027984619) + 0.00545022920987509*std::sin(0.367439836263657*x_29 + 5.02615976333618) - 0.00630553829704004*std::sin(0.31415992975235*x_3 - 1.13303995132446) - 0.000316808075548076*std::sin(0.335119843482971*x_3 + 5.19600009918213) - 0.0244784865726489*std::sin(0.361119836568832*x_3 + 1.96599984169006) - 0.000287354569287857*std::sin(0.473119854927063*x_3 + 5.00575971603394) - 0.0024874260121473*std::sin(0.33095982670784*x_30 + 2.03791975975037) - 0.00507535322546386*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.000387665007748704*std::sin(0.413679867982864*x_31 - 1.18167984485626) - 0.00117262368162676*std::sin(0.416479855775833*x_31 - 4.1956000328064) - 0.000208109498702198*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.0277742557422687*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 0.00090473984149201*std::sin(0.306559920310974*x_32 + 1.85255992412567) + 0.000257552968817791*std::sin(0.31399992108345*x_32 + 8.25504016876221) - 0.0124205888087689*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 0.00049511344981971*std::sin(0.337119847536087*x_32 + 1.98447978496552) - 0.00108535651890865*std::sin(0.22367998957634*x_33 + 5.18304014205933) - 0.00537573662460956*std::sin(0.23871998488903*x_34 + 1.98119986057281) - 0.0427847156834194*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 0.0410473713309116*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 0.000670021745830478*std::sin(0.246799975633621*x_35 - 1.19687986373901) + 0.000284405317697135*std::sin(0.251999974250793*x_35 + 1.95895981788635) + 0.000393379561758362*std::sin(0.195119991898537*x_36 + 1.80503988265991) - 0.0140716768558787*std::sin(0.206160008907318*x_36 - 4.38503980636597) - 0.000225520277434063*std::sin(0.233519986271858*x_37 + 1.96423983573914) + 0.00529351762335197*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.0344341300850097*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.00132395378939167*std::sin(0.236719980835915*x_39 + 1.96407985687256) + 0.00887621194281481*std::sin(0.306159913539886*x_4 - 1.14551985263824) + 0.000305068649871028*std::sin(0.310319930315018*x_4 + 2.00831985473633) + 0.0102360537693409*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.000887562853471807*std::sin(0.33095982670784*x_4 + 2.00415992736816) - 0.00150813948721955*std::sin(0.366239845752716*x_4 + 4.79080009460449) - 0.00205151729321756*std::sin(0.216800004243851*x_40 + 2.00239968299866) - 0.00166598978078612*std::sin(0.226639986038208*x_41 + 1.97247982025146) - 0.000951239758235584*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.0130712969492991*std::sin(0.285039931535721*x_42 + 8.16335964202881) + 0.00944910880188308*std::sin(0.130480051040649*x_44 + 8.17927932739258) - 0.0318814880671512*std::sin(0.204159989953041*x_46 - 1.17471981048584) + 0.0330863700095026*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.000490292434681986*std::sin(0.215120002627373*x_48 + 1.96871984004974) + 0.00865217244938096*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 0.00102877605781957*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.000532279239556771*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.015585884980427*std::sin(0.369519829750061*x_5 - 7.58495998382568) - 0.00030070339445305*std::sin(0.380479842424393*x_5 - 1.16351985931396) - 0.00726256291758583*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.0344953418721115*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.00161834432639427*std::sin(0.218799993395805*x_52 - 7.39351987838745) - 0.000105700998803178*std::sin(0.242159977555275*x_52 + 8.19295978546143) + 0.00609466485086049*std::sin(0.254639983177185*x_52 - 1.21143984794617) - 0.00122817904601704*std::sin(0.267039954662323*x_52 + 1.93775975704193) - 0.000414810554050819*std::sin(0.244799971580505*x_53 - 7.4125599861145) - 0.0299387758694795*std::sin(0.258399993181229*x_53 + 5.15200042724609) + 0.00299061260769721*std::sin(0.259919971227646*x_53 - 1.20503985881805) - 0.00339654652909617*std::sin(0.248719975352287*x_57 - 7.43688011169434) + 0.00128878133735737*std::sin(0.245999962091446*x_59 - 4.24624013900757) + 0.0248082120364515*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 0.00440276458925589*std::sin(0.31007993221283*x_6 - 7.38839960098267) - 0.000710875333773444*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.00716042707137476*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 0.00411526297197181*std::sin(0.277519941329956*x_7 + 8.40375995635986) - 0.019739347787421*std::sin(0.320879906415939*x_7 + 5.20904016494751) + 0.00713687192749387*std::sin(0.466479867696762*x_7 - 7.62304019927979) - 0.00756223486937165*std::sin(0.334319829940796*x_8 - 4.33663988113403) - 0.0188612946311271*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 0.00258056100088811*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.0314198583682886*std::sin(0.302399933338165*x_9 - 7.42071962356567) - 0.0328778223920757*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 0.000777121457673484*std::sin(0.31839993596077*x_9 - 7.44271993637085) - 0.00350308630111745*std::sin(0.322079926729202*x_9 - 7.60824012756348) + 0.000679833627012059*std::sin(0.329679846763611*x_9 + 8.27055931091309) + 0.000127614004452063*std::sin(0.343599855899811*x_9 + 8.2553596496582) + 0.0174681903275737*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 0.000573346934849041*std::sin(0.360399842262268*x_91 + 2.0033597946167) - 0.000245883232313978*std::sin(0.370799839496613*x_91 - 7.39167976379395) - 0.0066688276197832*std::sin(0.408639848232269*x_91 - 1.21063983440399) + 0.00223640932989045*std::sin(0.272479951381683*x_92 + 1.9845597743988) - 0.000620482447932625*std::sin(0.296559929847717*x_92 + 1.81431996822357) - 0.00597108494906657*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.000566602745628233*std::sin(0.350959837436676*x_92 - 7.59128046035767) + 0.000499151283792918*std::sin(0.251839965581894*x_94 - 1.18175983428955) - 0.00994500292909557*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.0229456380185812*std::sin(0.293039947748184*x_94 - 1.20255982875824) + 0.00288401400384612*std::sin(0.303999930620193*x_94 + 1.95023989677429) - 0.000663492045395436*std::sin(0.304239928722382*x_94 - 1.20943987369537) - 0.00545822811643693*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.0200832076659168*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.000663482232145878*std::sin(0.283679932355881*x_95 - 1.21423995494843) - 0.00107462450342144*std::sin(0.285359919071198*x_95 - 1.20247983932495) + 0.00457160487455623*std::sin(0.271519958972931*x_96 + 8.18879985809326) - 0.0039832886354114*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 0.0316758352856777*std::sin(0.26199996471405*x_97 - 1.21223986148834) + 0.00576351540464456*std::sin(0.265839964151382*x_97 + 8.19623947143555) - 0.00089156679297012*std::sin(0.293199926614761*x_97 - 1.21343982219696) + 0.00380118918180937*std::sin(0.253679990768433*x_98 + 1.97847986221313) + 0.000277193418185632*std::sin(0.259759962558746*x_98 + 1.97319984436035) - 0.00140072297812142*std::sin(0.262879967689514*x_98 + 1.95375978946686) - 0.00409974562132114*std::sin(0.240079984068871*x_99 - 7.41871976852417) + 0.000616836078241695*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.0109093387448705*std::sin(0.254879981279373*x_99 + 4.98095989227295) - 0.00023542701187267*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.000926589366349992*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.153392463922501*std::sin(0.0017999369071699*x_1 - 0.00647839980287651*x_10 + 0.0512155335827258*x_100 - 0.00173064436308723*x_101 + 0.0355348587842474*x_102 + 0.0681592912708305*x_103 - 0.0498065804007124*x_104 - 0.0255793193877913*x_105 + 0.00200164410130204*x_106 + 0.00774809927105322*x_107 + 0.0738645954909916*x_109 + 0.042604813087869*x_110 - 0.045791482961543*x_111 + 0.0572127565478942*x_112 + 0.0144144414628436*x_113 + 0.0739917716288592*x_114 + 0.0245028761965917*x_115 - 0.0345899540617359*x_116 + 0.0332347295343042*x_117 + 0.0531071720984864*x_118 + 0.0209638738394564*x_119 + 0.0085687847574513*x_120 + 0.0112445097158403*x_14 + 0.00351358620820454*x_17 - 0.00166808299015427*x_19 + 0.0515453382015765*x_2 - 0.0296870294043051*x_21 - 0.0339519905369836*x_22 - 0.021120677259517*x_23 + 0.00107039564736028*x_24 + 0.0259995011325457*x_25 + 0.00530506393860206*x_26 - 0.0107222081114751*x_28 - 0.0336304960104467*x_29 + 0.00349641974894857*x_3 - 0.0441806909488861*x_30 - 0.00055866195743382*x_32 - 0.00493430814450913*x_33 + 0.0561541234234428*x_34 + 0.0278744360778616*x_35 - 0.0371027936224588*x_36 + 0.00310001287898719*x_37 + 0.0155416036798083*x_38 + 0.0334944317282949*x_39 - 0.000622980302119463*x_4 - 0.00598102833793045*x_40 + 0.0523613042806235*x_42 - 0.0454629325413364*x_43 + 0.00299969277450727*x_44 + 0.0168717404369083*x_45 + 0.0443767956924722*x_46 + 0.00840648735735018*x_47 + 0.0617129968350133*x_49 + 0.0193315814616075*x_50 - 0.0481211284421872*x_51 - 0.054390051939291*x_52 + 0.0502790983675176*x_53 - 0.0343646848044034*x_54 + 0.0627376042336392*x_55 + 0.0921294239224853*x_56 - 0.0483904151731546*x_57 - 0.0218581069405673*x_58 - 0.0246560308330474*x_59 + 0.0394718405718993*x_6 - 0.00214132781988821*x_61 + 0.00604554209773737*x_62 + 0.00644242391193152*x_63 + 0.00421161940438884*x_64 + 0.00728147636358433*x_65 + 0.00607593112340719*x_66 + 2.94167152279508e-5*x_67 - 0.01587045462641*x_68 + 0.0200995588747136*x_69 + 0.0690383322602184*x_7 + 0.0134597495271238*x_70 - 0.0206735176518671*x_71 + 0.000919902794660733*x_72 - 0.01973241270523*x_73 - 0.0048501982940741*x_74 - 0.0232334558916503*x_75 + 0.000233175480505814*x_76 - 0.0235056833736061*x_77 + 0.0200644139263487*x_78 - 3.266840629424e-5*x_79 + 0.0326835553225622*x_8 - 0.00080118629861475*x_80 + 0.0223276965227595*x_81 - 0.0277603628853351*x_82 + 0.014199196944716*x_83 + 0.0267616982613464*x_84 + 0.000716116989741794*x_85 - 0.00799531749588932*x_86 - 0.0123505758049596*x_87 + 0.000242350868487882*x_88 - 0.00348298565812885*x_89 + 0.000168442464121938*x_90 - 0.00497961289818388*x_91 + 0.00334258955060466*x_93 - 0.0160533198738317*x_94 + 0.0142909048299868*x_95 + 0.0194685094075741*x_96 + 0.00564670593288259*x_97 - 0.00746588287077156*x_98 + 0.0408584829586017*x_99 + 0.272992532883009*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.199276374041229*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.204016990309761*std::sin(0.319919914007187*x_12 + 8.1496000289917) + 0.0420513816004977*std::sin(0.375919848680496*x_13 - 7.79184007644653) - 0.421181941392568*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.364533925121478*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.368493203059046*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 0.473154375256975*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 1.58490968101853*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.151770030459186*std::sin(0.354239851236343*x_31 - 4.42335987091064) - 0.265649093073492*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.429934105953016*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.389461560752281*std::sin(0.161120027303696*x_5 + 4.78815984725952) + 0.299847110624903*std::sin(0.261199980974197*x_60 - 7.43887996673584) - 0.31775677588741*std::sin(0.293359935283661*x_9 + 1.99279975891113) + 0.116586703301342*std::sin(0.196879997849464*x_92 - 0.973359823226929) + 10.7337519371281) + 0.197898376018832);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00150851333599268*x_1 + 0.000320913269945666*x_10 - 0.000314121934843635*x_100 - 0.00117173537816564*x_101 + 0.00395117640851238*x_102 + 0.0035796453872401*x_103 - 0.00101299430851153*x_104 - 0.000884913446115075*x_105 - 9.25588009864561e-5*x_106 - 0.0011224696473897*x_107 - 0.00262223596371439*x_108 + 0.00122836834029951*x_109 - 0.00156427560229958*x_11 + 0.00460467136715427*x_110 - 0.000977954624097958*x_111 + 0.0031368145183726*x_112 + 0.000745322788868436*x_113 - 0.001442433480639*x_114 + 0.00415885458967701*x_115 + 0.00192850466315755*x_116 - 0.000104151480775802*x_117 + 0.00307419718974847*x_118 + 0.00247196294116818*x_119 - 0.00634620532415267*x_12 + 0.000455358523032206*x_120 - 0.00323978651929568*x_13 - 0.00199283063943814*x_14 - 0.00104563400179273*x_15 + 8.55052480747449e-6*x_16 - 0.00012597516874493*x_17 + 0.000328003034328568*x_18 - 0.000587020882848127*x_19 - 0.000556448312431197*x_2 - 5.37013241512459e-5*x_20 - 0.00340295463058012*x_21 - 0.000143227051672228*x_22 - 0.00122732022275376*x_23 - 0.000431696879096666*x_24 + 0.000910178273309769*x_25 + 0.000749374362750898*x_26 - 0.000219474695744802*x_27 - 0.0014876790005047*x_28 + 0.000367715935273223*x_29 - 0.000193930218876296*x_3 + 0.00442141032865413*x_30 + 0.00116765398161179*x_31 + 0.000750864162251841*x_32 + 0.000371290189271336*x_33 - 0.00150779863639473*x_34 + 0.000196545391618344*x_35 + 0.00220030769986012*x_36 - 0.00324886916551925*x_37 + 0.00247330244362574*x_38 + 0.0044955875539557*x_39 + 0.000183911109814703*x_4 - 0.00223456689061047*x_40 + 0.00607785460513085*x_41 - 0.00076842015593307*x_42 - 0.00253491241101503*x_43 + 0.00295827137724542*x_44 + 0.0032095262366583*x_45 - 0.00034124091620423*x_46 - 0.000831405730547653*x_47 + 0.000449202029360265*x_48 - 0.00147546530093606*x_49 - 0.000832202261282815*x_5 - 0.000538647626839287*x_50 - 0.00371221118292249*x_51 - 0.00385193047358568*x_52 + 0.00148374361591648*x_53 - 0.000789533802985116*x_54 - 0.00241646158957952*x_55 + 0.00114803291377033*x_56 - 0.000173169356000713*x_57 - 0.000392597146011153*x_58 + 0.00437052217172198*x_59 + 0.00134491027938943*x_6 - 0.00630378786664928*x_60 + 0.00233504171524423*x_61 + 0.000445381054709449*x_62 + 8.8541946898083e-5*x_63 - 0.00182179382093994*x_64 + 0.00153622967522032*x_65 - 0.00155737573347392*x_66 + 0.0022073096937539*x_67 - 0.00120104354791985*x_68 + 0.00101519952908112*x_69 + 0.000993899135934375*x_7 + 0.000202526169025028*x_70 - 0.000275218800158042*x_71 - 0.000425559499836632*x_72 - 0.00145959704282216*x_73 + 0.00214806970080923*x_74 - 0.000285576864333371*x_75 - 0.000544686700280354*x_76 - 0.000894770897523796*x_77 + 0.00176336184093932*x_78 - 0.00183692454913491*x_79 - 0.000980176519566918*x_8 + 0.00194278433658358*x_80 + 0.000277185612663352*x_81 - 0.000607179052243121*x_82 + 0.000984230875182987*x_83 + 0.000581043227561976*x_84 - 0.00112841608870855*x_85 - 0.00140290396564142*x_86 + 0.00172046955537256*x_87 + 0.000139544390936008*x_88 - 0.00133023521530737*x_89 + 0.00101437661712862*x_9 - 0.00184681547683996*x_90 - 0.000302240894812182*x_91 - 0.00254555230469177*x_92 - 0.00454633088381324*x_93 - 0.000509517477550942*x_94 - 0.00094225380176186*x_95 - 0.00129271705952845*x_96 + 0.000246829108764727*x_97 - 0.00201615682265398*x_98 + 1.5038602200272e-5*x_99 + 0.00216942055065805*std::sin(0.204080000519753*x_10 - 1.37511992454529) - 0.00310751154176719*std::sin(0.270079970359802*x_10 + 1.97511982917786) - 0.000180551636176886*std::sin(0.336399853229523*x_10 - 1.13703989982605) + 0.000791367168958967*std::sin(0.37255984544754*x_10 + 7.81288003921509) - 0.000653803482917675*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 0.0045086056486694*std::sin(0.253599971532822*x_100 + 8.17840003967285) + 0.000341803724460731*std::sin(0.256079971790314*x_100 + 1.9599198102951) - 0.00307330560465409*std::sin(0.259679973125458*x_100 + 1.94807982444763) - 0.00194039492845399*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 0.00603644129891062*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.000818489628558989*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.00190106896016684*std::sin(0.228479996323586*x_103 - 1.22135984897614) + 0.00360779800055437*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 0.010880291470736*std::sin(0.271919965744019*x_107 + 1.92799985408783) + 0.00261462706597611*std::sin(0.255839973688126*x_108 - 7.43215990066528) + 0.000181591701563082*std::sin(0.260479986667633*x_108 + 1.96487975120544) - 0.00291756703181134*std::sin(0.267119973897934*x_108 + 1.96311986446381) - 0.000773890522786802*std::sin(0.26895996928215*x_108 - 1.21239984035492) - 0.00340096460140848*std::sin(0.234399989247322*x_109 + 1.97207987308502) + 0.000174147115839313*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.00113717383786749*std::sin(0.241599977016449*x_109 + 1.95159983634949) - 0.0016078447753457*std::sin(0.255759954452515*x_109 + 8.17471981048584) - 0.00616513646220118*std::sin(0.249359980225563*x_11 - 7.42104005813599) + 0.00190859946122067*std::sin(0.290559947490692*x_11 - 1.21591985225677) + 0.0162530703463831*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.00641194499738896*std::sin(0.312399923801422*x_112 - 7.64192008972168) + 0.0025671969133809*std::sin(0.280639946460724*x_113 - 7.41319990158081) - 0.0202544732704062*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 0.00607743144245579*std::sin(0.295439928770065*x_113 - 4.42239999771118) - 0.00441724677764787*std::sin(0.279519945383072*x_116 - 1.23175990581512) + 0.0144724123022293*std::sin(0.266079962253571*x_117 - 1.24495995044708) + 0.00467631583480065*std::sin(0.237919986248016*x_118 - 7.43095970153809) - 0.00260211590951636*std::sin(0.194319993257523*x_119 + 2.19599986076355) - 0.00255253686008922*std::sin(0.238399982452393*x_119 + 1.98503983020782) - 0.000371837412750025*std::sin(0.238479986786842*x_119 + 5.15775966644287) - 0.00149830568571246*std::sin(0.261599957942963*x_119 - 1.24623990058899) + 0.00590878217318367*std::sin(0.265759944915771*x_12 - 4.24592018127441) - 0.00195400342694167*std::sin(0.319919914007187*x_12 + 8.1496000289917) - 0.0271411176958283*std::sin(0.257359951734543*x_120 - 7.41495990753174) + 0.000741376150812574*std::sin(0.285839945077896*x_120 + 8.15007972717285) - 0.000644980024709016*std::sin(0.287519931793213*x_120 - 1.24975991249084) + 0.000495734958904912*std::sin(0.300159931182861*x_120 + 1.77239990234375) - 0.00124946752257807*std::sin(0.275919944047928*x_13 - 4.24416017532349) - 0.00546163704350369*std::sin(0.302159935235977*x_13 - 7.44248008728027) - 0.00168415700318219*std::sin(0.349279850721359*x_13 - 1.33511984348297) + 0.000402753435536164*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.00118247927030228*std::sin(0.202239990234375*x_14 - 1.01215982437134) + 0.0074285360643676*std::sin(0.250879973173141*x_14 - 4.21776008605957) + 0.0019605232467735*std::sin(0.270719945430756*x_14 + 5.1691198348999) + 0.00357870576364123*std::sin(0.29751992225647*x_14 + 5.15399980545044) + 0.000126817487093098*std::sin(0.319439917802811*x_14 + 8.14727973937988) - 0.0040339334268066*std::sin(0.320319920778275*x_15 + 1.95847988128662) + 0.0012989675291017*std::sin(0.335039854049683*x_15 - 4.3471999168396) + 0.0033327831522999*std::sin(0.190400004386902*x_16 + 5.19712018966675) - 0.0138306137322554*std::sin(0.304959923028946*x_16 + 5.18527984619141) - 0.00349137852608439*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 0.0045874936329298*std::sin(0.363839834928513*x_16 + 5.03007984161377) - 0.000566393968408958*std::sin(0.358959853649139*x_17 - 1.18831992149353) - 0.00276852753639039*std::sin(0.386799842119217*x_17 - 1.18543982505798) + 0.00324303584454082*std::sin(0.389279842376709*x_17 - 1.1684798002243) + 0.0170447309565703*std::sin(0.406719863414764*x_17 - 1.20767986774445) + 0.003529299106358*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 0.000740030525888903*std::sin(0.35471984744072*x_18 + 2.02647995948792) - 0.000249602871896053*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.000622255377571644*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 0.000619528778073019*std::sin(0.36575984954834*x_2 + 5.18800020217896) - 0.00920596773594503*std::sin(0.367199838161469*x_2 + 1.99895977973938) - 0.00251472006600399*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.0008778601003075*std::sin(0.199680000543594*x_20 + 5.20136022567749) + 0.00453170723340653*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 0.00199414715697234*std::sin(0.282079964876175*x_20 - 7.40855979919434) - 0.000166940237799126*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 0.00258803189333069*std::sin(0.295519918203354*x_20 + 4.99823999404907) + 0.0242799991387239*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 0.00257006039713782*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 0.00279359972490419*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.000850717361739225*std::sin(0.318879932165146*x_21 + 1.80535984039307) + 0.0165345134288434*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 0.00771465745384053*std::sin(0.332959830760956*x_22 + 1.99087977409363) + 0.00180936655005035*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.000629708524713148*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.00265988318995723*std::sin(0.298639953136444*x_23 - 1.17119991779327) + 0.0221603464691039*std::sin(0.334719836711884*x_23 - 1.17023992538452) - 0.00144412797597159*std::sin(0.187760010361671*x_24 - 1.41407978534698) - 0.00175849550488696*std::sin(0.362239837646484*x_24 - 1.18511986732483) + 0.00012495462858783*std::sin(0.300559937953949*x_25 - 1.19079983234406) - 0.00194640094319056*std::sin(0.330639839172363*x_25 - 1.16295981407166) - 0.000218506712246089*std::sin(0.267359972000122*x_26 - 1.1807998418808) + 0.00339386377107551*std::sin(0.319199919700623*x_26 - 1.19415986537933) - 0.00136525780513989*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 0.00385841481560473*std::sin(0.36711984872818*x_26 - 4.38271999359131) + 0.0151797109809392*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 0.0147607849403746*std::sin(0.203199997544289*x_27 - 1.20415985584259) + 0.00401111110707537*std::sin(0.223600000143051*x_27 + 8.2227201461792) + 0.000147727394458769*std::sin(0.323919922113419*x_27 + 1.99407982826233) + 0.0181133014173234*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 0.000193350909209524*std::sin(0.284639924764633*x_28 - 1.18023991584778) - 0.0194635951552721*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 0.00357425923872882*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 0.0289448246044586*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 0.00211946836900592*std::sin(0.367439836263657*x_29 + 5.02615976333618) + 0.0024520783356996*std::sin(0.31415992975235*x_3 - 1.13303995132446) + 0.00281707056209823*std::sin(0.335119843482971*x_3 + 5.19600009918213) - 0.0203528375684979*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 0.00206321062991019*std::sin(0.473119854927063*x_3 + 5.00575971603394) - 0.00281885121909062*std::sin(0.33095982670784*x_30 + 2.03791975975037) - 0.00145360030639616*std::sin(0.354239851236343*x_31 - 4.42335987091064) - 0.00575159444222581*std::sin(0.384079843759537*x_31 + 5.18800020217896) - 0.000117614433783132*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 0.00841945771320992*std::sin(0.416479855775833*x_31 - 4.1956000328064) + 0.00185051830346419*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.000801305529897476*std::sin(0.297199934720993*x_32 + 8.2344799041748) - 0.00102528758350806*std::sin(0.306559920310974*x_32 + 1.85255992412567) - 0.0022901716926957*std::sin(0.31399992108345*x_32 + 8.25504016876221) - 0.0103271999998741*std::sin(0.316159933805466*x_32 - 1.14583992958069) + 0.000150213423690555*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 0.00779287802036449*std::sin(0.22367998957634*x_33 + 5.18304014205933) + 0.0020904999216038*std::sin(0.23871998488903*x_34 + 1.98119986057281) - 0.0355737012635405*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 0.0341291721133336*std::sin(0.231599986553192*x_35 + 1.97151982784271) - 0.000203279188688913*std::sin(0.246799975633621*x_35 - 1.19687986373901) - 0.00252894389387879*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 0.00282447185517423*std::sin(0.195119991898537*x_36 + 1.80503988265991) + 0.0054721504080727*std::sin(0.206160008907318*x_36 - 4.38503980636597) + 0.00200533567086839*std::sin(0.233519986271858*x_37 + 1.96423983573914) + 0.00285557232677322*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.000993447281193413*std::sin(0.225999981164932*x_38 - 1.19767987728119) + 0.00040167689159934*std::sin(0.236719980835915*x_39 + 1.96407985687256) + 0.00738019890892795*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 0.00271268310154016*std::sin(0.310319930315018*x_4 + 2.00831985473633) - 0.00398056510141876*std::sin(0.323759824037552*x_4 + 5.23343992233276) + 0.000269279404566988*std::sin(0.33095982670784*x_4 + 2.00415992736816) - 0.00170908433511058*std::sin(0.366239845752716*x_4 + 4.79080009460449) - 0.00232486192342246*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 0.011961834584911*std::sin(0.226639986038208*x_41 + 1.97247982025146) - 0.00254429416609581*std::sin(0.229359999299049*x_41 + 8.18479919433594) - 0.000288598463417172*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.000377115506734002*std::sin(0.285039931535721*x_42 + 8.16335964202881) + 0.0107081102052617*std::sin(0.130480051040649*x_44 + 8.17927932739258) - 0.026508123618956*std::sin(0.204159989953041*x_46 - 1.17471981048584) + 0.000954563517340279*std::sin(0.193120002746582*x_48 - 7.40735960006714) - 0.00411775859998609*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.00435970068683586*std::sin(0.215120002627373*x_48 + 1.96871984004974) + 0.00466738867628005*std::sin(0.221679985523224*x_48 - 1.18127989768982) - 0.00373012670766567*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 0.00738662936020397*std::sin(0.323039829730988*x_5 + 8.21255970001221) - 0.000161489224262324*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.000449663023882779*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.00267386706911185*std::sin(0.380479842424393*x_5 - 1.16351985931396) - 0.00391776795026049*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.000995213281476363*std::sin(0.203759998083115*x_52 + 1.97647976875305) - 0.000490992603950447*std::sin(0.218799993395805*x_52 - 7.39351987838745) + 0.000939897670214616*std::sin(0.242159977555275*x_52 + 8.19295978546143) + 0.003287748814191*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 0.00881834616186979*std::sin(0.267039954662323*x_52 + 1.93775975704193) + 0.0036885126701478*std::sin(0.244799971580505*x_53 - 7.4125599861145) - 0.0248928396967167*std::sin(0.258399993181229*x_53 + 5.15200042724609) + 0.00338908251094378*std::sin(0.259919971227646*x_53 - 1.20503985881805) - 0.00384910316024861*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 0.00925347163072924*std::sin(0.245999962091446*x_59 - 4.24624013900757) + 0.000715733219861751*std::sin(0.267279952764511*x_59 + 5.12815999984741) + 0.00498938994333313*std::sin(0.31007993221283*x_6 - 7.38839960098267) + 0.00124216981502076*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.000206583026453098*std::sin(0.481119841337204*x_6 + 4.95983982086182) + 0.00287183082560936*std::sin(0.261199980974197*x_60 - 7.43887996673584) - 0.0046635815452485*std::sin(0.277519941329956*x_7 + 8.40375995635986) - 0.0164124419225479*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 0.00277536480054135*std::sin(0.466479867696762*x_7 - 7.62304019927979) + 0.00294077863286675*std::sin(0.334319829940796*x_8 - 4.33663988113403) - 0.0156823774549788*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 7.44508806802146e-5*std::sin(0.418719857931137*x_8 - 1.58127987384796) - 0.00304336333986312*std::sin(0.293359935283661*x_9 + 1.99279975891113) + 0.0261242978358603*std::sin(0.302399933338165*x_9 - 7.42071962356567) - 0.000948546781531341*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 0.000235772376660413*std::sin(0.31839993596077*x_9 - 7.44271993637085) + 0.00136226942449757*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 0.00488121685100678*std::sin(0.329679846763611*x_9 + 8.27055931091309) - 0.00113474902630386*std::sin(0.343599855899811*x_9 + 8.2553596496582) + 0.0145240695047693*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 0.00017394883147998*std::sin(0.360399842262268*x_91 + 2.0033597946167) + 0.00218640391115962*std::sin(0.370799839496613*x_91 - 7.39167976379395) + 0.00259335316996834*std::sin(0.408639848232269*x_91 - 1.21063983440399) + 0.00111662669584904*std::sin(0.196879997849464*x_92 - 0.973359823226929) - 0.000869687980509938*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 0.00445507438917689*std::sin(0.296559929847717*x_92 + 1.81431996822357) - 0.00676667366417056*std::sin(0.297279924154282*x_92 - 1.16759991645813) - 0.000171902698915326*std::sin(0.350959837436676*x_92 - 7.59128046035767) - 0.000872207303304785*std::sin(0.251839965581894*x_94 - 1.18175983428955) + 0.00386738214600197*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.000661996735463668*std::sin(0.293039947748184*x_94 - 1.20255982875824) + 0.00326828068489887*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 0.00476388402075278*std::sin(0.304239928722382*x_94 - 1.20943987369537) - 0.00294442491203858*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.000579413738755473*std::sin(0.281199961900711*x_95 - 1.20783984661102) - 0.000201295153029625*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 0.0077158219690602*std::sin(0.285359919071198*x_95 - 1.20247983932495) - 0.0017777916403331*std::sin(0.271519958972931*x_96 + 8.18879985809326) - 0.00451402291810331*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 0.0263371319343019*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 0.00224129814068911*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 0.00640146453592038*std::sin(0.293199926614761*x_97 - 1.21343982219696) + 0.00205054019061359*std::sin(0.253679990768433*x_98 + 1.97847986221313) - 0.00246481538397411*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 0.0100572144900349*std::sin(0.262879967689514*x_98 + 1.95375978946686) - 0.00464599665927196*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 0.00442889339360215*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.000314741591814675*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 0.00209342676483828*std::sin(0.255439966917038*x_99 + 1.93951988220215) - 0.000281119733518404*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.128428177194761);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000198361527447005*x_1 - 0.00238857412811658*x_10 - 0.000400323798287004*x_100 - 0.000289308858344455*x_101 + 0.000275378281759238*x_102 - 0.00194755303872363*x_103 + 3.9222159551582e-5*x_104 + 0.00148993201079223*x_105 - 0.00164252991398359*x_106 + 0.000226741277060951*x_107 - 0.00313489141579911*x_108 + 1.66506888880945e-5*x_109 + 0.000254605452291533*x_11 - 0.00145233661802405*x_110 - 0.000592904388230644*x_111 - 0.00216071587915739*x_112 - 0.00229954068493583*x_113 + 0.000748076658771015*x_114 - 0.00108069588065899*x_115 + 0.000472254869583824*x_116 - 0.00385120674867234*x_117 + 0.000260019330318156*x_118 + 0.000342826525866974*x_119 - 0.000900543790253095*x_12 - 0.000997424481398492*x_120 + 0.000740184383579006*x_13 + 0.000168521753013352*x_14 - 0.00327381776213917*x_15 - 0.000299370601952392*x_16 - 0.00165024509917876*x_17 + 0.00100533947154261*x_18 - 0.000543670946185994*x_19 + 0.000607720060551216*x_2 + 9.15969527975594e-5*x_20 + 0.00279167125641894*x_21 + 5.48331915539655e-5*x_22 + 0.00232464739436684*x_23 + 0.000120081845286417*x_24 + 0.00139839407407228*x_25 + 0.000932227150586102*x_26 - 0.000788619488405651*x_27 + 0.00261058588698142*x_28 + 0.00186873582973195*x_29 + 0.00212618790932806*x_3 + 0.00185651769337343*x_30 + 0.000766340378497139*x_31 - 0.000693092777831879*x_32 + 0.00138407261878381*x_33 + 0.00237972082048284*x_34 + 0.00197177427044373*x_35 - 0.000569006964967752*x_36 + 0.00121832899851488*x_37 + 0.00307486076389993*x_38 - 0.00108341152850081*x_39 - 6.05767765948233e-5*x_4 - 0.00139087588760227*x_40 - 0.00152443250445191*x_41 + 0.00164406488151887*x_42 + 0.00125967908028656*x_43 + 0.00128628086869725*x_44 - 0.000851649575306369*x_45 + 0.00287972410417258*x_46 - 0.00129210838892018*x_47 + 0.00318335091506068*x_48 + 0.0046087826449615*x_49 - 0.000174433725628131*x_5 + 0.000816777803631617*x_50 + 0.00215521987795808*x_51 - 0.000407487842194287*x_52 - 0.00214622362953816*x_53 + 0.00333796476874079*x_54 - 0.000411066476503804*x_55 - 0.00184923657087304*x_56 - 0.000893497861207859*x_57 + 0.00299536156989956*x_58 + 0.000573725046445606*x_59 - 0.000774281350469775*x_6 + 0.000698117096383232*x_60 - 0.00059562211189346*x_61 + 0.000269943689440184*x_62 - 0.000538270511660166*x_63 + 4.3315820752547e-5*x_64 + 0.0011666886110075*x_65 + 0.000802589519481581*x_66 - 0.0012448215920413*x_67 - 0.000472941041649278*x_68 + 0.00117847360671204*x_69 - 0.00263549198670376*x_7 + 0.000426467689397892*x_70 + 0.000377835394231941*x_71 + 0.000679811912613987*x_72 - 0.000597509804936187*x_73 + 1.63374604228644e-5*x_74 - 0.000332465214297488*x_75 + 0.000186659859106044*x_76 + 0.00104506584899986*x_77 - 0.0012431317770163*x_78 + 0.00076067757219348*x_79 - 8.14013352860445e-5*x_8 - 7.00084958977563e-7*x_80 - 1.38841523115318e-5*x_81 - 0.00113227402595981*x_82 - 0.000621897717980826*x_83 - 0.000864134789115767*x_84 - 0.00152285569354584*x_85 + 0.00021357664358378*x_86 + 0.000697206102999573*x_87 - 0.000242284669380904*x_88 + 0.00016244483449375*x_89 - 0.00178293928401941*x_9 + 0.000541190705033095*x_90 + 6.33114558434454e-5*x_91 - 0.00110716989369947*x_92 - 0.00154083461918767*x_93 + 0.000120620052313985*x_94 - 0.000301680534488516*x_95 + 0.00203303704517914*x_96 - 0.000403748500771505*x_97 - 0.00021088491911242*x_98 + 0.000175250371237861*x_99 - 0.000926347507629544*std::pow(-0.175059389705657*x_1 + 0.0231464512268942*x_10 - 0.0963501018936608*x_100 - 0.122299705254194*x_101 + 0.358265736264045*x_102 + 0.226836946307168*x_103 - 0.00990417072798586*x_104 - 0.118062591126651*x_105 + 0.0179263498500359*x_106 - 0.0766309305868476*x_107 - 0.325242874047829*x_108 + 0.230512284563896*x_109 - 0.20982918963781*x_11 + 0.401226576632652*x_110 - 0.106454388413123*x_114 + 0.485144213726188*x_115 + 0.183276247957199*x_116 + 0.355816889500961*x_118 + 0.290315187959101*x_119 - 0.465129979851787*x_12 - 0.222219806766926*x_13 - 0.203419739007474*x_14 - 0.347930145110596*x_15 - 0.0117418728769066*x_18 - 0.126482645825598*x_19 - 0.221058153239027*x_21 - 0.0121099357408516*x_24 + 0.00656605472252557*x_25 + 0.0714184852266012*x_26 + 0.414701394200196*x_30 + 0.106004867086891*x_31 - 0.0758423328671169*x_33 + 0.292782040095037*x_36 - 0.31152087505228*x_37 + 0.344259528862068*x_38 + 0.613040074844405*x_39 - 0.333044848208625*x_40 + 0.600073827483647*x_41 - 0.00599473853105274*x_42 - 0.0568054401055294*x_43 + 0.299050297793163*x_44 + 0.498364330579885*x_45 - 0.24662616968352*x_47 + 0.290355818856855*x_48 - 0.178719808395667*x_49 - 0.0855842679164816*x_5 - 0.100923982830295*x_50 - 0.185566765743842*x_51 - 0.390989079406491*x_52 - 0.06720295291576*x_54 - 0.428694190246738*x_55 - 0.263193131974872*x_56 + 0.1296160767816*x_57 - 0.0908461360157448*x_58 + 0.436805684900252*x_59 + 0.0747213136355426*x_6 - 0.54375774987833*x_60 + 0.223531204881835*x_61 + 0.0580582117755808*x_62 + 0.00819965375465663*x_63 - 0.193070251968021*x_64 + 0.125819103964833*x_65 - 0.140630927199788*x_66 + 0.229719799019547*x_67 - 0.108524887166186*x_68 + 0.0674369974244339*x_69 + 0.0038777834029007*x_70 - 0.0060523177015917*x_71 + 0.00837447047830469*x_72 - 0.167633394697416*x_73 + 0.233557301653095*x_74 - 0.0271992796946724*x_75 - 0.0439811809124539*x_76 + 0.00478788871999589*x_77 + 0.093892341062672*x_78 - 0.139003339866693*x_79 + 0.178601488617269*x_80 - 0.000729932734895313*x_81 - 9.29801759113574e-6*x_82 + 0.00922822550392004*x_83 + 0.0619502575981204*x_84 - 0.108922517370906*x_85 - 0.131232871201854*x_86 + 0.216878883445053*x_87 - 0.0286888622944093*x_88 - 0.147100548195927*x_89 - 0.17413623967475*x_90 - 0.267359492612489*x_92 - 0.438712141793533*x_93 - 0.0423886341407088*x_94 - 0.123547620348066*x_95 - 0.0692298704889869*x_96 - 0.210140577318484*x_98 - 0.0283031088203305*x_99 + 1.70800422609783*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.673819095078507*std::sin(0.312399923801422*x_112 - 7.64192008972168) - 2.12850404298766*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 1.52087826159804*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 2.8522083974004*std::sin(0.257359951734543*x_120 - 7.41495990753174) - 1.453432871499*std::sin(0.304959923028946*x_16 + 5.18527984619141) + 1.79119833275078*std::sin(0.406719863414764*x_17 - 1.20767986774445) - 0.967437626442901*std::sin(0.367199838161469*x_2 + 1.99895977973938) + 2.55153889417704*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 1.737580543926*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 2.32878862974002*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 1.90349236852082*std::sin(0.333359837532043*x_27 + 8.24176025390625) - 2.04539216725041*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 3.04175652319609*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 2.13884095984443*std::sin(0.361119836568832*x_3 + 1.96599984169006) - 1.08526579087057*std::sin(0.316159933805466*x_32 - 1.14583992958069) - 3.73837255368738*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 3.58656973485421*std::sin(0.231599986553192*x_35 + 1.97151982784271) + 0.775571055637293*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 2.78568825472266*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 2.61594114191658*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 1.72475228168413*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 1.64803119641489*std::sin(0.338799834251404*x_8 + 8.23480033874512) + 2.74535273376316*std::sin(0.302399933338165*x_9 - 7.42071962356567) + 1.52630681868703*std::sin(0.32983985543251*x_91 + 5.19856023788452) + 2.7677190640533*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 4.78486078038139, 2) - 0.00554414689494258*std::sin(0.204080000519753*x_10 - 1.37511992454529) + 0.000381458973452635*std::sin(0.270079970359802*x_10 + 1.97511982917786) + 0.000492932465370559*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 0.00187186513714811*std::sin(0.37255984544754*x_10 + 7.81288003921509) + 0.00114152293384943*std::sin(0.252959966659546*x_100 - 1.23215985298157) - 0.00152791282906478*std::sin(0.253599971532822*x_100 + 8.17840003967285) - 0.000933174332500656*std::sin(0.256079971790314*x_100 + 1.9599198102951) + 0.00785410542925125*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.00290011066195933*std::sin(0.225839987397194*x_101 - 7.42223978042603) - 0.00204567815888356*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.0120633245869481*std::sin(0.251679986715317*x_101 + 8.1866397857666) + 0.000233363514265666*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.00539220820162609*std::sin(0.253919988870621*x_107 - 7.43423986434937) - 0.00368720136945397*std::sin(0.271919965744019*x_107 + 1.92799985408783) - 0.00258437687837837*std::sin(0.255839973688126*x_108 - 7.43215990066528) - 0.000495771996519764*std::sin(0.260479986667633*x_108 + 1.96487975120544) + 0.000358142555538537*std::sin(0.267119973897934*x_108 + 1.96311986446381) + 0.00135119160899468*std::sin(0.26895996928215*x_108 - 1.21239984035492) + 0.00869146709658903*std::sin(0.234399989247322*x_109 + 1.97207987308502) - 0.000475447184891444*std::sin(0.239599987864494*x_109 + 8.18639945983887) + 0.0167602577226699*std::sin(0.241599977016449*x_109 + 1.95159983634949) + 0.000197369119705912*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.0145827429567696*std::sin(0.249359980225563*x_11 - 7.42104005813599) - 0.00188651773013857*std::sin(0.290559947490692*x_11 - 1.21591985225677) - 0.000315133278208888*std::sin(0.280639946460724*x_113 - 7.41319990158081) - 0.00205956923099503*std::sin(0.295439928770065*x_113 - 4.42239999771118) + 0.0112886664593746*std::sin(0.279519945383072*x_116 - 1.23175990581512) - 0.0110611520477556*std::sin(0.237919986248016*x_118 - 7.43095970153809) + 0.00664993831447289*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.00603765855736968*std::sin(0.238399982452393*x_119 + 1.98503983020782) + 0.00101517070941584*std::sin(0.238479986786842*x_119 + 5.15775966644287) + 0.00018392277586364*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.013976373783025*std::sin(0.265759944915771*x_12 - 4.24592018127441) + 0.00193139639016737*std::sin(0.319919914007187*x_12 + 8.1496000289917) - 9.10067691238256e-5*std::sin(0.285839945077896*x_120 + 8.15007972717285) + 0.0011261174180267*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 0.00074092455032934*std::sin(0.300159931182861*x_120 + 1.77239990234375) - 0.0184153002796698*std::sin(0.275919944047928*x_13 - 4.24416017532349) + 0.0129187163361099*std::sin(0.302159935235977*x_13 - 7.44248008728027) + 0.00430401280054072*std::sin(0.349279850721359*x_13 - 1.33511984348297) - 0.000398093739650986*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 0.0174279926797703*std::sin(0.202239990234375*x_14 - 1.01215982437134) - 0.00251744251734844*std::sin(0.250879973173141*x_14 - 4.21776008605957) - 0.000240661756229215*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.00534872699828194*std::sin(0.29751992225647*x_14 + 5.15399980545044) - 0.000346230352095266*std::sin(0.319439917802811*x_14 + 8.14727973937988) + 0.00398726243326201*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00194143446029736*std::sin(0.335039854049683*x_15 - 4.3471999168396) - 0.00851722334783623*std::sin(0.190400004386902*x_16 + 5.19712018966675) + 0.00345098467536544*std::sin(0.31399992108345*x_16 - 4.2368803024292) - 0.00155464702863846*std::sin(0.363839834928513*x_16 + 5.03007984161377) + 0.000988908320964431*std::sin(0.358959853649139*x_17 - 1.18831992149353) + 0.00707521800684796*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.00484703535963304*std::sin(0.389279842376709*x_17 - 1.1684798002243) - 0.00348846652971825*std::sin(0.351359844207764*x_18 - 1.15703988075256) - 0.00129207298388958*std::sin(0.35471984744072*x_18 + 2.02647995948792) + 0.000681452473168139*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.00917112243540139*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 0.00913093639806768*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 0.006426590474289*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.0129383573871113*std::sin(0.199680000543594*x_20 + 5.20136022567749) - 0.00447927719635366*std::sin(0.276079952716827*x_20 - 1.17055988311768) - 0.000244789220309564*std::sin(0.282079964876175*x_20 - 7.40855979919434) + 0.000455771350126402*std::sin(0.290639936923981*x_20 - 1.18799984455109) - 0.000877053226647974*std::sin(0.295519918203354*x_20 + 4.99823999404907) - 0.00656801760556959*std::sin(0.364559859037399*x_20 - 4.37727975845337) + 0.000946717719748383*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.012538313630779*std::sin(0.318879932165146*x_21 + 1.80535984039307) - 0.00261440565311848*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.00270427589056545*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.0092809707829248*std::sin(0.413999855518341*x_22 - 4.39455986022949) - 0.000326510874539824*std::sin(0.298639953136444*x_23 - 1.17119991779327) - 0.0212843069861601*std::sin(0.187760010361671*x_24 - 1.41407978534698) + 0.0026282441207953*std::sin(0.362239837646484*x_24 - 1.18511986732483) - 0.000341144474974006*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.00290908724044755*std::sin(0.330639839172363*x_25 - 1.16295981407166) + 0.000596555393505034*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.00507246249894894*std::sin(0.319199919700623*x_26 - 1.19415986537933) + 0.00238370265057208*std::sin(0.346879839897156*x_26 - 1.15215992927551) + 0.00130757088909649*std::sin(0.36711984872818*x_26 - 4.38271999359131) - 0.0150040878066715*std::sin(0.121280059218407*x_27 + 4.92423963546753) + 0.00500225445179946*std::sin(0.203199997544289*x_27 - 1.20415985584259) - 0.0102507506821654*std::sin(0.223600000143051*x_27 + 8.2227201461792) - 0.00040331746803994*std::sin(0.323919922113419*x_27 + 1.99407982826233) + 0.000527876359231193*std::sin(0.284639924764633*x_28 - 1.18023991584778) - 0.00121127394383424*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 0.00541648965821261*std::sin(0.367439836263657*x_29 + 5.02615976333618) - 0.00626650396895211*std::sin(0.31415992975235*x_3 - 1.13303995132446) - 0.000345806228011794*std::sin(0.335119843482971*x_3 + 5.19600009918213) - 0.000699197542688829*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.00666758684311403*std::sin(0.33095982670784*x_30 + 2.03791975975037) + 0.00143678273323905*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.0136045688293844*std::sin(0.384079843759537*x_31 + 5.18800020217896) + 0.000321104665875655*std::sin(0.413679867982864*x_31 - 1.18167984485626) - 0.00285325407813798*std::sin(0.416479855775833*x_31 - 4.1956000328064) - 0.000227158227059498*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.011810056429778*std::sin(0.297199934720993*x_32 + 8.2344799041748) + 0.00242517020973244*std::sin(0.306559920310974*x_32 + 1.85255992412567) + 0.000281127368694881*std::sin(0.31399992108345*x_32 + 8.25504016876221) - 0.000410104692704063*std::sin(0.337119847536087*x_32 + 1.98447978496552) - 0.00264091367275953*std::sin(0.22367998957634*x_33 + 5.18304014205933) - 0.00534245821803516*std::sin(0.23871998488903*x_34 + 1.98119986057281) + 0.000554982019330936*std::sin(0.246799975633621*x_35 - 1.19687986373901) + 0.000310437573187486*std::sin(0.251999974250793*x_35 + 1.95895981788635) + 0.000957179917504372*std::sin(0.195119991898537*x_36 + 1.80503988265991) - 0.0139845663785072*std::sin(0.206160008907318*x_36 - 4.38503980636597) - 0.000246162653350079*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.0042679331044579*std::sin(0.266079962253571*x_37 - 1.21983981132507) + 0.0146419411986398*std::sin(0.225999981164932*x_38 - 1.19767987728119) - 0.00109663686605678*std::sin(0.236719980835915*x_39 + 1.96407985687256) + 0.000332992266418859*std::sin(0.310319930315018*x_4 + 2.00831985473633) + 0.0101726876517573*std::sin(0.323759824037552*x_4 + 5.23343992233276) - 0.00073517229518031*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 0.00404259300717256*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 0.00549912626380796*std::sin(0.216800004243851*x_40 + 2.00239968299866) - 0.00405372346699476*std::sin(0.226639986038208*x_41 + 1.97247982025146) + 0.00251485770197067*std::sin(0.229359999299049*x_41 + 8.18479919433594) + 0.000787916161197288*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.00555812389768824*std::sin(0.285039931535721*x_42 + 8.16335964202881) - 0.025328493478365*std::sin(0.130480051040649*x_44 + 8.17927932739258) + 0.0140688521231577*std::sin(0.193120002746582*x_48 - 7.40735960006714) + 0.00407011778277254*std::sin(0.20168000459671*x_48 - 1.18839991092682) + 0.000535169998955307*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.00697587046074831*std::sin(0.221679985523224*x_48 - 1.18127989768982) + 0.00368697063614077*std::sin(0.161120027303696*x_5 + 4.78815984725952) + 0.00250324083374492*std::sin(0.323039829730988*x_5 + 8.21255970001221) + 0.000440889283154538*std::sin(0.366639852523804*x_5 - 1.15799987316132) - 0.00662736682613398*std::sin(0.369519829750061*x_5 - 7.58495998382568) - 0.000328227449399004*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.0058554887136742*std::sin(0.22495998442173*x_51 + 1.95727980136871) - 0.0146679694265984*std::sin(0.203759998083115*x_52 + 1.97647976875305) + 0.0013404818691695*std::sin(0.218799993395805*x_52 - 7.39351987838745) - 0.000115376047880002*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.00491386328116016*std::sin(0.254639983177185*x_52 - 1.21143984794617) - 0.00298843262901724*std::sin(0.267039954662323*x_52 + 1.93775975704193) - 0.000452779092791871*std::sin(0.244799971580505*x_53 - 7.4125599861145) - 0.00801638689092875*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.00910449952635019*std::sin(0.248719975352287*x_57 - 7.43688011169434) + 0.00313589147503971*std::sin(0.245999962091446*x_59 - 4.24624013900757) + 0.0105488473495441*std::sin(0.267279952764511*x_59 + 5.12815999984741) - 0.0118016837909117*std::sin(0.31007993221283*x_6 - 7.38839960098267) - 0.00216879439866834*std::sin(0.445759862661362*x_6 + 5.1659197807312) - 0.00304472777088855*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 0.00283860489356187*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.011031030918659*std::sin(0.277519941329956*x_7 + 8.40375995635986) + 0.00709269124263939*std::sin(0.466479867696762*x_7 - 7.62304019927979) - 0.007515420982426*std::sin(0.334319829940796*x_8 - 4.33663988113403) - 0.0010972956871925*std::sin(0.418719857931137*x_8 - 1.58127987384796) + 0.00300815284535057*std::sin(0.293359935283661*x_9 + 1.99279975891113) - 0.0139801743507283*std::sin(0.316079914569855*x_9 - 4.24240016937256) + 0.000643693191346285*std::sin(0.31839993596077*x_9 - 7.44271993637085) - 0.00348140050467048*std::sin(0.322079926729202*x_9 - 7.60824012756348) + 0.00165418633370641*std::sin(0.329679846763611*x_9 + 8.27055931091309) + 0.000139294799997456*std::sin(0.343599855899811*x_9 + 8.2553596496582) - 0.00047490583948932*std::sin(0.360399842262268*x_91 + 2.0033597946167) - 0.000268389475081235*std::sin(0.370799839496613*x_91 - 7.39167976379395) - 0.00662754435529257*std::sin(0.408639848232269*x_91 - 1.21063983440399) - 0.00110370777235681*std::sin(0.196879997849464*x_92 - 0.973359823226929) + 0.00222256487579161*std::sin(0.272479951381683*x_92 + 1.9845597743988) - 0.00150977172192255*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.0160055926291225*std::sin(0.297279924154282*x_92 - 1.16759991645813) + 0.000469319597287771*std::sin(0.350959837436676*x_92 - 7.59128046035767) + 0.00152285000892041*std::sin(0.251839965581894*x_94 - 1.18175983428955) - 0.0098834385568116*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.00975685117654818*std::sin(0.293039947748184*x_94 - 1.20255982875824) - 0.00773064755835729*std::sin(0.303999930620193*x_94 + 1.95023989677429) - 0.00161442363308777*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.00440073201363462*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.00853970014629291*std::sin(0.281199961900711*x_95 - 1.20783984661102) + 0.000549565310794673*std::sin(0.283679932355881*x_95 - 1.21423995494843) - 0.00261480029347571*std::sin(0.285359919071198*x_95 - 1.20247983932495) + 0.00454330443196823*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.0106772715120348*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 0.00572783646009666*std::sin(0.265839964151382*x_97 + 8.19623947143555) - 0.00216938019232677*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.0030647335665388*std::sin(0.253679990768433*x_98 + 1.97847986221313) + 0.000302565552366809*std::sin(0.259759962558746*x_98 + 1.97319984436035) - 0.00340827037035622*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.0109894364018641*std::sin(0.240079984068871*x_99 - 7.41871976852417) + 0.00150089929391853*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.00463882479458873*std::sin(0.254879981279373*x_99 + 4.98095989227295) - 0.000256976173372265*std::sin(0.255439966917038*x_99 + 1.93951988220215) + 0.000767498130960063*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.222815464990198);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00317132249561599*x_1 + 0.00232261254604653*x_10 + 0.000188930499234891*x_100 + 0.00060574466023713*x_101 + 0.00695740090510201*x_102 - 0.00140133077587417*x_103 - 0.000387124858633444*x_104 - 0.00307235232338541*x_105 + 0.00476421584791189*x_106 + 0.000358208995695143*x_107 - 0.00153499794438869*x_108 + 0.00386996837813636*x_109 - 0.00262931598148009*x_11 + 0.0024999575895523*x_110 + 0.000140190991358408*x_111 - 0.00489468645090253*x_112 + 0.00248706994755831*x_113 + 0.000687898594882684*x_114 + 0.00667819182705345*x_115 + 0.00272167348226006*x_116 + 0.00644206986789895*x_117 + 0.000318144560316997*x_118 + 0.00227238478171727*x_119 - 0.00115099946357456*x_12 + 0.00313053209057582*x_120 - 0.000408767353403097*x_13 - 0.00208928860474485*x_14 - 0.00362028698382732*x_15 + 0.000578283216704024*x_16 + 0.00295798681079651*x_17 + 0.00064943304022205*x_18 - 0.00705731228197992*x_19 + 0.00180322463593194*x_2 + 7.36529613682659e-5*x_20 - 0.00436752953615972*x_21 + 0.00188322371830088*x_22 + 4.09550708659872e-5*x_23 + 0.000166429623022329*x_24 - 0.00214353372618528*x_25 - 0.00304532794388155*x_26 + 0.00165123699756623*x_27 + 0.00388776981875116*x_28 - 0.00255604828277326*x_29 - 0.000613960533262783*x_3 - 0.00136729350825669*x_30 + 0.000200705209093217*x_31 + 0.00021608872575968*x_32 - 0.00433380090972718*x_33 + 0.00377975185966032*x_34 - 0.00152366498620461*x_35 + 0.0037465042316061*x_36 + 0.00270749516805484*x_37 + 0.00188692086397057*x_38 + 0.00789084771297591*x_39 - 0.000134110659027184*x_4 + 3.62734770647815e-5*x_40 + 0.00265234104840483*x_41 - 0.00228315997187767*x_42 + 0.00258597522595673*x_43 + 0.00073718691329821*x_44 + 0.00398312318302391*x_45 - 0.00254783888489311*x_46 - 0.00133482733105718*x_47 + 0.00218607399882765*x_48 - 0.00173153596317164*x_49 - 0.00280812089948331*x_5 + 0.00432300354055959*x_50 + 5.34561898909619e-5*x_51 - 0.00122519358694267*x_52 + 0.000378668790256527*x_53 - 0.00569457192394375*x_54 - 0.000497426978285298*x_55 - 0.00257888335969384*x_56 + 0.00606771301676199*x_57 - 0.0025860987212255*x_58 + 0.0037145448600363*x_59 + 0.00240146684194912*x_6 - 0.00288730999290101*x_60 + 0.000646428038666136*x_61 + 0.000657249428337215*x_62 + 0.000355652531047698*x_63 - 0.00141595767959263*x_64 - 0.000280706346871854*x_65 - 0.00223426882632087*x_66 + 0.00303336973517046*x_67 - 0.000131691954401423*x_68 - 0.00112437413579825*x_69 + 0.00106377514297295*x_7 - 0.00126049643117516*x_70 - 0.000433384893268529*x_71 + 0.00184465376506568*x_72 - 0.00136185969269271*x_73 + 0.00286423591121847*x_74 - 0.00209951775224711*x_75 + 0.000658233773773017*x_76 - 0.000384669333135459*x_77 - 0.00105606870075498*x_78 + 0.000361061778176932*x_79 + 0.00185257315615041*x_8 + 0.00115312018593134*x_80 - 0.00212213786846046*x_81 + 0.00168458337173086*x_82 - 0.000492352927325949*x_83 + 0.00176604120776373*x_84 + 0.000298504023397458*x_85 - 0.00198966423156416*x_86 + 0.00152650084092932*x_87 - 0.00108995628818076*x_88 - 0.000644492003739377*x_89 - 0.00167369305257036*x_9 - 0.000419429995222609*x_90 + 0.000250656741606087*x_91 - 0.00120279262296183*x_92 + 0.00192274024920118*x_93 - 0.000341753034314407*x_94 + 0.00032527689811586*x_95 - 0.000294275035545943*x_96 + 0.000445230786459637*x_97 - 0.00241921476670304*x_98 - 0.0021245620652936*x_99 + 0.0103497249455513*std::sin(0.204080000519753*x_10 - 1.37511992454529) - 0.00388819343745352*std::sin(0.270079970359802*x_10 + 1.97511982917786) + 0.00031919524153632*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 0.00205106131444762*std::sin(0.37255984544754*x_10 + 7.81288003921509) + 0.000122616443782766*std::sin(0.252959966659546*x_100 - 1.23215985298157) - 0.00552676789261824*std::sin(0.253599971532822*x_100 + 8.17840003967285) - 0.00060427102571571*std::sin(0.256079971790314*x_100 + 1.9599198102951) - 0.0146619186732341*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.00241817277273604*std::sin(0.225839987397194*x_101 - 7.42223978042603) - 0.00739962918831457*std::sin(0.242479979991913*x_101 - 1.2021598815918) + 0.0132889048051362*std::sin(0.251679986715317*x_101 + 8.1866397857666) - 0.00237866336318215*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.00449613569203831*std::sin(0.253919988870621*x_107 - 7.43423986434937) - 0.0133373486724302*std::sin(0.271919965744019*x_107 + 1.92799985408783) + 0.00118400956210452*std::sin(0.255839973688126*x_108 - 7.43215990066528) - 0.000321033961634294*std::sin(0.260479986667633*x_108 + 1.96487975120544) - 0.00365053028249362*std::sin(0.267119973897934*x_108 + 1.96311986446381) + 0.000145137960045483*std::sin(0.26895996928215*x_108 - 1.21239984035492) - 0.0162250920705335*std::sin(0.234399989247322*x_109 + 1.97207987308502) - 0.000307872760835712*std::sin(0.239599987864494*x_109 + 8.18639945983887) - 0.0184630254935762*std::sin(0.241599977016449*x_109 + 1.95159983634949) - 0.00201177418648874*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.015978768632196*std::sin(0.249359980225563*x_11 - 7.42104005813599) + 0.000864291524293987*std::sin(0.290559947490692*x_11 - 1.21591985225677) + 0.010966813052139*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.00432648112561767*std::sin(0.312399923801422*x_112 - 7.64192008972168) + 0.00321213873451363*std::sin(0.280639946460724*x_113 - 7.41319990158081) - 0.0136667729291852*std::sin(0.287039935588837*x_113 - 7.43591976165771) - 0.00744987598896924*std::sin(0.295439928770065*x_113 - 4.42239999771118) - 0.0210735023927983*std::sin(0.279519945383072*x_116 - 1.23175990581512) + 0.00976530813867704*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 0.012120051069993*std::sin(0.237919986248016*x_118 - 7.43095970153809) - 0.0124139987204271*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.00661565176417126*std::sin(0.238399982452393*x_119 + 1.98503983020782) + 0.00065736725120954*std::sin(0.238479986786842*x_119 + 5.15775966644287) - 0.00187471623393344*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.015314350918623*std::sin(0.265759944915771*x_12 - 4.24592018127441) - 0.000884852288110244*std::sin(0.319919914007187*x_12 + 8.1496000289917) - 0.0183135590662406*std::sin(0.257359951734543*x_120 - 7.41495990753174) + 0.000927627732199735*std::sin(0.285839945077896*x_120 + 8.15007972717285) + 0.000120961663568712*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 0.000617798347407763*std::sin(0.300159931182861*x_120 + 1.77239990234375) + 0.0202862130261588*std::sin(0.275919944047928*x_13 - 4.24416017532349) + 0.0141554424960803*std::sin(0.302159935235977*x_13 - 7.44248008728027) - 0.008034662409173*std::sin(0.349279850721359*x_13 - 1.33511984348297) + 0.000182383149417616*std::sin(0.375919848680496*x_13 - 7.79184007644653) - 0.0191985993576477*std::sin(0.202239990234375*x_14 - 1.01215982437134) - 0.00910609572203773*std::sin(0.250879973173141*x_14 - 4.21776008605957) + 0.00245305400144863*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.00445988015757482*std::sin(0.29751992225647*x_14 + 5.15399980545044) - 0.000224199233420697*std::sin(0.319439917802811*x_14 + 8.14727973937988) - 0.00182672925419633*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00161880855566069*std::sin(0.335039854049683*x_15 - 4.3471999168396) + 0.0158998166210828*std::sin(0.190400004386902*x_16 + 5.19712018966675) - 0.00933225242772332*std::sin(0.304959923028946*x_16 + 5.18527984619141) - 0.00158103831081816*std::sin(0.31399992108345*x_16 - 4.2368803024292) - 0.00562347086743984*std::sin(0.363839834928513*x_16 + 5.03007984161377) + 0.000106223377514585*std::sin(0.358959853649139*x_17 - 1.18831992149353) - 0.0132079040631997*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.00404155920285977*std::sin(0.389279842376709*x_17 - 1.1684798002243) + 0.0115009886711227*std::sin(0.406719863414764*x_17 - 1.20767986774445) + 0.00159821029309768*std::sin(0.351359844207764*x_18 - 1.15703988075256) - 0.000138787745470933*std::sin(0.35471984744072*x_18 + 2.02647995948792) + 0.000441270157778937*std::sin(0.172080010175705*x_19 + 4.98967981338501) + 0.0101028677560545*std::sin(0.295999944210052*x_19 + 2.15703988075256) + 0.0100585989957493*std::sin(0.36575984954834*x_2 + 5.18800020217896) - 0.00621175722324981*std::sin(0.367199838161469*x_2 + 1.99895977973938) - 0.0119970565367352*std::sin(0.424879848957062*x_2 + 5.19400024414063) - 0.0142528370527457*std::sin(0.199680000543594*x_20 + 5.20136022567749) + 0.00205214149537171*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 0.00249512504936574*std::sin(0.282079964876175*x_20 - 7.40855979919434) + 0.000295131800822995*std::sin(0.290639936923981*x_20 - 1.18799984455109) - 0.00317247785406855*std::sin(0.295519918203354*x_20 + 4.99823999404907) + 0.0163830098427979*std::sin(0.319999933242798*x_20 + 1.95359981060028) + 0.0122610704484026*std::sin(0.364559859037399*x_20 - 4.37727975845337) + 0.00342446833179661*std::sin(0.304159939289093*x_21 + 1.8031998872757) - 0.0138121506269207*std::sin(0.318879932165146*x_21 + 1.80535984039307) + 0.0111567177042681*std::sin(0.302559942007065*x_22 + 8.23855972290039) - 0.00945683087874787*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.00225488165479652*std::sin(0.339119851589203*x_22 - 1.16015994548798) - 0.0102238762079716*std::sin(0.413999855518341*x_22 - 4.39455986022949) + 0.0033281100406479*std::sin(0.298639953136444*x_23 - 1.17119991779327) + 0.0149527671829326*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 0.0234466980759516*std::sin(0.187760010361671*x_24 - 1.41407978534698) + 0.00219148477896941*std::sin(0.362239837646484*x_24 - 1.18511986732483) - 0.00022090590646378*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.00242565763115102*std::sin(0.330639839172363*x_25 - 1.16295981407166) + 0.000386295600912568*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.00422952505453565*std::sin(0.319199919700623*x_26 - 1.19415986537933) + 0.000256044914545059*std::sin(0.346879839897156*x_26 - 1.15215992927551) + 0.00472974679557086*std::sin(0.36711984872818*x_26 - 4.38271999359131) + 0.00687399101206244*std::sin(0.121280059218407*x_27 + 4.92423963546753) + 0.0180941600652924*std::sin(0.203199997544289*x_27 - 1.20415985584259) + 0.0191359377837937*std::sin(0.223600000143051*x_27 + 8.2227201461792) - 0.000261165627486209*std::sin(0.323919922113419*x_27 + 1.99407982826233) + 0.0122220101289992*std::sin(0.333359837532043*x_27 + 8.24176025390625) + 0.000341822934830329*std::sin(0.284639924764633*x_28 - 1.18023991584778) - 0.0131331253013304*std::sin(0.341039836406708*x_28 + 8.24183940887451) - 0.00438142138386632*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 0.0195306162773541*std::sin(0.277119934558868*x_29 + 8.20456027984619) - 0.01011141645328*std::sin(0.367439836263657*x_29 + 5.02615976333618) + 0.0116982096033607*std::sin(0.31415992975235*x_3 - 1.13303995132446) + 0.00352478667421614*std::sin(0.335119843482971*x_3 + 5.19600009918213) - 0.0137331445651399*std::sin(0.361119836568832*x_3 + 1.96599984169006) - 0.00252913808695191*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.00730588393534947*std::sin(0.33095982670784*x_30 + 2.03791975975037) - 0.000658249386555858*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.0149069525746942*std::sin(0.384079843759537*x_31 + 5.18800020217896) + 0.000207929257216948*std::sin(0.413679867982864*x_31 - 1.18167984485626) - 0.0103207936529908*std::sin(0.416479855775833*x_31 - 4.1956000328064) + 0.00231541316153095*std::sin(0.419359862804413*x_31 + 5.2006402015686) - 0.0130099057276806*std::sin(0.297199934720993*x_32 + 8.2344799041748) + 0.00265733502879991*std::sin(0.306559920310974*x_32 + 1.85255992412567) - 0.0028655180926914*std::sin(0.31399992108345*x_32 + 8.25504016876221) - 0.00696831240725371*std::sin(0.316159933805466*x_32 - 1.14583992958069) - 0.00026556065108117*std::sin(0.337119847536087*x_32 + 1.98447978496552) - 0.00955271571527923*std::sin(0.22367998957634*x_33 + 5.18304014205933) + 0.00997321574220962*std::sin(0.23871998488903*x_34 + 1.98119986057281) - 0.0240034727602535*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 0.02302877193136*std::sin(0.231599986553192*x_35 + 1.97151982784271) + 0.000359375030361377*std::sin(0.246799975633621*x_35 - 1.19687986373901) - 0.00316427563331777*std::sin(0.251999974250793*x_35 + 1.95895981788635) + 0.00346231220452554*std::sin(0.195119991898537*x_36 + 1.80503988265991) + 0.0261061653385092*std::sin(0.206160008907318*x_36 - 4.38503980636597) + 0.00250912438797502*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.00355869166112657*std::sin(0.266079962253571*x_37 - 1.21983981132507) - 0.0161294974157991*std::sin(0.225999981164932*x_38 - 1.19767987728119) - 0.000710120135981482*std::sin(0.236719980835915*x_39 + 1.96407985687256) + 0.00497981365962799*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 0.00339417456428862*std::sin(0.310319930315018*x_4 + 2.00831985473633) - 0.0189902109644201*std::sin(0.323759824037552*x_4 + 5.23343992233276) - 0.000476056082357008*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 0.00442959589476666*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 0.00602556504692621*std::sin(0.216800004243851*x_40 + 2.00239968299866) - 0.0146631327892266*std::sin(0.226639986038208*x_41 + 1.97247982025146) - 0.00115215996218549*std::sin(0.229359999299049*x_41 + 8.18479919433594) + 0.000510210032919369*std::sin(0.257199972867966*x_42 - 7.44295978546143) + 0.00612280460822926*std::sin(0.285039931535721*x_42 + 8.16335964202881) - 0.0277532243620192*std::sin(0.130480051040649*x_44 + 8.17927932739258) - 0.0178864442161708*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 0.015498185034701*std::sin(0.193120002746582*x_48 - 7.40735960006714) - 0.00186468870465911*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.00545496271597975*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.00581662632243092*std::sin(0.221679985523224*x_48 - 1.18127989768982) - 0.0016891532055218*std::sin(0.161120027303696*x_5 + 4.78815984725952) + 0.00905472537716728*std::sin(0.323039829730988*x_5 + 8.21255970001221) + 0.000285495014254123*std::sin(0.366639852523804*x_5 - 1.15799987316132) + 0.00730067787088307*std::sin(0.369519829750061*x_5 - 7.58495998382568) + 0.00334560700773181*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.0048824286480516*std::sin(0.22495998442173*x_51 + 1.95727980136871) + 0.0161581699961558*std::sin(0.203759998083115*x_52 + 1.97647976875305) + 0.000868020396430908*std::sin(0.218799993395805*x_52 - 7.39351987838745) + 0.00117602264837545*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.00409728171800899*std::sin(0.254639983177185*x_52 - 1.21143984794617) - 0.0108097616494356*std::sin(0.267039954662323*x_52 + 1.93775975704193) + 0.00461515607111051*std::sin(0.244799971580505*x_53 - 7.4125599861145) - 0.0167965260392482*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 0.00878380643312768*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.00997608556049836*std::sin(0.248719975352287*x_57 - 7.43688011169434) + 0.011343149942391*std::sin(0.245999962091446*x_59 - 4.24624013900757) - 0.0116205634045257*std::sin(0.267279952764511*x_59 + 5.12815999984741) - 0.0129314749169171*std::sin(0.31007993221283*x_6 - 7.38839960098267) - 0.000232960590256324*std::sin(0.445759862661362*x_6 + 5.1659197807312) + 0.00335405859415149*std::sin(0.481119841337204*x_6 + 4.95983982086182) + 0.00130048189377195*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.0120870464045332*std::sin(0.277519941329956*x_7 + 8.40375995635986) - 0.0110743495510512*std::sin(0.320879906415939*x_7 + 5.20904016494751) - 0.0132405228209233*std::sin(0.466479867696762*x_7 - 7.62304019927979) + 0.0140296679528978*std::sin(0.334319829940796*x_8 - 4.33663988113403) - 0.0105817361333273*std::sin(0.338799834251404*x_8 + 8.23480033874512) + 0.00120877605713805*std::sin(0.418719857931137*x_8 - 1.58127987384796) - 0.0013781587983413*std::sin(0.293359935283661*x_9 + 1.99279975891113) + 0.0176274564976602*std::sin(0.302399933338165*x_9 - 7.42071962356567) + 0.0154004979943125*std::sin(0.316079914569855*x_9 - 4.24240016937256) + 0.000416819378152758*std::sin(0.31839993596077*x_9 - 7.44271993637085) + 0.00649902290314695*std::sin(0.322079926729202*x_9 - 7.60824012756348) + 0.00598352454644444*std::sin(0.329679846763611*x_9 + 8.27055931091309) - 0.00141982536763881*std::sin(0.343599855899811*x_9 + 8.2553596496582) + 0.00980016400719783*std::sin(0.32983985543251*x_91 + 5.19856023788452) - 0.00030752221610895*std::sin(0.360399842262268*x_91 + 2.0033597946167) + 0.00273568134011148*std::sin(0.370799839496613*x_91 - 7.39167976379395) + 0.01237219403481*std::sin(0.408639848232269*x_91 - 1.21063983440399) + 0.000505654019416673*std::sin(0.196879997849464*x_92 - 0.973359823226929) - 0.00414904864066101*std::sin(0.272479951381683*x_92 + 1.9845597743988) - 0.00546114786077937*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.0175378296250643*std::sin(0.297279924154282*x_92 - 1.16759991645813) + 0.000303904880968601*std::sin(0.350959837436676*x_92 - 7.59128046035767) + 0.000163576610658796*std::sin(0.251839965581894*x_94 - 1.18175983428955) + 0.0184502453700437*std::sin(0.285679936408997*x_94 + 1.97303986549377) + 0.01074810393673*std::sin(0.293039947748184*x_94 - 1.20255982875824) - 0.00847071288839383*std::sin(0.303999930620193*x_94 + 1.95023989677429) - 0.00583969486393734*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.00366942216208036*std::sin(0.278879970312119*x_95 + 1.96503984928131) - 0.00940729576581871*std::sin(0.281199961900711*x_95 - 1.20783984661102) + 0.000355867475653523*std::sin(0.283679932355881*x_95 - 1.21423995494843) - 0.00945825837226318*std::sin(0.285359919071198*x_95 - 1.20247983932495) - 0.00848136820791475*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.0116994211322049*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 0.0177710670105655*std::sin(0.26199996471405*x_97 - 1.21223986148834) - 0.010692633694316*std::sin(0.265839964151382*x_97 + 8.19623947143555) - 0.00784708431381672*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.00255543878497636*std::sin(0.253679990768433*x_98 + 1.97847986221313) - 0.00308403649405354*std::sin(0.259759962558746*x_98 + 1.97319984436035) - 0.0123283991690655*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.0120414699884773*std::sin(0.240079984068871*x_99 - 7.41871976852417) + 0.00542905450486966*std::sin(0.247679978609085*x_99 + 1.9799998998642) - 0.00511010879784263*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 0.00261934609073242*std::sin(0.255439966917038*x_99 + 1.93951988220215) + 0.000496988469011284*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.102709951301418);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000171502907369363*x_1 - 5.57942130616244e-5*x_10 + 0.00036156693934887*x_100 - 0.000395317731346681*x_101 + 0.000342580815835179*x_102 + 0.000223897441628086*x_103 - 0.000340297517335323*x_104 - 8.35857853080408e-5*x_105 - 0.000123433606623024*x_106 + 3.35903414020536e-5*x_107 - 0.000281830143217283*x_108 + 0.000529101296880916*x_109 - 4.31505362148837e-5*x_11 + 0.000853832198970244*x_110 - 8.29964310912015e-5*x_111 - 0.000295569568662695*x_112 - 0.000688630009763097*x_113 + 0.000372002734788601*x_114 + 0.000570961275934961*x_115 + 0.000109027985983152*x_116 - 0.000221060133441533*x_117 - 0.000102726839810708*x_118 + 4.70453627611458e-5*x_119 - 0.00104334614617172*x_12 + 6.9947910805595e-5*x_120 + 0.000152498490539759*x_13 - 0.000926828955044931*x_14 - 0.000349903516587697*x_15 + 0.000252400458852906*x_16 + 6.51599334593197e-5*x_17 + 0.000321933031106193*x_18 - 0.00116625908092967*x_19 + 0.00105988597880898*x_2 + 1.15562129228478e-5*x_20 + 1.8720204746823e-5*x_21 - 9.37409120005925e-5*x_22 + 0.000234618530714714*x_23 - 0.00028758944080829*x_24 + 0.000132495543557067*x_25 - 1.29293404328705e-5*x_26 - 0.000134076865832417*x_27 + 0.000550575895891888*x_28 - 0.000868266419764648*x_29 + 0.000326410697311694*x_3 + 5.5809766719004e-5*x_30 + 0.00034047446409595*x_31 + 7.27294405713232e-5*x_32 - 0.000774358733018134*x_33 - 0.000440624877676611*x_34 + 0.000586299916764281*x_35 + 0.000167370691571558*x_36 + 0.000133316518003228*x_37 + 0.000534075151369838*x_38 + 0.000840208681485938*x_39 + 0.000305687766792183*x_4 + 9.05518215254048e-5*x_40 - 0.000199484079438806*x_41 + 0.00095198040217585*x_42 - 0.000594891425282105*x_43 + 0.000221324302535137*x_44 + 0.000934590430494281*x_45 + 0.00016073216569318*x_46 - 0.000280889648366315*x_47 + 0.000320807591545758*x_48 - 8.36483793937185e-5*x_49 + 0.000167457405452121*x_5 + 0.000347434817407921*x_50 - 0.000282332588125686*x_51 - 0.000115671811513522*x_52 - 0.000145275497766299*x_53 - 0.000647338343032595*x_54 - 8.7178765149928e-5*x_55 - 6.06380408686358e-6*x_56 - 0.000382655437856433*x_57 + 0.000928217462405868*x_58 + 0.000342346037727187*x_59 + 0.000531699896318973*x_6 - 0.00127358817071608*x_60 + 0.000162239385488928*x_61 + 0.000242923320691485*x_62 + 3.92796919267939e-5*x_63 - 0.000131891019201752*x_64 + 0.000171730509731564*x_65 + 0.000192313998028589*x_66 + 0.00014505847622135*x_67 - 0.000197163433478652*x_68 + 0.000388517605921686*x_69 - 3.97428348000095e-5*x_7 - 0.00023359898035057*x_70 + 1.33156131559566e-5*x_71 + 4.05604702772385e-5*x_72 - 0.000264823078406851*x_73 + 0.000226004160980964*x_74 - 0.000199240298382274*x_75 + 3.4429916384429e-5*x_76 - 0.000162175203083353*x_77 - 0.000249549052398379*x_78 + 0.000108118161717993*x_79 + 0.000613565760002562*x_8 - 1.53276531193418e-6*x_80 + 8.0923683306681e-5*x_81 - 0.000142490736191062*x_82 - 0.000179100976658776*x_83 + 1.4547094319488e-5*x_84 - 0.000284973656222581*x_85 - 0.000157705127710161*x_86 + 0.000102058758511143*x_87 - 0.000204051943963178*x_88 + 2.03610879255089e-6*x_89 - 0.000803344048496919*x_9 - 0.000150045466450407*x_90 - 8.05261717405247e-5*x_91 - 0.000318935839436737*x_92 - 0.000260677240166562*x_93 - 0.000113798366510177*x_94 + 4.16032623496232e-5*x_95 - 3.03833978800887e-5*x_96 + 0.000195993422397828*x_97 - 7.85459273332496e-5*x_98 - 0.00046532413070508*x_99 - 0.00192349194549024*std::pow(-0.0626989759870075*x_1 - 0.311644453562206*x_10 - 0.0114712244024601*x_100 - 0.0265866930482332*x_102 - 0.0731508517120501*x_103 + 0.0498801047778234*x_104 - 0.0210215118434491*x_105 - 0.292838840220358*x_106 - 0.0918630917869118*x_107 - 0.248427182638956*x_108 + 0.0514309665592955*x_11 - 0.183486952832582*x_110 - 0.134940165580645*x_111 + 0.160704187340025*x_112 - 0.102561772370589*x_113 + 0.173623200242485*x_114 - 0.0172367584994017*x_115 - 0.0296219428633973*x_116 - 0.262268037718888*x_117 - 0.0469641087587046*x_118 + 0.0270254550998067*x_119 - 0.343656694466839*x_12 + 0.0188759675898182*x_120 - 0.105331106588889*x_15 - 0.0477217569005071*x_16 - 0.260302120369291*x_17 + 0.00366049489849445*x_18 + 0.103975689917255*x_23 + 0.269648179786343*x_25 + 0.10613547997204*x_26 - 0.1527074573762*x_27 - 0.013698465504223*x_28 + 0.262002359105711*x_29 + 0.183055473022651*x_3 + 0.086050852224008*x_30 + 0.13639218085016*x_31 + 0.338154919713881*x_33 + 0.0481503275911559*x_34 + 0.212044907727019*x_35 - 0.175587980429583*x_36 + 0.0557826387606996*x_37 - 0.196443273941978*x_39 - 0.00555743781819482*x_4 - 0.0259602858755704*x_40 - 0.0307166262876013*x_41 + 0.031365937343495*x_43 + 0.169027837680678*x_44 - 0.258329519301863*x_45 - 0.000167559728086118*x_46 - 0.0894571506864762*x_47 + 0.409173568543607*x_49 - 0.0317461400995658*x_50 + 0.138018828315411*x_51 - 0.0929902027721826*x_53 + 0.184578074861837*x_54 + 0.201025390117939*x_55 + 0.151930276293142*x_56 - 0.0489409163357733*x_57 + 0.213950179662504*x_58 - 0.234807369277877*x_60 + 0.00281647026945661*x_61 + 0.00482029879661564*x_62 - 0.113025899296426*x_63 + 0.00170899686509601*x_64 + 0.161625413160854*x_65 + 0.0851628772100179*x_66 - 0.137924673266542*x_67 - 0.0495022089104602*x_68 + 0.163857785239485*x_69 - 0.175291848369219*x_7 + 0.101988403883784*x_70 - 0.00185142926462145*x_71 - 0.00255736412789944*x_72 + 0.00112314795557942*x_73 - 0.0727952084034447*x_74 + 0.00100216077909483*x_75 - 0.00772063663680205*x_76 + 0.0821536580836254*x_77 - 0.0102512563011945*x_78 - 0.00936249804468702*x_79 + 0.0181618155467908*x_80 + 0.0821604758953593*x_81 - 0.188677114737327*x_82 + 0.0245171112926518*x_83 - 0.0296051743478576*x_84 - 0.135522787268156*x_85 - 0.00423855642939667*x_86 + 0.0097330960075014*x_87 + 0.0693788690092761*x_88 + 0.00198585856157608*x_89 - 0.00390629642299961*x_90 - 0.00239331412571838*x_91 - 0.108972302201554*x_92 - 0.260534252256814*x_93 + 0.128516270632851*x_96 - 0.033161895197003*x_97 - 0.0225360611472679*x_98 - 1.58453061709247*std::sin(0.251679986715317*x_101 + 8.1866397857666) + 2.20147781985941*std::sin(0.241599977016449*x_109 + 1.95159983634949) - 2.41886943402477*std::sin(0.275919944047928*x_13 - 4.24416017532349) + 2.28918552232588*std::sin(0.202239990234375*x_14 - 1.01215982437134) - 1.20463676387519*std::sin(0.295999944210052*x_19 + 2.15703988075256) - 1.1993582847896*std::sin(0.36575984954834*x_2 + 5.18800020217896) + 1.69946711348078*std::sin(0.199680000543594*x_20 + 5.20136022567749) + 1.64692093721598*std::sin(0.318879932165146*x_21 + 1.80535984039307) + 1.21906546208631*std::sin(0.413999855518341*x_22 - 4.39455986022949) - 2.795716540667*std::sin(0.187760010361671*x_24 - 1.41407978534698) + 1.55126357312975*std::sin(0.297199934720993*x_32 + 8.2344799041748) + 1.92323467346756*std::sin(0.225999981164932*x_38 - 1.19767987728119) - 0.730065532598623*std::sin(0.285039931535721*x_42 + 8.16335964202881) + 1.84795880901763*std::sin(0.193120002746582*x_48 - 7.40735960006714) - 0.870511737541577*std::sin(0.369519829750061*x_5 - 7.58495998382568) - 1.92665350911372*std::sin(0.203759998083115*x_52 + 1.97647976875305) + 1.38560240835035*std::sin(0.267279952764511*x_59 + 5.12815999984741) - 0.399928256834308*std::sin(0.481119841337204*x_6 + 4.95983982086182) - 0.144130964878556*std::sin(0.418719857931137*x_8 - 1.58127987384796) - 1.83631088854122*std::sin(0.316079914569855*x_9 - 4.24240016937256) - 1.28157286196064*std::sin(0.293039947748184*x_94 - 1.20255982875824) + 1.12169876927878*std::sin(0.281199961900711*x_95 - 1.20783984661102) + 0.609314609863539*std::sin(0.254879981279373*x_99 + 4.98095989227295) + 5.96239523117182, 2) - 1.2481543191808e-5*std::sin(0.204080000519753*x_10 - 1.37511992454529) - 0.000611080501290757*std::sin(0.270079970359802*x_10 + 1.97511982917786) + 0.000244155519698232*std::sin(0.336399853229523*x_10 - 1.13703989982605) - 0.000199641482141532*std::sin(0.37255984544754*x_10 + 7.81288003921509) - 0.00244846958737931*std::sin(0.252959966659546*x_100 - 1.23215985298157) + 5.386356803186e-6*std::sin(0.253599971532822*x_100 + 8.17840003967285) - 0.000462212737295507*std::sin(0.256079971790314*x_100 + 1.9599198102951) + 1.76819550430091e-5*std::sin(0.259679973125458*x_100 + 1.94807982444763) + 0.00201434967597216*std::sin(0.225839987397194*x_101 - 7.42223978042603) + 7.21163685429352e-6*std::sin(0.242479979991913*x_101 - 1.2021598815918) - 0.000373838087985478*std::sin(0.228479996323586*x_103 - 1.22135984897614) - 0.00374530289005649*std::sin(0.253919988870621*x_107 - 7.43423986434937) + 1.29985047597457e-5*std::sin(0.271919965744019*x_107 + 1.92799985408783) + 0.00115297559496491*std::sin(0.255839973688126*x_108 - 7.43215990066528) - 0.000245561974440288*std::sin(0.260479986667633*x_108 + 1.96487975120544) - 0.000573728625102634*std::sin(0.267119973897934*x_108 + 1.96311986446381) - 0.0028981910597181*std::sin(0.26895996928215*x_108 - 1.21239984035492) + 1.95671081632439e-5*std::sin(0.234399989247322*x_109 + 1.97207987308502) - 0.000235494844976314*std::sin(0.239599987864494*x_109 + 8.18639945983887) - 0.000316176650709148*std::sin(0.255759954452515*x_109 + 8.17471981048584) + 0.00155530457819948*std::sin(0.249359980225563*x_11 - 7.42104005813599) + 0.000841637657617176*std::sin(0.290559947490692*x_11 - 1.21591985225677) + 0.00106212354528289*std::sin(0.234959989786148*x_111 - 4.40944004058838) + 0.000419014845050564*std::sin(0.312399923801422*x_112 - 7.64192008972168) + 0.000504829654099613*std::sin(0.280639946460724*x_113 - 7.41319990158081) - 0.00132361163148405*std::sin(0.287039935588837*x_113 - 7.43591976165771) + 7.26060710269243e-6*std::sin(0.295439928770065*x_113 - 4.42239999771118) + 2.54141855655248e-5*std::sin(0.279519945383072*x_116 - 1.23175990581512) + 0.000945759141851013*std::sin(0.266079962253571*x_117 - 1.24495995044708) - 0.00117971361567809*std::sin(0.237919986248016*x_118 - 7.43095970153809) + 1.49710124691442e-5*std::sin(0.194319993257523*x_119 + 2.19599986076355) + 0.000643939073994522*std::sin(0.238399982452393*x_119 + 1.98503983020782) + 0.000502826552423404*std::sin(0.238479986786842*x_119 + 5.15775966644287) - 0.00029463619915995*std::sin(0.261599957942963*x_119 - 1.24623990058899) - 0.00149063301710842*std::sin(0.265759944915771*x_12 - 4.24592018127441) - 0.000861659505119695*std::sin(0.319919914007187*x_12 + 8.1496000289917) - 0.00177364765768385*std::sin(0.257359951734543*x_120 - 7.41495990753174) + 0.000145788842227734*std::sin(0.285839945077896*x_120 + 8.15007972717285) - 0.00241542606643782*std::sin(0.287519931793213*x_120 - 1.24975991249084) - 0.000514629026903199*std::sin(0.300159931182861*x_120 + 1.77239990234375) + 0.0013778298583179*std::sin(0.302159935235977*x_13 - 7.44248008728027) + 9.68962812241648e-6*std::sin(0.349279850721359*x_13 - 1.33511984348297) + 0.000177602721246255*std::sin(0.375919848680496*x_13 - 7.79184007644653) + 8.87474950926962e-6*std::sin(0.250879973173141*x_14 - 4.21776008605957) + 0.000385529550680037*std::sin(0.270719945430756*x_14 + 5.1691198348999) - 0.00371510185358708*std::sin(0.29751992225647*x_14 + 5.15399980545044) - 0.000171492156613328*std::sin(0.319439917802811*x_14 + 8.14727973937988) - 0.00177884901955791*std::sin(0.320319920778275*x_15 + 1.95847988128662) - 0.00134847539692815*std::sin(0.335039854049683*x_15 - 4.3471999168396) - 1.91748330455076e-5*std::sin(0.190400004386902*x_16 + 5.19712018966675) - 0.000903818181898801*std::sin(0.304959923028946*x_16 + 5.18527984619141) - 0.00153959785919107*std::sin(0.31399992108345*x_16 - 4.2368803024292) + 5.48060297679758e-6*std::sin(0.363839834928513*x_16 + 5.03007984161377) - 0.00212112422518103*std::sin(0.358959853649139*x_17 - 1.18831992149353) + 1.59284450461599e-5*std::sin(0.386799842119217*x_17 - 1.18543982505798) - 0.00336663846458398*std::sin(0.389279842376709*x_17 - 1.1684798002243) + 0.00111385785492611*std::sin(0.406719863414764*x_17 - 1.20767986774445) + 0.00155631974820206*std::sin(0.351359844207764*x_18 - 1.15703988075256) + 0.00277138663790118*std::sin(0.35471984744072*x_18 + 2.02647995948792) + 0.000337531800854175*std::sin(0.172080010175705*x_19 + 4.98967981338501) - 0.000601601720848869*std::sin(0.367199838161469*x_2 + 1.99895977973938) + 1.44681892635406e-5*std::sin(0.424879848957062*x_2 + 5.19400024414063) + 0.00199835300094435*std::sin(0.276079952716827*x_20 - 1.17055988311768) + 0.000392141566636695*std::sin(0.282079964876175*x_20 - 7.40855979919434) + 0.000225749161743736*std::sin(0.290639936923981*x_20 - 1.18799984455109) + 3.09187901577024e-6*std::sin(0.295519918203354*x_20 + 4.99823999404907) + 0.00158667613042268*std::sin(0.319999933242798*x_20 + 1.95359981060028) - 1.47865842990658e-5*std::sin(0.364559859037399*x_20 - 4.37727975845337) - 3.3374675134999e-6*std::sin(0.304159939289093*x_21 + 1.8031998872757) + 0.00108051559787156*std::sin(0.302559942007065*x_22 + 8.23855972290039) + 9.2165740139653e-6*std::sin(0.332959830760956*x_22 + 1.99087977409363) - 0.00187832738086607*std::sin(0.339119851589203*x_22 - 1.16015994548798) + 0.00052305606310623*std::sin(0.298639953136444*x_23 - 1.17119991779327) + 0.00144815873277135*std::sin(0.334719836711884*x_23 - 1.17023992538452) + 0.00182551747508936*std::sin(0.362239837646484*x_24 - 1.18511986732483) - 0.000168973059051496*std::sin(0.300559937953949*x_25 - 1.19079983234406) + 0.00202058459942051*std::sin(0.330639839172363*x_25 - 1.16295981407166) + 0.000295481231938156*std::sin(0.267359972000122*x_26 - 1.1807998418808) - 0.0035232149328521*std::sin(0.319199919700623*x_26 - 1.19415986537933) - 0.00511283941146909*std::sin(0.346879839897156*x_26 - 1.15215992927551) - 4.60958453921995e-6*std::sin(0.36711984872818*x_26 - 4.38271999359131) + 0.00669381745771448*std::sin(0.121280059218407*x_27 + 4.92423963546753) - 1.7634466302773e-5*std::sin(0.203199997544289*x_27 - 1.20415985584259) - 2.30775247864763e-5*std::sin(0.223600000143051*x_27 + 8.2227201461792) - 0.000199768108068599*std::sin(0.323919922113419*x_27 + 1.99407982826233) + 0.00118368797452639*std::sin(0.333359837532043*x_27 + 8.24176025390625) + 0.000261463660600271*std::sin(0.284639924764633*x_28 - 1.18023991584778) - 0.00127192845718956*std::sin(0.341039836406708*x_28 + 8.24183940887451) + 4.27010855840967e-6*std::sin(0.413119852542877*x_28 + 5.00263977050781) + 0.00189151828370203*std::sin(0.277119934558868*x_29 + 8.20456027984619) + 1.21941483330164e-5*std::sin(0.367439836263657*x_29 + 5.02615976333618) - 1.41077863614078e-5*std::sin(0.31415992975235*x_3 - 1.13303995132446) + 0.000553966370879336*std::sin(0.335119843482971*x_3 + 5.19600009918213) - 0.00133003964999329*std::sin(0.361119836568832*x_3 + 1.96599984169006) + 2.46488370880301e-6*std::sin(0.473119854927063*x_3 + 5.00575971603394) + 0.000711123303303092*std::sin(0.33095982670784*x_30 + 2.03791975975037) - 0.000640996071645348*std::sin(0.354239851236343*x_31 - 4.42335987091064) + 0.00145097861544279*std::sin(0.384079843759537*x_31 + 5.18800020217896) + 0.000159047094849923*std::sin(0.413679867982864*x_31 - 1.18167984485626) + 1.00585872588056e-5*std::sin(0.416479855775833*x_31 - 4.1956000328064) + 0.000363897490750925*std::sin(0.419359862804413*x_31 + 5.2006402015686) + 0.000258653556555962*std::sin(0.306559920310974*x_32 + 1.85255992412567) - 0.000450353682425432*std::sin(0.31399992108345*x_32 + 8.25504016876221) - 0.000674873241975022*std::sin(0.316159933805466*x_32 - 1.14583992958069) - 0.000203129904017527*std::sin(0.337119847536087*x_32 + 1.98447978496552) + 9.31002283461558e-6*std::sin(0.22367998957634*x_33 + 5.18304014205933) - 1.20274812811442e-5*std::sin(0.23871998488903*x_34 + 1.98119986057281) - 0.00232470941795156*std::sin(0.239839985966682*x_34 + 1.97279977798462) - 0.00223031073575896*std::sin(0.231599986553192*x_35 + 1.97151982784271) + 0.000274889427806416*std::sin(0.246799975633621*x_35 - 1.19687986373901) - 0.000497307341143071*std::sin(0.251999974250793*x_35 + 1.95895981788635) - 3.37434993832628e-6*std::sin(0.195119991898537*x_36 + 1.80503988265991) - 3.14834676244363e-5*std::sin(0.206160008907318*x_36 - 4.38503980636597) + 0.000394341745972603*std::sin(0.233519986271858*x_37 + 1.96423983573914) - 0.00296440745479256*std::sin(0.266079962253571*x_37 - 1.21983981132507) - 0.000543177742920738*std::sin(0.236719980835915*x_39 + 1.96407985687256) + 0.000482289368284672*std::sin(0.306159913539886*x_4 - 1.14551985263824) - 0.000533438967885357*std::sin(0.310319930315018*x_4 + 2.00831985473633) + 2.29017814116731e-5*std::sin(0.323759824037552*x_4 + 5.23343992233276) - 0.000364139890162348*std::sin(0.33095982670784*x_4 + 2.00415992736816) + 0.000431157802787296*std::sin(0.366239845752716*x_4 + 4.79080009460449) + 0.000586502572221995*std::sin(0.216800004243851*x_40 + 2.00239968299866) + 1.42906064791974e-5*std::sin(0.226639986038208*x_41 + 1.97247982025146) - 0.00112196080201782*std::sin(0.229359999299049*x_41 + 8.18479919433594) + 0.000390264576448914*std::sin(0.257199972867966*x_42 - 7.44295978546143) - 0.00270137943064475*std::sin(0.130480051040649*x_44 + 8.17927932739258) - 0.00173228206344582*std::sin(0.204159989953041*x_46 - 1.17471981048584) - 0.00181581351831084*std::sin(0.20168000459671*x_48 - 1.18839991092682) - 0.000857318804896302*std::sin(0.215120002627373*x_48 + 1.96871984004974) - 0.00484527800492226*std::sin(0.221679985523224*x_48 - 1.18127989768982) - 0.00164487896420507*std::sin(0.161120027303696*x_5 + 4.78815984725952) - 8.82468426101764e-6*std::sin(0.323039829730988*x_5 + 8.21255970001221) + 0.000218377890725975*std::sin(0.366639852523804*x_5 - 1.15799987316132) + 0.000525805940546408*std::sin(0.380479842424393*x_5 - 1.16351985931396) + 0.00406708680043246*std::sin(0.22495998442173*x_51 + 1.95727980136871) + 0.000663957175486711*std::sin(0.218799993395805*x_52 - 7.39351987838745) + 0.000184827355186632*std::sin(0.242159977555275*x_52 + 8.19295978546143) - 0.00341305559060603*std::sin(0.254639983177185*x_52 - 1.21143984794617) + 1.05351327091236e-5*std::sin(0.267039954662323*x_52 + 1.93775975704193) + 0.000725332196259334*std::sin(0.244799971580505*x_53 - 7.4125599861145) - 0.00162672471030798*std::sin(0.258399993181229*x_53 + 5.15200042724609) - 0.000854977919383264*std::sin(0.259919971227646*x_53 - 1.20503985881805) + 0.000971029238979626*std::sin(0.248719975352287*x_57 - 7.43688011169434) - 1.10549699297779e-5*std::sin(0.245999962091446*x_59 - 4.24624013900757) - 0.00125869412118704*std::sin(0.31007993221283*x_6 - 7.38839960098267) + 0.00465187949269748*std::sin(0.445759862661362*x_6 + 5.1659197807312) + 0.00126639508092118*std::sin(0.261199980974197*x_60 - 7.43887996673584) + 0.00117650108356919*std::sin(0.277519941329956*x_7 + 8.40375995635986) - 0.0010725383346049*std::sin(0.320879906415939*x_7 + 5.20904016494751) + 1.59677825585606e-5*std::sin(0.466479867696762*x_7 - 7.62304019927979) - 1.69194744248821e-5*std::sin(0.334319829940796*x_8 - 4.33663988113403) - 0.00102482927754344*std::sin(0.338799834251404*x_8 + 8.23480033874512) - 0.00134203600319692*std::sin(0.293359935283661*x_9 + 1.99279975891113) + 0.00170719939335184*std::sin(0.302399933338165*x_9 - 7.42071962356567) + 0.00031882916362837*std::sin(0.31839993596077*x_9 - 7.44271993637085) - 7.83768027623244e-6*std::sin(0.322079926729202*x_9 - 7.60824012756348) - 5.83150926074138e-6*std::sin(0.329679846763611*x_9 + 8.27055931091309) - 0.000223144144281641*std::sin(0.343599855899811*x_9 + 8.2553596496582) + 0.00094913489362787*std::sin(0.32983985543251*x_91 + 5.19856023788452) - 0.000235226709932921*std::sin(0.360399842262268*x_91 + 2.0033597946167) + 0.000429948136989282*std::sin(0.370799839496613*x_91 - 7.39167976379395) - 1.49205969274853e-5*std::sin(0.408639848232269*x_91 - 1.21063983440399) + 0.000492400367820568*std::sin(0.196879997849464*x_92 - 0.973359823226929) + 5.00366242443792e-6*std::sin(0.272479951381683*x_92 + 1.9845597743988) + 5.32240389041891e-6*std::sin(0.296559929847717*x_92 + 1.81431996822357) + 0.00170705686623339*std::sin(0.297279924154282*x_92 - 1.16759991645813) + 0.000232459775385703*std::sin(0.350959837436676*x_92 - 7.59128046035767) - 0.00326638372512432*std::sin(0.251839965581894*x_94 - 1.18175983428955) - 2.22505946483769e-5*std::sin(0.285679936408997*x_94 + 1.97303986549377) - 0.000824502741055187*std::sin(0.303999930620193*x_94 + 1.95023989677429) + 5.69133366373342e-6*std::sin(0.304239928722382*x_94 - 1.20943987369537) + 0.00305664650041878*std::sin(0.278879970312119*x_95 + 1.96503984928131) + 0.000272206465371124*std::sin(0.283679932355881*x_95 - 1.21423995494843) + 9.21796524109063e-6*std::sin(0.285359919071198*x_95 - 1.20247983932495) + 1.02283456004518e-5*std::sin(0.271519958972931*x_96 + 8.18879985809326) + 0.0011387713076049*std::sin(0.260719984769821*x_97 + 8.19032001495361) + 0.0017211079104736*std::sin(0.26199996471405*x_97 - 1.21223986148834) + 1.28950836850165e-5*std::sin(0.265839964151382*x_97 + 8.19623947143555) + 7.64772409482846e-6*std::sin(0.293199926614761*x_97 - 1.21343982219696) - 0.00212869293150614*std::sin(0.253679990768433*x_98 + 1.97847986221313) - 0.000484696709950598*std::sin(0.259759962558746*x_98 + 1.97319984436035) + 1.20151882667955e-5*std::sin(0.262879967689514*x_98 + 1.95375978946686) + 0.00117206487135652*std::sin(0.240079984068871*x_99 - 7.41871976852417) - 5.29112588683706e-6*std::sin(0.247679978609085*x_99 + 1.9799998998642) + 0.000411664529537153*std::sin(0.255439966917038*x_99 + 1.93951988220215) + 0.000380151274660125*std::sin(0.258239984512329*x_99 - 1.22207987308502) + 0.0764554860824492);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
